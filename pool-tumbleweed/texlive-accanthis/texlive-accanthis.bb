SUMMARY = "Accanthis fonts, with LaTeX support"
DESCRIPTION = "Accanthis No. 3 is designed by Hirwin Harendal and is suitable \
as an alternative to fonts such as Garamond, Galliard, Horley \
old style, Sabon, and Bembo. The support files are suitable for \
use with all LaTeX engines."
LICENSE = "GPL-2.0-or-later"

PV = "2026.226.svn77682"

RPM_NAME = "texlive-accanthis-2026.226.svn77682-61.2.noarch.rpm"
RPM_HASH = "d184781aedb197e68832aed13487328fdffdbfa9c6888f3a77936df4dcf7badc9cd7239fdcc7ccb673aaec9aee5e0ba73276078003a7bb0ddb2cce98cb12c48a"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-AccanthisADFStdNo3-Bold-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ly1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ly1.vf \
tex-AccanthisADFStdNo3-Bold-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ot1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ot1.vf \
tex-AccanthisADFStdNo3-Bold-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Bold-lf-t1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-t1.vf \
tex-AccanthisADFStdNo3-Bold-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ts1.tfm \
tex-AccanthisADFStdNo3-Bold-lf-ts1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ly1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ot1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-t1.vf \
tex-AccanthisADFStdNo3-BoldItalic-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ts1.tfm \
tex-AccanthisADFStdNo3-BoldItalic-lf-ts1.vf \
tex-AccanthisADFStdNo3-Italic-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ly1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ly1.vf \
tex-AccanthisADFStdNo3-Italic-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ot1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ot1.vf \
tex-AccanthisADFStdNo3-Italic-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Italic-lf-t1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-t1.vf \
tex-AccanthisADFStdNo3-Italic-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ts1.tfm \
tex-AccanthisADFStdNo3-Italic-lf-ts1.vf \
tex-AccanthisADFStdNo3-Regular-lf-ly1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ly1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ly1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ly1.vf \
tex-AccanthisADFStdNo3-Regular-lf-ot1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ot1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ot1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ot1.vf \
tex-AccanthisADFStdNo3-Regular-lf-t1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-t1--lcdfj.tfm \
tex-AccanthisADFStdNo3-Regular-lf-t1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-t1.vf \
tex-AccanthisADFStdNo3-Regular-lf-ts1--base.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ts1.tfm \
tex-AccanthisADFStdNo3-Regular-lf-ts1.vf \
tex-LY1AccanthisADFStdNoThree-LF.fd \
tex-OT1AccanthisADFStdNoThree-LF.fd \
tex-T1AccanthisADFStdNoThree-LF.fd \
tex-TS1AccanthisADFStdNoThree-LF.fd \
tex-accanthis.map \
tex-accanthis.sty \
tex-acnt-m4gnvn.enc \
tex-acnt-qu6a6x.enc \
tex-acnt-sjpjw4.enc \
tex-acnt-z4e4wk.enc \
texlive-accanthis"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-accanthis-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
