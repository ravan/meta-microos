SUMMARY = "Translations for package libKF6Holidays6"
DESCRIPTION = "Provides translations for the 'libKF6Holidays6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6Holidays6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "73c26fc92cabc3f15eff4729a54e70481d28529478fc90d0044077aa7382e2ad75ad02bd845287ffcce0112a67a30f2b01d72a18c956a8a613aa417e048fc0e3"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6Holidays6-lang \
libKF6Holidays6-lang-all \
locale-libKF6Holidays6-ar \
locale-libKF6Holidays6-ast \
locale-libKF6Holidays6-az \
locale-libKF6Holidays6-be \
locale-libKF6Holidays6-bg \
locale-libKF6Holidays6-br \
locale-libKF6Holidays6-bs \
locale-libKF6Holidays6-ca \
locale-libKF6Holidays6-ca@valencia \
locale-libKF6Holidays6-cs \
locale-libKF6Holidays6-cy \
locale-libKF6Holidays6-da \
locale-libKF6Holidays6-de \
locale-libKF6Holidays6-el \
locale-libKF6Holidays6-en-GB \
locale-libKF6Holidays6-eo \
locale-libKF6Holidays6-es \
locale-libKF6Holidays6-et \
locale-libKF6Holidays6-eu \
locale-libKF6Holidays6-fa \
locale-libKF6Holidays6-fi \
locale-libKF6Holidays6-fr \
locale-libKF6Holidays6-ga \
locale-libKF6Holidays6-gl \
locale-libKF6Holidays6-he \
locale-libKF6Holidays6-hi \
locale-libKF6Holidays6-hu \
locale-libKF6Holidays6-ia \
locale-libKF6Holidays6-id \
locale-libKF6Holidays6-is \
locale-libKF6Holidays6-it \
locale-libKF6Holidays6-ja \
locale-libKF6Holidays6-ka \
locale-libKF6Holidays6-kk \
locale-libKF6Holidays6-km \
locale-libKF6Holidays6-ko \
locale-libKF6Holidays6-lt \
locale-libKF6Holidays6-lv \
locale-libKF6Holidays6-mk \
locale-libKF6Holidays6-ml \
locale-libKF6Holidays6-mr \
locale-libKF6Holidays6-ms \
locale-libKF6Holidays6-nb \
locale-libKF6Holidays6-nds \
locale-libKF6Holidays6-ne \
locale-libKF6Holidays6-nl \
locale-libKF6Holidays6-nn \
locale-libKF6Holidays6-pa \
locale-libKF6Holidays6-pl \
locale-libKF6Holidays6-pt \
locale-libKF6Holidays6-pt-BR \
locale-libKF6Holidays6-ro \
locale-libKF6Holidays6-ru \
locale-libKF6Holidays6-sk \
locale-libKF6Holidays6-sl \
locale-libKF6Holidays6-sq \
locale-libKF6Holidays6-sr \
locale-libKF6Holidays6-sr@ijekavian \
locale-libKF6Holidays6-sr@ijekavianlatin \
locale-libKF6Holidays6-sr@latin \
locale-libKF6Holidays6-sv \
locale-libKF6Holidays6-ta \
locale-libKF6Holidays6-th \
locale-libKF6Holidays6-tr \
locale-libKF6Holidays6-ug \
locale-libKF6Holidays6-uk \
locale-libKF6Holidays6-wa \
locale-libKF6Holidays6-zh-CN \
locale-libKF6Holidays6-zh-TW"

RDEPENDS:${PN} += "libKF6Holidays6"

inherit rpm
