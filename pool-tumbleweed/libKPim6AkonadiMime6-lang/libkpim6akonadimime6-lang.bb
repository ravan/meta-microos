SUMMARY = "Translations for package libKPim6AkonadiMime6"
DESCRIPTION = "Provides translations for the 'libKPim6AkonadiMime6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6AkonadiMime6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "9496c25d456d98ecc56a6443b0837a8d04d7823c29e53eb2365ac15a5c415679c1001d6c6969baa291937b56c7d153803f56e095cff3053548669824d0919f27"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6AkonadiMime6-lang \
libKPim6AkonadiMime6-lang-all \
locale-libKPim6AkonadiMime6-ar \
locale-libKPim6AkonadiMime6-ast \
locale-libKPim6AkonadiMime6-az \
locale-libKPim6AkonadiMime6-bg \
locale-libKPim6AkonadiMime6-bs \
locale-libKPim6AkonadiMime6-ca \
locale-libKPim6AkonadiMime6-ca@valencia \
locale-libKPim6AkonadiMime6-cs \
locale-libKPim6AkonadiMime6-da \
locale-libKPim6AkonadiMime6-de \
locale-libKPim6AkonadiMime6-el \
locale-libKPim6AkonadiMime6-en-GB \
locale-libKPim6AkonadiMime6-eo \
locale-libKPim6AkonadiMime6-es \
locale-libKPim6AkonadiMime6-et \
locale-libKPim6AkonadiMime6-eu \
locale-libKPim6AkonadiMime6-fi \
locale-libKPim6AkonadiMime6-fr \
locale-libKPim6AkonadiMime6-ga \
locale-libKPim6AkonadiMime6-gl \
locale-libKPim6AkonadiMime6-he \
locale-libKPim6AkonadiMime6-hi \
locale-libKPim6AkonadiMime6-hu \
locale-libKPim6AkonadiMime6-ia \
locale-libKPim6AkonadiMime6-id \
locale-libKPim6AkonadiMime6-it \
locale-libKPim6AkonadiMime6-ja \
locale-libKPim6AkonadiMime6-ka \
locale-libKPim6AkonadiMime6-kk \
locale-libKPim6AkonadiMime6-km \
locale-libKPim6AkonadiMime6-ko \
locale-libKPim6AkonadiMime6-lt \
locale-libKPim6AkonadiMime6-lv \
locale-libKPim6AkonadiMime6-mai \
locale-libKPim6AkonadiMime6-mr \
locale-libKPim6AkonadiMime6-nb \
locale-libKPim6AkonadiMime6-nds \
locale-libKPim6AkonadiMime6-nl \
locale-libKPim6AkonadiMime6-nn \
locale-libKPim6AkonadiMime6-pl \
locale-libKPim6AkonadiMime6-pt \
locale-libKPim6AkonadiMime6-pt-BR \
locale-libKPim6AkonadiMime6-ro \
locale-libKPim6AkonadiMime6-ru \
locale-libKPim6AkonadiMime6-sk \
locale-libKPim6AkonadiMime6-sl \
locale-libKPim6AkonadiMime6-sr \
locale-libKPim6AkonadiMime6-sr@ijekavian \
locale-libKPim6AkonadiMime6-sr@ijekavianlatin \
locale-libKPim6AkonadiMime6-sr@latin \
locale-libKPim6AkonadiMime6-sv \
locale-libKPim6AkonadiMime6-ta \
locale-libKPim6AkonadiMime6-tr \
locale-libKPim6AkonadiMime6-ug \
locale-libKPim6AkonadiMime6-uk \
locale-libKPim6AkonadiMime6-zh-CN \
locale-libKPim6AkonadiMime6-zh-TW"

RDEPENDS:${PN} += "libKPim6AkonadiMime6"

inherit rpm
