SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "4.3.1"

RPM_NAME = "python314-astroid-4.3.1-1.1.noarch.rpm"
RPM_HASH = "c44cabc264c5b9efdb93adb54831d069187ad0b9b7dcbc29c62439633a125a46ae193b87af718045ba3c8c9f1cf59a02925c90306c9df5b0666a07d1a217d575"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3.14dist-astroid \
python314-astroid \
python3dist-astroid"

RDEPENDS:${PN} += "python-abi"

inherit rpm
