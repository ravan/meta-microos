SUMMARY = "VDE ecryption module"
DESCRIPTION = "slirpvde is a slirp interface for a VDE network. \
Slirpvde  connects  all  the units (virtual or real machines) to the network \
of the host where slirpvde runs as it were a NAT/Masquerading router. \
The default route is the node 2 (10.0.2.2 in the default  network  configuration) \
and DNS is re-mapped in node 3 (10.0.2.3). \
 \
Slirpvde  runs  using  standard user privileges (no need for root access): \
all the connections are re-generated by slirpvde itself. \
 \
IPv4 only. IPv6 is still unsupported (will be supported when slirpvde \
will be rewritten using the  LWIPv6  network stack)."
LICENSE = "BSD-4-Clause & MIT"

PV = "2.3.2+svn587"

RPM_NAME = "vde2-slirp-2.3.2+svn587-6.6.aarch64.rpm"
RPM_HASH = "5659bfba76e27e69f323d70787cb6d6db71b74e1cc53cbf36a0f3405543e94399a35bd043c294084970f5bda8e6ea7ee1b79cd3d3d508b53c0efef1714223431"

RPROVIDES:${PN} += "vde2-slirp"

RDEPENDS:${PN} += "ld-linux-aarch64.so.1 \
libc.so.6 \
libvdeplug.so.3"

inherit rpm
