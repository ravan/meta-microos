SUMMARY = "A kernel module to create V4L2 loopback devices"
DESCRIPTION = "This module allows you to create 'virtual video devices'. Normal (v4l2) \
applications will read these devices as if they were ordinary video \
devices, but the video will not be read from e.g. a capture card but \
instead it is generated by another application."
LICENSE = "GPL-2.0-or-later"

PV = "0.15.4_k7.2.4_1"

RPM_NAME = "v4l2loopback-kmp-default-0.15.4_k7.2.4_1-2.2.aarch64.rpm"
RPM_HASH = "e04121187aca21072f349920985e224b50cd17f53c0b94a80bb1dce698027df2763e74a1bbecb55b3a0c50a56fd883bc9868ab4a4f30a48afeb126bebd6470e3"

RPROVIDES:${PN} += "kmod-v4l2loopback.ko \
multiversion-kernel \
v4l2loopback-kmp \
v4l2loopback-kmp-default \
v4l2loopback-kmp-default-k7.2.4-1"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
grep \
kernel-default \
ksym-default----ratelimit \
ksym-default---arch-copy-from-user \
ksym-default---arch-copy-to-user \
ksym-default---check-object-size \
ksym-default---init-waitqueue-head \
ksym-default---kmalloc-cache-noprof \
ksym-default---list-add-valid-or-report \
ksym-default---list-del-entry-valid-or-report \
ksym-default---msecs-to-jiffies \
ksym-default---stack-chk-fail \
ksym-default---video-register-device \
ksym-default---wake-up \
ksym-default--dev-err \
ksym-default--dev-warn \
ksym-default--printk \
ksym-default--raw-spin-lock \
ksym-default--raw-spin-lock-bh \
ksym-default--raw-spin-unlock \
ksym-default--raw-spin-unlock-bh \
ksym-default-alt-cb-patch-nops \
ksym-default-device-create-file \
ksym-default-device-remove-file \
ksym-default-dynamic-might-resched \
ksym-default-finish-wait \
ksym-default-idr-alloc \
ksym-default-idr-destroy \
ksym-default-idr-find \
ksym-default-idr-for-each \
ksym-default-idr-remove \
ksym-default-init-wait-entry \
ksym-default-jiffies \
ksym-default-kfree \
ksym-default-kmalloc-caches \
ksym-default-kstrtoull \
ksym-default-ktime-get-ts64 \
ksym-default-memcpy \
ksym-default-memset \
ksym-default-misc-deregister \
ksym-default-misc-register \
ksym-default-mod-timer \
ksym-default-module-layout \
ksym-default-mutex-init-generic \
ksym-default-mutex-lock \
ksym-default-mutex-lock-killable \
ksym-default-mutex-unlock \
ksym-default-nonseekable-open \
ksym-default-noop-llseek \
ksym-default-param-array-ops \
ksym-default-param-ops-bool \
ksym-default-param-ops-charp \
ksym-default-param-ops-int \
ksym-default-prepare-to-wait-event \
ksym-default-random-kmalloc-seed \
ksym-default-schedule \
ksym-default-snprintf \
ksym-default-sprintf \
ksym-default-sscanf \
ksym-default-timer-delete-sync \
ksym-default-timer-init-key \
ksym-default-v4l2-ctrl-handler-free \
ksym-default-v4l2-ctrl-handler-init-class \
ksym-default-v4l2-ctrl-handler-setup \
ksym-default-v4l2-ctrl-new-custom \
ksym-default-v4l2-ctrl-subscribe-event \
ksym-default-v4l2-device-register \
ksym-default-v4l2-device-unregister \
ksym-default-v4l2-event-pending \
ksym-default-v4l2-event-queue \
ksym-default-v4l2-event-subscribe \
ksym-default-v4l2-event-unsubscribe \
ksym-default-v4l2-fh-add \
ksym-default-v4l2-fh-del \
ksym-default-v4l2-fh-exit \
ksym-default-v4l2-fh-init \
ksym-default-v4l2-fill-pixfmt \
ksym-default-v4l2-fill-pixfmt-mp \
ksym-default-v4l2-format-info \
ksym-default-validate-usercopy-range \
ksym-default-vfree \
ksym-default-video-devdata \
ksym-default-video-device-alloc \
ksym-default-video-device-release \
ksym-default-video-ioctl2 \
ksym-default-video-unregister-device \
ksym-default-vm-insert-page \
ksym-default-vmalloc-noprof \
ksym-default-vmalloc-to-page \
ksym-default-vzalloc-noprof \
suse-kernel-rpm-scriptlets"

inherit rpm
