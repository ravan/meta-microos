SUMMARY = "Microsoft EASM Data Plane Client Client Library for Python"
DESCRIPTION = "Microsoft Defender External Attack Surface Management (Defender EASM) continuously discovers \
and maps your digital attack surface to provide an external view of your online infrastructure. \
 \
This visibility enables security and IT teams to identify unknowns, prioritize risk, eliminate \
threats, and extend vulnerability and exposure control beyond the firewall. Defender EASM \
leverages Microsoft’s crawling technology to discover assets that are related to your known online \
infrastructure, and actively scans these assets to discover new connections over time. \
 \
Attack Surface Insights are generated by leveraging vulnerability and infrastructure data to \
showcase the key areas of concern for your organization."
LICENSE = "MIT"

PV = "1.0.0~b1"

RPM_NAME = "python314-azure-defender-easm-1.0.0~b1-2.8.noarch.rpm"
RPM_HASH = "24c3db0155f70c50c40f5a4405f92d54463849d525508b3c3c9315be8e20eb39e70d449fae04d4a9ab78898dfa12f23cc7c6dc8bf930d6635eaa137ec6e1ad15"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3.14dist-azure-defender-easm \
python314-azure-defender-easm \
python3dist-azure-defender-easm"

RDEPENDS:${PN} += "python-abi \
python314-azure-core \
python314-azure-nspkg \
python314-isodate"

inherit rpm
