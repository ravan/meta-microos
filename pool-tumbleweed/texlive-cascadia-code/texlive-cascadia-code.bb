SUMMARY = "The Cascadia Code font with support for LaTeX and pdfLaTeX"
DESCRIPTION = "Cascadia Code is a monospaced font by Microsoft. This package \
provides the Cascadia Code family of fonts with support for \
LaTeX and pdfLaTeX. Adding \\usepackage{cascadia-code} to the \
preamble of your document will activate Cascadia Code as the \
typewriter font (\\ttdefault)."
LICENSE = "OFL-1.1"

PV = "2026.226.0.0.0.2svn77682"

RPM_NAME = "texlive-cascadia-code-2026.226.0.0.0.2svn77682-59.2.noarch.rpm"
RPM_HASH = "ba8561434a9204d5bae8c341a4a68e06ddcdf595fef4240b95733236ebff378a7b6652f033cbc735a5cd44c6ac0adc2cdce1ad5880fb411206b798098e960afd"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-CascadiaCode-Bold-sup-lgr--base.tfm \
tex-CascadiaCode-Bold-sup-lgr.tfm \
tex-CascadiaCode-Bold-sup-lgr.vf \
tex-CascadiaCode-Bold-sup-ly1--base.tfm \
tex-CascadiaCode-Bold-sup-ly1.tfm \
tex-CascadiaCode-Bold-sup-ly1.vf \
tex-CascadiaCode-Bold-sup-ot1.tfm \
tex-CascadiaCode-Bold-sup-t1--base.tfm \
tex-CascadiaCode-Bold-sup-t1.tfm \
tex-CascadiaCode-Bold-sup-t1.vf \
tex-CascadiaCode-Bold-tlf-lgr--base.tfm \
tex-CascadiaCode-Bold-tlf-lgr.tfm \
tex-CascadiaCode-Bold-tlf-lgr.vf \
tex-CascadiaCode-Bold-tlf-ly1--base.tfm \
tex-CascadiaCode-Bold-tlf-ly1.tfm \
tex-CascadiaCode-Bold-tlf-ly1.vf \
tex-CascadiaCode-Bold-tlf-ot1.tfm \
tex-CascadiaCode-Bold-tlf-t1--base.tfm \
tex-CascadiaCode-Bold-tlf-t1.tfm \
tex-CascadiaCode-Bold-tlf-t1.vf \
tex-CascadiaCode-Bold-tlf-ts1--base.tfm \
tex-CascadiaCode-Bold-tlf-ts1.tfm \
tex-CascadiaCode-Bold-tlf-ts1.vf \
tex-CascadiaCode-BoldItalic-sup-lgr--base.tfm \
tex-CascadiaCode-BoldItalic-sup-lgr.tfm \
tex-CascadiaCode-BoldItalic-sup-lgr.vf \
tex-CascadiaCode-BoldItalic-sup-ly1--base.tfm \
tex-CascadiaCode-BoldItalic-sup-ly1.tfm \
tex-CascadiaCode-BoldItalic-sup-ly1.vf \
tex-CascadiaCode-BoldItalic-sup-ot1.tfm \
tex-CascadiaCode-BoldItalic-sup-t1--base.tfm \
tex-CascadiaCode-BoldItalic-sup-t1.tfm \
tex-CascadiaCode-BoldItalic-sup-t1.vf \
tex-CascadiaCode-BoldItalic-tlf-lgr--base.tfm \
tex-CascadiaCode-BoldItalic-tlf-lgr.tfm \
tex-CascadiaCode-BoldItalic-tlf-lgr.vf \
tex-CascadiaCode-BoldItalic-tlf-ly1--base.tfm \
tex-CascadiaCode-BoldItalic-tlf-ly1.tfm \
tex-CascadiaCode-BoldItalic-tlf-ly1.vf \
tex-CascadiaCode-BoldItalic-tlf-ot1.tfm \
tex-CascadiaCode-BoldItalic-tlf-t1--base.tfm \
tex-CascadiaCode-BoldItalic-tlf-t1.tfm \
tex-CascadiaCode-BoldItalic-tlf-t1.vf \
tex-CascadiaCode-BoldItalic-tlf-ts1--base.tfm \
tex-CascadiaCode-BoldItalic-tlf-ts1.tfm \
tex-CascadiaCode-BoldItalic-tlf-ts1.vf \
tex-CascadiaCode-ExtraLight-sup-lgr--base.tfm \
tex-CascadiaCode-ExtraLight-sup-lgr.tfm \
tex-CascadiaCode-ExtraLight-sup-lgr.vf \
tex-CascadiaCode-ExtraLight-sup-ly1--base.tfm \
tex-CascadiaCode-ExtraLight-sup-ly1.tfm \
tex-CascadiaCode-ExtraLight-sup-ly1.vf \
tex-CascadiaCode-ExtraLight-sup-ot1.tfm \
tex-CascadiaCode-ExtraLight-sup-t1--base.tfm \
tex-CascadiaCode-ExtraLight-sup-t1.tfm \
tex-CascadiaCode-ExtraLight-sup-t1.vf \
tex-CascadiaCode-ExtraLight-tlf-lgr--base.tfm \
tex-CascadiaCode-ExtraLight-tlf-lgr.tfm \
tex-CascadiaCode-ExtraLight-tlf-lgr.vf \
tex-CascadiaCode-ExtraLight-tlf-ly1--base.tfm \
tex-CascadiaCode-ExtraLight-tlf-ly1.tfm \
tex-CascadiaCode-ExtraLight-tlf-ly1.vf \
tex-CascadiaCode-ExtraLight-tlf-ot1.tfm \
tex-CascadiaCode-ExtraLight-tlf-t1--base.tfm \
tex-CascadiaCode-ExtraLight-tlf-t1.tfm \
tex-CascadiaCode-ExtraLight-tlf-t1.vf \
tex-CascadiaCode-ExtraLight-tlf-ts1--base.tfm \
tex-CascadiaCode-ExtraLight-tlf-ts1.tfm \
tex-CascadiaCode-ExtraLight-tlf-ts1.vf \
tex-CascadiaCode-ExtraLightItalic-sup-lgr--base.tfm \
tex-CascadiaCode-ExtraLightItalic-sup-lgr.tfm \
tex-CascadiaCode-ExtraLightItalic-sup-lgr.vf \
tex-CascadiaCode-ExtraLightItalic-sup-ly1--base.tfm \
tex-CascadiaCode-ExtraLightItalic-sup-ly1.tfm \
tex-CascadiaCode-ExtraLightItalic-sup-ly1.vf \
tex-CascadiaCode-ExtraLightItalic-sup-ot1.tfm \
tex-CascadiaCode-ExtraLightItalic-sup-t1--base.tfm \
tex-CascadiaCode-ExtraLightItalic-sup-t1.tfm \
tex-CascadiaCode-ExtraLightItalic-sup-t1.vf \
tex-CascadiaCode-ExtraLightItalic-tlf-lgr--base.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-lgr.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-lgr.vf \
tex-CascadiaCode-ExtraLightItalic-tlf-ly1--base.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-ly1.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-ly1.vf \
tex-CascadiaCode-ExtraLightItalic-tlf-ot1.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-t1--base.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-t1.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-t1.vf \
tex-CascadiaCode-ExtraLightItalic-tlf-ts1--base.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-ts1.tfm \
tex-CascadiaCode-ExtraLightItalic-tlf-ts1.vf \
tex-CascadiaCode-Italic-sup-lgr--base.tfm \
tex-CascadiaCode-Italic-sup-lgr.tfm \
tex-CascadiaCode-Italic-sup-lgr.vf \
tex-CascadiaCode-Italic-sup-ly1--base.tfm \
tex-CascadiaCode-Italic-sup-ly1.tfm \
tex-CascadiaCode-Italic-sup-ly1.vf \
tex-CascadiaCode-Italic-sup-ot1.tfm \
tex-CascadiaCode-Italic-sup-t1--base.tfm \
tex-CascadiaCode-Italic-sup-t1.tfm \
tex-CascadiaCode-Italic-sup-t1.vf \
tex-CascadiaCode-Italic-tlf-lgr--base.tfm \
tex-CascadiaCode-Italic-tlf-lgr.tfm \
tex-CascadiaCode-Italic-tlf-lgr.vf \
tex-CascadiaCode-Italic-tlf-ly1--base.tfm \
tex-CascadiaCode-Italic-tlf-ly1.tfm \
tex-CascadiaCode-Italic-tlf-ly1.vf \
tex-CascadiaCode-Italic-tlf-ot1.tfm \
tex-CascadiaCode-Italic-tlf-t1--base.tfm \
tex-CascadiaCode-Italic-tlf-t1.tfm \
tex-CascadiaCode-Italic-tlf-t1.vf \
tex-CascadiaCode-Italic-tlf-ts1--base.tfm \
tex-CascadiaCode-Italic-tlf-ts1.tfm \
tex-CascadiaCode-Italic-tlf-ts1.vf \
tex-CascadiaCode-Light-sup-lgr--base.tfm \
tex-CascadiaCode-Light-sup-lgr.tfm \
tex-CascadiaCode-Light-sup-lgr.vf \
tex-CascadiaCode-Light-sup-ly1--base.tfm \
tex-CascadiaCode-Light-sup-ly1.tfm \
tex-CascadiaCode-Light-sup-ly1.vf \
tex-CascadiaCode-Light-sup-ot1.tfm \
tex-CascadiaCode-Light-sup-t1--base.tfm \
tex-CascadiaCode-Light-sup-t1.tfm \
tex-CascadiaCode-Light-sup-t1.vf \
tex-CascadiaCode-Light-tlf-lgr--base.tfm \
tex-CascadiaCode-Light-tlf-lgr.tfm \
tex-CascadiaCode-Light-tlf-lgr.vf \
tex-CascadiaCode-Light-tlf-ly1--base.tfm \
tex-CascadiaCode-Light-tlf-ly1.tfm \
tex-CascadiaCode-Light-tlf-ly1.vf \
tex-CascadiaCode-Light-tlf-ot1.tfm \
tex-CascadiaCode-Light-tlf-t1--base.tfm \
tex-CascadiaCode-Light-tlf-t1.tfm \
tex-CascadiaCode-Light-tlf-t1.vf \
tex-CascadiaCode-Light-tlf-ts1--base.tfm \
tex-CascadiaCode-Light-tlf-ts1.tfm \
tex-CascadiaCode-Light-tlf-ts1.vf \
tex-CascadiaCode-LightItalic-sup-lgr--base.tfm \
tex-CascadiaCode-LightItalic-sup-lgr.tfm \
tex-CascadiaCode-LightItalic-sup-lgr.vf \
tex-CascadiaCode-LightItalic-sup-ly1--base.tfm \
tex-CascadiaCode-LightItalic-sup-ly1.tfm \
tex-CascadiaCode-LightItalic-sup-ly1.vf \
tex-CascadiaCode-LightItalic-sup-ot1.tfm \
tex-CascadiaCode-LightItalic-sup-t1--base.tfm \
tex-CascadiaCode-LightItalic-sup-t1.tfm \
tex-CascadiaCode-LightItalic-sup-t1.vf \
tex-CascadiaCode-LightItalic-tlf-lgr--base.tfm \
tex-CascadiaCode-LightItalic-tlf-lgr.tfm \
tex-CascadiaCode-LightItalic-tlf-lgr.vf \
tex-CascadiaCode-LightItalic-tlf-ly1--base.tfm \
tex-CascadiaCode-LightItalic-tlf-ly1.tfm \
tex-CascadiaCode-LightItalic-tlf-ly1.vf \
tex-CascadiaCode-LightItalic-tlf-ot1.tfm \
tex-CascadiaCode-LightItalic-tlf-t1--base.tfm \
tex-CascadiaCode-LightItalic-tlf-t1.tfm \
tex-CascadiaCode-LightItalic-tlf-t1.vf \
tex-CascadiaCode-LightItalic-tlf-ts1--base.tfm \
tex-CascadiaCode-LightItalic-tlf-ts1.tfm \
tex-CascadiaCode-LightItalic-tlf-ts1.vf \
tex-CascadiaCode-Regular-sup-lgr--base.tfm \
tex-CascadiaCode-Regular-sup-lgr.tfm \
tex-CascadiaCode-Regular-sup-lgr.vf \
tex-CascadiaCode-Regular-sup-ly1--base.tfm \
tex-CascadiaCode-Regular-sup-ly1.tfm \
tex-CascadiaCode-Regular-sup-ly1.vf \
tex-CascadiaCode-Regular-sup-ot1.tfm \
tex-CascadiaCode-Regular-sup-t1--base.tfm \
tex-CascadiaCode-Regular-sup-t1.tfm \
tex-CascadiaCode-Regular-sup-t1.vf \
tex-CascadiaCode-Regular-tlf-lgr--base.tfm \
tex-CascadiaCode-Regular-tlf-lgr.tfm \
tex-CascadiaCode-Regular-tlf-lgr.vf \
tex-CascadiaCode-Regular-tlf-ly1--base.tfm \
tex-CascadiaCode-Regular-tlf-ly1.tfm \
tex-CascadiaCode-Regular-tlf-ly1.vf \
tex-CascadiaCode-Regular-tlf-ot1.tfm \
tex-CascadiaCode-Regular-tlf-t1--base.tfm \
tex-CascadiaCode-Regular-tlf-t1.tfm \
tex-CascadiaCode-Regular-tlf-t1.vf \
tex-CascadiaCode-Regular-tlf-ts1--base.tfm \
tex-CascadiaCode-Regular-tlf-ts1.tfm \
tex-CascadiaCode-Regular-tlf-ts1.vf \
tex-CascadiaCode-SemiBold-sup-lgr--base.tfm \
tex-CascadiaCode-SemiBold-sup-lgr.tfm \
tex-CascadiaCode-SemiBold-sup-lgr.vf \
tex-CascadiaCode-SemiBold-sup-ly1--base.tfm \
tex-CascadiaCode-SemiBold-sup-ly1.tfm \
tex-CascadiaCode-SemiBold-sup-ly1.vf \
tex-CascadiaCode-SemiBold-sup-ot1.tfm \
tex-CascadiaCode-SemiBold-sup-t1--base.tfm \
tex-CascadiaCode-SemiBold-sup-t1.tfm \
tex-CascadiaCode-SemiBold-sup-t1.vf \
tex-CascadiaCode-SemiBold-tlf-lgr--base.tfm \
tex-CascadiaCode-SemiBold-tlf-lgr.tfm \
tex-CascadiaCode-SemiBold-tlf-lgr.vf \
tex-CascadiaCode-SemiBold-tlf-ly1--base.tfm \
tex-CascadiaCode-SemiBold-tlf-ly1.tfm \
tex-CascadiaCode-SemiBold-tlf-ly1.vf \
tex-CascadiaCode-SemiBold-tlf-ot1.tfm \
tex-CascadiaCode-SemiBold-tlf-t1--base.tfm \
tex-CascadiaCode-SemiBold-tlf-t1.tfm \
tex-CascadiaCode-SemiBold-tlf-t1.vf \
tex-CascadiaCode-SemiBold-tlf-ts1--base.tfm \
tex-CascadiaCode-SemiBold-tlf-ts1.tfm \
tex-CascadiaCode-SemiBold-tlf-ts1.vf \
tex-CascadiaCode-SemiBoldItalic-sup-lgr--base.tfm \
tex-CascadiaCode-SemiBoldItalic-sup-lgr.tfm \
tex-CascadiaCode-SemiBoldItalic-sup-lgr.vf \
tex-CascadiaCode-SemiBoldItalic-sup-ly1--base.tfm \
tex-CascadiaCode-SemiBoldItalic-sup-ly1.tfm \
tex-CascadiaCode-SemiBoldItalic-sup-ly1.vf \
tex-CascadiaCode-SemiBoldItalic-sup-ot1.tfm \
tex-CascadiaCode-SemiBoldItalic-sup-t1--base.tfm \
tex-CascadiaCode-SemiBoldItalic-sup-t1.tfm \
tex-CascadiaCode-SemiBoldItalic-sup-t1.vf \
tex-CascadiaCode-SemiBoldItalic-tlf-lgr--base.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-lgr.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-lgr.vf \
tex-CascadiaCode-SemiBoldItalic-tlf-ly1--base.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-ly1.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-ly1.vf \
tex-CascadiaCode-SemiBoldItalic-tlf-ot1.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-t1--base.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-t1.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-t1.vf \
tex-CascadiaCode-SemiBoldItalic-tlf-ts1--base.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-ts1.tfm \
tex-CascadiaCode-SemiBoldItalic-tlf-ts1.vf \
tex-CascadiaCode-SemiLight-sup-lgr--base.tfm \
tex-CascadiaCode-SemiLight-sup-lgr.tfm \
tex-CascadiaCode-SemiLight-sup-lgr.vf \
tex-CascadiaCode-SemiLight-sup-ly1--base.tfm \
tex-CascadiaCode-SemiLight-sup-ly1.tfm \
tex-CascadiaCode-SemiLight-sup-ly1.vf \
tex-CascadiaCode-SemiLight-sup-ot1.tfm \
tex-CascadiaCode-SemiLight-sup-t1--base.tfm \
tex-CascadiaCode-SemiLight-sup-t1.tfm \
tex-CascadiaCode-SemiLight-sup-t1.vf \
tex-CascadiaCode-SemiLight-tlf-lgr--base.tfm \
tex-CascadiaCode-SemiLight-tlf-lgr.tfm \
tex-CascadiaCode-SemiLight-tlf-lgr.vf \
tex-CascadiaCode-SemiLight-tlf-ly1--base.tfm \
tex-CascadiaCode-SemiLight-tlf-ly1.tfm \
tex-CascadiaCode-SemiLight-tlf-ly1.vf \
tex-CascadiaCode-SemiLight-tlf-ot1.tfm \
tex-CascadiaCode-SemiLight-tlf-t1--base.tfm \
tex-CascadiaCode-SemiLight-tlf-t1.tfm \
tex-CascadiaCode-SemiLight-tlf-t1.vf \
tex-CascadiaCode-SemiLight-tlf-ts1--base.tfm \
tex-CascadiaCode-SemiLight-tlf-ts1.tfm \
tex-CascadiaCode-SemiLight-tlf-ts1.vf \
tex-CascadiaCode-SemiLightItalic-sup-lgr--base.tfm \
tex-CascadiaCode-SemiLightItalic-sup-lgr.tfm \
tex-CascadiaCode-SemiLightItalic-sup-lgr.vf \
tex-CascadiaCode-SemiLightItalic-sup-ly1--base.tfm \
tex-CascadiaCode-SemiLightItalic-sup-ly1.tfm \
tex-CascadiaCode-SemiLightItalic-sup-ly1.vf \
tex-CascadiaCode-SemiLightItalic-sup-ot1.tfm \
tex-CascadiaCode-SemiLightItalic-sup-t1--base.tfm \
tex-CascadiaCode-SemiLightItalic-sup-t1.tfm \
tex-CascadiaCode-SemiLightItalic-sup-t1.vf \
tex-CascadiaCode-SemiLightItalic-tlf-lgr--base.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-lgr.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-lgr.vf \
tex-CascadiaCode-SemiLightItalic-tlf-ly1--base.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-ly1.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-ly1.vf \
tex-CascadiaCode-SemiLightItalic-tlf-ot1.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-t1--base.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-t1.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-t1.vf \
tex-CascadiaCode-SemiLightItalic-tlf-ts1--base.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-ts1.tfm \
tex-CascadiaCode-SemiLightItalic-tlf-ts1.vf \
tex-CascadiaCode.map \
tex-LGRCascadiaCode-Sup.fd \
tex-LGRCascadiaCode-TLF.fd \
tex-LY1CascadiaCode-Sup.fd \
tex-LY1CascadiaCode-TLF.fd \
tex-OT1CascadiaCode-Sup.fd \
tex-OT1CascadiaCode-TLF.fd \
tex-T1CascadiaCode-Sup.fd \
tex-T1CascadiaCode-TLF.fd \
tex-TS1CascadiaCode-TLF.fd \
tex-a-i3ioen.enc \
tex-a-ktghj4.enc \
tex-a-lzhlbi.enc \
tex-a-pv6ajo.enc \
tex-a-r2ngzv.enc \
tex-a-rzdm5y.enc \
tex-a-vqpkf5.enc \
tex-a-zqfkiw.enc \
tex-a-zrxj4s.enc \
tex-cascadia-code.sty \
texlive-cascadia-code"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-cascadia-code-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
