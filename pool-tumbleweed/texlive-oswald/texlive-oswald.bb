SUMMARY = "The Oswald family of fonts with support for LaTeX and pdfLaTeX"
DESCRIPTION = "This package provides the Oswald family of fonts, designed by \
Vernon Adams, Kalapi Gajjar, Cyreal, with support for LaTeX and \
pdfLaTeX."
LICENSE = "OFL-1.1"

PV = "2026.226.svn60784"

RPM_NAME = "texlive-oswald-2026.226.svn60784-61.2.noarch.rpm"
RPM_HASH = "39b2ee6d7eaf83603cc0531e77b745cf5bae71b521f3ee6329a5b7cdf990cd236e7ee6c6bfdd392a993381487bb1c342ca74bbb5f3acb0d5c0043be9599e1b5e"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-0swald-Bold-sup-ly1--base.tfm \
tex-0swald-Bold-sup-ly1.tfm \
tex-0swald-Bold-sup-ly1.vf \
tex-0swald-Bold-sup-ot1.tfm \
tex-0swald-Bold-sup-t1--base.tfm \
tex-0swald-Bold-sup-t1.tfm \
tex-0swald-Bold-sup-t1.vf \
tex-0swald-Bold-tlf-ly1--base.tfm \
tex-0swald-Bold-tlf-ly1.tfm \
tex-0swald-Bold-tlf-ly1.vf \
tex-0swald-Bold-tlf-ot1.tfm \
tex-0swald-Bold-tlf-t1--base.tfm \
tex-0swald-Bold-tlf-t1.tfm \
tex-0swald-Bold-tlf-t1.vf \
tex-0swald-Bold-tlf-ts1--base.tfm \
tex-0swald-Bold-tlf-ts1.tfm \
tex-0swald-Bold-tlf-ts1.vf \
tex-0swald-ExtraLight-sup-ly1--base.tfm \
tex-0swald-ExtraLight-sup-ly1.tfm \
tex-0swald-ExtraLight-sup-ly1.vf \
tex-0swald-ExtraLight-sup-ot1.tfm \
tex-0swald-ExtraLight-sup-t1--base.tfm \
tex-0swald-ExtraLight-sup-t1.tfm \
tex-0swald-ExtraLight-sup-t1.vf \
tex-0swald-ExtraLight-tlf-ly1--base.tfm \
tex-0swald-ExtraLight-tlf-ly1.tfm \
tex-0swald-ExtraLight-tlf-ly1.vf \
tex-0swald-ExtraLight-tlf-ot1.tfm \
tex-0swald-ExtraLight-tlf-t1--base.tfm \
tex-0swald-ExtraLight-tlf-t1.tfm \
tex-0swald-ExtraLight-tlf-t1.vf \
tex-0swald-ExtraLight-tlf-ts1--base.tfm \
tex-0swald-ExtraLight-tlf-ts1.tfm \
tex-0swald-ExtraLight-tlf-ts1.vf \
tex-0swald-Light-sup-ly1--base.tfm \
tex-0swald-Light-sup-ly1.tfm \
tex-0swald-Light-sup-ly1.vf \
tex-0swald-Light-sup-ot1.tfm \
tex-0swald-Light-sup-t1--base.tfm \
tex-0swald-Light-sup-t1.tfm \
tex-0swald-Light-sup-t1.vf \
tex-0swald-Light-tlf-ly1--base.tfm \
tex-0swald-Light-tlf-ly1.tfm \
tex-0swald-Light-tlf-ly1.vf \
tex-0swald-Light-tlf-ot1.tfm \
tex-0swald-Light-tlf-t1--base.tfm \
tex-0swald-Light-tlf-t1.tfm \
tex-0swald-Light-tlf-t1.vf \
tex-0swald-Light-tlf-ts1--base.tfm \
tex-0swald-Light-tlf-ts1.tfm \
tex-0swald-Light-tlf-ts1.vf \
tex-0swald-Medium-sup-ly1--base.tfm \
tex-0swald-Medium-sup-ly1.tfm \
tex-0swald-Medium-sup-ly1.vf \
tex-0swald-Medium-sup-ot1.tfm \
tex-0swald-Medium-sup-t1--base.tfm \
tex-0swald-Medium-sup-t1.tfm \
tex-0swald-Medium-sup-t1.vf \
tex-0swald-Medium-tlf-ly1--base.tfm \
tex-0swald-Medium-tlf-ly1.tfm \
tex-0swald-Medium-tlf-ly1.vf \
tex-0swald-Medium-tlf-ot1.tfm \
tex-0swald-Medium-tlf-t1--base.tfm \
tex-0swald-Medium-tlf-t1.tfm \
tex-0swald-Medium-tlf-t1.vf \
tex-0swald-Medium-tlf-ts1--base.tfm \
tex-0swald-Medium-tlf-ts1.tfm \
tex-0swald-Medium-tlf-ts1.vf \
tex-0swald-Regular-sup-ly1--base.tfm \
tex-0swald-Regular-sup-ly1.tfm \
tex-0swald-Regular-sup-ly1.vf \
tex-0swald-Regular-sup-ot1.tfm \
tex-0swald-Regular-sup-t1--base.tfm \
tex-0swald-Regular-sup-t1.tfm \
tex-0swald-Regular-sup-t1.vf \
tex-0swald-Regular-tlf-ly1--base.tfm \
tex-0swald-Regular-tlf-ly1.tfm \
tex-0swald-Regular-tlf-ly1.vf \
tex-0swald-Regular-tlf-ot1.tfm \
tex-0swald-Regular-tlf-t1--base.tfm \
tex-0swald-Regular-tlf-t1.tfm \
tex-0swald-Regular-tlf-t1.vf \
tex-0swald-Regular-tlf-ts1--base.tfm \
tex-0swald-Regular-tlf-ts1.tfm \
tex-0swald-Regular-tlf-ts1.vf \
tex-0swald-SemiBold-sup-ly1--base.tfm \
tex-0swald-SemiBold-sup-ly1.tfm \
tex-0swald-SemiBold-sup-ly1.vf \
tex-0swald-SemiBold-sup-ot1.tfm \
tex-0swald-SemiBold-sup-t1--base.tfm \
tex-0swald-SemiBold-sup-t1.tfm \
tex-0swald-SemiBold-sup-t1.vf \
tex-0swald-SemiBold-tlf-ly1--base.tfm \
tex-0swald-SemiBold-tlf-ly1.tfm \
tex-0swald-SemiBold-tlf-ly1.vf \
tex-0swald-SemiBold-tlf-ot1.tfm \
tex-0swald-SemiBold-tlf-t1--base.tfm \
tex-0swald-SemiBold-tlf-t1.tfm \
tex-0swald-SemiBold-tlf-t1.vf \
tex-0swald-SemiBold-tlf-ts1--base.tfm \
tex-0swald-SemiBold-tlf-ts1.tfm \
tex-0swald-SemiBold-tlf-ts1.vf \
tex-LY1Zeroswald-Sup.fd \
tex-LY1Zeroswald-TLF.fd \
tex-OT1Zeroswald-Sup.fd \
tex-OT1Zeroswald-TLF.fd \
tex-Oswald.sty \
tex-T1Zeroswald-Sup.fd \
tex-T1Zeroswald-TLF.fd \
tex-TS1Zeroswald-TLF.fd \
tex-Zeroswald.map \
tex-a-7goukv.enc \
tex-a-d2anrk.enc \
tex-a-j5f6hs.enc \
tex-a-leqwth.enc \
tex-a-rymxky.enc \
tex-a-ts7dz6.enc \
tex-a-wbqrrh.enc \
texlive-oswald"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-oswald-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
