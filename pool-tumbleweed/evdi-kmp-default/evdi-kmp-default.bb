SUMMARY = "Extensible Virtual Display Interface (EVDI) is a Linux Kernel Module"
DESCRIPTION = "The Extensible Virtual Display Interface (EVDI) is a Linux kernel module \
that enables management of multiple screens, allowing user-space programs \
to take control over what happens with the image. It is essentially \
a virtual display you can add, remove and receive screen updates for, in \
an application that uses the libevdi library."
LICENSE = "GPL-2.0-only & LGPL-2.1-only"

PV = "1.15.0_k7.2.4_1"

RPM_NAME = "evdi-kmp-default-1.15.0_k7.2.4_1-1.2.aarch64.rpm"
RPM_HASH = "23516c3493a2a4aa0e07da844bbb9358fb6eca4c1efe8b887e4720ffa73f0df364e3dcb260c2778581cf8c0cba1fe163dfae61576c51a8308d6aba7fc83c345d"

RPROVIDES:${PN} += "evdi-kmp \
evdi-kmp-default \
evdi-kmp-default-k7.2.4-1 \
kmod-evdi.ko \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
grep \
kernel-default \
ksym-default---arch-copy-from-user \
ksym-default---arch-copy-to-user \
ksym-default---check-object-size \
ksym-default---copy-overflow \
ksym-default---drm-dev-dbg \
ksym-default---drm-err \
ksym-default---drmm-add-action-or-reset \
ksym-default---fortify-panic \
ksym-default---init-swait-queue-head \
ksym-default---kmalloc-cache-noprof \
ksym-default---kmalloc-noprof \
ksym-default---kvmalloc-node-noprof \
ksym-default---list-add-valid-or-report \
ksym-default---list-del-entry-valid-or-report \
ksym-default---platform-driver-register \
ksym-default---root-device-register \
ksym-default---sg-page-iter-next \
ksym-default---sg-page-iter-start \
ksym-default---stack-chk-fail \
ksym-default---vma-start-write \
ksym-default---warn-printk \
ksym-default--printk \
ksym-default--raw-spin-lock \
ksym-default--raw-spin-lock-irqsave \
ksym-default--raw-spin-unlock \
ksym-default--raw-spin-unlock-irqrestore \
ksym-default-alt-cb-patch-nops \
ksym-default-arm64-use-ng-mappings \
ksym-default-cancel-delayed-work-sync \
ksym-default-complete \
ksym-default-debugfs-attr-read \
ksym-default-debugfs-attr-write \
ksym-default-debugfs-create-file-full \
ksym-default-debugfs-lookup-and-remove \
ksym-default-delayed-work-timer-fn \
ksym-default-device-create-file \
ksym-default-device-remove-file \
ksym-default-dma-buf-begin-cpu-access \
ksym-default-dma-buf-end-cpu-access \
ksym-default-dma-buf-vmap-unlocked \
ksym-default-dma-buf-vunmap-unlocked \
ksym-default-dma-set-mask \
ksym-default-drm-add-edid-modes \
ksym-default-drm-atomic-helper-check \
ksym-default-drm-atomic-helper-commit \
ksym-default-drm-atomic-helper-connector-destroy-state \
ksym-default-drm-atomic-helper-connector-duplicate-state \
ksym-default-drm-atomic-helper-connector-reset \
ksym-default-drm-atomic-helper-crtc-destroy-state \
ksym-default-drm-atomic-helper-crtc-duplicate-state \
ksym-default-drm-atomic-helper-crtc-reset \
ksym-default-drm-atomic-helper-damage-iter-init \
ksym-default-drm-atomic-helper-damage-iter-next \
ksym-default-drm-atomic-helper-dirtyfb \
ksym-default-drm-atomic-helper-disable-plane \
ksym-default-drm-atomic-helper-page-flip \
ksym-default-drm-atomic-helper-plane-destroy-state \
ksym-default-drm-atomic-helper-plane-duplicate-state \
ksym-default-drm-atomic-helper-plane-reset \
ksym-default-drm-atomic-helper-set-config \
ksym-default-drm-atomic-helper-shutdown \
ksym-default-drm-atomic-helper-update-plane \
ksym-default-drm-compat-ioctl \
ksym-default-drm-connector-attach-encoder \
ksym-default-drm-connector-cleanup \
ksym-default-drm-connector-init \
ksym-default-drm-connector-register \
ksym-default-drm-connector-unregister \
ksym-default-drm-connector-update-edid-property \
ksym-default-drm-crtc-cleanup \
ksym-default-drm-crtc-init-with-planes \
ksym-default-drm-crtc-send-vblank-event \
ksym-default-drm-crtc-vblank-off \
ksym-default-drm-dev-alloc \
ksym-default-drm-dev-put \
ksym-default-drm-dev-register \
ksym-default-drm-dev-unplug \
ksym-default-drm-encoder-cleanup \
ksym-default-drm-encoder-init \
ksym-default-drm-event-cancel-free \
ksym-default-drm-event-reserve-init-locked \
ksym-default-drm-format-info \
ksym-default-drm-framebuffer-cleanup \
ksym-default-drm-framebuffer-init \
ksym-default-drm-framebuffer-lookup \
ksym-default-drm-gem-create-mmap-offset \
ksym-default-drm-gem-dmabuf-vmap \
ksym-default-drm-gem-fb-begin-cpu-access \
ksym-default-drm-gem-fb-end-cpu-access \
ksym-default-drm-gem-free-mmap-offset \
ksym-default-drm-gem-get-pages \
ksym-default-drm-gem-handle-create \
ksym-default-drm-gem-mmap \
ksym-default-drm-gem-object-free \
ksym-default-drm-gem-object-init \
ksym-default-drm-gem-object-lookup \
ksym-default-drm-gem-object-release \
ksym-default-drm-gem-plane-helper-prepare-fb \
ksym-default-drm-gem-prime-export \
ksym-default-drm-gem-prime-fd-to-handle \
ksym-default-drm-gem-prime-handle-to-fd \
ksym-default-drm-gem-prime-import \
ksym-default-drm-gem-put-pages \
ksym-default-drm-gem-ttm-vmap \
ksym-default-drm-gem-ttm-vunmap \
ksym-default-drm-gem-vm-close \
ksym-default-drm-gem-vm-open \
ksym-default-drm-get-format-info \
ksym-default-drm-helper-hpd-irq-event \
ksym-default-drm-helper-mode-fill-fb-struct \
ksym-default-drm-helper-probe-single-connector-modes \
ksym-default-drm-ioctl \
ksym-default-drm-ioctl-kernel \
ksym-default-drm-kms-helper-poll-fini \
ksym-default-drm-kms-helper-poll-init \
ksym-default-drm-mode-config-reset \
ksym-default-drm-mode-object-get \
ksym-default-drm-mode-object-put \
ksym-default-drm-mode-vrefresh \
ksym-default-drm-open \
ksym-default-drm-plane-cleanup \
ksym-default-drm-plane-enable-fb-damage-clips \
ksym-default-drm-poll \
ksym-default-drm-prime-gem-destroy \
ksym-default-drm-prime-pages-to-sg \
ksym-default-drm-prime-sg-to-page-array \
ksym-default-drm-read \
ksym-default-drm-release \
ksym-default-drm-send-event-locked \
ksym-default-drm-universal-plane-init \
ksym-default-drm-vblank-init \
ksym-default-drmm-mode-config-init \
ksym-default-fg-console \
ksym-default-i2c-add-adapter \
ksym-default-i2c-del-adapter \
ksym-default-idr-get-next \
ksym-default-kfree \
ksym-default-kmalloc-caches \
ksym-default-kstrdup \
ksym-default-kstrtouint \
ksym-default-ktime-get \
ksym-default-kvfree \
ksym-default-memcpy \
ksym-default-memset \
ksym-default-module-layout \
ksym-default-mutex-init-generic \
ksym-default-mutex-lock \
ksym-default-mutex-unlock \
ksym-default-noop-llseek \
ksym-default-param-ops-int \
ksym-default-param-ops-ushort \
ksym-default-platform-device-register-full \
ksym-default-platform-device-unregister \
ksym-default-platform-driver-unregister \
ksym-default-queue-delayed-work-on \
ksym-default-random-kmalloc-seed \
ksym-default-refcount-warn-saturate \
ksym-default-register-vt-notifier \
ksym-default-root-device-unregister \
ksym-default-simple-attr-open \
ksym-default-simple-attr-release \
ksym-default-sized-strscpy \
ksym-default-snprintf \
ksym-default-strcmp \
ksym-default-strim \
ksym-default-strncmp \
ksym-default-strnlen \
ksym-default-strnstr \
ksym-default-strsep \
ksym-default-sysfs-create-link \
ksym-default-sysfs-remove-link \
ksym-default-system-percpu-wq \
ksym-default-timer-init-key \
ksym-default-unregister-vt-notifier \
ksym-default-usb-for-each-dev \
ksym-default-usb-register-notify \
ksym-default-usb-unregister-notify \
ksym-default-validate-usercopy-range \
ksym-default-vfree \
ksym-default-vm-insert-page \
ksym-default-vmalloc-noprof \
ksym-default-vmap \
ksym-default-vunmap \
ksym-default-wait-for-completion-interruptible-timeout \
ksym-default-ww-mutex-lock \
ksym-default-ww-mutex-unlock \
suse-kernel-rpm-scriptlets"

inherit rpm
