SUMMARY = "Microsoft Azure Resource Management bundle"
DESCRIPTION = "This is the Microsoft Azure Resource Management bundle. \
 \
Azure Resource Manager (ARM) is the next generation of management APIs that \
replace the old Azure Service Management (ASM). \
 \
This package does not contain any code in itself. It installs a set \
of packages that provide management APIs for the various Azure services. \
 \
All packages in this bundle have been tested with Python 2.7, 3.4, 3.5, 3.6 and 3.7."
LICENSE = "MIT"

PV = "4.0.0"

RPM_NAME = "python313-azure-mgmt-4.0.0-28.4.noarch.rpm"
RPM_HASH = "fd4f89126789625db2d36413e040f0ecfe9b5778bb8e02b576e764d31180d7955391d1efedbb0f3808518f3f76b68a32c147a585932cda39c8abd4949af2694b"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3-azure-mgmt \
python3.13dist-azure-mgmt \
python313-azure-mgmt \
python3dist-azure-mgmt"

RDEPENDS:${PN} += "python313-azure-mgmt-advisor \
python313-azure-mgmt-agfood \
python313-azure-mgmt-agrifood \
python313-azure-mgmt-alertsmanagement \
python313-azure-mgmt-apicenter \
python313-azure-mgmt-apimanagement \
python313-azure-mgmt-app \
python313-azure-mgmt-appcomplianceautomation \
python313-azure-mgmt-appconfiguration \
python313-azure-mgmt-appcontainers \
python313-azure-mgmt-applicationinsights \
python313-azure-mgmt-appplatform \
python313-azure-mgmt-arizeaiobservabilityeval \
python313-azure-mgmt-astro \
python313-azure-mgmt-attestation \
python313-azure-mgmt-authorization \
python313-azure-mgmt-automanage \
python313-azure-mgmt-automation \
python313-azure-mgmt-avs \
python313-azure-mgmt-azureadb2c \
python313-azure-mgmt-azurearcdata \
python313-azure-mgmt-azurestack \
python313-azure-mgmt-azurestackhci \
python313-azure-mgmt-azurestackhcivm \
python313-azure-mgmt-baremetalinfrastructure \
python313-azure-mgmt-batch \
python313-azure-mgmt-batchai \
python313-azure-mgmt-billing \
python313-azure-mgmt-billingbenefits \
python313-azure-mgmt-botservice \
python313-azure-mgmt-carbonoptimization \
python313-azure-mgmt-cdn \
python313-azure-mgmt-chaos \
python313-azure-mgmt-cloudhealth \
python313-azure-mgmt-cognitiveservices \
python313-azure-mgmt-commerce \
python313-azure-mgmt-communication \
python313-azure-mgmt-compute \
python313-azure-mgmt-computefleet \
python313-azure-mgmt-computerecommender \
python313-azure-mgmt-computeschedule \
python313-azure-mgmt-confidentialledger \
python313-azure-mgmt-confluent \
python313-azure-mgmt-connectedcache \
python313-azure-mgmt-connectedvmware \
python313-azure-mgmt-consumption \
python313-azure-mgmt-containerinstance \
python313-azure-mgmt-containerorchestratorruntime \
python313-azure-mgmt-containerregistry \
python313-azure-mgmt-containerservice \
python313-azure-mgmt-containerservicefleet \
python313-azure-mgmt-containerservicesafeguards \
python313-azure-mgmt-core \
python313-azure-mgmt-cosmosdb \
python313-azure-mgmt-cosmosdbforpostgresql \
python313-azure-mgmt-costmanagement \
python313-azure-mgmt-customproviders \
python313-azure-mgmt-dashboard \
python313-azure-mgmt-databasewatcher \
python313-azure-mgmt-databox \
python313-azure-mgmt-databoxedge \
python313-azure-mgmt-databricks \
python313-azure-mgmt-datadog \
python313-azure-mgmt-datafactory \
python313-azure-mgmt-datalake-analytics \
python313-azure-mgmt-datalake-nspkg \
python313-azure-mgmt-datalake-store \
python313-azure-mgmt-datamigration \
python313-azure-mgmt-dataprotection \
python313-azure-mgmt-datashare \
python313-azure-mgmt-defendereasm \
python313-azure-mgmt-dependencymap \
python313-azure-mgmt-deploymentmanager \
python313-azure-mgmt-desktopvirtualization \
python313-azure-mgmt-devcenter \
python313-azure-mgmt-devhub \
python313-azure-mgmt-deviceregistry \
python313-azure-mgmt-deviceupdate \
python313-azure-mgmt-devopsinfrastructure \
python313-azure-mgmt-devspaces \
python313-azure-mgmt-devtestlabs \
python313-azure-mgmt-digitaltwins \
python313-azure-mgmt-dns \
python313-azure-mgmt-dnsresolver \
python313-azure-mgmt-durabletask \
python313-azure-mgmt-dynatrace \
python313-azure-mgmt-edgegateway \
python313-azure-mgmt-edgeorder \
python313-azure-mgmt-edgezones \
python313-azure-mgmt-education \
python313-azure-mgmt-elastic \
python313-azure-mgmt-elasticsan \
python313-azure-mgmt-eventgrid \
python313-azure-mgmt-eventhub \
python313-azure-mgmt-extendedlocation \
python313-azure-mgmt-fabric \
python313-azure-mgmt-fluidrelay \
python313-azure-mgmt-frontdoor \
python313-azure-mgmt-graphservices \
python313-azure-mgmt-guestconfig \
python313-azure-mgmt-hanaonazure \
python313-azure-mgmt-hardwaresecuritymodules \
python313-azure-mgmt-hdinsight \
python313-azure-mgmt-hdinsightcontainers \
python313-azure-mgmt-healthcareapis \
python313-azure-mgmt-healthdataaiservices \
python313-azure-mgmt-hybridcompute \
python313-azure-mgmt-hybridconnectivity \
python313-azure-mgmt-hybridcontainerservice \
python313-azure-mgmt-hybridkubernetes \
python313-azure-mgmt-hybridnetwork \
python313-azure-mgmt-imagebuilder \
python313-azure-mgmt-impactreporting \
python313-azure-mgmt-informaticadatamanagement \
python313-azure-mgmt-iotcentral \
python313-azure-mgmt-iotfirmwaredefense \
python313-azure-mgmt-iothub \
python313-azure-mgmt-iothubprovisioningservices \
python313-azure-mgmt-iotoperations \
python313-azure-mgmt-keyvault \
python313-azure-mgmt-kubernetesconfiguration \
python313-azure-mgmt-kubernetesconfiguration-extensions \
python313-azure-mgmt-kubernetesconfiguration-extensiontypes \
python313-azure-mgmt-kubernetesconfiguration-fluxconfigurations \
python313-azure-mgmt-kusto \
python313-azure-mgmt-labservices \
python313-azure-mgmt-lambdatesthyperexecute \
python313-azure-mgmt-largeinstance \
python313-azure-mgmt-loadtesting \
python313-azure-mgmt-loadtestservice \
python313-azure-mgmt-loganalytics \
python313-azure-mgmt-logic \
python313-azure-mgmt-logz \
python313-azure-mgmt-machinelearningcompute \
python313-azure-mgmt-machinelearningservices \
python313-azure-mgmt-maintenance \
python313-azure-mgmt-managedapplications \
python313-azure-mgmt-managednetworkfabric \
python313-azure-mgmt-managedservices \
python313-azure-mgmt-managementgroups \
python313-azure-mgmt-managementpartner \
python313-azure-mgmt-maps \
python313-azure-mgmt-marketplaceordering \
python313-azure-mgmt-media \
python313-azure-mgmt-migrationassessment \
python313-azure-mgmt-migrationdiscoverysap \
python313-azure-mgmt-mixedreality \
python313-azure-mgmt-mobilenetwork \
python313-azure-mgmt-mongodbatlas \
python313-azure-mgmt-monitor \
python313-azure-mgmt-msi \
python313-azure-mgmt-mysqlflexibleservers \
python313-azure-mgmt-neonpostgres \
python313-azure-mgmt-netapp \
python313-azure-mgmt-network \
python313-azure-mgmt-networkanalytics \
python313-azure-mgmt-networkcloud \
python313-azure-mgmt-networkfunction \
python313-azure-mgmt-newrelicobservability \
python313-azure-mgmt-nginx \
python313-azure-mgmt-notificationhubs \
python313-azure-mgmt-nspkg \
python313-azure-mgmt-oep \
python313-azure-mgmt-onlineexperimentation \
python313-azure-mgmt-oracledatabase \
python313-azure-mgmt-orbital \
python313-azure-mgmt-paloaltonetworksngfw \
python313-azure-mgmt-peering \
python313-azure-mgmt-pineconevectordb \
python313-azure-mgmt-planetarycomputer \
python313-azure-mgmt-playwright \
python313-azure-mgmt-playwrighttesting \
python313-azure-mgmt-policyinsights \
python313-azure-mgmt-portal \
python313-azure-mgmt-portalservicescopilot \
python313-azure-mgmt-postgresqlflexibleservers \
python313-azure-mgmt-powerbidedicated \
python313-azure-mgmt-powerbiembedded \
python313-azure-mgmt-privatedns \
python313-azure-mgmt-purestorageblock \
python313-azure-mgmt-purview \
python313-azure-mgmt-quantum \
python313-azure-mgmt-qumulo \
python313-azure-mgmt-quota \
python313-azure-mgmt-rdbms \
python313-azure-mgmt-recoveryservices \
python313-azure-mgmt-recoveryservicesbackup \
python313-azure-mgmt-recoveryservicesdatareplication \
python313-azure-mgmt-recoveryservicessiterecovery \
python313-azure-mgmt-redhatopenshift \
python313-azure-mgmt-redis \
python313-azure-mgmt-redisenterprise \
python313-azure-mgmt-regionmove \
python313-azure-mgmt-relay \
python313-azure-mgmt-reservations \
python313-azure-mgmt-resource \
python313-azure-mgmt-resource-bicep \
python313-azure-mgmt-resourceconnector \
python313-azure-mgmt-resourcegraph \
python313-azure-mgmt-resourcehealth \
python313-azure-mgmt-resourcemover \
python313-azure-mgmt-scheduler \
python313-azure-mgmt-scvmm \
python313-azure-mgmt-search \
python313-azure-mgmt-security \
python313-azure-mgmt-securitydevops \
python313-azure-mgmt-securityinsight \
python313-azure-mgmt-selfhelp \
python313-azure-mgmt-serialconsole \
python313-azure-mgmt-servermanager \
python313-azure-mgmt-servicebus \
python313-azure-mgmt-servicefabric \
python313-azure-mgmt-servicefabricmanagedclusters \
python313-azure-mgmt-servicelinker \
python313-azure-mgmt-servicenetworking \
python313-azure-mgmt-signalr \
python313-azure-mgmt-sitemanager \
python313-azure-mgmt-sphere \
python313-azure-mgmt-springappdiscovery \
python313-azure-mgmt-sql \
python313-azure-mgmt-sqlvirtualmachine \
python313-azure-mgmt-standbypool \
python313-azure-mgmt-storage \
python313-azure-mgmt-storageactions \
python313-azure-mgmt-storagecache \
python313-azure-mgmt-storagediscovery \
python313-azure-mgmt-storageimportexport \
python313-azure-mgmt-storagemover \
python313-azure-mgmt-storagepool \
python313-azure-mgmt-storagesync \
python313-azure-mgmt-streamanalytics \
python313-azure-mgmt-subscription \
python313-azure-mgmt-support \
python313-azure-mgmt-synapse \
python313-azure-mgmt-terraform \
python313-azure-mgmt-testbase \
python313-azure-mgmt-timeseriesinsights \
python313-azure-mgmt-trafficmanager \
python313-azure-mgmt-trustedsigning \
python313-azure-mgmt-videoanalyzer \
python313-azure-mgmt-vmwarecloudsimple \
python313-azure-mgmt-voiceservices \
python313-azure-mgmt-web \
python313-azure-mgmt-webpubsub \
python313-azure-mgmt-weightsandbiases \
python313-azure-mgmt-workloadmonitor \
python313-azure-mgmt-workloadorchestration \
python313-azure-mgmt-workloads \
python313-azure-mgmt-workloadssapvirtualinstance"

inherit rpm
