SUMMARY = "The go-to CLI tool for Kubewarden users"
DESCRIPTION = "kwctl is the go-to CLI tool for Kubewarden users. \
 \
Think of it as the docker CLI tool if you were working with containers. \
 \
As a policy author \
- e2e testing of your policy. Test your policy against crafted Kubernetes \
  requests, and ensure your policy behaves as you expect. You can even test \
  context-aware policies, that require access to a running cluster. \
- Embed metadata in your Wasm module, so the binary is annotated with the \
  permissions it needs to execute. \
- Publish policies to OCI registries. \
- Generate initial ClusterAdmissionPolicy scaffolding for your policy. \
 \
As a cluster administrator \
- Inspect remote policies. Given a policy in an OCI registry, or in an HTTP \
  server, show all static information about the policy. \
- Dry-run of a policy in your cluster. Test the policy against crafted \
  Kubernetes requests, and ensure the policy behaves as you expect given the \
  input data you provide. You can even test context-aware policies, that \
  require access to a running cluster, also in a dry-run mode. \
- Generate ClusterAdmissionPolicy scaffolding for a given policy."
LICENSE = "Apache-2.0"

PV = "1.31.0"

RPM_NAME = "kwctl-1.31.0-1.7.aarch64.rpm"
RPM_HASH = "950623a0dabb25d0541e0ff57f7cebbe5e866605573cc0639fd1a9b7d0a29bdf80fc27f443e8208f80f6ad473633ff99ceebeed2e072b4ee87806c77c0692e4a"

RPROVIDES:${PN} += "bundled-rust-crate-addr2line \
bundled-rust-crate-adler2 \
bundled-rust-crate-aead \
bundled-rust-crate-aes \
bundled-rust-crate-ahash \
bundled-rust-crate-aho-corasick \
bundled-rust-crate-allocator-api2 \
bundled-rust-crate-ambient-authority \
bundled-rust-crate-anstream \
bundled-rust-crate-anstyle \
bundled-rust-crate-anstyle-parse \
bundled-rust-crate-anstyle-query \
bundled-rust-crate-anyhow \
bundled-rust-crate-arbitrary \
bundled-rust-crate-asn1-rs \
bundled-rust-crate-asn1-rs-derive \
bundled-rust-crate-asn1-rs-impl \
bundled-rust-crate-async-broadcast \
bundled-rust-crate-async-recursion \
bundled-rust-crate-async-stream \
bundled-rust-crate-async-stream-impl \
bundled-rust-crate-async-trait \
bundled-rust-crate-atomic-waker \
bundled-rust-crate-autocfg \
bundled-rust-crate-aws-lc-fips-sys \
bundled-rust-crate-aws-lc-rs \
bundled-rust-crate-aws-lc-sys \
bundled-rust-crate-backon \
bundled-rust-crate-base16ct \
bundled-rust-crate-base64 \
bundled-rust-crate-base64ct \
bundled-rust-crate-bindgen \
bundled-rust-crate-bitflags \
bundled-rust-crate-block-buffer \
bundled-rust-crate-block-padding \
bundled-rust-crate-bstr \
bundled-rust-crate-bumpalo \
bundled-rust-crate-burrego \
bundled-rust-crate-byteorder \
bundled-rust-crate-bytes \
bundled-rust-crate-cached \
bundled-rust-crate-cached-proc-macro \
bundled-rust-crate-cached-proc-macro-types \
bundled-rust-crate-cap-fs-ext \
bundled-rust-crate-cap-net-ext \
bundled-rust-crate-cap-primitives \
bundled-rust-crate-cap-rand \
bundled-rust-crate-cap-std \
bundled-rust-crate-cap-time-ext \
bundled-rust-crate-cbc \
bundled-rust-crate-cc \
bundled-rust-crate-cexpr \
bundled-rust-crate-cfg-aliases \
bundled-rust-crate-cfg-if \
bundled-rust-crate-chrono \
bundled-rust-crate-chrono-tz \
bundled-rust-crate-cipher \
bundled-rust-crate-clang-sys \
bundled-rust-crate-clap \
bundled-rust-crate-clap-builder \
bundled-rust-crate-clap-complete \
bundled-rust-crate-clap-lex \
bundled-rust-crate-clap-markdown \
bundled-rust-crate-cmake \
bundled-rust-crate-cobs \
bundled-rust-crate-color-print \
bundled-rust-crate-color-print-proc-macro \
bundled-rust-crate-colorchoice \
bundled-rust-crate-concurrent-queue \
bundled-rust-crate-console \
bundled-rust-crate-const-format \
bundled-rust-crate-const-format-proc-macros \
bundled-rust-crate-const-oid \
bundled-rust-crate-const-random \
bundled-rust-crate-const-random-macro \
bundled-rust-crate-convert-case \
bundled-rust-crate-coolor \
bundled-rust-crate-cpp-demangle \
bundled-rust-crate-cpufeatures \
bundled-rust-crate-cranelift-assembler-x64 \
bundled-rust-crate-cranelift-assembler-x64-meta \
bundled-rust-crate-cranelift-bforest \
bundled-rust-crate-cranelift-bitset \
bundled-rust-crate-cranelift-codegen \
bundled-rust-crate-cranelift-codegen-meta \
bundled-rust-crate-cranelift-codegen-shared \
bundled-rust-crate-cranelift-control \
bundled-rust-crate-cranelift-entity \
bundled-rust-crate-cranelift-frontend \
bundled-rust-crate-cranelift-isle \
bundled-rust-crate-cranelift-native \
bundled-rust-crate-cranelift-srcgen \
bundled-rust-crate-crc32fast \
bundled-rust-crate-crokey \
bundled-rust-crate-crokey-proc-macros \
bundled-rust-crate-crossbeam \
bundled-rust-crate-crossbeam-channel \
bundled-rust-crate-crossbeam-deque \
bundled-rust-crate-crossbeam-epoch \
bundled-rust-crate-crossbeam-queue \
bundled-rust-crate-crossbeam-utils \
bundled-rust-crate-crossterm \
bundled-rust-crate-crunchy \
bundled-rust-crate-crypto-bigint \
bundled-rust-crate-crypto-common \
bundled-rust-crate-crypto-secretbox \
bundled-rust-crate-csv \
bundled-rust-crate-csv-core \
bundled-rust-crate-curve25519-dalek \
bundled-rust-crate-darling \
bundled-rust-crate-darling-core \
bundled-rust-crate-darling-macro \
bundled-rust-crate-data-encoding \
bundled-rust-crate-debugid \
bundled-rust-crate-der \
bundled-rust-crate-der-derive \
bundled-rust-crate-der-parser \
bundled-rust-crate-deranged \
bundled-rust-crate-derive-builder \
bundled-rust-crate-derive-builder-core \
bundled-rust-crate-derive-builder-macro \
bundled-rust-crate-derive-more \
bundled-rust-crate-derive-more-impl \
bundled-rust-crate-digest \
bundled-rust-crate-directories \
bundled-rust-crate-directories-next \
bundled-rust-crate-dirs-next \
bundled-rust-crate-dirs-sys \
bundled-rust-crate-dirs-sys-next \
bundled-rust-crate-displaydoc \
bundled-rust-crate-dns-lookup \
bundled-rust-crate-docker-credential \
bundled-rust-crate-document-features \
bundled-rust-crate-dunce \
bundled-rust-crate-dyn-clone \
bundled-rust-crate-ecdsa \
bundled-rust-crate-ed25519 \
bundled-rust-crate-ed25519-dalek \
bundled-rust-crate-educe \
bundled-rust-crate-either \
bundled-rust-crate-elliptic-curve \
bundled-rust-crate-email-address \
bundled-rust-crate-embedded-io \
bundled-rust-crate-encode-unicode \
bundled-rust-crate-encoding-rs \
bundled-rust-crate-enum-ordinalize \
bundled-rust-crate-enum-ordinalize-derive \
bundled-rust-crate-env-home \
bundled-rust-crate-equivalent \
bundled-rust-crate-errno \
bundled-rust-crate-event-listener \
bundled-rust-crate-event-listener-strategy \
bundled-rust-crate-fallible-iterator \
bundled-rust-crate-fastrand \
bundled-rust-crate-ff \
bundled-rust-crate-filetime \
bundled-rust-crate-find-msvc-tools \
bundled-rust-crate-fixedbitset \
bundled-rust-crate-flagset \
bundled-rust-crate-flate2 \
bundled-rust-crate-fnv \
bundled-rust-crate-foldhash \
bundled-rust-crate-form-urlencoded \
bundled-rust-crate-fs-extra \
bundled-rust-crate-fs-set-times \
bundled-rust-crate-futures \
bundled-rust-crate-futures-channel \
bundled-rust-crate-futures-core \
bundled-rust-crate-futures-executor \
bundled-rust-crate-futures-io \
bundled-rust-crate-futures-macro \
bundled-rust-crate-futures-sink \
bundled-rust-crate-futures-task \
bundled-rust-crate-futures-util \
bundled-rust-crate-fxprof-processed-profile \
bundled-rust-crate-generic-array \
bundled-rust-crate-getrandom \
bundled-rust-crate-getset \
bundled-rust-crate-gimli \
bundled-rust-crate-glob \
bundled-rust-crate-globset \
bundled-rust-crate-group \
bundled-rust-crate-gtmpl \
bundled-rust-crate-gtmpl-value \
bundled-rust-crate-h2 \
bundled-rust-crate-hashbrown \
bundled-rust-crate-hashify \
bundled-rust-crate-heck \
bundled-rust-crate-hex \
bundled-rust-crate-hkdf \
bundled-rust-crate-hmac \
bundled-rust-crate-home \
bundled-rust-crate-hostname \
bundled-rust-crate-hostname-validator \
bundled-rust-crate-http \
bundled-rust-crate-http-auth \
bundled-rust-crate-http-body \
bundled-rust-crate-http-body-util \
bundled-rust-crate-httparse \
bundled-rust-crate-httpdate \
bundled-rust-crate-humansize \
bundled-rust-crate-hyper \
bundled-rust-crate-hyper-rustls \
bundled-rust-crate-hyper-timeout \
bundled-rust-crate-hyper-util \
bundled-rust-crate-iana-time-zone \
bundled-rust-crate-icu-collections \
bundled-rust-crate-icu-locale-core \
bundled-rust-crate-icu-normalizer \
bundled-rust-crate-icu-normalizer-data \
bundled-rust-crate-icu-properties \
bundled-rust-crate-icu-properties-data \
bundled-rust-crate-icu-provider \
bundled-rust-crate-id-arena \
bundled-rust-crate-ident-case \
bundled-rust-crate-idna \
bundled-rust-crate-idna-adapter \
bundled-rust-crate-indexmap \
bundled-rust-crate-indicatif \
bundled-rust-crate-inout \
bundled-rust-crate-io-extras \
bundled-rust-crate-io-lifetimes \
bundled-rust-crate-ipnet \
bundled-rust-crate-iri-string \
bundled-rust-crate-is-terminal \
bundled-rust-crate-is-terminal-polyfill \
bundled-rust-crate-itertools \
bundled-rust-crate-itoa \
bundled-rust-crate-jobserver \
bundled-rust-crate-json-patch \
bundled-rust-crate-jsonpath-rust \
bundled-rust-crate-jsonptr \
bundled-rust-crate-jwt \
bundled-rust-crate-k8s-openapi \
bundled-rust-crate-k8s-openapi-codegen-common \
bundled-rust-crate-k8s-openapi-derive \
bundled-rust-crate-kube \
bundled-rust-crate-kube-client \
bundled-rust-crate-kube-core \
bundled-rust-crate-kube-runtime \
bundled-rust-crate-kubewarden-policy-sdk \
bundled-rust-crate-kwctl \
bundled-rust-crate-lazy-regex \
bundled-rust-crate-lazy-regex-proc-macros \
bundled-rust-crate-lazy-static \
bundled-rust-crate-lazycell \
bundled-rust-crate-leb128 \
bundled-rust-crate-leb128fmt \
bundled-rust-crate-libc \
bundled-rust-crate-libloading \
bundled-rust-crate-libm \
bundled-rust-crate-linux-raw-sys \
bundled-rust-crate-litemap \
bundled-rust-crate-litrs \
bundled-rust-crate-lock-api \
bundled-rust-crate-log \
bundled-rust-crate-lru-slab \
bundled-rust-crate-mail-parser \
bundled-rust-crate-matchers \
bundled-rust-crate-maybe-owned \
bundled-rust-crate-memchr \
bundled-rust-crate-memfd \
bundled-rust-crate-mime \
bundled-rust-crate-mime-guess \
bundled-rust-crate-minimad \
bundled-rust-crate-minimal-lexical \
bundled-rust-crate-miniz-oxide \
bundled-rust-crate-mio \
bundled-rust-crate-multimap \
bundled-rust-crate-no-std-compat \
bundled-rust-crate-nom \
bundled-rust-crate-nu-ansi-term \
bundled-rust-crate-num \
bundled-rust-crate-num-bigint \
bundled-rust-crate-num-bigint-dig \
bundled-rust-crate-num-complex \
bundled-rust-crate-num-conv \
bundled-rust-crate-num-derive \
bundled-rust-crate-num-integer \
bundled-rust-crate-num-iter \
bundled-rust-crate-num-rational \
bundled-rust-crate-num-traits \
bundled-rust-crate-oauth2 \
bundled-rust-crate-object \
bundled-rust-crate-oci-client \
bundled-rust-crate-oci-spec \
bundled-rust-crate-oid-registry \
bundled-rust-crate-olpc-cjson \
bundled-rust-crate-once-cell \
bundled-rust-crate-opaque-debug \
bundled-rust-crate-openidconnect \
bundled-rust-crate-openssl-probe \
bundled-rust-crate-option-ext \
bundled-rust-crate-ordered-float \
bundled-rust-crate-p256 \
bundled-rust-crate-p384 \
bundled-rust-crate-parking \
bundled-rust-crate-parking-lot \
bundled-rust-crate-parking-lot-core \
bundled-rust-crate-password-hash \
bundled-rust-crate-path-slash \
bundled-rust-crate-pbkdf2 \
bundled-rust-crate-pem \
bundled-rust-crate-pem-rfc7468 \
bundled-rust-crate-percent-encoding \
bundled-rust-crate-pest \
bundled-rust-crate-pest-derive \
bundled-rust-crate-pest-generator \
bundled-rust-crate-pest-meta \
bundled-rust-crate-petgraph \
bundled-rust-crate-phf \
bundled-rust-crate-phf-shared \
bundled-rust-crate-pin-project \
bundled-rust-crate-pin-project-internal \
bundled-rust-crate-pin-project-lite \
bundled-rust-crate-pin-utils \
bundled-rust-crate-pkcs1 \
bundled-rust-crate-pkcs5 \
bundled-rust-crate-pkcs8 \
bundled-rust-crate-pkg-config \
bundled-rust-crate-policy-evaluator \
bundled-rust-crate-policy-fetcher \
bundled-rust-crate-poly1305 \
bundled-rust-crate-portable-atomic \
bundled-rust-crate-postcard \
bundled-rust-crate-potential-utf \
bundled-rust-crate-powerfmt \
bundled-rust-crate-ppv-lite86 \
bundled-rust-crate-prettyplease \
bundled-rust-crate-prettytable-rs \
bundled-rust-crate-primeorder \
bundled-rust-crate-proc-macro-error-attr2 \
bundled-rust-crate-proc-macro-error2 \
bundled-rust-crate-proc-macro2 \
bundled-rust-crate-prost \
bundled-rust-crate-prost-build \
bundled-rust-crate-prost-derive \
bundled-rust-crate-prost-reflect \
bundled-rust-crate-prost-reflect-build \
bundled-rust-crate-prost-reflect-derive \
bundled-rust-crate-prost-types \
bundled-rust-crate-pulley-interpreter \
bundled-rust-crate-pulley-macros \
bundled-rust-crate-quinn \
bundled-rust-crate-quinn-proto \
bundled-rust-crate-quinn-udp \
bundled-rust-crate-quote \
bundled-rust-crate-rand \
bundled-rust-crate-rand-chacha \
bundled-rust-crate-rand-core \
bundled-rust-crate-rayon \
bundled-rust-crate-rayon-core \
bundled-rust-crate-ref-cast \
bundled-rust-crate-ref-cast-impl \
bundled-rust-crate-regalloc2 \
bundled-rust-crate-regex \
bundled-rust-crate-regex-automata \
bundled-rust-crate-regex-syntax \
bundled-rust-crate-reqwest \
bundled-rust-crate-rfc6979 \
bundled-rust-crate-rhai \
bundled-rust-crate-rhai-codegen \
bundled-rust-crate-ring \
bundled-rust-crate-rsa \
bundled-rust-crate-rustc-demangle \
bundled-rust-crate-rustc-hash \
bundled-rust-crate-rustc-version \
bundled-rust-crate-rusticata-macros \
bundled-rust-crate-rustix \
bundled-rust-crate-rustix-linux-procfs \
bundled-rust-crate-rustls \
bundled-rust-crate-rustls-native-certs \
bundled-rust-crate-rustls-pki-types \
bundled-rust-crate-rustls-webpki \
bundled-rust-crate-ryu \
bundled-rust-crate-salsa20 \
bundled-rust-crate-same-file \
bundled-rust-crate-schemars \
bundled-rust-crate-schemars-derive \
bundled-rust-crate-scopeguard \
bundled-rust-crate-scrypt \
bundled-rust-crate-sec1 \
bundled-rust-crate-secrecy \
bundled-rust-crate-semver \
bundled-rust-crate-serde \
bundled-rust-crate-serde-bytes \
bundled-rust-crate-serde-core \
bundled-rust-crate-serde-derive \
bundled-rust-crate-serde-derive-internals \
bundled-rust-crate-serde-json \
bundled-rust-crate-serde-path-to-error \
bundled-rust-crate-serde-plain \
bundled-rust-crate-serde-spanned \
bundled-rust-crate-serde-urlencoded \
bundled-rust-crate-serde-value \
bundled-rust-crate-serde-with \
bundled-rust-crate-serde-with-macros \
bundled-rust-crate-serde-yaml \
bundled-rust-crate-sha1 \
bundled-rust-crate-sha2 \
bundled-rust-crate-sharded-slab \
bundled-rust-crate-shlex \
bundled-rust-crate-signal-hook \
bundled-rust-crate-signal-hook-mio \
bundled-rust-crate-signal-hook-registry \
bundled-rust-crate-signature \
bundled-rust-crate-sigstore \
bundled-rust-crate-sigstore-protobuf-specs \
bundled-rust-crate-sigstore-protobuf-specs-derive \
bundled-rust-crate-simd-adler32 \
bundled-rust-crate-siphasher \
bundled-rust-crate-slab \
bundled-rust-crate-slog \
bundled-rust-crate-smallvec \
bundled-rust-crate-smartstring \
bundled-rust-crate-snafu \
bundled-rust-crate-snafu-derive \
bundled-rust-crate-socket2 \
bundled-rust-crate-spin \
bundled-rust-crate-spki \
bundled-rust-crate-stable-deref-trait \
bundled-rust-crate-static-assertions \
bundled-rust-crate-strict \
bundled-rust-crate-strsim \
bundled-rust-crate-strum \
bundled-rust-crate-strum-macros \
bundled-rust-crate-subtle \
bundled-rust-crate-syn \
bundled-rust-crate-sync-wrapper \
bundled-rust-crate-synstructure \
bundled-rust-crate-system-interface \
bundled-rust-crate-tar \
bundled-rust-crate-target-lexicon \
bundled-rust-crate-tempfile \
bundled-rust-crate-term \
bundled-rust-crate-termcolor \
bundled-rust-crate-termimad \
bundled-rust-crate-thin-vec \
bundled-rust-crate-thiserror \
bundled-rust-crate-thiserror-impl \
bundled-rust-crate-thread-local \
bundled-rust-crate-time \
bundled-rust-crate-time-core \
bundled-rust-crate-time-macros \
bundled-rust-crate-tiny-bench \
bundled-rust-crate-tiny-keccak \
bundled-rust-crate-tinystr \
bundled-rust-crate-tinyvec \
bundled-rust-crate-tinyvec-macros \
bundled-rust-crate-tls-codec \
bundled-rust-crate-tls-codec-derive \
bundled-rust-crate-tokio \
bundled-rust-crate-tokio-macros \
bundled-rust-crate-tokio-rustls \
bundled-rust-crate-tokio-util \
bundled-rust-crate-toml \
bundled-rust-crate-toml-datetime \
bundled-rust-crate-toml-edit \
bundled-rust-crate-toml-write \
bundled-rust-crate-tough \
bundled-rust-crate-tower \
bundled-rust-crate-tower-http \
bundled-rust-crate-tower-layer \
bundled-rust-crate-tower-service \
bundled-rust-crate-tracing \
bundled-rust-crate-tracing-attributes \
bundled-rust-crate-tracing-core \
bundled-rust-crate-tracing-log \
bundled-rust-crate-tracing-subscriber \
bundled-rust-crate-try-lock \
bundled-rust-crate-typed-path \
bundled-rust-crate-typenum \
bundled-rust-crate-ucd-trie \
bundled-rust-crate-unicase \
bundled-rust-crate-unicode-ident \
bundled-rust-crate-unicode-normalization \
bundled-rust-crate-unicode-segmentation \
bundled-rust-crate-unicode-width \
bundled-rust-crate-unicode-xid \
bundled-rust-crate-unit-prefix \
bundled-rust-crate-universal-hash \
bundled-rust-crate-unsafe-libyaml \
bundled-rust-crate-untrusted \
bundled-rust-crate-url \
bundled-rust-crate-utf8-iter \
bundled-rust-crate-utf8parse \
bundled-rust-crate-uuid \
bundled-rust-crate-validator \
bundled-rust-crate-validator-derive \
bundled-rust-crate-version-check \
bundled-rust-crate-walkdir \
bundled-rust-crate-walrus \
bundled-rust-crate-walrus-macro \
bundled-rust-crate-want \
bundled-rust-crate-wapc \
bundled-rust-crate-wapc-guest \
bundled-rust-crate-wasi-common \
bundled-rust-crate-wasm-encoder \
bundled-rust-crate-wasmparser \
bundled-rust-crate-wasmprinter \
bundled-rust-crate-wasmtime \
bundled-rust-crate-wasmtime-environ \
bundled-rust-crate-wasmtime-internal-cache \
bundled-rust-crate-wasmtime-internal-component-macro \
bundled-rust-crate-wasmtime-internal-component-util \
bundled-rust-crate-wasmtime-internal-cranelift \
bundled-rust-crate-wasmtime-internal-fiber \
bundled-rust-crate-wasmtime-internal-jit-debug \
bundled-rust-crate-wasmtime-internal-jit-icache-coherence \
bundled-rust-crate-wasmtime-internal-math \
bundled-rust-crate-wasmtime-internal-slab \
bundled-rust-crate-wasmtime-internal-unwinder \
bundled-rust-crate-wasmtime-internal-versioned-export-macros \
bundled-rust-crate-wasmtime-internal-winch \
bundled-rust-crate-wasmtime-internal-wit-bindgen \
bundled-rust-crate-wasmtime-provider \
bundled-rust-crate-wasmtime-wasi \
bundled-rust-crate-wasmtime-wasi-io \
bundled-rust-crate-wast \
bundled-rust-crate-wat \
bundled-rust-crate-web-time \
bundled-rust-crate-webpki-roots \
bundled-rust-crate-which \
bundled-rust-crate-wiggle \
bundled-rust-crate-wiggle-generate \
bundled-rust-crate-wiggle-macro \
bundled-rust-crate-winch-codegen \
bundled-rust-crate-winnow \
bundled-rust-crate-wit-parser \
bundled-rust-crate-witx \
bundled-rust-crate-writeable \
bundled-rust-crate-x509-cert \
bundled-rust-crate-x509-parser \
bundled-rust-crate-xattr \
bundled-rust-crate-yoke \
bundled-rust-crate-yoke-derive \
bundled-rust-crate-zerocopy \
bundled-rust-crate-zerofrom \
bundled-rust-crate-zerofrom-derive \
bundled-rust-crate-zeroize \
bundled-rust-crate-zeroize-derive \
bundled-rust-crate-zerotrie \
bundled-rust-crate-zerovec \
bundled-rust-crate-zerovec-derive \
bundled-rust-crate-zstd \
bundled-rust-crate-zstd-safe \
bundled-rust-crate-zstd-sys \
kwctl"

RDEPENDS:${PN} += "libc.so.6 \
libgcc-s.so.1 \
libm.so.6"

inherit rpm
