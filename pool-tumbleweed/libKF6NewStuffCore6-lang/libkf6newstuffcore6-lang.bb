SUMMARY = "Translations for package libKF6NewStuffCore6"
DESCRIPTION = "Provides translations for the 'libKF6NewStuffCore6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6NewStuffCore6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "5ef915a01c1bcb5f35e61cafd0c3d094ba8787a4c8e2b1629a2864e243a14636ce414d180f6006d9799b00a87d3a4145c8d20bbe2dd7fb1ff66c4e3000d2a647"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6NewStuffCore6-lang \
libKF6NewStuffCore6-lang-all \
locale-libKF6NewStuffCore6-af \
locale-libKF6NewStuffCore6-ar \
locale-libKF6NewStuffCore6-as \
locale-libKF6NewStuffCore6-ast \
locale-libKF6NewStuffCore6-az \
locale-libKF6NewStuffCore6-be \
locale-libKF6NewStuffCore6-be@latin \
locale-libKF6NewStuffCore6-bg \
locale-libKF6NewStuffCore6-bn \
locale-libKF6NewStuffCore6-bn-IN \
locale-libKF6NewStuffCore6-br \
locale-libKF6NewStuffCore6-bs \
locale-libKF6NewStuffCore6-ca \
locale-libKF6NewStuffCore6-ca@valencia \
locale-libKF6NewStuffCore6-cs \
locale-libKF6NewStuffCore6-cy \
locale-libKF6NewStuffCore6-da \
locale-libKF6NewStuffCore6-de \
locale-libKF6NewStuffCore6-el \
locale-libKF6NewStuffCore6-en-GB \
locale-libKF6NewStuffCore6-eo \
locale-libKF6NewStuffCore6-es \
locale-libKF6NewStuffCore6-et \
locale-libKF6NewStuffCore6-eu \
locale-libKF6NewStuffCore6-fa \
locale-libKF6NewStuffCore6-fi \
locale-libKF6NewStuffCore6-fr \
locale-libKF6NewStuffCore6-ga \
locale-libKF6NewStuffCore6-gd \
locale-libKF6NewStuffCore6-gl \
locale-libKF6NewStuffCore6-gu \
locale-libKF6NewStuffCore6-he \
locale-libKF6NewStuffCore6-hi \
locale-libKF6NewStuffCore6-hr \
locale-libKF6NewStuffCore6-hu \
locale-libKF6NewStuffCore6-ia \
locale-libKF6NewStuffCore6-id \
locale-libKF6NewStuffCore6-is \
locale-libKF6NewStuffCore6-it \
locale-libKF6NewStuffCore6-ja \
locale-libKF6NewStuffCore6-ka \
locale-libKF6NewStuffCore6-kk \
locale-libKF6NewStuffCore6-km \
locale-libKF6NewStuffCore6-kn \
locale-libKF6NewStuffCore6-ko \
locale-libKF6NewStuffCore6-lt \
locale-libKF6NewStuffCore6-lv \
locale-libKF6NewStuffCore6-mai \
locale-libKF6NewStuffCore6-mk \
locale-libKF6NewStuffCore6-ml \
locale-libKF6NewStuffCore6-mr \
locale-libKF6NewStuffCore6-ms \
locale-libKF6NewStuffCore6-nb \
locale-libKF6NewStuffCore6-nds \
locale-libKF6NewStuffCore6-ne \
locale-libKF6NewStuffCore6-nl \
locale-libKF6NewStuffCore6-nn \
locale-libKF6NewStuffCore6-oc \
locale-libKF6NewStuffCore6-or \
locale-libKF6NewStuffCore6-pa \
locale-libKF6NewStuffCore6-pl \
locale-libKF6NewStuffCore6-pt \
locale-libKF6NewStuffCore6-pt-BR \
locale-libKF6NewStuffCore6-ro \
locale-libKF6NewStuffCore6-ru \
locale-libKF6NewStuffCore6-si \
locale-libKF6NewStuffCore6-sk \
locale-libKF6NewStuffCore6-sl \
locale-libKF6NewStuffCore6-sq \
locale-libKF6NewStuffCore6-sr \
locale-libKF6NewStuffCore6-sr@ijekavian \
locale-libKF6NewStuffCore6-sr@ijekavianlatin \
locale-libKF6NewStuffCore6-sr@latin \
locale-libKF6NewStuffCore6-sv \
locale-libKF6NewStuffCore6-ta \
locale-libKF6NewStuffCore6-te \
locale-libKF6NewStuffCore6-th \
locale-libKF6NewStuffCore6-tr \
locale-libKF6NewStuffCore6-ug \
locale-libKF6NewStuffCore6-uk \
locale-libKF6NewStuffCore6-vi \
locale-libKF6NewStuffCore6-wa \
locale-libKF6NewStuffCore6-zh-CN \
locale-libKF6NewStuffCore6-zh-HK \
locale-libKF6NewStuffCore6-zh-TW"

RDEPENDS:${PN} += "libKF6NewStuffCore6"

inherit rpm
