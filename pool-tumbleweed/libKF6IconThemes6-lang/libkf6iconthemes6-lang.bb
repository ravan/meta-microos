SUMMARY = "Translations for package libKF6IconThemes6"
DESCRIPTION = "Provides translations for the 'libKF6IconThemes6' package."
LICENSE = "LGPL-2.1-or-later & GPL-2.0-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6IconThemes6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "25db30a929f398ecdcfa39072e7d7f24d0f282aee8333675155738c535f38906d0c705dd2367c489673288ef6ce0da17fb8c9de7e8b415dad88c80a17c9c87db"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6IconThemes6-lang \
libKF6IconThemes6-lang-all \
locale-libKF6IconThemes6-af \
locale-libKF6IconThemes6-ar \
locale-libKF6IconThemes6-ast \
locale-libKF6IconThemes6-az \
locale-libKF6IconThemes6-be \
locale-libKF6IconThemes6-be@latin \
locale-libKF6IconThemes6-bg \
locale-libKF6IconThemes6-bn \
locale-libKF6IconThemes6-br \
locale-libKF6IconThemes6-bs \
locale-libKF6IconThemes6-ca \
locale-libKF6IconThemes6-ca@valencia \
locale-libKF6IconThemes6-cs \
locale-libKF6IconThemes6-cy \
locale-libKF6IconThemes6-da \
locale-libKF6IconThemes6-de \
locale-libKF6IconThemes6-el \
locale-libKF6IconThemes6-en-GB \
locale-libKF6IconThemes6-eo \
locale-libKF6IconThemes6-es \
locale-libKF6IconThemes6-et \
locale-libKF6IconThemes6-eu \
locale-libKF6IconThemes6-fa \
locale-libKF6IconThemes6-fi \
locale-libKF6IconThemes6-fr \
locale-libKF6IconThemes6-ga \
locale-libKF6IconThemes6-gd \
locale-libKF6IconThemes6-gl \
locale-libKF6IconThemes6-gu \
locale-libKF6IconThemes6-he \
locale-libKF6IconThemes6-hi \
locale-libKF6IconThemes6-hr \
locale-libKF6IconThemes6-hu \
locale-libKF6IconThemes6-ia \
locale-libKF6IconThemes6-id \
locale-libKF6IconThemes6-is \
locale-libKF6IconThemes6-it \
locale-libKF6IconThemes6-ja \
locale-libKF6IconThemes6-ka \
locale-libKF6IconThemes6-kk \
locale-libKF6IconThemes6-km \
locale-libKF6IconThemes6-ko \
locale-libKF6IconThemes6-lt \
locale-libKF6IconThemes6-lv \
locale-libKF6IconThemes6-mai \
locale-libKF6IconThemes6-mk \
locale-libKF6IconThemes6-ml \
locale-libKF6IconThemes6-mr \
locale-libKF6IconThemes6-ms \
locale-libKF6IconThemes6-nb \
locale-libKF6IconThemes6-nds \
locale-libKF6IconThemes6-ne \
locale-libKF6IconThemes6-nl \
locale-libKF6IconThemes6-nn \
locale-libKF6IconThemes6-oc \
locale-libKF6IconThemes6-pa \
locale-libKF6IconThemes6-pl \
locale-libKF6IconThemes6-pt \
locale-libKF6IconThemes6-pt-BR \
locale-libKF6IconThemes6-ro \
locale-libKF6IconThemes6-ru \
locale-libKF6IconThemes6-sk \
locale-libKF6IconThemes6-sl \
locale-libKF6IconThemes6-sq \
locale-libKF6IconThemes6-sr \
locale-libKF6IconThemes6-sr@ijekavian \
locale-libKF6IconThemes6-sr@ijekavianlatin \
locale-libKF6IconThemes6-sr@latin \
locale-libKF6IconThemes6-sv \
locale-libKF6IconThemes6-ta \
locale-libKF6IconThemes6-th \
locale-libKF6IconThemes6-tr \
locale-libKF6IconThemes6-ug \
locale-libKF6IconThemes6-uk \
locale-libKF6IconThemes6-vi \
locale-libKF6IconThemes6-wa \
locale-libKF6IconThemes6-zh-CN \
locale-libKF6IconThemes6-zh-TW"

RDEPENDS:${PN} += "libKF6IconThemes6"

inherit rpm
