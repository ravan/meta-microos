SUMMARY = "Kernel firmware files for various sound drivers"
DESCRIPTION = "This package contains kernel firmware files for various sound drivers."
LICENSE = "GPL-2.0-or-later & SUSE-Firmware"

PV = "20260825"

RPM_NAME = "kernel-firmware-sound-20260825-1.1.noarch.rpm"
RPM_HASH = "975b8b70e6b7277951698000f463ed86c785a0117e120ddd3445849763c23a4de939f24f1c042561e682cc16c9f6e1d01ba3f518be470ca4cb7d0e8119ca0447"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "avs-topology-firmware \
firmware-1534-2-0x8.bin \
firmware-1534-2-0xB.bin \
firmware-15E2-0-0x8.bin \
firmware-15E2-0-0x9.bin \
firmware-15E2-0-0xA.bin \
firmware-15E2-0-0xB.bin \
firmware-15E2-0-0xC.bin \
firmware-15E2-0-0xD.bin \
firmware-15E2-0-0xE.bin \
firmware-15E2-0-0xF.bin \
firmware-15E2-1-0x8.bin \
firmware-15E2-1-0x9.bin \
firmware-15E2-1-0xA.bin \
firmware-15E2-1-0xB.bin \
firmware-15E2-1-0xC.bin \
firmware-15E2-1-0xD.bin \
firmware-15E2-1-0xE.bin \
firmware-15E2-1-0xF.bin \
firmware-16F4-1-0x9.bin \
firmware-16F4-1-0xC.bin \
firmware-1714-1-0x8.bin \
firmware-1714-1-0xB.bin \
firmware-1954-0-0-0x8.bin \
firmware-1954-0-0-0xB.bin \
firmware-1954-0-1-0x8.bin \
firmware-1954-0-1-0xB.bin \
firmware-1954-1-0-0x8.bin \
firmware-1954-1-0-0xB.bin \
firmware-1954-1-1-0x8.bin \
firmware-1954-1-1-0xB.bin \
firmware-1964-0-0-0x8.bin \
firmware-1964-0-0-0xB.bin \
firmware-1964-0-1-0x8.bin \
firmware-1964-0-1-0xB.bin \
firmware-1964-1-0-0x8.bin \
firmware-1964-1-0-0xB.bin \
firmware-1964-1-1-0x8.bin \
firmware-1964-1-1-0xB.bin \
firmware-1994-0-2-0xB.bin \
firmware-1994-0-2-0xC.bin \
firmware-1994-1-2-0xB.bin \
firmware-1994-1-2-0xC.bin \
firmware-1AC4-0-0-0x8.bin \
firmware-1AC4-0-0-0xB.bin \
firmware-1AC4-1-0-0x8.bin \
firmware-1AC4-1-0-0xB.bin \
firmware-1AD4-0-2-0xB.bin \
firmware-1AD4-0-2-0xC.bin \
firmware-1AD4-1-2-0xB.bin \
firmware-1AD4-1-2-0xC.bin \
firmware-1AD4-2-2-0xB.bin \
firmware-1AD4-2-2-0xC.bin \
firmware-1AD4-3-2-0xB.bin \
firmware-1AD4-3-2-0xC.bin \
firmware-1B04-0-2-0x8.bin \
firmware-1B04-0-2-0xB.bin \
firmware-1B04-1-2-0x8.bin \
firmware-1B04-1-2-0xB.bin \
firmware-1B94-0-0-0xB.bin \
firmware-1B94-0-0-0xC.bin \
firmware-1B94-1-0-0xB.bin \
firmware-1B94-1-0-0xC.bin \
firmware-1B94-2-0-0xB.bin \
firmware-1B94-2-0-0xC.bin \
firmware-1B94-3-0-0xB.bin \
firmware-1B94-3-0-0xC.bin \
firmware-1C64-0-0-0x8.bin \
firmware-1C64-0-0-0xB.bin \
firmware-1C64-1-0-0x8.bin \
firmware-1C64-1-0-0xB.bin \
firmware-3431-2-0x8.bin \
firmware-3431-2-0xB.bin \
firmware-35C1-1-0x9.bin \
firmware-35C1-1-0xC.bin \
firmware-35D1-1-0x9.bin \
firmware-35D1-1-0xC.bin \
firmware-35E1-1-0x9.bin \
firmware-35E1-1-0xC.bin \
firmware-36A1-1-0x9.bin \
firmware-36A1-1-0xC.bin \
firmware-36B1-1-0x9.bin \
firmware-36B1-1-0xC.bin \
firmware-8E86-1-0x9.bin \
firmware-8E86-1-0xA.bin \
firmware-8E86-1-0xC.bin \
firmware-8E86-1-0xD.bin \
firmware-8E86-2-0x9.bin \
firmware-8E86-2-0xA.bin \
firmware-8E86-2-0xC.bin \
firmware-8E86-2-0xD.bin \
firmware-8E87-1-0x9.bin \
firmware-8E87-1-0xA.bin \
firmware-8E87-1-0xC.bin \
firmware-8E87-1-0xD.bin \
firmware-8E87-2-0x9.bin \
firmware-8E87-2-0xA.bin \
firmware-8E87-2-0xC.bin \
firmware-8E87-2-0xD.bin \
firmware-8EA1-0-0-0x9.bin \
firmware-8EA1-0-0-0xC.bin \
firmware-8EA1-1-0-0x9.bin \
firmware-8EA1-1-0-0xC.bin \
firmware-8EA2-0-0-0x9.bin \
firmware-8EA2-0-0-0xC.bin \
firmware-8EA2-1-0-0x9.bin \
firmware-8EA2-1-0-0xC.bin \
firmware-8EA4-0-2-0x9.bin \
firmware-8EA4-0-2-0xC.bin \
firmware-8EA4-1-2-0x9.bin \
firmware-8EA4-1-2-0xC.bin \
firmware-8EA5-0-2-0x9.bin \
firmware-8EA5-0-2-0xC.bin \
firmware-8EA5-1-2-0x9.bin \
firmware-8EA5-1-2-0xC.bin \
firmware-8EA6-0-2-0x9.bin \
firmware-8EA6-0-2-0xC.bin \
firmware-8EA6-1-2-0x9.bin \
firmware-8EA6-1-2-0xC.bin \
firmware-8EA7-0-2-0x9.bin \
firmware-8EA7-0-2-0xC.bin \
firmware-8EA7-1-2-0x9.bin \
firmware-8EA7-1-2-0xC.bin \
firmware-8EA8-0-2-0x9.bin \
firmware-8EA8-0-2-0xC.bin \
firmware-8EA8-1-2-0x9.bin \
firmware-8EA8-1-2-0xC.bin \
firmware-8EB4-1-0xA.bin \
firmware-8EB4-1-0xD.bin \
firmware-8EB4-2-0x9.bin \
firmware-8EB4-2-0xC.bin \
firmware-8ED0-1-0xC.bin \
firmware-8ED0-2-0x9.bin \
firmware-8EF5-0-0x9.bin \
firmware-8EF5-0-0xA.bin \
firmware-8EF5-0-0xC.bin \
firmware-8EF5-0-0xD.bin \
firmware-8EF6-2-0x9.bin \
firmware-8EF6-2-0xC.bin \
firmware-8F6D-0-0x9.bin \
firmware-8F6D-0-0xA.bin \
firmware-8F6D-0-0xC.bin \
firmware-8F6D-0-0xD.bin \
firmware-8F7B-1-0x9.bin \
firmware-8F7B-1-0xA.bin \
firmware-8F7B-1-0xC.bin \
firmware-8F7B-1-0xD.bin \
firmware-8F7B-2-0x9.bin \
firmware-8F7B-2-0xA.bin \
firmware-8F7B-2-0xC.bin \
firmware-8F7B-2-0xD.bin \
firmware-8FA4-0-0x9.bin \
firmware-8FA4-0-0xA.bin \
firmware-8FA4-0-0xC.bin \
firmware-8FA4-0-0xD.bin \
firmware-8FA5-0-0x9.bin \
firmware-8FA5-0-0xA.bin \
firmware-8FA5-0-0xC.bin \
firmware-8FA5-0-0xD.bin \
firmware-8FF4-1-0xC.bin \
firmware-8FF4-1-0xD.bin \
firmware-8FF4-2-0x9.bin \
firmware-8FF4-2-0xA.bin \
firmware-8FF5-1-0xC.bin \
firmware-8FF5-1-0xD.bin \
firmware-8FF5-2-0x9.bin \
firmware-8FF5-2-0xA.bin \
firmware-8FF7-1-0xC.bin \
firmware-8FF7-2-0x9.bin \
firmware-9001-1-0xA.bin \
firmware-9001-1-0xD.bin \
firmware-9001-2-0x9.bin \
firmware-9001-2-0xC.bin \
firmware-9013-0-2-0x9.bin \
firmware-9013-0-2-0xC.bin \
firmware-9013-1-2-0x9.bin \
firmware-9013-1-2-0xC.bin \
firmware-9014-0-2-0x9.bin \
firmware-9014-0-2-0xC.bin \
firmware-9014-1-2-0x9.bin \
firmware-9014-1-2-0xC.bin \
firmware-9015-0-2-0x9.bin \
firmware-9015-0-2-0xC.bin \
firmware-9015-1-2-0x9.bin \
firmware-9015-1-2-0xC.bin \
firmware-9026-0-2-0x9.bin \
firmware-9026-0-2-0xC.bin \
firmware-9026-1-2-0x9.bin \
firmware-9026-1-2-0xC.bin \
firmware-9028-2-0xC.bin \
firmware-9028-2-0xD.bin \
firmware-9028-3-0x9.bin \
firmware-9028-3-0xA.bin \
firmware-9029-2-0xC.bin \
firmware-9029-3-0x9.bin \
firmware-INT8866RCA2.bin \
firmware-TAS2XXX0C94.bin \
firmware-TAS2XXX0C95.bin \
firmware-TAS2XXX0C96.bin \
firmware-TAS2XXX0C97.bin \
firmware-TAS2XXX103C8DE8-0.bin \
firmware-TAS2XXX103C8DE8-1.bin \
firmware-TAS2XXX103C8DE80.bin \
firmware-TAS2XXX103C8DE81.bin \
firmware-TAS2XXX103C8DE9-0.bin \
firmware-TAS2XXX103C8DE9-1.bin \
firmware-TAS2XXX103C8DE90.bin \
firmware-TAS2XXX103C8DE91.bin \
firmware-TAS2XXX10A40.bin \
firmware-TAS2XXX10A41.bin \
firmware-TAS2XXX11540.bin \
firmware-TAS2XXX11541.bin \
firmware-TAS2XXX12040.bin \
firmware-TAS2XXX12041.bin \
firmware-TAS2XXX12140.bin \
firmware-TAS2XXX12141.bin \
firmware-TAS2XXX13840.bin \
firmware-TAS2XXX13841.bin \
firmware-TAS2XXX13940.bin \
firmware-TAS2XXX13941.bin \
firmware-TAS2XXX13A40.bin \
firmware-TAS2XXX13A41.bin \
firmware-TAS2XXX1EB3.bin \
firmware-TAS2XXX1EB30.bin \
firmware-TAS2XXX1EB31.bin \
firmware-TAS2XXX2234.bin \
firmware-TAS2XXX2326.bin \
firmware-TAS2XXX3870.bin \
firmware-TAS2XXX387D.bin \
firmware-TAS2XXX387E.bin \
firmware-TAS2XXX387F.bin \
firmware-TAS2XXX3880.bin \
firmware-TAS2XXX3881.bin \
firmware-TAS2XXX3882.bin \
firmware-TAS2XXX3884.bin \
firmware-TAS2XXX3886.bin \
firmware-TAS2XXX38A5.bin \
firmware-TAS2XXX38A7.bin \
firmware-TAS2XXX38A8.bin \
firmware-TAS2XXX38B8.bin \
firmware-TAS2XXX38B9.bin \
firmware-TAS2XXX38BA.bin \
firmware-TAS2XXX38BB.bin \
firmware-TAS2XXX38BE.bin \
firmware-TAS2XXX38BF.bin \
firmware-TAS2XXX38C3.bin \
firmware-TAS2XXX38CB.bin \
firmware-TAS2XXX38CD.bin \
firmware-TAS2XXX38D3.bin \
firmware-TAS2XXX38D4.bin \
firmware-TAS2XXX38D5.bin \
firmware-TAS2XXX38D6.bin \
firmware-TAS2XXX38DF.bin \
firmware-TAS2XXX38E0.bin \
firmware-TAS2XXX38FD.bin \
firmware-TAS2XXX391F.bin \
firmware-TAS2XXX3920.bin \
firmware-TAS2XXX3E300.bin \
firmware-TAS2XXX3E301.bin \
firmware-TAS2XXX3EE00.bin \
firmware-TAS2XXX3EE01.bin \
firmware-TAS2XXX3EF00.bin \
firmware-TAS2XXX3EF01.bin \
firmware-TAS2XXX3F000.bin \
firmware-TAS2XXX3F001.bin \
firmware-TAS2XXX3F100.bin \
firmware-TAS2XXX3F101.bin \
firmware-TAS2XXX3F200.bin \
firmware-TAS2XXX3F201.bin \
firmware-TAS2XXX3F300.bin \
firmware-TAS2XXX3F301.bin \
firmware-TAS2XXX8C70.bin \
firmware-TAS2XXX8C71.bin \
firmware-TAS2XXX8C72.bin \
firmware-TAS2XXX8D8E.bin \
firmware-TAS2XXX8DAA.bin \
firmware-TAS2XXX8DE8-0.bin \
firmware-TAS2XXX8DE8-1.bin \
firmware-TAS2XXX8DE8.bin \
firmware-TAS2XXX8DE80.bin \
firmware-TAS2XXX8DE81.bin \
firmware-TAS2XXX8DE9-0.bin \
firmware-TAS2XXX8DE9-1.bin \
firmware-TAS2XXX8DE9.bin \
firmware-TAS2XXX8DE90.bin \
firmware-TAS2XXX8DE91.bin \
firmware-TAS2XXX8E17.bin \
firmware-TAS2XXX8E19.bin \
firmware-TAS2XXX8E1C.bin \
firmware-TAS2XXX8E8A.bin \
firmware-TAS2XXX8ED5-0.bin \
firmware-TAS2XXX8ED5-1.bin \
firmware-TAS2XXX8ED5.bin \
firmware-TAS2XXX8ED6-0.bin \
firmware-TAS2XXX8ED6-1.bin \
firmware-TAS2XXX8ED6.bin \
firmware-TAS2XXX8ED7-0.bin \
firmware-TAS2XXX8ED7-1.bin \
firmware-TAS2XXX8ED7.bin \
firmware-TAS2XXX8ED8-0.bin \
firmware-TAS2XXX8ED8-1.bin \
firmware-TAS2XXX8ED8.bin \
firmware-TAS2XXX8ED9-0.bin \
firmware-TAS2XXX8ED9-1.bin \
firmware-TAS2XXX8ED9.bin \
firmware-TAS2XXX8EDA-0.bin \
firmware-TAS2XXX8EDA-1.bin \
firmware-TAS2XXX8EDA.bin \
firmware-TAS2XXX8F40.bin \
firmware-TAS2XXX8F41.bin \
firmware-TAS2XXX8F42.bin \
firmware-TAS2XXX8F62.bin \
firmware-TAS2XXX8F7E.bin \
firmware-TAS2XXX8F94.bin \
firmware-TAS2XXX8F95.bin \
firmware-TIAS2781RCA2.bin \
firmware-TIAS2781RCA4.bin \
firmware-TXNW2781RCA0.bin \
firmware-TXNW2781RCA1.bin \
firmware-TXNW2781RCA2.bin \
firmware-TXNW2781RCA4.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10251826-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10251826-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10251826.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-1025182c-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-1025182c-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-1025182c.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10251844-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10251844-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10251844.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b27-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b27-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b27.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b28-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b28-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b28-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b28-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280b28.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280beb-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280beb-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280beb.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid0-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid0-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid1-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d-spkid1-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280c4d.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbd.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbe.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cbf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc2.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10280cc4.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c896e-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c896e-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c896e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8971.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8971.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8972.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8972.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8973.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8973.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8974.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8974.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8975-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8975-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8975.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8981.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898e.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898f.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c898f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8991.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8991.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8992.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8992.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8994.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8994.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8995.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8995.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c6-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c6-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89c6.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89e7-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89e7-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c89e7.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a28-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a28-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a28-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a28-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a28.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a29-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a29-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a29-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a29-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a29.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2a-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2a-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2a-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2a-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2a.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2b-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2b-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2b-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2b-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2b.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2c-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2c-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2c-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2c-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2c.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2d-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2d-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2d-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2d-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2d.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2e-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2e-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2e-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2e-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a2e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a30-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a30-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a30-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a30-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a30.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a31-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a31-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a31-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a31-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a31.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a6e-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a6e-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a6e-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a6e-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8a6e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ad8.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ad8.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b3a-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b3a-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b3a-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b3a-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b3a.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b42.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b42.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b43.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b43.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b44.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b44.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b45.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b45.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b46.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b46.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b47.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b47.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b63.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b70.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b70.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b72.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b72.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b74.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b74.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b77.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b77.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b8f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b92.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8b92.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bb4.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdd-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdd-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdd-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdd-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdd.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bde-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bde-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bde-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bde-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bde.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8bdf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be0-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be0-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be0-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be0-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be0.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be1-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be1-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be1-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be1-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be2-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be2-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be2-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be2-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be2.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be5-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be5-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be5-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be5-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be5.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be6-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be6-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be6-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be6-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be6.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be7-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be7-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be7-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be7-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be7.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be8-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be8-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be8-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be8-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be8.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be9-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be9-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be9-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be9-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8be9.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c15-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c15-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c15-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c15-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c15.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c16-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c16-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c16-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c16-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c16.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c17-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c17-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c17-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c17-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c17.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c26.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c26.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c46.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c46.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c47.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c47.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c48.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c48.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c49.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c49.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4d.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c4f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c50-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c50-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c50-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c50-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c50.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c51-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c51-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c51-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c51-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c51.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c66-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c66-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c66-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c66-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c66.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c67-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c67-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c67-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c67-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c67.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c68-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c68-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c68-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c68-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c68.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c6a-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c6a-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c6a-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c6a-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c6a.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c70.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c70.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c71.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c71.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c72.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8c72.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ca4.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ca4.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ca7.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ca7.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdd-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdd-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdd.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cde-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cde-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cde.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cdf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ce0-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ce0-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ce0-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ce0-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8ce0.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cf5-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cf5-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cf5-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cf5-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8cf5.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9b-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9b-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9b.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9c-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9c-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9c.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9d-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9d-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9d.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9e-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9e-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9f-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9f-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8d9f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da0-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da0-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da0.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da1-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da1-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da7-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da7-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da7.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da8-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da8-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8da8.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e11-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e11-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e11.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e12-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e12-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e12.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e13-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e13-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e13.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e36-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e36-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e36.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e37-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e37-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e37.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e3a-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e3a-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e3a.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e3b-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e3b-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e3b.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e60-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e60-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e60.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e61-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e61-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e61.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e62-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e62-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e62.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e75-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e75-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e75.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9c-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9c-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9c.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9d-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9d-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9d.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9e-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9e-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8e9e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f07-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f07-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f07.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f2d-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f2d-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f2d.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f2e-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f2e-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f2e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f57-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f57-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-103c8f57.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431054-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431054-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431054-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431054-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431054.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431074-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431074-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431074-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431074-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431074.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431194-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431194-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431194-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431194-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431194.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431294-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431294-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431294-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431294-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431294.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312af.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312b4-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312b4-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312b4-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312b4-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104312b4.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431433.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431454-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431454-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431454-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431454-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431454.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431463.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431473.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431483.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431493.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314d3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104314e3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431503.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431514-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431514-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431514-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431514-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431514.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431533.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431573.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431584-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431584-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431584-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431584-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431584.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431663.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431683-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431683-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431683-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431683-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431683.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316a3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316a3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316a3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316a3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316a3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316d3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316d3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316d3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316d3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316d3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316f3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316f3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316f3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316f3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104316f3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104317f3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431863-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431863-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431863-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431863-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431863.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104318d3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104318d3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104318d3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104318d3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104318d3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a63.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a83-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a83-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a83-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a83-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a83.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431a8f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431b93.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid0-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid0-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03-spkid1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c03.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c33-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c33-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c33-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c33-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c33.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c43-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c43-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c43-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c43-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c43.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431c9f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431caf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ccf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cdf.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431cef.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431d1f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431da2-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431da2-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431da2-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431da2-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431da2.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e02.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431e12.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ed3-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ed3-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ed3-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ed3-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ed3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ee2-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ee2-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431ee2.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f12.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f1f-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f1f-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f1f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f62-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f62-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f62-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f62-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f62.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f63-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f63-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431f63.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431fb3-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431fb3-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431fb3-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431fb3-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10431fb3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433011-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433011-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433011-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433011-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433011.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433061-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433061-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433061-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433061-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433061.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433071-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433071-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433071-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433071-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433071.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330c1-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330c1-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330c1-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330c1-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330c1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330d1-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330d1-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330d1-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330d1-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330d1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330e1-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330e1-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330e1-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330e1-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104330e1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331e1-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331e1-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331e1-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331e1-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331e1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331f1-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331f1-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331f1-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331f1-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104331f1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433391-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433391-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433391-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433391-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433391.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433601-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433601-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433601-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433601-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433601.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433611-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433611-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433611-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433611-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433611.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433701-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433701-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433701-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433701-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433701.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433711-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433711-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433711-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433711-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433711.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a20.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a30.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a40.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a50.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433a60.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d78-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d78-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d78-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d78-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d78.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d88-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d88-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d88-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d88-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433d88.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e00-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e00-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e00-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e00-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e00.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e20-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e20-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e20-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e20-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433e20.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433fd0-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433fd0-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433fd0-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433fd0-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433fd0.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433ff0-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433ff0-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433ff0-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433ff0-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-10433ff0.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-104388f4-spkid0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104388f4-spkid1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-104388f4.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f1.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f2.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa22f3.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2316.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2317.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2318.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa2319.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a-l0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a-r0.bincfg \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa231a.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3847.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3855.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3865-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3865-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3865.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3866-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3866-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3866.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386e-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386e-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386e-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386e-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386e.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386f-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386f-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa386f.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3877-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3877-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3877.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3878-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3878-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa3878.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38a9-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38a9-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38a9-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38a9-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38a9.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38ab-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38ab-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38ab-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38ab-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38ab.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b4-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b4-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b4-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b4-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b4.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b5-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b5-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b5-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b5-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b5.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b6-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b6-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b6-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b6-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b6.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b7-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b7-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b7-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b7-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38b7.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c7-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c7-spkid0-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c7-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c7-spkid0-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c7.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c8-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c8-spkid1-l1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c8-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c8-spkid1-r1.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38c8.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38f9-spkid1-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38f9-spkid1-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38f9.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38fa-spkid0-l0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38fa-spkid0-r0.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-17aa38fa.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-1f660105.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-1f660105.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot-vlv1776.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot-vlv1776.wmfw \
firmware-cirrus/cs35l41-dsp1-spk-prot.bin \
firmware-cirrus/cs35l41-dsp1-spk-prot.wmfw \
firmware-cirrus/cs35l41/bincfgs/cs35l41-dsp1-14-5dB.bincfg \
firmware-cirrus/cs35l41/bincfgs/cs35l41-dsp1-15-5dB.bincfg \
firmware-cirrus/cs35l41/bincfgs/cs35l41-dsp1-16-5dB.bincfg \
firmware-cirrus/cs35l41/bincfgs/cs35l41-dsp1-19-5dB.bincfg \
firmware-cirrus/cs35l41/v6.39.0/halo-cspl-RAM-revB2-29.41.0.wmfw \
firmware-cirrus/cs35l41/v6.47.0/halo-cspl-RAM-revB2-29.49.0.wmfw \
firmware-cirrus/cs35l41/v6.51.0/halo-cspl-RAM-revB2-29.53.0.wmfw \
firmware-cirrus/cs35l41/v6.56.0/halo-cspl-RAM-revB2-29.58.0.wmfw \
firmware-cirrus/cs35l41/v6.61.1/halo-cspl-RAM-revB2-29.63.1.wmfw \
firmware-cirrus/cs35l41/v6.63.0/halo-cspl-RAM-revB2-29.65.0.wmfw \
firmware-cirrus/cs35l41/v6.68.0/halo-cspl-RAM-revB2-29.70.0.wmfw \
firmware-cirrus/cs35l41/v6.78.0/halo-cspl-RAM-revB2-29.80.0.wmfw \
firmware-cirrus/cs35l41/v6.80.0/halo-cspl-RAM-revB2-29.82.0.wmfw \
firmware-cirrus/cs35l41/v6.83.0/halo-cspl-RAM-revB2-29.85.0.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d01-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d01-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d01-amp3.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d01-amp4.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d01.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d08-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d08-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d08-amp3.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d08-amp4.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d08.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d85-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d85-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d85-amp3.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d85-amp4.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d85.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d86-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d86-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d86-amp3.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d86-amp4.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d86.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8c-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8c-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8c.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8d-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8d-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8d.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8e-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8e-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8e.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8f-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8f-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d8f.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d91-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d91-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8d91.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e14-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e14-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e14.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e15-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e15-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e15.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e16-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e16-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e16.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e17-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e17-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e17.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e18-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e18-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e18.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e19-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e19-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e19.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e1a-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e1a-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c8e1a.wmfw \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c900c-amp1.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c900c-amp2.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c900c-amp3.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c900c-amp4.bin \
firmware-cirrus/cs35l54-b0-dsp1-misc-103c900c.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c62-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c63-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280c6b-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid0-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid0-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid2-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid2-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid2.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid3-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid3-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce3-spkid3.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid0-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid0-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid2-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid2-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid2.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid3-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid3-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce4-spkid3.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce5-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce6-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280ce7-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d12-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d12-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d12-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d12-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d12-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d12-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d13-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d13-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d13-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d13-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d13-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d13-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d32-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid0-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid0-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid1-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid1-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280d33-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e86-spkid0-l2u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e86-spkid0-l3u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e86-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e86-spkid1-l2u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e86-spkid1-l3u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e86-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e87-spkid0-l2u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e87-spkid0-l3u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e87-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e87-spkid1-l2u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e87-spkid1-l3u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10280e87-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c52-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c52-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c52-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c52-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c52.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c53-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c53-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c53-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c53-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8c53.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d90-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d90-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d90.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d91-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d91-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d91.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d92-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d92-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8d92.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e1b-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e1b-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e1b.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e1c-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e1c-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e1c.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e2c-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e2c-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-103c8e2c.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431024-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431024-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431024-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431024-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431024-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431024-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431034-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431034-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431034-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431034-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431034-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431034-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431044-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431044-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431044-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431044-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431044-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431044-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431264-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431264-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431264-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431264-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431264.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431314-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431314-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431314-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431314-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431314-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431314-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431444-l2u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431444-l2u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431444.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431464-l1u2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431464-l1u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431464-l2u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431464-l2u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431464.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431564-l1u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431564-l1u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431564-l1u2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431564-l1u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431564.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315d4-l2u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315d4-l2u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315d4.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315e4-l2u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315e4-l2u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315e4.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315f4-l2u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315f4-l2u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-104315f4.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431634-l2u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431634-l2u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431634.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431b13-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431b13-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431b13-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431b13-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431b13-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431b13-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c63-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c63-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c63-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c63-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c63-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c63-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c74-l2u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c74-l2u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431c74.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431df3-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431df3-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431df3-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431df3-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431df3.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e13-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e13-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e13-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e13-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e13.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e63-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e63-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e63-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e63-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e63-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e63-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e83-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e83-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e83-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e83-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e83-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431e83-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431f43-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431f43-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431f43-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431f43-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10431f43.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-10433451-l1u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10433451-l1u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10433451-l1u2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10433451-l1u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-10433451.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233b-spkid0-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233b-spkid0-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233b-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233b-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233b-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233b-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233c-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233c-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233c-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233c-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233c-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa233c.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2347-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2347-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2347.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2348-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2348-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2348.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2349-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2349-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa2349.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid0-l0u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid0-l0u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid0-l0u2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid0-l0u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid1-l0u0.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid1-l0u1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid1-l0u2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid1-l0u3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3806-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa380e-spkid0-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa380e-spkid0-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa380e-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa380e-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa380e-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa380e-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3832-spkid0-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3832-spkid0-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3832-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3832-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3832-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3832-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3838-spkid0-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3838-spkid0-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3838-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3838-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3838-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3838-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa383c-spkid0-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa383c-spkid0-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa383c-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa383c-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa383c-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa383c-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3905-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3905-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3905.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390b-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390b-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390b.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390c-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390c-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390c-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390d-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390d-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa390d-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3910-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3910-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3910-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3911-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3911-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3911-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa391b-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa391b-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa391b.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa391e-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa391e-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa391e-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3921-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3921-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3921-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392c-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392c-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392c-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392d-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392d-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392d-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392e-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392e-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392e-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392e-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa392e.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3932-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3932-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3932-amp3.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3932-amp4.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3932.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3953-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3953-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3953-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3956-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3956-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3956-spkid1.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa395b-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa395b-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa395b.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa395f-spkid0-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa395f-spkid0-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa395f-spkid0.wmfw \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3960-spkid1-amp1.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3960-spkid1-amp2.bin \
firmware-cirrus/cs35l56-b0-dsp1-misc-17aa3960-spkid1.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-00-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-00-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-00.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-01-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-01-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-01.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-02-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-02-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-02.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-03-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-03-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280dd6-03.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid1.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid2-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid2-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid2.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid3-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid3-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e53-spkid3.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid1-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid1-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid1.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid2-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid2-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid2.wmfw \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid3-ampl.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid3-ampr.bin \
firmware-cirrus/cs35l56-b2-dsp1-misc-10280e54-spkid3.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.11.1.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.11.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.16.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.18.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.20.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.21.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.25.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.26.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.28.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.11.28B.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.12.2.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.13.0.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.13.3.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.13.3R.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev3.13.4.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev4.5.3.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev4.5.9.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev4.7.0.wmfw \
firmware-cirrus/cs35l56/CS35L56-Rev4.7.2.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid0-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid0-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid0-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid0-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid1-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid1-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid1-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid1-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db3-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid0-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid0-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid0-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid0-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid1-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid1-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid1-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid1-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db4-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid0-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid0-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid0-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid0-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid1-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid1-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid1-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid1-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280db9-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid0-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid0-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid0-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid0-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid1-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid1-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid1-l3u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid1-l3u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-10280dba-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1dc-l1u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1dc-l1u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1dc-l1u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1dc-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1dc-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1dc-l2u5.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1dc.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1de-l1u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1de-l1u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1de-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1de-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc1de.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc910-l1u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc910-l2u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dc910.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dca0a-l1u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dca0a-l1u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dca0a-l1u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dca0a-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dca0a-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dca0a-l2u5.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-144dca0a.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid0-l1u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid0-l1u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid0-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid0-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid1-l1u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid1-l1u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid1-l2u2.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid1-l2u3.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa2355-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa235c-l2u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa235c-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa235c.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa235d-l2u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa235d-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa235d.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3809-spkid0-l0u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3809-spkid0-l0u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3809-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3809-spkid1-l0u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3809-spkid1-l0u1.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3809-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3821-spkid0-ampl.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3821-spkid0-ampr.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3821-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3821-spkid1-ampl.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3821-spkid1-ampr.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa3821-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5158-spkid0-l2u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5158-spkid0-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5158-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5158-spkid1-l2u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5158-spkid1-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5158-spkid1.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5159-spkid0-l2u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5159-spkid0-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5159-spkid0.wmfw \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5159-spkid1-l2u0.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5159-spkid1-l2u4.bin \
firmware-cirrus/cs35l57-b2-dsp1-misc-17aa5159-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e13-spkid0-00-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e13-spkid0-00-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e13-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e13-spkid1-00-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e13-spkid1-00-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e13-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e14-spkid0-00-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e14-spkid0-00-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e14-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e14-spkid1-00-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e14-spkid1-00-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e14-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid0-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid0-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid2-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid2-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid3-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid3-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid3-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid3-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1a-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid0-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid0-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid2-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid2-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid3-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid3-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid3-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid3-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1b-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid0-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid0-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid0-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid0-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid1-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid1-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid1-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid1-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid2-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid2-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid2-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid2-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid3-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid3-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid3-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid3-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1c-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid0-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid0-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid0-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid0-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid2-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid2-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid2-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid2-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid3-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid3-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1d-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid0-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid0-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid0-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid0-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid1-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid1-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid1-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid1-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid2-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid2-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid2-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid2-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid3-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid3-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid3-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid3-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1e-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid0-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid0-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid1-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid1-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid2-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid2-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid3-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid3-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e1f-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid0-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid0-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid1-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid1-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid2-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid2-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid3-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid3-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e20-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid0-04-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid0-04-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid2-03-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid2-03-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid3-03-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid3-03-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid3-04-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid3-04-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e21-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid0-02-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid0-02-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid2-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid2-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid3-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid3-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid3-02-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid3-02-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e22-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid0-03-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid0-03-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid0-04-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid0-04-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid2-03-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid2-03-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid2-04-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid2-04-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid3-04-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid3-04-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e23-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid0-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid0-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid0-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid0-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid2-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid2-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid2-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid2-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid3-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid3-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e24-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid0-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid0-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid1-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid1-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid2-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid2-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid3-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid3-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e25-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid0-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid0-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid1-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid1-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid2-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid2-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid3-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid3-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e26-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid0-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid0-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid1-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid1-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid2-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid2-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid3-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid3-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e27-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid0-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid0-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid1-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid1-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid2-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid2-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid3-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid3-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e28-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2b-spkid0-00-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2b-spkid0-00-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2b-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2b-spkid1-00-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2b-spkid1-00-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2b-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2c-spkid0-00-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2c-spkid0-00-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2c-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2c-spkid1-00-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2c-spkid1-00-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e2c-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid0-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid0-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid0-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid0-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid2-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid2-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid2-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid2-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid3-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid3-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e38-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid0-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid0-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid1-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid1-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid2-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid2-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid3-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid3-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3e-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid0-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid0-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid0-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid0-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid1-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid1-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid1-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid1-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid2-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid2-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid2-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid2-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid3-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid3-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid3-07-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid3-07-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e3f-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid0-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid0-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid1-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid1-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid2-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid2-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid3-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid3-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e5f-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid0-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid0-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid1-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid1-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid2-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid2-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid3-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid3-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e60-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid0-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid0-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid1-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid1-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid2-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid2-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid3-01-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid3-01-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e65-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid0-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid0-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid1-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid1-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid2-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid2-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid3-06-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid3-06-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e66-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid0-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid0-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid2-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid2-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid3-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid3-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid3-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid3-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e82-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid0-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid0-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid2-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid2-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid3-01-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid3-01-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid3-02-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid3-02-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e83-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid0-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid0-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid0-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid0-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid2-05-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid2-05-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid2-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid2-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid3-06-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid3-06-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e84-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid0-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid0-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid0-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid0-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid2-03-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid2-03-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid2-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid2-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid3-04-l3u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid3-04-l3u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280e85-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid0-02-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid0-02-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid1-02-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid1-02-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid2-02-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid2-02-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid3-02-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid3-02-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efb-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid0-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid0-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid0.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid1-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid1-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid1.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid2-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid2-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid2.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid3-05-l1u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid3-05-l1u3.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-10280efc-spkid3.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-17aa2352-l2u0.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-17aa2352-l2u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-17aa2352.wmfw \
firmware-cirrus/cs35l63-a1-dsp1-misc-17aa2353-l2u0.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-17aa2353-l2u1.bin \
firmware-cirrus/cs35l63-a1-dsp1-misc-17aa2353.wmfw \
firmware-cirrus/cs35l63/CS35L63-Rev2.5.4.wmfw \
firmware-cirrus/cs35l63/CS35L63-Rev2.5.7.wmfw \
firmware-cs42l43.bin \
firmware-ctefx.bin \
firmware-ctspeq.bin \
firmware-emi26/bitstream.fw \
firmware-emi26/firmware.fw \
firmware-emi26/loader.fw \
firmware-intel/IntcSST2.bin \
firmware-intel/avs/apl/dsp-basefw.bin \
firmware-intel/avs/cnl/dsp-basefw.bin \
firmware-intel/avs/da7219-tplg.bin \
firmware-intel/avs/dmic-tplg.bin \
firmware-intel/avs/hda-8086-generic-tplg.bin \
firmware-intel/avs/hda-808628xx-3ep-tplg.bin \
firmware-intel/avs/hda-generic-1ep-tplg.bin \
firmware-intel/avs/hda-generic-tplg.bin \
firmware-intel/avs/lkf/dsp-basefw.bin \
firmware-intel/avs/max98357a-tplg.bin \
firmware-intel/avs/max98373-tplg.bin \
firmware-intel/avs/max98927-tplg.bin \
firmware-intel/avs/nau8825-tplg.bin \
firmware-intel/avs/rt274-tplg.bin \
firmware-intel/avs/rt286-tplg.bin \
firmware-intel/avs/rt298-tplg.bin \
firmware-intel/avs/rt5514-tplg.bin \
firmware-intel/avs/rt5640-tplg.bin \
firmware-intel/avs/rt5663-tplg.bin \
firmware-intel/avs/skl/dsp-basefw.bin \
firmware-intel/avs/skl/dsp-mod-7CAD0808-AB10-CD23-EF45-12AB34CD56EF.bin \
firmware-intel/avs/ssm4567-tplg.bin \
firmware-intel/catpt/bdw/dsp-basefw.bin \
firmware-intel/dsp-fw-bxtn-v2219.bin \
firmware-intel/dsp-fw-bxtn-v3366.bin \
firmware-intel/dsp-fw-bxtn.bin \
firmware-intel/dsp-fw-cnl-v1191.bin \
firmware-intel/dsp-fw-cnl-v1858.bin \
firmware-intel/dsp-fw-cnl.bin \
firmware-intel/dsp-fw-glk-v1814.bin \
firmware-intel/dsp-fw-glk-v2768.bin \
firmware-intel/dsp-fw-glk-v2880.bin \
firmware-intel/dsp-fw-glk-v3366.bin \
firmware-intel/dsp-fw-glk.bin \
firmware-intel/dsp-fw-kbl-v1037.bin \
firmware-intel/dsp-fw-kbl-v2042.bin \
firmware-intel/dsp-fw-kbl-v2630.bin \
firmware-intel/dsp-fw-kbl-v3266.bin \
firmware-intel/dsp-fw-kbl-v3402.bin \
firmware-intel/dsp-fw-kbl-v3420.bin \
firmware-intel/dsp-fw-kbl-v701.bin \
firmware-intel/dsp-fw-kbl.bin \
firmware-intel/dsp-fw-release-v3402.bin \
firmware-intel/dsp-fw-release-v969.bin \
firmware-intel/dsp-fw-release.bin \
firmware-intel/fw-sst-0f28-ssp0.bin \
firmware-intel/fw-sst-0f28.bin \
firmware-intel/fw-sst-0f28.bin-48kHz-i2s-master \
firmware-intel/fw-sst-22a8.bin \
firmware-mediatek/sof-tplg/sof-mt8186.tplg \
firmware-mediatek/sof-tplg/sof-mt8188.tplg \
firmware-mediatek/sof-tplg/sof-mt8195-mt6359-max98390-rt5682.tplg \
firmware-mediatek/sof-tplg/sof-mt8195-mt6359-rt1019-rt5682.tplg \
firmware-mediatek/sof-tplg/sof-mt8195.tplg \
firmware-mediatek/sof/sof-mt8186.ldc \
firmware-mediatek/sof/sof-mt8186.ri \
firmware-mediatek/sof/sof-mt8188.ldc \
firmware-mediatek/sof/sof-mt8188.ri \
firmware-mediatek/sof/sof-mt8195.ldc \
firmware-mediatek/sof/sof-mt8195.ri \
firmware-qcom/glymur/GLYMUR-CRD-tplg.bin \
firmware-qcom/kaanapali/Kaanapali-MTP-tplg.bin \
firmware-qcom/qcm6490/QCM6490-IDP-tplg.bin \
firmware-qcom/qcs615/TALOS-EVK-tplg.bin \
firmware-qcom/qcs6490/QCS6490-RB3Gen2-Industrial-Mezz-tplg.bin \
firmware-qcom/qcs6490/QCS6490-RB3Gen2-tplg.bin \
firmware-qcom/qcs6490/QCS6490-Radxa-Dragon-Q6A-tplg.bin \
firmware-qcom/qcs6490/QCS6490-Thundercomm-RubikPi3-tplg.bin \
firmware-qcom/qcs6490/Thundercomm/RubikPi3/QCS6490-Thundercomm-RubikPi3-tplg.bin \
firmware-qcom/qcs6490/radxa/dragon-q6a/QCS6490-Radxa-Dragon-Q6A-tplg.bin \
firmware-qcom/qcs8300/MONACO-EVK-tplg.bin \
firmware-qcom/qcs8300/arduino-monza-tplg.bin \
firmware-qcom/qcs9100/LEMANS-EVK-tplg.bin \
firmware-qcom/sa8775p/LEMANS-EVK-tplg.bin \
firmware-qcom/sc8280xp/LENOVO/21BX/audioreach-tplg.bin \
firmware-qcom/sc8280xp/SC8280XP-LENOVO-X13S-tplg.bin \
firmware-qcom/sm8450/SM8450-HDK-tplg.bin \
firmware-qcom/sm8550/SM8550-HDK-tplg.bin \
firmware-qcom/sm8550/SM8550-QRD-tplg.bin \
firmware-qcom/sm8650/SM8650-HDK-tplg.bin \
firmware-qcom/sm8650/SM8650-MTP-tplg.bin \
firmware-qcom/sm8650/SM8650-QRD-tplg.bin \
firmware-qcom/sm8650/ayaneo/ps2/SM8650-APS2-tplg.bin \
firmware-qcom/sm8750/SM8750-MTP-tplg.bin \
firmware-qcom/sm8750/SM8750-QRD-tplg.bin \
firmware-qcom/x1e80100/ASUSTeK/vivobook-16/X1E80100-ASUS-Vivobook-16-tplg.bin \
firmware-qcom/x1e80100/ASUSTeK/vivobook-s15/X1E80100-ASUS-Vivobook-S15-tplg.bin \
firmware-qcom/x1e80100/ASUSTeK/zenbook-a14/X1E80100-ASUS-Zenbook-A14-tplg.bin \
firmware-qcom/x1e80100/LENOVO/21N1/X1E80100-LENOVO-Thinkpad-T14s-tplg.bin \
firmware-qcom/x1e80100/LENOVO/83ED/X1E80100-LENOVO-Yoga-Slim7x-tplg.bin \
firmware-qcom/x1e80100/X1E001DE-DEVKIT-tplg.bin \
firmware-qcom/x1e80100/X1E80100-ASUS-Vivobook-16-tplg.bin \
firmware-qcom/x1e80100/X1E80100-ASUS-Vivobook-S15-tplg.bin \
firmware-qcom/x1e80100/X1E80100-ASUS-Zenbook-A14-tplg.bin \
firmware-qcom/x1e80100/X1E80100-CRD-tplg.bin \
firmware-qcom/x1e80100/X1E80100-Dell-Inspiron-14p-7441-tplg.bin \
firmware-qcom/x1e80100/X1E80100-Dell-Latitude-7455-tplg.bin \
firmware-qcom/x1e80100/X1E80100-Dell-XPS-13-9345-tplg.bin \
firmware-qcom/x1e80100/X1E80100-EVK-tplg.bin \
firmware-qcom/x1e80100/X1E80100-HP-OMNIBOOK-X14-tplg.bin \
firmware-qcom/x1e80100/X1E80100-LENOVO-Thinkpad-T14s-tplg.bin \
firmware-qcom/x1e80100/X1E80100-LENOVO-Yoga-Slim7x-tplg.bin \
firmware-qcom/x1e80100/X1E80100-Romulus-tplg.bin \
firmware-qcom/x1e80100/X1E80100-TUXEDO-Elite-14-tplg.bin \
firmware-qcom/x1e80100/X1P42100-Microsoft-Surface-Pro-12in-tplg.bin \
firmware-qcom/x1e80100/dell/inspiron-14-plus-7441/X1E80100-Dell-Inspiron-14p-7441-tplg.bin \
firmware-qcom/x1e80100/dell/latitude-7455/X1E80100-Dell-Latitude-7455-tplg.bin \
firmware-qcom/x1e80100/dell/xps13-9345/X1E80100-Dell-XPS-13-9345-tplg.bin \
firmware-qcom/x1e80100/hp/omnibook-x14/X1E80100-HP-OMNIBOOK-X14-tplg.bin \
firmware-sb16/alaw-main.csp \
firmware-sb16/ima-adpcm-capture.csp \
firmware-sb16/ima-adpcm-init.csp \
firmware-sb16/ima-adpcm-playback.csp \
firmware-sb16/mulaw-main.csp \
firmware-sdca/1fa/1028/db3/1.bin \
firmware-sdca/1fa/1028/db3/2.bin \
firmware-sdca/1fa/1028/db3/3.bin \
firmware-sdca/1fa/1028/db3/4.bin \
firmware-sdca/1fa/1028/db3/42450005.bin \
firmware-sdca/1fa/1028/db4/1.bin \
firmware-sdca/1fa/1028/db4/2.bin \
firmware-sdca/1fa/1028/db4/3.bin \
firmware-sdca/1fa/1028/db4/4.bin \
firmware-sdca/1fa/1028/db4/42450005.bin \
firmware-sdca/1fa/1028/db9/1.bin \
firmware-sdca/1fa/1028/db9/2.bin \
firmware-sdca/1fa/1028/db9/3.bin \
firmware-sdca/1fa/1028/db9/4.bin \
firmware-sdca/1fa/1028/db9/42450005.bin \
firmware-sdca/1fa/1028/dba/1.bin \
firmware-sdca/1fa/1028/dba/2.bin \
firmware-sdca/1fa/1028/dba/3.bin \
firmware-sdca/1fa/1028/dba/4.bin \
firmware-sdca/1fa/1028/dba/42450005.bin \
firmware-sdca/1fa/1028/e13/1.bin \
firmware-sdca/1fa/1028/e13/2.bin \
firmware-sdca/1fa/1028/e13/3.bin \
firmware-sdca/1fa/1028/e13/4.bin \
firmware-sdca/1fa/1028/e13/42450005.bin \
firmware-sdca/1fa/1028/e14/1.bin \
firmware-sdca/1fa/1028/e14/2.bin \
firmware-sdca/1fa/1028/e14/3.bin \
firmware-sdca/1fa/1028/e14/4.bin \
firmware-sdca/1fa/1028/e14/42450005.bin \
firmware-sdca/1fa/1028/e1a/1.bin \
firmware-sdca/1fa/1028/e1a/2.bin \
firmware-sdca/1fa/1028/e1a/3.bin \
firmware-sdca/1fa/1028/e1a/4.bin \
firmware-sdca/1fa/1028/e1a/42450005.bin \
firmware-sdca/1fa/1028/e1b/1.bin \
firmware-sdca/1fa/1028/e1b/2.bin \
firmware-sdca/1fa/1028/e1b/3.bin \
firmware-sdca/1fa/1028/e1b/4.bin \
firmware-sdca/1fa/1028/e1b/42450005.bin \
firmware-sdca/1fa/1028/e1c/1.bin \
firmware-sdca/1fa/1028/e1c/2.bin \
firmware-sdca/1fa/1028/e1c/3.bin \
firmware-sdca/1fa/1028/e1c/4.bin \
firmware-sdca/1fa/1028/e1c/42450005.bin \
firmware-sdca/1fa/1028/e1d/1.bin \
firmware-sdca/1fa/1028/e1d/2.bin \
firmware-sdca/1fa/1028/e1d/3.bin \
firmware-sdca/1fa/1028/e1d/4.bin \
firmware-sdca/1fa/1028/e1d/42450005.bin \
firmware-sdca/1fa/1028/e1e/1.bin \
firmware-sdca/1fa/1028/e1e/2.bin \
firmware-sdca/1fa/1028/e1e/3.bin \
firmware-sdca/1fa/1028/e1e/4.bin \
firmware-sdca/1fa/1028/e1e/42450005.bin \
firmware-sdca/1fa/1028/e1f/1.bin \
firmware-sdca/1fa/1028/e1f/2.bin \
firmware-sdca/1fa/1028/e1f/3.bin \
firmware-sdca/1fa/1028/e1f/4.bin \
firmware-sdca/1fa/1028/e1f/42450005.bin \
firmware-sdca/1fa/1028/e20/1.bin \
firmware-sdca/1fa/1028/e20/2.bin \
firmware-sdca/1fa/1028/e20/3.bin \
firmware-sdca/1fa/1028/e20/4.bin \
firmware-sdca/1fa/1028/e20/42450005.bin \
firmware-sdca/1fa/1028/e21/1.bin \
firmware-sdca/1fa/1028/e21/2.bin \
firmware-sdca/1fa/1028/e21/3.bin \
firmware-sdca/1fa/1028/e21/4.bin \
firmware-sdca/1fa/1028/e21/42450005.bin \
firmware-sdca/1fa/1028/e22/1.bin \
firmware-sdca/1fa/1028/e22/2.bin \
firmware-sdca/1fa/1028/e22/3.bin \
firmware-sdca/1fa/1028/e22/4.bin \
firmware-sdca/1fa/1028/e22/42450005.bin \
firmware-sdca/1fa/1028/e23/1.bin \
firmware-sdca/1fa/1028/e23/2.bin \
firmware-sdca/1fa/1028/e23/3.bin \
firmware-sdca/1fa/1028/e23/4.bin \
firmware-sdca/1fa/1028/e23/42450005.bin \
firmware-sdca/1fa/1028/e24/1.bin \
firmware-sdca/1fa/1028/e24/2.bin \
firmware-sdca/1fa/1028/e24/3.bin \
firmware-sdca/1fa/1028/e24/4.bin \
firmware-sdca/1fa/1028/e24/42450005.bin \
firmware-sdca/1fa/1028/e25/1.bin \
firmware-sdca/1fa/1028/e25/2.bin \
firmware-sdca/1fa/1028/e25/3.bin \
firmware-sdca/1fa/1028/e25/4.bin \
firmware-sdca/1fa/1028/e25/42450005.bin \
firmware-sdca/1fa/1028/e26/1.bin \
firmware-sdca/1fa/1028/e26/2.bin \
firmware-sdca/1fa/1028/e26/3.bin \
firmware-sdca/1fa/1028/e26/4.bin \
firmware-sdca/1fa/1028/e26/42450005.bin \
firmware-sdca/1fa/1028/e27/1.bin \
firmware-sdca/1fa/1028/e27/2.bin \
firmware-sdca/1fa/1028/e27/3.bin \
firmware-sdca/1fa/1028/e27/4.bin \
firmware-sdca/1fa/1028/e27/42450005.bin \
firmware-sdca/1fa/1028/e28/1.bin \
firmware-sdca/1fa/1028/e28/2.bin \
firmware-sdca/1fa/1028/e28/3.bin \
firmware-sdca/1fa/1028/e28/4.bin \
firmware-sdca/1fa/1028/e28/42450005.bin \
firmware-sdca/1fa/1028/e2b/1.bin \
firmware-sdca/1fa/1028/e2b/2.bin \
firmware-sdca/1fa/1028/e2b/3.bin \
firmware-sdca/1fa/1028/e2b/4.bin \
firmware-sdca/1fa/1028/e2b/42450005.bin \
firmware-sdca/1fa/1028/e2c/1.bin \
firmware-sdca/1fa/1028/e2c/2.bin \
firmware-sdca/1fa/1028/e2c/3.bin \
firmware-sdca/1fa/1028/e2c/4.bin \
firmware-sdca/1fa/1028/e2c/42450005.bin \
firmware-sdca/1fa/1028/e38/1.bin \
firmware-sdca/1fa/1028/e38/2.bin \
firmware-sdca/1fa/1028/e38/3.bin \
firmware-sdca/1fa/1028/e38/4.bin \
firmware-sdca/1fa/1028/e38/42450005.bin \
firmware-sdca/1fa/1028/e3e/1.bin \
firmware-sdca/1fa/1028/e3e/2.bin \
firmware-sdca/1fa/1028/e3e/3.bin \
firmware-sdca/1fa/1028/e3e/4.bin \
firmware-sdca/1fa/1028/e3e/42450005.bin \
firmware-sdca/1fa/1028/e3f/1.bin \
firmware-sdca/1fa/1028/e3f/2.bin \
firmware-sdca/1fa/1028/e3f/3.bin \
firmware-sdca/1fa/1028/e3f/4.bin \
firmware-sdca/1fa/1028/e3f/42450005.bin \
firmware-sdca/1fa/1028/e5f/1.bin \
firmware-sdca/1fa/1028/e5f/2.bin \
firmware-sdca/1fa/1028/e5f/3.bin \
firmware-sdca/1fa/1028/e5f/4.bin \
firmware-sdca/1fa/1028/e5f/42450005.bin \
firmware-sdca/1fa/1028/e60/1.bin \
firmware-sdca/1fa/1028/e60/2.bin \
firmware-sdca/1fa/1028/e60/3.bin \
firmware-sdca/1fa/1028/e60/4.bin \
firmware-sdca/1fa/1028/e60/42450005.bin \
firmware-sdca/1fa/1028/e65/1.bin \
firmware-sdca/1fa/1028/e65/2.bin \
firmware-sdca/1fa/1028/e65/3.bin \
firmware-sdca/1fa/1028/e65/4.bin \
firmware-sdca/1fa/1028/e65/42450005.bin \
firmware-sdca/1fa/1028/e66/1.bin \
firmware-sdca/1fa/1028/e66/2.bin \
firmware-sdca/1fa/1028/e66/3.bin \
firmware-sdca/1fa/1028/e66/4.bin \
firmware-sdca/1fa/1028/e66/42450005.bin \
firmware-sdca/1fa/1028/e82/1.bin \
firmware-sdca/1fa/1028/e82/2.bin \
firmware-sdca/1fa/1028/e82/3.bin \
firmware-sdca/1fa/1028/e82/4.bin \
firmware-sdca/1fa/1028/e82/42450005.bin \
firmware-sdca/1fa/1028/e83/1.bin \
firmware-sdca/1fa/1028/e83/2.bin \
firmware-sdca/1fa/1028/e83/3.bin \
firmware-sdca/1fa/1028/e83/4.bin \
firmware-sdca/1fa/1028/e83/42450005.bin \
firmware-sdca/1fa/1028/e84/1.bin \
firmware-sdca/1fa/1028/e84/2.bin \
firmware-sdca/1fa/1028/e84/3.bin \
firmware-sdca/1fa/1028/e84/4.bin \
firmware-sdca/1fa/1028/e84/42450005.bin \
firmware-sdca/1fa/1028/e85/1.bin \
firmware-sdca/1fa/1028/e85/2.bin \
firmware-sdca/1fa/1028/e85/3.bin \
firmware-sdca/1fa/1028/e85/4.bin \
firmware-sdca/1fa/1028/e85/42450005.bin \
firmware-sdca/1fa/1028/efb/1.bin \
firmware-sdca/1fa/1028/efb/2.bin \
firmware-sdca/1fa/1028/efb/3.bin \
firmware-sdca/1fa/1028/efb/4.bin \
firmware-sdca/1fa/1028/efb/42450005.bin \
firmware-sdca/1fa/1028/efc/1.bin \
firmware-sdca/1fa/1028/efc/2.bin \
firmware-sdca/1fa/1028/efc/3.bin \
firmware-sdca/1fa/1028/efc/4.bin \
firmware-sdca/1fa/1028/efc/42450005.bin \
firmware-sdca/1fa/144d/c1dc/1.bin \
firmware-sdca/1fa/144d/c1dc/2.bin \
firmware-sdca/1fa/144d/c1dc/3.bin \
firmware-sdca/1fa/144d/c1dc/4.bin \
firmware-sdca/1fa/144d/c1dc/42450005.bin \
firmware-sdca/1fa/144d/c1de/1.bin \
firmware-sdca/1fa/144d/c1de/2.bin \
firmware-sdca/1fa/144d/c1de/3.bin \
firmware-sdca/1fa/144d/c1de/4.bin \
firmware-sdca/1fa/144d/c1de/42450005.bin \
firmware-sdca/1fa/144d/c910/1.bin \
firmware-sdca/1fa/144d/c910/2.bin \
firmware-sdca/1fa/144d/c910/3.bin \
firmware-sdca/1fa/144d/c910/4.bin \
firmware-sdca/1fa/144d/c910/42450005.bin \
firmware-sdca/1fa/144d/ca0a/1.bin \
firmware-sdca/1fa/144d/ca0a/2.bin \
firmware-sdca/1fa/144d/ca0a/3.bin \
firmware-sdca/1fa/144d/ca0a/4.bin \
firmware-sdca/1fa/144d/ca0a/42450005.bin \
firmware-sdca/1fa/17aa/2352/1.bin \
firmware-sdca/1fa/17aa/2352/2.bin \
firmware-sdca/1fa/17aa/2352/3.bin \
firmware-sdca/1fa/17aa/2352/4.bin \
firmware-sdca/1fa/17aa/2352/42450005.bin \
firmware-sdca/1fa/17aa/2353/1.bin \
firmware-sdca/1fa/17aa/2353/2.bin \
firmware-sdca/1fa/17aa/2353/3.bin \
firmware-sdca/1fa/17aa/2353/4.bin \
firmware-sdca/1fa/17aa/2353/42450005.bin \
firmware-sdca/1fa/17aa/5158/1.bin \
firmware-sdca/1fa/17aa/5158/2.bin \
firmware-sdca/1fa/17aa/5158/3.bin \
firmware-sdca/1fa/17aa/5158/4.bin \
firmware-sdca/1fa/17aa/5158/42450005.bin \
firmware-sdca/1fa/17aa/5159/1.bin \
firmware-sdca/1fa/17aa/5159/2.bin \
firmware-sdca/1fa/17aa/5159/3.bin \
firmware-sdca/1fa/17aa/5159/4.bin \
firmware-sdca/1fa/17aa/5159/42450005.bin \
firmware-tas2572-1-1amp-reg.bin \
firmware-tas2572-2-1amp-reg.bin \
firmware-tas2572-3-1amp-reg.bin \
firmware-tas2572-3amp-reg.bin \
firmware-tas2573-2amp-reg.bin \
firmware-tas257x-1amp-reg.bin \
firmware-ti/audio/tas2563/INT8866RCA2.bin \
firmware-ti/audio/tas2563/TAS2XXX3870.bin \
firmware-ti/audio/tas257x/tas2572-1-1amp-reg.bin \
firmware-ti/audio/tas257x/tas2572-2-1amp-reg.bin \
firmware-ti/audio/tas257x/tas2572-3-1amp-reg.bin \
firmware-ti/audio/tas257x/tas2572-3amp-reg.bin \
firmware-ti/audio/tas257x/tas2573-2amp-reg.bin \
firmware-ti/audio/tas257x/tas257x-1amp-reg.bin \
firmware-ti/audio/tas2781/TAS2XXX0C94.bin \
firmware-ti/audio/tas2781/TAS2XXX0C95.bin \
firmware-ti/audio/tas2781/TAS2XXX0C96.bin \
firmware-ti/audio/tas2781/TAS2XXX0C97.bin \
firmware-ti/audio/tas2781/TAS2XXX10A40.bin \
firmware-ti/audio/tas2781/TAS2XXX10A41.bin \
firmware-ti/audio/tas2781/TAS2XXX11540.bin \
firmware-ti/audio/tas2781/TAS2XXX11541.bin \
firmware-ti/audio/tas2781/TAS2XXX12040.bin \
firmware-ti/audio/tas2781/TAS2XXX12041.bin \
firmware-ti/audio/tas2781/TAS2XXX12140.bin \
firmware-ti/audio/tas2781/TAS2XXX12141.bin \
firmware-ti/audio/tas2781/TAS2XXX13840.bin \
firmware-ti/audio/tas2781/TAS2XXX13841.bin \
firmware-ti/audio/tas2781/TAS2XXX13940.bin \
firmware-ti/audio/tas2781/TAS2XXX13941.bin \
firmware-ti/audio/tas2781/TAS2XXX13A40.bin \
firmware-ti/audio/tas2781/TAS2XXX13A41.bin \
firmware-ti/audio/tas2781/TAS2XXX1EB30.bin \
firmware-ti/audio/tas2781/TAS2XXX1EB31.bin \
firmware-ti/audio/tas2781/TAS2XXX2234.bin \
firmware-ti/audio/tas2781/TAS2XXX2326.bin \
firmware-ti/audio/tas2781/TAS2XXX387D.bin \
firmware-ti/audio/tas2781/TAS2XXX387E.bin \
firmware-ti/audio/tas2781/TAS2XXX387F.bin \
firmware-ti/audio/tas2781/TAS2XXX3880.bin \
firmware-ti/audio/tas2781/TAS2XXX3881.bin \
firmware-ti/audio/tas2781/TAS2XXX3882.bin \
firmware-ti/audio/tas2781/TAS2XXX3884.bin \
firmware-ti/audio/tas2781/TAS2XXX3886.bin \
firmware-ti/audio/tas2781/TAS2XXX38A5.bin \
firmware-ti/audio/tas2781/TAS2XXX38A7.bin \
firmware-ti/audio/tas2781/TAS2XXX38A8.bin \
firmware-ti/audio/tas2781/TAS2XXX38B8.bin \
firmware-ti/audio/tas2781/TAS2XXX38B9.bin \
firmware-ti/audio/tas2781/TAS2XXX38BA.bin \
firmware-ti/audio/tas2781/TAS2XXX38BB.bin \
firmware-ti/audio/tas2781/TAS2XXX38BE.bin \
firmware-ti/audio/tas2781/TAS2XXX38BF.bin \
firmware-ti/audio/tas2781/TAS2XXX38C3.bin \
firmware-ti/audio/tas2781/TAS2XXX38CB.bin \
firmware-ti/audio/tas2781/TAS2XXX38CD.bin \
firmware-ti/audio/tas2781/TAS2XXX38D3.bin \
firmware-ti/audio/tas2781/TAS2XXX38D4.bin \
firmware-ti/audio/tas2781/TAS2XXX38D5.bin \
firmware-ti/audio/tas2781/TAS2XXX38D6.bin \
firmware-ti/audio/tas2781/TAS2XXX38DF.bin \
firmware-ti/audio/tas2781/TAS2XXX38E0.bin \
firmware-ti/audio/tas2781/TAS2XXX38FD.bin \
firmware-ti/audio/tas2781/TAS2XXX391F.bin \
firmware-ti/audio/tas2781/TAS2XXX3920.bin \
firmware-ti/audio/tas2781/TAS2XXX3E300.bin \
firmware-ti/audio/tas2781/TAS2XXX3E301.bin \
firmware-ti/audio/tas2781/TAS2XXX3EE00.bin \
firmware-ti/audio/tas2781/TAS2XXX3EE01.bin \
firmware-ti/audio/tas2781/TAS2XXX3EF00.bin \
firmware-ti/audio/tas2781/TAS2XXX3EF01.bin \
firmware-ti/audio/tas2781/TAS2XXX3F000.bin \
firmware-ti/audio/tas2781/TAS2XXX3F001.bin \
firmware-ti/audio/tas2781/TAS2XXX3F100.bin \
firmware-ti/audio/tas2781/TAS2XXX3F101.bin \
firmware-ti/audio/tas2781/TAS2XXX3F200.bin \
firmware-ti/audio/tas2781/TAS2XXX3F201.bin \
firmware-ti/audio/tas2781/TAS2XXX3F300.bin \
firmware-ti/audio/tas2781/TAS2XXX3F301.bin \
firmware-ti/audio/tas2781/TAS2XXX8C70.bin \
firmware-ti/audio/tas2781/TAS2XXX8C71.bin \
firmware-ti/audio/tas2781/TAS2XXX8C72.bin \
firmware-ti/audio/tas2781/TAS2XXX8D8E.bin \
firmware-ti/audio/tas2781/TAS2XXX8DAA.bin \
firmware-ti/audio/tas2781/TAS2XXX8DE8.bin \
firmware-ti/audio/tas2781/TAS2XXX8DE9.bin \
firmware-ti/audio/tas2781/TAS2XXX8E17.bin \
firmware-ti/audio/tas2781/TAS2XXX8E19.bin \
firmware-ti/audio/tas2781/TAS2XXX8E1C.bin \
firmware-ti/audio/tas2781/TAS2XXX8E8A.bin \
firmware-ti/audio/tas2781/TAS2XXX8ED5.bin \
firmware-ti/audio/tas2781/TAS2XXX8ED6.bin \
firmware-ti/audio/tas2781/TAS2XXX8ED7.bin \
firmware-ti/audio/tas2781/TAS2XXX8ED8.bin \
firmware-ti/audio/tas2781/TAS2XXX8ED9.bin \
firmware-ti/audio/tas2781/TAS2XXX8EDA.bin \
firmware-ti/audio/tas2781/TAS2XXX8F40.bin \
firmware-ti/audio/tas2781/TAS2XXX8F41.bin \
firmware-ti/audio/tas2781/TAS2XXX8F42.bin \
firmware-ti/audio/tas2781/TAS2XXX8F62.bin \
firmware-ti/audio/tas2781/TAS2XXX8F7E.bin \
firmware-ti/audio/tas2781/TAS2XXX8F94.bin \
firmware-ti/audio/tas2781/TAS2XXX8F95.bin \
firmware-ti/audio/tas2781/TIAS2781RCA2.bin \
firmware-ti/audio/tas2781/TIAS2781RCA4.bin \
firmware-ti/audio/tas2781/TXNW2781RCA0.bin \
firmware-ti/audio/tas2781/TXNW2781RCA1.bin \
firmware-ti/audio/tas2783/1534-2-0x8.bin \
firmware-ti/audio/tas2783/1534-2-0xB.bin \
firmware-ti/audio/tas2783/15E2-0-0x8.bin \
firmware-ti/audio/tas2783/15E2-0-0x9.bin \
firmware-ti/audio/tas2783/15E2-0-0xA.bin \
firmware-ti/audio/tas2783/15E2-0-0xB.bin \
firmware-ti/audio/tas2783/15E2-0-0xC.bin \
firmware-ti/audio/tas2783/15E2-0-0xD.bin \
firmware-ti/audio/tas2783/15E2-0-0xE.bin \
firmware-ti/audio/tas2783/15E2-0-0xF.bin \
firmware-ti/audio/tas2783/15E2-1-0x8.bin \
firmware-ti/audio/tas2783/15E2-1-0x9.bin \
firmware-ti/audio/tas2783/15E2-1-0xA.bin \
firmware-ti/audio/tas2783/15E2-1-0xB.bin \
firmware-ti/audio/tas2783/15E2-1-0xC.bin \
firmware-ti/audio/tas2783/15E2-1-0xD.bin \
firmware-ti/audio/tas2783/15E2-1-0xE.bin \
firmware-ti/audio/tas2783/15E2-1-0xF.bin \
firmware-ti/audio/tas2783/16F4-1-0x9.bin \
firmware-ti/audio/tas2783/16F4-1-0xC.bin \
firmware-ti/audio/tas2783/1714-1-0x8.bin \
firmware-ti/audio/tas2783/1714-1-0xB.bin \
firmware-ti/audio/tas2783/1954-0-0-0x8.bin \
firmware-ti/audio/tas2783/1954-0-0-0xB.bin \
firmware-ti/audio/tas2783/1954-0-1-0x8.bin \
firmware-ti/audio/tas2783/1954-0-1-0xB.bin \
firmware-ti/audio/tas2783/1954-1-0-0x8.bin \
firmware-ti/audio/tas2783/1954-1-0-0xB.bin \
firmware-ti/audio/tas2783/1954-1-1-0x8.bin \
firmware-ti/audio/tas2783/1954-1-1-0xB.bin \
firmware-ti/audio/tas2783/1964-0-0-0x8.bin \
firmware-ti/audio/tas2783/1964-0-0-0xB.bin \
firmware-ti/audio/tas2783/1964-0-1-0x8.bin \
firmware-ti/audio/tas2783/1964-0-1-0xB.bin \
firmware-ti/audio/tas2783/1964-1-0-0x8.bin \
firmware-ti/audio/tas2783/1964-1-0-0xB.bin \
firmware-ti/audio/tas2783/1964-1-1-0x8.bin \
firmware-ti/audio/tas2783/1964-1-1-0xB.bin \
firmware-ti/audio/tas2783/1994-0-2-0xB.bin \
firmware-ti/audio/tas2783/1994-0-2-0xC.bin \
firmware-ti/audio/tas2783/1994-1-2-0xB.bin \
firmware-ti/audio/tas2783/1994-1-2-0xC.bin \
firmware-ti/audio/tas2783/1AC4-0-0-0x8.bin \
firmware-ti/audio/tas2783/1AC4-0-0-0xB.bin \
firmware-ti/audio/tas2783/1AC4-1-0-0x8.bin \
firmware-ti/audio/tas2783/1AC4-1-0-0xB.bin \
firmware-ti/audio/tas2783/1AD4-0-2-0xB.bin \
firmware-ti/audio/tas2783/1AD4-0-2-0xC.bin \
firmware-ti/audio/tas2783/1AD4-1-2-0xB.bin \
firmware-ti/audio/tas2783/1AD4-1-2-0xC.bin \
firmware-ti/audio/tas2783/1AD4-2-2-0xB.bin \
firmware-ti/audio/tas2783/1AD4-2-2-0xC.bin \
firmware-ti/audio/tas2783/1AD4-3-2-0xB.bin \
firmware-ti/audio/tas2783/1AD4-3-2-0xC.bin \
firmware-ti/audio/tas2783/1B04-0-2-0x8.bin \
firmware-ti/audio/tas2783/1B04-0-2-0xB.bin \
firmware-ti/audio/tas2783/1B04-1-2-0x8.bin \
firmware-ti/audio/tas2783/1B04-1-2-0xB.bin \
firmware-ti/audio/tas2783/1B94-0-0-0xB.bin \
firmware-ti/audio/tas2783/1B94-0-0-0xC.bin \
firmware-ti/audio/tas2783/1B94-1-0-0xB.bin \
firmware-ti/audio/tas2783/1B94-1-0-0xC.bin \
firmware-ti/audio/tas2783/1B94-2-0-0xB.bin \
firmware-ti/audio/tas2783/1B94-2-0-0xC.bin \
firmware-ti/audio/tas2783/1B94-3-0-0xB.bin \
firmware-ti/audio/tas2783/1B94-3-0-0xC.bin \
firmware-ti/audio/tas2783/1C64-0-0-0x8.bin \
firmware-ti/audio/tas2783/1C64-0-0-0xB.bin \
firmware-ti/audio/tas2783/1C64-1-0-0x8.bin \
firmware-ti/audio/tas2783/1C64-1-0-0xB.bin \
firmware-ti/audio/tas2783/3431-2-0x8.bin \
firmware-ti/audio/tas2783/3431-2-0xB.bin \
firmware-ti/audio/tas2783/35C1-1-0x9.bin \
firmware-ti/audio/tas2783/35C1-1-0xC.bin \
firmware-ti/audio/tas2783/35D1-1-0x9.bin \
firmware-ti/audio/tas2783/35D1-1-0xC.bin \
firmware-ti/audio/tas2783/35E1-1-0x9.bin \
firmware-ti/audio/tas2783/35E1-1-0xC.bin \
firmware-ti/audio/tas2783/36A1-1-0x9.bin \
firmware-ti/audio/tas2783/36A1-1-0xC.bin \
firmware-ti/audio/tas2783/36B1-1-0x9.bin \
firmware-ti/audio/tas2783/36B1-1-0xC.bin \
firmware-ti/audio/tas2783/8E86-1-0x9.bin \
firmware-ti/audio/tas2783/8E86-1-0xA.bin \
firmware-ti/audio/tas2783/8E86-1-0xC.bin \
firmware-ti/audio/tas2783/8E86-1-0xD.bin \
firmware-ti/audio/tas2783/8E86-2-0x9.bin \
firmware-ti/audio/tas2783/8E86-2-0xA.bin \
firmware-ti/audio/tas2783/8E86-2-0xC.bin \
firmware-ti/audio/tas2783/8E86-2-0xD.bin \
firmware-ti/audio/tas2783/8E87-1-0x9.bin \
firmware-ti/audio/tas2783/8E87-1-0xA.bin \
firmware-ti/audio/tas2783/8E87-1-0xC.bin \
firmware-ti/audio/tas2783/8E87-1-0xD.bin \
firmware-ti/audio/tas2783/8E87-2-0x9.bin \
firmware-ti/audio/tas2783/8E87-2-0xA.bin \
firmware-ti/audio/tas2783/8E87-2-0xC.bin \
firmware-ti/audio/tas2783/8E87-2-0xD.bin \
firmware-ti/audio/tas2783/8EA1-0-0-0x9.bin \
firmware-ti/audio/tas2783/8EA1-0-0-0xC.bin \
firmware-ti/audio/tas2783/8EA1-1-0-0x9.bin \
firmware-ti/audio/tas2783/8EA1-1-0-0xC.bin \
firmware-ti/audio/tas2783/8EA2-0-0-0x9.bin \
firmware-ti/audio/tas2783/8EA2-0-0-0xC.bin \
firmware-ti/audio/tas2783/8EA2-1-0-0x9.bin \
firmware-ti/audio/tas2783/8EA2-1-0-0xC.bin \
firmware-ti/audio/tas2783/8EA4-0-2-0x9.bin \
firmware-ti/audio/tas2783/8EA4-0-2-0xC.bin \
firmware-ti/audio/tas2783/8EA4-1-2-0x9.bin \
firmware-ti/audio/tas2783/8EA4-1-2-0xC.bin \
firmware-ti/audio/tas2783/8EA5-0-2-0x9.bin \
firmware-ti/audio/tas2783/8EA5-0-2-0xC.bin \
firmware-ti/audio/tas2783/8EA5-1-2-0x9.bin \
firmware-ti/audio/tas2783/8EA5-1-2-0xC.bin \
firmware-ti/audio/tas2783/8EA6-0-2-0x9.bin \
firmware-ti/audio/tas2783/8EA6-0-2-0xC.bin \
firmware-ti/audio/tas2783/8EA6-1-2-0x9.bin \
firmware-ti/audio/tas2783/8EA6-1-2-0xC.bin \
firmware-ti/audio/tas2783/8EA7-0-2-0x9.bin \
firmware-ti/audio/tas2783/8EA7-0-2-0xC.bin \
firmware-ti/audio/tas2783/8EA7-1-2-0x9.bin \
firmware-ti/audio/tas2783/8EA7-1-2-0xC.bin \
firmware-ti/audio/tas2783/8EA8-0-2-0x9.bin \
firmware-ti/audio/tas2783/8EA8-0-2-0xC.bin \
firmware-ti/audio/tas2783/8EA8-1-2-0x9.bin \
firmware-ti/audio/tas2783/8EA8-1-2-0xC.bin \
firmware-ti/audio/tas2783/8EB4-1-0xA.bin \
firmware-ti/audio/tas2783/8EB4-1-0xD.bin \
firmware-ti/audio/tas2783/8EB4-2-0x9.bin \
firmware-ti/audio/tas2783/8EB4-2-0xC.bin \
firmware-ti/audio/tas2783/8ED0-1-0xC.bin \
firmware-ti/audio/tas2783/8ED0-2-0x9.bin \
firmware-ti/audio/tas2783/8EF5-0-0x9.bin \
firmware-ti/audio/tas2783/8EF5-0-0xA.bin \
firmware-ti/audio/tas2783/8EF5-0-0xC.bin \
firmware-ti/audio/tas2783/8EF5-0-0xD.bin \
firmware-ti/audio/tas2783/8EF6-2-0x9.bin \
firmware-ti/audio/tas2783/8EF6-2-0xC.bin \
firmware-ti/audio/tas2783/8EF6-X-9.bin \
firmware-ti/audio/tas2783/8EF6-X-C.bin \
firmware-ti/audio/tas2783/8EXX-X-9.bin \
firmware-ti/audio/tas2783/8EXX-X-A.bin \
firmware-ti/audio/tas2783/8EXX-X-C.bin \
firmware-ti/audio/tas2783/8EXX-X-D.bin \
firmware-ti/audio/tas2783/8F6D-0-0x9.bin \
firmware-ti/audio/tas2783/8F6D-0-0xA.bin \
firmware-ti/audio/tas2783/8F6D-0-0xC.bin \
firmware-ti/audio/tas2783/8F6D-0-0xD.bin \
firmware-ti/audio/tas2783/8F7B-1-0x9.bin \
firmware-ti/audio/tas2783/8F7B-1-0xA.bin \
firmware-ti/audio/tas2783/8F7B-1-0xC.bin \
firmware-ti/audio/tas2783/8F7B-1-0xD.bin \
firmware-ti/audio/tas2783/8F7B-2-0x9.bin \
firmware-ti/audio/tas2783/8F7B-2-0xA.bin \
firmware-ti/audio/tas2783/8F7B-2-0xC.bin \
firmware-ti/audio/tas2783/8F7B-2-0xD.bin \
firmware-ti/audio/tas2783/8FA4-0-0x9.bin \
firmware-ti/audio/tas2783/8FA4-0-0xA.bin \
firmware-ti/audio/tas2783/8FA4-0-0xC.bin \
firmware-ti/audio/tas2783/8FA4-0-0xD.bin \
firmware-ti/audio/tas2783/8FA5-0-0x9.bin \
firmware-ti/audio/tas2783/8FA5-0-0xA.bin \
firmware-ti/audio/tas2783/8FA5-0-0xC.bin \
firmware-ti/audio/tas2783/8FA5-0-0xD.bin \
firmware-ti/audio/tas2783/8FF4-1-0xC.bin \
firmware-ti/audio/tas2783/8FF4-1-0xD.bin \
firmware-ti/audio/tas2783/8FF4-2-0x9.bin \
firmware-ti/audio/tas2783/8FF4-2-0xA.bin \
firmware-ti/audio/tas2783/8FF5-1-0xC.bin \
firmware-ti/audio/tas2783/8FF5-1-0xD.bin \
firmware-ti/audio/tas2783/8FF5-2-0x9.bin \
firmware-ti/audio/tas2783/8FF5-2-0xA.bin \
firmware-ti/audio/tas2783/8FF7-1-0xC.bin \
firmware-ti/audio/tas2783/8FF7-2-0x9.bin \
firmware-ti/audio/tas2783/9001-1-0xA.bin \
firmware-ti/audio/tas2783/9001-1-0xD.bin \
firmware-ti/audio/tas2783/9001-2-0x9.bin \
firmware-ti/audio/tas2783/9001-2-0xC.bin \
firmware-ti/audio/tas2783/9013-0-2-0x9.bin \
firmware-ti/audio/tas2783/9013-0-2-0xC.bin \
firmware-ti/audio/tas2783/9013-1-2-0x9.bin \
firmware-ti/audio/tas2783/9013-1-2-0xC.bin \
firmware-ti/audio/tas2783/9014-0-2-0x9.bin \
firmware-ti/audio/tas2783/9014-0-2-0xC.bin \
firmware-ti/audio/tas2783/9014-1-2-0x9.bin \
firmware-ti/audio/tas2783/9014-1-2-0xC.bin \
firmware-ti/audio/tas2783/9015-0-2-0x9.bin \
firmware-ti/audio/tas2783/9015-0-2-0xC.bin \
firmware-ti/audio/tas2783/9015-1-2-0x9.bin \
firmware-ti/audio/tas2783/9015-1-2-0xC.bin \
firmware-ti/audio/tas2783/9026-0-2-0x9.bin \
firmware-ti/audio/tas2783/9026-0-2-0xC.bin \
firmware-ti/audio/tas2783/9026-1-2-0x9.bin \
firmware-ti/audio/tas2783/9026-1-2-0xC.bin \
firmware-ti/audio/tas2783/9028-2-0xC.bin \
firmware-ti/audio/tas2783/9028-2-0xD.bin \
firmware-ti/audio/tas2783/9028-3-0x9.bin \
firmware-ti/audio/tas2783/9028-3-0xA.bin \
firmware-ti/audio/tas2783/9029-2-0xC.bin \
firmware-ti/audio/tas2783/9029-3-0x9.bin \
firmware-ti/pcm6240/pcm6240-i2c-1-2dev.bin \
firmware-yamaha/yss225-registers.bin \
kernel-firmware-sound"

RDEPENDS:${PN} += "/usr/bin/mkdir \
/usr/bin/sh \
/usr/bin/touch \
dracut"

inherit rpm
