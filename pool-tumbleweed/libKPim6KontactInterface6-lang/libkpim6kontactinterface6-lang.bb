SUMMARY = "Translations for package libKPim6KontactInterface6"
DESCRIPTION = "Provides translations for the 'libKPim6KontactInterface6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6KontactInterface6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "3015d837cbe293e7af7ec88e62707f7086831898fe6f61472c6b596ad8bde6681db82c2b3d0043dfd60b883e26a0e9d1f99b5f9f1314f60e2e3f4a45dda2c00c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6KontactInterface6-lang \
libKPim6KontactInterface6-lang-all \
locale-libKPim6KontactInterface6-ar \
locale-libKPim6KontactInterface6-ast \
locale-libKPim6KontactInterface6-az \
locale-libKPim6KontactInterface6-bg \
locale-libKPim6KontactInterface6-bs \
locale-libKPim6KontactInterface6-ca \
locale-libKPim6KontactInterface6-ca@valencia \
locale-libKPim6KontactInterface6-cs \
locale-libKPim6KontactInterface6-da \
locale-libKPim6KontactInterface6-de \
locale-libKPim6KontactInterface6-el \
locale-libKPim6KontactInterface6-en-GB \
locale-libKPim6KontactInterface6-eo \
locale-libKPim6KontactInterface6-es \
locale-libKPim6KontactInterface6-et \
locale-libKPim6KontactInterface6-eu \
locale-libKPim6KontactInterface6-fa \
locale-libKPim6KontactInterface6-fi \
locale-libKPim6KontactInterface6-fr \
locale-libKPim6KontactInterface6-ga \
locale-libKPim6KontactInterface6-gl \
locale-libKPim6KontactInterface6-he \
locale-libKPim6KontactInterface6-hi \
locale-libKPim6KontactInterface6-hu \
locale-libKPim6KontactInterface6-ia \
locale-libKPim6KontactInterface6-is \
locale-libKPim6KontactInterface6-it \
locale-libKPim6KontactInterface6-ja \
locale-libKPim6KontactInterface6-ka \
locale-libKPim6KontactInterface6-kk \
locale-libKPim6KontactInterface6-km \
locale-libKPim6KontactInterface6-ko \
locale-libKPim6KontactInterface6-lt \
locale-libKPim6KontactInterface6-lv \
locale-libKPim6KontactInterface6-mr \
locale-libKPim6KontactInterface6-nb \
locale-libKPim6KontactInterface6-nds \
locale-libKPim6KontactInterface6-nl \
locale-libKPim6KontactInterface6-nn \
locale-libKPim6KontactInterface6-pa \
locale-libKPim6KontactInterface6-pl \
locale-libKPim6KontactInterface6-pt \
locale-libKPim6KontactInterface6-pt-BR \
locale-libKPim6KontactInterface6-ro \
locale-libKPim6KontactInterface6-ru \
locale-libKPim6KontactInterface6-sk \
locale-libKPim6KontactInterface6-sl \
locale-libKPim6KontactInterface6-sq \
locale-libKPim6KontactInterface6-sr \
locale-libKPim6KontactInterface6-sr@ijekavian \
locale-libKPim6KontactInterface6-sr@ijekavianlatin \
locale-libKPim6KontactInterface6-sr@latin \
locale-libKPim6KontactInterface6-sv \
locale-libKPim6KontactInterface6-tr \
locale-libKPim6KontactInterface6-ug \
locale-libKPim6KontactInterface6-uk \
locale-libKPim6KontactInterface6-vi \
locale-libKPim6KontactInterface6-wa \
locale-libKPim6KontactInterface6-zh-CN \
locale-libKPim6KontactInterface6-zh-TW"

RDEPENDS:${PN} += "libKPim6KontactInterface6"

inherit rpm
