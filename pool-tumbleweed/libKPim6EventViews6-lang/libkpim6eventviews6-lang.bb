SUMMARY = "Translations for package libKPim6EventViews6"
DESCRIPTION = "Provides translations for the 'libKPim6EventViews6' package."
LICENSE = "GPL-2.0-or-later & LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6EventViews6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "052f46a61f4948871f46006b11926c02a3989610b3c6ef88d4b58a8cc62355f27fda376f9cb43a741fc8cc9b4874f7a423668171c1feba549c70658d80886f2f"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6EventViews6-lang \
libKPim6EventViews6-lang-all \
locale-libKPim6EventViews6-ar \
locale-libKPim6EventViews6-ast \
locale-libKPim6EventViews6-bg \
locale-libKPim6EventViews6-bs \
locale-libKPim6EventViews6-ca \
locale-libKPim6EventViews6-ca@valencia \
locale-libKPim6EventViews6-cs \
locale-libKPim6EventViews6-da \
locale-libKPim6EventViews6-de \
locale-libKPim6EventViews6-el \
locale-libKPim6EventViews6-en-GB \
locale-libKPim6EventViews6-eo \
locale-libKPim6EventViews6-es \
locale-libKPim6EventViews6-et \
locale-libKPim6EventViews6-eu \
locale-libKPim6EventViews6-fi \
locale-libKPim6EventViews6-fr \
locale-libKPim6EventViews6-ga \
locale-libKPim6EventViews6-gl \
locale-libKPim6EventViews6-he \
locale-libKPim6EventViews6-hi \
locale-libKPim6EventViews6-hu \
locale-libKPim6EventViews6-ia \
locale-libKPim6EventViews6-it \
locale-libKPim6EventViews6-ja \
locale-libKPim6EventViews6-ka \
locale-libKPim6EventViews6-kk \
locale-libKPim6EventViews6-ko \
locale-libKPim6EventViews6-lt \
locale-libKPim6EventViews6-lv \
locale-libKPim6EventViews6-mr \
locale-libKPim6EventViews6-nb \
locale-libKPim6EventViews6-nds \
locale-libKPim6EventViews6-nl \
locale-libKPim6EventViews6-pa \
locale-libKPim6EventViews6-pl \
locale-libKPim6EventViews6-pt \
locale-libKPim6EventViews6-pt-BR \
locale-libKPim6EventViews6-ro \
locale-libKPim6EventViews6-ru \
locale-libKPim6EventViews6-sk \
locale-libKPim6EventViews6-sl \
locale-libKPim6EventViews6-sv \
locale-libKPim6EventViews6-ta \
locale-libKPim6EventViews6-tr \
locale-libKPim6EventViews6-ug \
locale-libKPim6EventViews6-uk \
locale-libKPim6EventViews6-zh-CN \
locale-libKPim6EventViews6-zh-TW"

RDEPENDS:${PN} += "libKPim6EventViews6"

inherit rpm
