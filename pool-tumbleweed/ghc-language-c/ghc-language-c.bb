SUMMARY = "Analysis and generation of C code"
DESCRIPTION = "Language C is a Haskell library for the analysis and generation of C code. \
It features a complete, well tested parser and pretty printer for all of C99 \
and a large set of C11 and clang/GNU extensions."
LICENSE = "BSD-3-Clause"

PV = "0.10.2"

RPM_NAME = "ghc-language-c-0.10.2-1.3.aarch64.rpm"
RPM_HASH = "aaf58322f91df42b85ed50ba6a9d35fec029ad86db43219eef11f978df9c16ea01c08960d643ea8730d47583e43d93641e8ba1dd34aed008d2f9308c85c48caa"

RPROVIDES:${PN} += "ghc-language-c \
libHSlanguage-c-0.10.2-AEpVayAmt2043LoOEuxA1J-ghc9.12.4.so"

RDEPENDS:${PN} += "libHSarray-0.5.8.0-2a42-ghc9.12.4.so \
libHSbase-4.21.2.0-8844-ghc9.12.4.so \
libHSbytestring-0.12.2.0-65be-ghc9.12.4.so \
libHScontainers-0.7-d5e1-ghc9.12.4.so \
libHSdeepseq-1.5.1.0-1350-ghc9.12.4.so \
libHSdirectory-1.3.10.1-b1d7-ghc9.12.4.so \
libHSexceptions-0.10.12-f655-ghc9.12.4.so \
libHSfile-io-0.1.6-8374-ghc9.12.4.so \
libHSfilepath-1.5.5.0-b25b-ghc9.12.4.so \
libHSghc-bignum-1.3-03b0-ghc9.12.4.so \
libHSghc-boot-th-9.12.4-0605-ghc9.12.4.so \
libHSghc-internal-9.1204.0-f1e1-ghc9.12.4.so \
libHSghc-prim-0.13.0-f55c-ghc9.12.4.so \
libHSmtl-2.3.2-37ef-ghc9.12.4.so \
libHSos-string-2.0.10-5320-ghc9.12.4.so \
libHSpretty-1.1.3.6-b7fd-ghc9.12.4.so \
libHSprocess-1.6.26.1-905d-ghc9.12.4.so \
libHSstm-2.5.3.1-6d74-ghc9.12.4.so \
libHStemplate-haskell-2.23.0.0-358a-ghc9.12.4.so \
libHStime-1.14-a7dc-ghc9.12.4.so \
libHStransformers-0.6.3.0-4709-ghc9.12.4.so \
libHSunix-2.8.8.0-178a-ghc9.12.4.so \
libc.so.6 \
libgmp.so.10 \
libm.so.6"

inherit rpm
