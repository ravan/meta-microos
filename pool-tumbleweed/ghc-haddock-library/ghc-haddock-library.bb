SUMMARY = "Haskell haddock-library library"
DESCRIPTION = "This package provides the Haskell haddock-library library."
LICENSE = "BSD-3-Clause"

PV = "1.11.0"

RPM_NAME = "ghc-haddock-library-1.11.0-1.3.aarch64.rpm"
RPM_HASH = "d38e050991395857ad2d754e9d6d6232fbfba27acd04b1a3f2a77ffec08dbf0828edb055d8dc44d1be234ceaf5cc1d61a5dcb1094fb36cd5c0bb4e05afdc2705"

RPROVIDES:${PN} += "ghc-haddock-library \
libHShaddock-library-1.11.0-799c-ghc9.12.4.so"

RDEPENDS:${PN} += "/sbin/ldconfig \
libHSarray-0.5.8.0-2a42-ghc9.12.4.so \
libHSbase-4.21.2.0-8844-ghc9.12.4.so \
libHSbinary-0.8.9.3-9861-ghc9.12.4.so \
libHSbytestring-0.12.2.0-65be-ghc9.12.4.so \
libHScontainers-0.7-d5e1-ghc9.12.4.so \
libHSdeepseq-1.5.1.0-1350-ghc9.12.4.so \
libHSghc-bignum-1.3-03b0-ghc9.12.4.so \
libHSghc-boot-th-9.12.4-0605-ghc9.12.4.so \
libHSghc-internal-9.1204.0-f1e1-ghc9.12.4.so \
libHSghc-prim-0.13.0-f55c-ghc9.12.4.so \
libHSmtl-2.3.2-37ef-ghc9.12.4.so \
libHSparsec-3.1.18.0-be05-ghc9.12.4.so \
libHSpretty-1.1.3.6-b7fd-ghc9.12.4.so \
libHStemplate-haskell-2.23.0.0-358a-ghc9.12.4.so \
libHStext-2.1.4-cf23-ghc9.12.4.so \
libHStransformers-0.6.3.0-4709-ghc9.12.4.so \
libc.so.6 \
libgmp.so.10 \
libm.so.6"

inherit rpm
