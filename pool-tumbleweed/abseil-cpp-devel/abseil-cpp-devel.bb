SUMMARY = "Header files for Abseil"
DESCRIPTION = "Abseil is a collection of C++ libraries which augment the C++ standard \
library. \
 \
This package contains headers and build system files for it."
LICENSE = "Apache-2.0"

PV = "20260817.0"

RPM_NAME = "abseil-cpp-devel-20260817.0-1.1.aarch64.rpm"
RPM_HASH = "ea8ac90f8de5855f89fa740f8dbe7fbc12c984574647e282d8deac6b14a40ef5d6cbdd77278b7e3c31e5eb01dc5cf452c7ada5a125ae930bb7ed9fb60f4546ef"

RPROVIDES:${PN} += "abseil-cpp-devel \
cmake-absl \
pkgconfig-absl-absl-check \
pkgconfig-absl-absl-log \
pkgconfig-absl-absl-vlog-is-on \
pkgconfig-absl-algorithm \
pkgconfig-absl-algorithm-container \
pkgconfig-absl-any \
pkgconfig-absl-any-invocable \
pkgconfig-absl-any-span \
pkgconfig-absl-atomic-hook \
pkgconfig-absl-bad-any-cast \
pkgconfig-absl-bad-optional-access \
pkgconfig-absl-bad-variant-access \
pkgconfig-absl-base \
pkgconfig-absl-base-cpu-detect \
pkgconfig-absl-base-internal \
pkgconfig-absl-bind-back \
pkgconfig-absl-bind-front \
pkgconfig-absl-bits \
pkgconfig-absl-bounded-utf8-length-sequence \
pkgconfig-absl-btree \
pkgconfig-absl-charset \
pkgconfig-absl-check \
pkgconfig-absl-chunked-queue \
pkgconfig-absl-city \
pkgconfig-absl-civil-time \
pkgconfig-absl-cleanup \
pkgconfig-absl-cleanup-internal \
pkgconfig-absl-clock-interface \
pkgconfig-absl-common-policy-traits \
pkgconfig-absl-compare \
pkgconfig-absl-compressed-tuple \
pkgconfig-absl-config \
pkgconfig-absl-constexpr-testing-internal \
pkgconfig-absl-container-common \
pkgconfig-absl-container-memory \
pkgconfig-absl-cord \
pkgconfig-absl-cord-internal \
pkgconfig-absl-cordz-functions \
pkgconfig-absl-cordz-handle \
pkgconfig-absl-cordz-info \
pkgconfig-absl-cordz-sample-token \
pkgconfig-absl-cordz-statistics \
pkgconfig-absl-cordz-update-scope \
pkgconfig-absl-cordz-update-tracker \
pkgconfig-absl-core-headers \
pkgconfig-absl-crc-cord-state \
pkgconfig-absl-crc-internal \
pkgconfig-absl-crc32c \
pkgconfig-absl-debugging \
pkgconfig-absl-debugging-internal \
pkgconfig-absl-decode-rust-punycode \
pkgconfig-absl-demangle-internal \
pkgconfig-absl-demangle-rust \
pkgconfig-absl-die-if-null \
pkgconfig-absl-dynamic-annotations \
pkgconfig-absl-endian \
pkgconfig-absl-errno-saver \
pkgconfig-absl-examine-stack \
pkgconfig-absl-exponential-biased \
pkgconfig-absl-failure-signal-handler \
pkgconfig-absl-fast-type-id \
pkgconfig-absl-fixed-array \
pkgconfig-absl-flags \
pkgconfig-absl-flags-commandlineflag \
pkgconfig-absl-flags-commandlineflag-internal \
pkgconfig-absl-flags-config \
pkgconfig-absl-flags-internal \
pkgconfig-absl-flags-marshalling \
pkgconfig-absl-flags-parse \
pkgconfig-absl-flags-path-util \
pkgconfig-absl-flags-private-handle-accessor \
pkgconfig-absl-flags-program-name \
pkgconfig-absl-flags-reflection \
pkgconfig-absl-flags-usage \
pkgconfig-absl-flags-usage-internal \
pkgconfig-absl-flat-hash-map \
pkgconfig-absl-flat-hash-set \
pkgconfig-absl-function-ref \
pkgconfig-absl-generic-printer-internal \
pkgconfig-absl-graphcycles-internal \
pkgconfig-absl-hardening \
pkgconfig-absl-has-ostream-operator \
pkgconfig-absl-hash \
pkgconfig-absl-hash-container-defaults \
pkgconfig-absl-hash-function-defaults \
pkgconfig-absl-hash-policy-traits \
pkgconfig-absl-hashtable-control-bytes \
pkgconfig-absl-hashtable-debug \
pkgconfig-absl-hashtable-debug-hooks \
pkgconfig-absl-hashtable-profiler \
pkgconfig-absl-hashtablez-sampler \
pkgconfig-absl-inlined-vector \
pkgconfig-absl-inlined-vector-internal \
pkgconfig-absl-int128 \
pkgconfig-absl-internal-optional-ref \
pkgconfig-absl-iterator-traits-internal \
pkgconfig-absl-iterator-traits-test-helper-internal \
pkgconfig-absl-kernel-timeout-internal \
pkgconfig-absl-layout \
pkgconfig-absl-leak-check \
pkgconfig-absl-linked-hash-map \
pkgconfig-absl-linked-hash-set \
pkgconfig-absl-log \
pkgconfig-absl-log-entry \
pkgconfig-absl-log-flags \
pkgconfig-absl-log-globals \
pkgconfig-absl-log-initialize \
pkgconfig-absl-log-internal-append-truncated \
pkgconfig-absl-log-internal-check-impl \
pkgconfig-absl-log-internal-check-op \
pkgconfig-absl-log-internal-conditions \
pkgconfig-absl-log-internal-config \
pkgconfig-absl-log-internal-container \
pkgconfig-absl-log-internal-flags \
pkgconfig-absl-log-internal-fnmatch \
pkgconfig-absl-log-internal-format \
pkgconfig-absl-log-internal-globals \
pkgconfig-absl-log-internal-log-impl \
pkgconfig-absl-log-internal-log-sink-set \
pkgconfig-absl-log-internal-message \
pkgconfig-absl-log-internal-nullguard \
pkgconfig-absl-log-internal-nullstream \
pkgconfig-absl-log-internal-proto \
pkgconfig-absl-log-internal-strip \
pkgconfig-absl-log-internal-structured \
pkgconfig-absl-log-internal-structured-proto \
pkgconfig-absl-log-internal-voidify \
pkgconfig-absl-log-severity \
pkgconfig-absl-log-sink \
pkgconfig-absl-log-sink-registry \
pkgconfig-absl-log-streamer \
pkgconfig-absl-log-structured \
pkgconfig-absl-malloc-internal \
pkgconfig-absl-memory \
pkgconfig-absl-meta \
pkgconfig-absl-no-destructor \
pkgconfig-absl-node-hash-map \
pkgconfig-absl-node-hash-set \
pkgconfig-absl-node-slot-policy \
pkgconfig-absl-non-temporal-arm-intrinsics \
pkgconfig-absl-non-temporal-memcpy \
pkgconfig-absl-nullability \
pkgconfig-absl-nullability-traits-internal \
pkgconfig-absl-numeric \
pkgconfig-absl-numeric-representation \
pkgconfig-absl-optional \
pkgconfig-absl-overload \
pkgconfig-absl-periodic-sampler \
pkgconfig-absl-poison \
pkgconfig-absl-prefetch \
pkgconfig-absl-pretty-function \
pkgconfig-absl-profile-builder \
pkgconfig-absl-random-bit-gen-ref \
pkgconfig-absl-random-distributions \
pkgconfig-absl-random-internal-distribution-caller \
pkgconfig-absl-random-internal-distribution-test-util \
pkgconfig-absl-random-internal-entropy-pool \
pkgconfig-absl-random-internal-fast-uniform-bits \
pkgconfig-absl-random-internal-fastmath \
pkgconfig-absl-random-internal-generate-real \
pkgconfig-absl-random-internal-iostream-state-saver \
pkgconfig-absl-random-internal-mock-helpers \
pkgconfig-absl-random-internal-nonsecure-base \
pkgconfig-absl-random-internal-pcg-engine \
pkgconfig-absl-random-internal-platform \
pkgconfig-absl-random-internal-randen \
pkgconfig-absl-random-internal-randen-engine \
pkgconfig-absl-random-internal-randen-hwaes \
pkgconfig-absl-random-internal-randen-hwaes-impl \
pkgconfig-absl-random-internal-randen-slow \
pkgconfig-absl-random-internal-salted-seed-seq \
pkgconfig-absl-random-internal-seed-material \
pkgconfig-absl-random-internal-traits \
pkgconfig-absl-random-internal-uniform-helper \
pkgconfig-absl-random-internal-wide-multiply \
pkgconfig-absl-random-mocking-access \
pkgconfig-absl-random-random \
pkgconfig-absl-random-seed-gen-exception \
pkgconfig-absl-random-seed-sequences \
pkgconfig-absl-raw-hash-map \
pkgconfig-absl-raw-hash-set \
pkgconfig-absl-raw-hash-set-resize-impl \
pkgconfig-absl-raw-logging-internal \
pkgconfig-absl-requires-internal \
pkgconfig-absl-sample-recorder \
pkgconfig-absl-scoped-set-env \
pkgconfig-absl-source-location \
pkgconfig-absl-span \
pkgconfig-absl-spinlock-wait \
pkgconfig-absl-stacktrace \
pkgconfig-absl-status \
pkgconfig-absl-status-builder \
pkgconfig-absl-status-macros \
pkgconfig-absl-statusor \
pkgconfig-absl-str-format \
pkgconfig-absl-str-format-internal \
pkgconfig-absl-strerror \
pkgconfig-absl-string-view \
pkgconfig-absl-stringify-stream \
pkgconfig-absl-strings \
pkgconfig-absl-strings-append-and-overwrite \
pkgconfig-absl-strings-internal \
pkgconfig-absl-strings-resize-and-overwrite \
pkgconfig-absl-symbolize \
pkgconfig-absl-synchronization \
pkgconfig-absl-throw-delegate \
pkgconfig-absl-time \
pkgconfig-absl-time-zone \
pkgconfig-absl-tracing-internal \
pkgconfig-absl-type-traits \
pkgconfig-absl-utf8-for-code-point \
pkgconfig-absl-utility \
pkgconfig-absl-variant \
pkgconfig-absl-vlog-config-internal \
pkgconfig-absl-vlog-is-on \
pkgconfig-absl-weakly-mixed-integer"

RDEPENDS:${PN} += "/usr/bin/pkg-config \
libabsl-base-cpu-detect2608-0-0 \
libabsl-base2608-0-0 \
libabsl-city2608-0-0 \
libabsl-civil-time2608-0-0 \
libabsl-clock-interface2608-0-0 \
libabsl-cord-internal2608-0-0 \
libabsl-cord2608-0-0 \
libabsl-cordz-functions2608-0-0 \
libabsl-cordz-handle2608-0-0 \
libabsl-cordz-info2608-0-0 \
libabsl-cordz-sample-token2608-0-0 \
libabsl-crc-cord-state2608-0-0 \
libabsl-crc-internal2608-0-0 \
libabsl-crc32c2608-0-0 \
libabsl-debugging-internal2608-0-0 \
libabsl-decode-rust-punycode2608-0-0 \
libabsl-demangle-internal2608-0-0 \
libabsl-demangle-rust2608-0-0 \
libabsl-die-if-null2608-0-0 \
libabsl-examine-stack2608-0-0 \
libabsl-exponential-biased2608-0-0 \
libabsl-failure-signal-handler2608-0-0 \
libabsl-flags-commandlineflag-internal2608-0-0 \
libabsl-flags-commandlineflag2608-0-0 \
libabsl-flags-config2608-0-0 \
libabsl-flags-internal2608-0-0 \
libabsl-flags-marshalling2608-0-0 \
libabsl-flags-parse2608-0-0 \
libabsl-flags-private-handle-accessor2608-0-0 \
libabsl-flags-program-name2608-0-0 \
libabsl-flags-reflection2608-0-0 \
libabsl-flags-usage-internal2608-0-0 \
libabsl-flags-usage2608-0-0 \
libabsl-generic-printer-internal2608-0-0 \
libabsl-graphcycles-internal2608-0-0 \
libabsl-hardening2608-0-0 \
libabsl-hash2608-0-0 \
libabsl-hashtable-profiler2608-0-0 \
libabsl-hashtablez-sampler2608-0-0 \
libabsl-int128-2608-0-0 \
libabsl-kernel-timeout-internal2608-0-0 \
libabsl-leak-check2608-0-0 \
libabsl-log-entry2608-0-0 \
libabsl-log-flags2608-0-0 \
libabsl-log-globals2608-0-0 \
libabsl-log-initialize2608-0-0 \
libabsl-log-internal-check-op2608-0-0 \
libabsl-log-internal-conditions2608-0-0 \
libabsl-log-internal-fnmatch2608-0-0 \
libabsl-log-internal-format2608-0-0 \
libabsl-log-internal-globals2608-0-0 \
libabsl-log-internal-log-sink-set2608-0-0 \
libabsl-log-internal-message2608-0-0 \
libabsl-log-internal-nullguard2608-0-0 \
libabsl-log-internal-proto2608-0-0 \
libabsl-log-internal-structured-proto2608-0-0 \
libabsl-log-severity2608-0-0 \
libabsl-log-sink2608-0-0 \
libabsl-malloc-internal2608-0-0 \
libabsl-periodic-sampler2608-0-0 \
libabsl-poison2608-0-0 \
libabsl-profile-builder2608-0-0 \
libabsl-random-distributions2608-0-0 \
libabsl-random-internal-distribution-test-util2608-0-0 \
libabsl-random-internal-entropy-pool2608-0-0 \
libabsl-random-internal-platform2608-0-0 \
libabsl-random-internal-randen-hwaes-impl2608-0-0 \
libabsl-random-internal-randen-hwaes2608-0-0 \
libabsl-random-internal-randen-slow2608-0-0 \
libabsl-random-internal-randen2608-0-0 \
libabsl-random-internal-seed-material2608-0-0 \
libabsl-random-seed-gen-exception2608-0-0 \
libabsl-random-seed-sequences2608-0-0 \
libabsl-raw-hash-set2608-0-0 \
libabsl-raw-logging-internal2608-0-0 \
libabsl-scoped-set-env2608-0-0 \
libabsl-source-location2608-0-0 \
libabsl-spinlock-wait2608-0-0 \
libabsl-stacktrace2608-0-0 \
libabsl-status-builder2608-0-0 \
libabsl-status2608-0-0 \
libabsl-statusor2608-0-0 \
libabsl-str-format-internal2608-0-0 \
libabsl-strerror2608-0-0 \
libabsl-strings-internal2608-0-0 \
libabsl-strings2608-0-0 \
libabsl-symbolize2608-0-0 \
libabsl-synchronization2608-0-0 \
libabsl-throw-delegate2608-0-0 \
libabsl-time-zone2608-0-0 \
libabsl-time2608-0-0 \
libabsl-tracing-internal2608-0-0 \
libabsl-utf8-for-code-point2608-0-0 \
libabsl-vlog-config-internal2608-0-0"

inherit rpm
