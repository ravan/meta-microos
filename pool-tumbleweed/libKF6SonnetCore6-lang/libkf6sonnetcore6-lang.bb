SUMMARY = "Translations for package libKF6SonnetCore6"
DESCRIPTION = "Provides translations for the 'libKF6SonnetCore6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6SonnetCore6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "34a7dfb20a7752e376c2f52d67407fc27bb8dca039b8d886902f944431c16dedacb77606da67a6bd1fc0c0e2b0e0ad7d0ff3592616dd1d9761b0880e5e446a4c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6SonnetCore6-lang \
libKF6SonnetCore6-lang-all \
locale-libKF6SonnetCore6-af \
locale-libKF6SonnetCore6-ar \
locale-libKF6SonnetCore6-as \
locale-libKF6SonnetCore6-ast \
locale-libKF6SonnetCore6-az \
locale-libKF6SonnetCore6-be \
locale-libKF6SonnetCore6-be@latin \
locale-libKF6SonnetCore6-bg \
locale-libKF6SonnetCore6-bn \
locale-libKF6SonnetCore6-bn-IN \
locale-libKF6SonnetCore6-br \
locale-libKF6SonnetCore6-bs \
locale-libKF6SonnetCore6-ca \
locale-libKF6SonnetCore6-ca@valencia \
locale-libKF6SonnetCore6-cs \
locale-libKF6SonnetCore6-cy \
locale-libKF6SonnetCore6-da \
locale-libKF6SonnetCore6-de \
locale-libKF6SonnetCore6-el \
locale-libKF6SonnetCore6-en-GB \
locale-libKF6SonnetCore6-eo \
locale-libKF6SonnetCore6-es \
locale-libKF6SonnetCore6-et \
locale-libKF6SonnetCore6-eu \
locale-libKF6SonnetCore6-fa \
locale-libKF6SonnetCore6-fi \
locale-libKF6SonnetCore6-fr \
locale-libKF6SonnetCore6-ga \
locale-libKF6SonnetCore6-gd \
locale-libKF6SonnetCore6-gl \
locale-libKF6SonnetCore6-gu \
locale-libKF6SonnetCore6-he \
locale-libKF6SonnetCore6-hi \
locale-libKF6SonnetCore6-hr \
locale-libKF6SonnetCore6-hu \
locale-libKF6SonnetCore6-ia \
locale-libKF6SonnetCore6-id \
locale-libKF6SonnetCore6-is \
locale-libKF6SonnetCore6-it \
locale-libKF6SonnetCore6-ja \
locale-libKF6SonnetCore6-ka \
locale-libKF6SonnetCore6-kk \
locale-libKF6SonnetCore6-km \
locale-libKF6SonnetCore6-kn \
locale-libKF6SonnetCore6-ko \
locale-libKF6SonnetCore6-lt \
locale-libKF6SonnetCore6-lv \
locale-libKF6SonnetCore6-mai \
locale-libKF6SonnetCore6-mk \
locale-libKF6SonnetCore6-ml \
locale-libKF6SonnetCore6-mr \
locale-libKF6SonnetCore6-ms \
locale-libKF6SonnetCore6-nb \
locale-libKF6SonnetCore6-nds \
locale-libKF6SonnetCore6-ne \
locale-libKF6SonnetCore6-nl \
locale-libKF6SonnetCore6-nn \
locale-libKF6SonnetCore6-oc \
locale-libKF6SonnetCore6-or \
locale-libKF6SonnetCore6-pa \
locale-libKF6SonnetCore6-pl \
locale-libKF6SonnetCore6-pt \
locale-libKF6SonnetCore6-pt-BR \
locale-libKF6SonnetCore6-ro \
locale-libKF6SonnetCore6-ru \
locale-libKF6SonnetCore6-si \
locale-libKF6SonnetCore6-sk \
locale-libKF6SonnetCore6-sl \
locale-libKF6SonnetCore6-sq \
locale-libKF6SonnetCore6-sr \
locale-libKF6SonnetCore6-sr@ijekavian \
locale-libKF6SonnetCore6-sr@ijekavianlatin \
locale-libKF6SonnetCore6-sr@latin \
locale-libKF6SonnetCore6-sv \
locale-libKF6SonnetCore6-ta \
locale-libKF6SonnetCore6-te \
locale-libKF6SonnetCore6-th \
locale-libKF6SonnetCore6-tr \
locale-libKF6SonnetCore6-ug \
locale-libKF6SonnetCore6-uk \
locale-libKF6SonnetCore6-vi \
locale-libKF6SonnetCore6-wa \
locale-libKF6SonnetCore6-zh-CN \
locale-libKF6SonnetCore6-zh-HK \
locale-libKF6SonnetCore6-zh-TW"

RDEPENDS:${PN} += "libKF6SonnetCore6"

inherit rpm
