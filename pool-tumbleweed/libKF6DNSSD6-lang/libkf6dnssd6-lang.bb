SUMMARY = "Translations for package libKF6DNSSD6"
DESCRIPTION = "Provides translations for the 'libKF6DNSSD6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6DNSSD6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "001f720b8f9666d589ffad03de76a6fb3bac89ec41a0d4a8c66defde614496153b0921e790eaa092dddc2eda350bd7214344925ec86de1e33a6468bb31c42d8a"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6DNSSD6-lang \
libKF6DNSSD6-lang-all \
locale-libKF6DNSSD6-af \
locale-libKF6DNSSD6-ar \
locale-libKF6DNSSD6-as \
locale-libKF6DNSSD6-ast \
locale-libKF6DNSSD6-az \
locale-libKF6DNSSD6-be \
locale-libKF6DNSSD6-be@latin \
locale-libKF6DNSSD6-bg \
locale-libKF6DNSSD6-bn \
locale-libKF6DNSSD6-bn-IN \
locale-libKF6DNSSD6-br \
locale-libKF6DNSSD6-bs \
locale-libKF6DNSSD6-ca \
locale-libKF6DNSSD6-ca@valencia \
locale-libKF6DNSSD6-cs \
locale-libKF6DNSSD6-cy \
locale-libKF6DNSSD6-da \
locale-libKF6DNSSD6-de \
locale-libKF6DNSSD6-el \
locale-libKF6DNSSD6-en-GB \
locale-libKF6DNSSD6-eo \
locale-libKF6DNSSD6-es \
locale-libKF6DNSSD6-et \
locale-libKF6DNSSD6-eu \
locale-libKF6DNSSD6-fa \
locale-libKF6DNSSD6-fi \
locale-libKF6DNSSD6-fr \
locale-libKF6DNSSD6-ga \
locale-libKF6DNSSD6-gd \
locale-libKF6DNSSD6-gl \
locale-libKF6DNSSD6-gu \
locale-libKF6DNSSD6-he \
locale-libKF6DNSSD6-hi \
locale-libKF6DNSSD6-hr \
locale-libKF6DNSSD6-hu \
locale-libKF6DNSSD6-ia \
locale-libKF6DNSSD6-id \
locale-libKF6DNSSD6-is \
locale-libKF6DNSSD6-it \
locale-libKF6DNSSD6-ja \
locale-libKF6DNSSD6-ka \
locale-libKF6DNSSD6-kk \
locale-libKF6DNSSD6-km \
locale-libKF6DNSSD6-kn \
locale-libKF6DNSSD6-ko \
locale-libKF6DNSSD6-lt \
locale-libKF6DNSSD6-lv \
locale-libKF6DNSSD6-mai \
locale-libKF6DNSSD6-mk \
locale-libKF6DNSSD6-ml \
locale-libKF6DNSSD6-mr \
locale-libKF6DNSSD6-ms \
locale-libKF6DNSSD6-nb \
locale-libKF6DNSSD6-nds \
locale-libKF6DNSSD6-ne \
locale-libKF6DNSSD6-nl \
locale-libKF6DNSSD6-nn \
locale-libKF6DNSSD6-oc \
locale-libKF6DNSSD6-or \
locale-libKF6DNSSD6-pa \
locale-libKF6DNSSD6-pl \
locale-libKF6DNSSD6-pt \
locale-libKF6DNSSD6-pt-BR \
locale-libKF6DNSSD6-ro \
locale-libKF6DNSSD6-ru \
locale-libKF6DNSSD6-si \
locale-libKF6DNSSD6-sk \
locale-libKF6DNSSD6-sl \
locale-libKF6DNSSD6-sq \
locale-libKF6DNSSD6-sr \
locale-libKF6DNSSD6-sr@ijekavian \
locale-libKF6DNSSD6-sr@ijekavianlatin \
locale-libKF6DNSSD6-sr@latin \
locale-libKF6DNSSD6-sv \
locale-libKF6DNSSD6-ta \
locale-libKF6DNSSD6-te \
locale-libKF6DNSSD6-th \
locale-libKF6DNSSD6-tr \
locale-libKF6DNSSD6-ug \
locale-libKF6DNSSD6-uk \
locale-libKF6DNSSD6-vi \
locale-libKF6DNSSD6-wa \
locale-libKF6DNSSD6-zh-CN \
locale-libKF6DNSSD6-zh-HK \
locale-libKF6DNSSD6-zh-TW"

RDEPENDS:${PN} += "libKF6DNSSD6"

inherit rpm
