ksym-64kb-sdw-amd-get-slave-info \
ksym-64kb-sdw-amd-probe \
ksym-64kb-sdw-bpt-send-async \
ksym-64kb-sdw-bpt-send-sync \
ksym-64kb-sdw-bpt-wait \
ksym-64kb-sdw-bread-no-pm-unlocked \
ksym-64kb-sdw-bus-clk-stop \
ksym-64kb-sdw-bus-exit-clk-stop \
ksym-64kb-sdw-bus-master-add \
ksym-64kb-sdw-bus-master-delete \
ksym-64kb-sdw-bus-prep-clk-stop \
ksym-64kb-sdw-bus-type \
ksym-64kb-sdw-bwrite-no-pm-unlocked \
ksym-64kb-sdw-clear-slave-status \
ksym-64kb-sdw-cols \
ksym-64kb-sdw-compare-devid \
ksym-64kb-sdw-compute-params \
ksym-64kb-sdw-compute-slave-ports \
ksym-64kb-sdw-deprepare-stream \
ksym-64kb-sdw-disable-stream \
ksym-64kb-sdw-enable-stream \
ksym-64kb-sdw-extract-slave-id \
ksym-64kb-sdw-find-col-index \
ksym-64kb-sdw-find-row-index \
ksym-64kb-sdw-handle-slave-status \
ksym-64kb-sdw-intel-acpi-scan \
ksym-64kb-sdw-master-read-prop \
ksym-64kb-sdw-nread \
ksym-64kb-sdw-nread-no-pm \
ksym-64kb-sdw-nwrite \
ksym-64kb-sdw-nwrite-no-pm \
ksym-64kb-sdw-prepare-stream \
ksym-64kb-sdw-read \
ksym-64kb-sdw-read-no-pm \
ksym-64kb-sdw-release-stream \
ksym-64kb-sdw-rows \
ksym-64kb-sdw-show-ping-status \
ksym-64kb-sdw-shutdown-stream \
ksym-64kb-sdw-slave-add \
ksym-64kb-sdw-slave-get-current-bank \
ksym-64kb-sdw-slave-get-scale-index \
ksym-64kb-sdw-slave-read-lane-mapping \
ksym-64kb-sdw-slave-read-prop \
ksym-64kb-sdw-slave-type \
ksym-64kb-sdw-startup-stream \
ksym-64kb-sdw-stream-add-master \
ksym-64kb-sdw-stream-add-slave \
ksym-64kb-sdw-stream-remove-master \
ksym-64kb-sdw-stream-remove-slave \
ksym-64kb-sdw-unregister-driver \
ksym-64kb-sdw-update \
ksym-64kb-sdw-update-no-pm \
ksym-64kb-sdw-write \
ksym-64kb-sdw-write-no-pm \
ksym-64kb-sec-pmic-pm-ops \
ksym-64kb-sec-pmic-probe \
ksym-64kb-sec-pmic-shutdown \
ksym-64kb-secpath-set \
ksym-64kb-sections-per-block \
ksym-64kb-secure-ipv4-port-ephemeral \
ksym-64kb-secure-ipv6-port-ephemeral \
ksym-64kb-secure-tcp-seq-and-ts-off \
ksym-64kb-secure-tcpv6-seq-and-ts-off \
ksym-64kb-security-bdev-alloc \
ksym-64kb-security-bdev-free \
ksym-64kb-security-bdev-setintegrity \
ksym-64kb-security-cred-getlsmprop \
ksym-64kb-security-cred-getsecid \
ksym-64kb-security-current-getlsmprop-subj \
ksym-64kb-security-d-instantiate \
ksym-64kb-security-dentry-create-files-as \
ksym-64kb-security-dentry-init-security \
ksym-64kb-security-file-ioctl \
ksym-64kb-security-file-ioctl-compat \
ksym-64kb-security-file-post-open \
ksym-64kb-security-free-mnt-opts \
ksym-64kb-security-ib-alloc-security \
ksym-64kb-security-ib-endport-manage-subnet \
ksym-64kb-security-ib-free-security \
ksym-64kb-security-ib-pkey-access \
ksym-64kb-security-inet-conn-established \
ksym-64kb-security-inet-conn-request \
ksym-64kb-security-inode-copy-up \
ksym-64kb-security-inode-copy-up-xattr \
ksym-64kb-security-inode-create \
ksym-64kb-security-inode-getsecctx \
ksym-64kb-security-inode-init-security \
ksym-64kb-security-inode-invalidate-secctx \
ksym-64kb-security-inode-listsecurity \
ksym-64kb-security-inode-mkdir \
ksym-64kb-security-inode-notifysecctx \
ksym-64kb-security-inode-setattr \
ksym-64kb-security-inode-setintegrity \
ksym-64kb-security-inode-setsecctx \
ksym-64kb-security-ismaclabel \
ksym-64kb-security-kernel-load-data \
ksym-64kb-security-kernel-post-load-data \
ksym-64kb-security-kernel-post-read-file \
ksym-64kb-security-kernel-read-file \
ksym-64kb-security-lock-kernel-down \
ksym-64kb-security-locked-down \
ksym-64kb-security-lsmprop-to-secctx \
ksym-64kb-security-mmap-backing-file \
ksym-64kb-security-path-mkdir \
ksym-64kb-security-path-mknod \
ksym-64kb-security-path-rename \
ksym-64kb-security-path-unlink \
ksym-64kb-security-release-secctx \
ksym-64kb-security-req-classify-flow \
ksym-64kb-security-sb-clone-mnt-opts \
ksym-64kb-security-sb-eat-lsm-opts \
ksym-64kb-security-sb-mnt-opts-compat \
ksym-64kb-security-sb-remount \
ksym-64kb-security-sb-set-mnt-opts \
ksym-64kb-security-sctp-assoc-established \
ksym-64kb-security-sctp-assoc-request \
ksym-64kb-security-sctp-bind-connect \
ksym-64kb-security-sctp-sk-clone \
ksym-64kb-security-secctx-to-secid \
ksym-64kb-security-secid-to-secctx \
ksym-64kb-security-secmark-refcount-dec \
ksym-64kb-security-secmark-refcount-inc \
ksym-64kb-security-secmark-relabel-packet \
ksym-64kb-security-sk-classify-flow \
ksym-64kb-security-sk-clone \
ksym-64kb-security-skb-classify-flow \
ksym-64kb-security-sock-graft \
ksym-64kb-security-sock-rcv-skb \
ksym-64kb-security-socket-getpeersec-dgram \
ksym-64kb-security-socket-socketpair \
ksym-64kb-security-task-getlsmprop-obj \
ksym-64kb-security-tun-dev-alloc-security \
ksym-64kb-security-tun-dev-attach \
ksym-64kb-security-tun-dev-attach-queue \
ksym-64kb-security-tun-dev-create \
ksym-64kb-security-tun-dev-free-security \
ksym-64kb-security-tun-dev-open \
ksym-64kb-security-unix-find \
ksym-64kb-security-unix-may-send \
ksym-64kb-security-unix-stream-connect \
ksym-64kb-security-xfrm-policy-alloc \
ksym-64kb-security-xfrm-policy-free \
ksym-64kb-security-xfrm-state-alloc \
ksym-64kb-security-xfrm-state-delete \
ksym-64kb-securityfs-create-dir \
ksym-64kb-securityfs-create-file \
ksym-64kb-securityfs-create-symlink \
ksym-64kb-securityfs-remove \
ksym-64kb-sed-ioctl \
ksym-64kb-seg6-do-srh-encap \
ksym-64kb-seg6-do-srh-inline \
ksym-64kb-seg6-hmac-compute \
ksym-64kb-seg6-hmac-info-add \
ksym-64kb-seg6-hmac-info-del \
ksym-64kb-seg6-hmac-info-lookup \
ksym-64kb-seg6-hmac-net-exit \
ksym-64kb-seg6-hmac-validate-skb \
ksym-64kb-seg6-push-hmac \
ksym-64kb-send-implementation-id \
ksym-64kb-send-sig \
ksym-64kb-send-sig-info \
ksym-64kb-send-sig-mceerr \
ksym-64kb-sensor-hub-device-close \
ksym-64kb-sensor-hub-device-open \
ksym-64kb-sensor-hub-get-feature \
ksym-64kb-sensor-hub-input-attr-get-raw-value \
ksym-64kb-sensor-hub-input-attr-read-values \
ksym-64kb-sensor-hub-input-get-attribute-info \
ksym-64kb-sensor-hub-register-callback \
ksym-64kb-sensor-hub-remove-callback \
ksym-64kb-sensor-hub-set-feature \
ksym-64kb-seq-bprintf \
ksym-64kb-seq-buf-do-printk \
ksym-64kb-seq-buf-printf \
ksym-64kb-seq-buf-putc \
ksym-64kb-seq-buf-putmem-hex \
ksym-64kb-seq-buf-puts \
ksym-64kb-seq-dentry \
ksym-64kb-seq-escape-mem \
ksym-64kb-seq-file-path \
ksym-64kb-seq-hex-dump \
ksym-64kb-seq-hlist-next \
ksym-64kb-seq-hlist-next-percpu \
ksym-64kb-seq-hlist-next-rcu \
ksym-64kb-seq-hlist-start \
ksym-64kb-seq-hlist-start-head \
ksym-64kb-seq-hlist-start-head-rcu \
ksym-64kb-seq-hlist-start-percpu \
ksym-64kb-seq-hlist-start-rcu \
ksym-64kb-seq-list-next \
ksym-64kb-seq-list-next-rcu \
ksym-64kb-seq-list-start \
ksym-64kb-seq-list-start-head \
ksym-64kb-seq-list-start-head-rcu \
ksym-64kb-seq-list-start-rcu \
ksym-64kb-seq-lseek \
ksym-64kb-seq-open \
ksym-64kb-seq-open-private \
ksym-64kb-seq-pad \
ksym-64kb-seq-path \
ksym-64kb-seq-printf \
ksym-64kb-seq-put-decimal-ll \
ksym-64kb-seq-put-decimal-ull \
ksym-64kb-seq-putc \
ksym-64kb-seq-read \
ksym-64kb-seq-read-iter \
ksym-64kb-seq-release \
ksym-64kb-seq-release-private \
ksym-64kb-seq-vprintf \
ksym-64kb-seq-write \
ksym-64kb-serdev-acpi-get-uart-resource \
ksym-64kb-serdev-controller-add \
ksym-64kb-serdev-controller-alloc \
ksym-64kb-serdev-controller-remove \
ksym-64kb-serdev-device-add \
ksym-64kb-serdev-device-alloc \
ksym-64kb-serdev-device-break-ctl \
ksym-64kb-serdev-device-close \
ksym-64kb-serdev-device-get-tiocm \
ksym-64kb-serdev-device-open \
ksym-64kb-serdev-device-remove \
ksym-64kb-serdev-device-set-baudrate \
ksym-64kb-serdev-device-set-flow-control \
ksym-64kb-serdev-device-set-parity \
ksym-64kb-serdev-device-set-tiocm \
ksym-64kb-serdev-device-wait-until-sent \
ksym-64kb-serdev-device-write \
ksym-64kb-serdev-device-write-buf \
ksym-64kb-serdev-device-write-flush \
ksym-64kb-serdev-device-write-wakeup \
ksym-64kb-serial-8250-warn-need-ioport \
ksym-64kb-serial8250-clear-and-reinit-fifos \
ksym-64kb-serial8250-clear-fifos \
ksym-64kb-serial8250-do-get-mctrl \
ksym-64kb-serial8250-do-pm \
ksym-64kb-serial8250-do-set-divisor \
ksym-64kb-serial8250-do-set-ldisc \
ksym-64kb-serial8250-do-set-mctrl \
ksym-64kb-serial8250-do-set-termios \
ksym-64kb-serial8250-do-shutdown \
ksym-64kb-serial8250-do-startup \
ksym-64kb-serial8250-em485-config \
ksym-64kb-serial8250-em485-destroy \
ksym-64kb-serial8250-em485-start-tx \
ksym-64kb-serial8250-em485-stop-tx \
ksym-64kb-serial8250-em485-supported \
ksym-64kb-serial8250-fifo-wait-for-lsr-thre \
ksym-64kb-serial8250-get-port \
ksym-64kb-serial8250-handle-irq \
ksym-64kb-serial8250-handle-irq-locked \
ksym-64kb-serial8250-init-port \
ksym-64kb-serial8250-modem-status \
ksym-64kb-serial8250-pci-setup-port \
ksym-64kb-serial8250-read-char \
ksym-64kb-serial8250-register-8250-port \
ksym-64kb-serial8250-release-dma \
ksym-64kb-serial8250-request-dma \
ksym-64kb-serial8250-resume-port \
ksym-64kb-serial8250-rpm-get \
ksym-64kb-serial8250-rpm-put \
ksym-64kb-serial8250-rx-chars \
ksym-64kb-serial8250-rx-dma-flush \
ksym-64kb-serial8250-set-defaults \
ksym-64kb-serial8250-set-isa-configurator \
ksym-64kb-serial8250-suspend-port \
ksym-64kb-serial8250-tx-chars \
ksym-64kb-serial8250-unregister-port \
ksym-64kb-serial8250-update-uartclk \
ksym-64kb-serio-bus \
ksym-64kb-serio-close \
ksym-64kb-serio-interrupt \
ksym-64kb-serio-open \
ksym-64kb-serio-reconnect \
ksym-64kb-serio-rescan \
ksym-64kb-serio-unregister-child-port \
ksym-64kb-serio-unregister-driver \
ksym-64kb-serio-unregister-port \
ksym-64kb-serpent-setkey \
ksym-64kb-servreg-get-domain-list-req-ei \
ksym-64kb-servreg-get-domain-list-resp-ei \
ksym-64kb-servreg-loc-pfr-req-ei \
ksym-64kb-servreg-loc-pfr-resp-ei \
ksym-64kb-servreg-register-listener-req-ei \
ksym-64kb-servreg-register-listener-resp-ei \
ksym-64kb-servreg-restart-pd-req-ei \
ksym-64kb-servreg-restart-pd-resp-ei \
ksym-64kb-servreg-set-ack-req-ei \
ksym-64kb-servreg-set-ack-resp-ei \
ksym-64kb-servreg-state-updated-ind-ei \
ksym-64kb-set-and-calc-slave-port-state \
ksym-64kb-set-anon-super \
ksym-64kb-set-anon-super-fc \
ksym-64kb-set-binfmt \
ksym-64kb-set-blocksize \
ksym-64kb-set-cached-acl \
ksym-64kb-set-capacity \
ksym-64kb-set-capacity-and-notify \
ksym-64kb-set-cpus-allowed-ptr \
ksym-64kb-set-create-files-as \
ksym-64kb-set-current-groups \
ksym-64kb-set-dax-nocache \
ksym-64kb-set-dax-nomc \
ksym-64kb-set-dax-synchronous \
ksym-64kb-set-default-d-op \
ksym-64kb-set-disk-ro \
ksym-64kb-set-exclusive-cxl-commands \
ksym-64kb-set-freezable \
ksym-64kb-set-groups \
ksym-64kb-set-memory-decrypted \
ksym-64kb-set-memory-encrypted \
ksym-64kb-set-movable-ops \
ksym-64kb-set-nlink \
ksym-64kb-set-normalized-timespec64 \
ksym-64kb-set-online-page-callback \
ksym-64kb-set-page-dirty \
ksym-64kb-set-page-dirty-lock \
ksym-64kb-set-page-writeback \
ksym-64kb-set-phv-bit \
ksym-64kb-set-posix-acl \
ksym-64kb-set-primary-fwnode \
ksym-64kb-set-secondary-fwnode \
ksym-64kb-set-security-override \
ksym-64kb-set-selection-kernel \
ksym-64kb-set-task-ioprio \
ksym-64kb-set-user-nice \
ksym-64kb-set-worker-desc \
ksym-64kb-setattr-copy \
ksym-64kb-setattr-prepare \
ksym-64kb-setattr-should-drop-sgid \
ksym-64kb-setattr-should-drop-suidgid \
ksym-64kb-setup-arg-pages \
ksym-64kb-setup-bdev-super \
ksym-64kb-setup-cn23xx-octeon-pf-device \
ksym-64kb-setup-fault-attr \
ksym-64kb-setup-max-cpus \
ksym-64kb-setup-new-exec \
ksym-64kb-setup-rx-oom-poll-fn \
ksym-64kb-setup-udp-tunnel-sock \
ksym-64kb-setup-ufile-idr-uobject \
ksym-64kb-sfp-add-phy \
ksym-64kb-sfp-bus-add-upstream \
ksym-64kb-sfp-bus-del-upstream \
ksym-64kb-sfp-bus-find-fwnode \
ksym-64kb-sfp-bus-put \
ksym-64kb-sfp-get-module-caps \
ksym-64kb-sfp-get-module-eeprom \
ksym-64kb-sfp-get-module-eeprom-by-page \
ksym-64kb-sfp-get-module-info \
ksym-64kb-sfp-get-name \
ksym-64kb-sfp-link-down \
ksym-64kb-sfp-link-up \
ksym-64kb-sfp-module-insert \
ksym-64kb-sfp-module-remove \
ksym-64kb-sfp-module-start \
ksym-64kb-sfp-module-stop \
ksym-64kb-sfp-register-socket \
ksym-64kb-sfp-remove-phy \
ksym-64kb-sfp-select-interface \
ksym-64kb-sfp-unregister-socket \
ksym-64kb-sfp-upstream-set-signal-rate \
ksym-64kb-sfp-upstream-start \
ksym-64kb-sfp-upstream-stop \
ksym-64kb-sg-alloc-append-table-from-pages \
ksym-64kb-sg-alloc-table \
ksym-64kb-sg-alloc-table-chained \
ksym-64kb-sg-alloc-table-from-pages-segment \
ksym-64kb-sg-copy-buffer \
ksym-64kb-sg-copy-from-buffer \
ksym-64kb-sg-copy-to-buffer \
ksym-64kb-sg-free-append-table \
ksym-64kb-sg-free-table \
ksym-64kb-sg-free-table-chained \
ksym-64kb-sg-init-one \
ksym-64kb-sg-init-table \
ksym-64kb-sg-last \
ksym-64kb-sg-miter-next \
ksym-64kb-sg-miter-skip \
ksym-64kb-sg-miter-start \
ksym-64kb-sg-miter-stop \
ksym-64kb-sg-nents \
ksym-64kb-sg-nents-for-dma \
ksym-64kb-sg-nents-for-len \
ksym-64kb-sg-pcopy-from-buffer \
ksym-64kb-sg-pcopy-to-buffer \
ksym-64kb-sg-split \
ksym-64kb-sg-zero-buffer \
ksym-64kb-sg2042-cfg-ops \
ksym-64kb-sg2042-pconf-ops \
ksym-64kb-sg2042-pctrl-ops \
ksym-64kb-sg2042-pmx-ops \
ksym-64kb-sget-dev \
ksym-64kb-sget-fc \
ksym-64kb-sgl-alloc \
ksym-64kb-sgl-alloc-order \
ksym-64kb-sgl-free \
ksym-64kb-sgl-free-n-order \
ksym-64kb-sgl-free-order \
ksym-64kb-sha1 \
ksym-64kb-sha1-final \
ksym-64kb-sha1-init \
ksym-64kb-sha1-update \
ksym-64kb-sha1-zero-message-hash \
ksym-64kb-sha224 \
ksym-64kb-sha224-final \
ksym-64kb-sha224-init \
ksym-64kb-sha224-zero-message-hash \
ksym-64kb-sha256 \
ksym-64kb-sha256-final \
ksym-64kb-sha256-finup-2x \
ksym-64kb-sha256-finup-2x-is-optimized \
ksym-64kb-sha256-init \
ksym-64kb-sha256-zero-message-hash \
ksym-64kb-sha3-224 \
ksym-64kb-sha3-256 \
ksym-64kb-sha3-384 \
ksym-64kb-sha3-512 \
ksym-64kb-sha3-final \
ksym-64kb-sha384 \
ksym-64kb-sha384-final \
ksym-64kb-sha384-init \
ksym-64kb-sha384-zero-message-hash \
ksym-64kb-sha512 \
ksym-64kb-sha512-final \
ksym-64kb-sha512-init \
ksym-64kb-sha512-zero-message-hash \
ksym-64kb-shake-folio \
ksym-64kb-shake-squeeze \
ksym-64kb-shake128 \
ksym-64kb-shake256 \
ksym-64kb-shash-ahash-digest \
ksym-64kb-shash-ahash-finup \
ksym-64kb-shash-ahash-update \
ksym-64kb-shash-free-singlespawn-instance \
ksym-64kb-shash-no-setkey \
ksym-64kb-shash-register-instance \
ksym-64kb-shmem-file-setup \
ksym-64kb-shmem-file-setup-with-mnt \
ksym-64kb-shmem-get-folio \
ksym-64kb-shmem-kernel-file-setup \
ksym-64kb-shmem-mapping \
ksym-64kb-shmem-read-folio-gfp \
ksym-64kb-shmem-read-mapping-page-gfp \
ksym-64kb-shmem-truncate-range \
ksym-64kb-shmem-writeout \
ksym-64kb-should-fail \
ksym-64kb-show-class-attr-string \
ksym-64kb-show-rcu-gp-kthreads \
ksym-64kb-show-rcu-tasks-classic-gp-kthread \
ksym-64kb-show-rcu-tasks-rude-gp-kthread \
ksym-64kb-shrink-dcache-parent \
ksym-64kb-shrink-dcache-sb \
ksym-64kb-shrink-dentry-list \
ksym-64kb-shrinker-alloc \
ksym-64kb-shrinker-free \
ksym-64kb-shrinker-register \
ksym-64kb-si-mem-available \
ksym-64kb-si-meminfo \
ksym-64kb-si21xx-attach \
ksym-64kb-si470x-ctrl-ops \
ksym-64kb-si470x-set-freq \
ksym-64kb-si470x-start \
ksym-64kb-si470x-stop \
ksym-64kb-si470x-viddev-template \
ksym-64kb-sig-register-instance \
ksym-64kb-sigmadsp-attach \
ksym-64kb-sigmadsp-reset \
ksym-64kb-sigmadsp-restrict-params \
ksym-64kb-sigmadsp-setup \
ksym-64kb-sigprocmask \
ksym-64kb-simple-attr-open \
ksym-64kb-simple-attr-read \
ksym-64kb-simple-attr-release \
ksym-64kb-simple-attr-write \
ksym-64kb-simple-attr-write-signed \
ksym-64kb-simple-dir-inode-operations \
ksym-64kb-simple-dir-operations \
ksym-64kb-simple-done-creating \
ksym-64kb-simple-empty \
ksym-64kb-simple-fill-super \
ksym-64kb-simple-fsync \
ksym-64kb-simple-fsync-noflush \
ksym-64kb-simple-get-link \
ksym-64kb-simple-getattr \
ksym-64kb-simple-inode-init-ts \
ksym-64kb-simple-link \
ksym-64kb-simple-lookup \
ksym-64kb-simple-map-init \
ksym-64kb-simple-open \
ksym-64kb-simple-pin-fs \
ksym-64kb-simple-read-from-buffer \
ksym-64kb-simple-recursive-removal \
ksym-64kb-simple-release-fs \
ksym-64kb-simple-remove-by-name \
ksym-64kb-simple-rename \
ksym-64kb-simple-rename-exchange \
ksym-64kb-simple-rename-timestamp \
ksym-64kb-simple-rmdir \
ksym-64kb-simple-setattr \
ksym-64kb-simple-start-creating \
ksym-64kb-simple-statfs \
ksym-64kb-simple-strtol \
ksym-64kb-simple-strtoll \
ksym-64kb-simple-strtoul \
ksym-64kb-simple-strtoull \
ksym-64kb-simple-symlink-inode-operations \
ksym-64kb-simple-transaction-get \
ksym-64kb-simple-transaction-read \
ksym-64kb-simple-transaction-release \
ksym-64kb-simple-transaction-set \
ksym-64kb-simple-tuner-attach \
ksym-64kb-simple-unlink \
ksym-64kb-simple-util-be-hw-params-fixup \
ksym-64kb-simple-util-canonicalize-cpu \
ksym-64kb-simple-util-canonicalize-platform \
ksym-64kb-simple-util-clean-reference \
ksym-64kb-simple-util-dai-init \
ksym-64kb-simple-util-get-sample-fmt \
ksym-64kb-simple-util-hw-params \
ksym-64kb-simple-util-init-aux-jacks \
ksym-64kb-simple-util-init-jack \
ksym-64kb-simple-util-init-priv \
ksym-64kb-simple-util-is-convert-required \
ksym-64kb-simple-util-parse-card-name \
ksym-64kb-simple-util-parse-clk \
ksym-64kb-simple-util-parse-convert \
ksym-64kb-simple-util-parse-daifmt \
ksym-64kb-simple-util-parse-pin-switches \
ksym-64kb-simple-util-parse-routing \
ksym-64kb-simple-util-parse-tdm-width-map \
ksym-64kb-simple-util-parse-widgets \
ksym-64kb-simple-util-remove \
ksym-64kb-simple-util-set-dailink-name \
ksym-64kb-simple-util-shutdown \
ksym-64kb-simple-util-startup \
ksym-64kb-simple-write-begin \
ksym-64kb-simple-write-to-buffer \
ksym-64kb-single-open \
ksym-64kb-single-open-size \
ksym-64kb-single-release \
ksym-64kb-single-task-running \
ksym-64kb-siphash-1u32 \
ksym-64kb-siphash-1u64 \
ksym-64kb-siphash-2u64 \
ksym-64kb-siphash-3u32 \
ksym-64kb-siphash-3u64 \
ksym-64kb-siphash-4u64 \
ksym-64kb-sis-info133-for-sata \
ksym-64kb-sized-strscpy \
ksym-64kb-sja1000-interrupt \
ksym-64kb-sk-alloc \
ksym-64kb-sk-attach-filter \
ksym-64kb-sk-busy-loop-end \
ksym-64kb-sk-capable \
ksym-64kb-sk-clear-memalloc \
ksym-64kb-sk-clone \
ksym-64kb-sk-common-release \
ksym-64kb-sk-detach-filter \
ksym-64kb-sk-dst-check \
ksym-64kb-sk-error-report \
ksym-64kb-sk-filter-trim-cap \
ksym-64kb-sk-free \
ksym-64kb-sk-ioctl \
ksym-64kb-sk-mc-loop \
ksym-64kb-sk-msg-alloc \
ksym-64kb-sk-msg-clone \
ksym-64kb-sk-msg-free \
ksym-64kb-sk-msg-free-nocharge \
ksym-64kb-sk-msg-free-partial \
ksym-64kb-sk-msg-is-readable \
ksym-64kb-sk-msg-memcopy-from-iter \
ksym-64kb-sk-msg-recvmsg \
ksym-64kb-sk-msg-return \
ksym-64kb-sk-msg-return-zero \
ksym-64kb-sk-msg-trim \
ksym-64kb-sk-msg-zerocopy-from-iter \
ksym-64kb-sk-net-capable \
ksym-64kb-sk-net-refcnt-upgrade \
ksym-64kb-sk-ns-capable \
ksym-64kb-sk-page-frag-refill \
ksym-64kb-sk-psock-drop \
ksym-64kb-sk-psock-init \
ksym-64kb-sk-psock-msg-verdict \
ksym-64kb-sk-reset-timer \
ksym-64kb-sk-send-sigurg \
ksym-64kb-sk-set-memalloc \
ksym-64kb-sk-set-peek-off \
ksym-64kb-sk-setup-caps \
ksym-64kb-sk-skb-reason-drop \
ksym-64kb-sk-stop-timer \
ksym-64kb-sk-stop-timer-sync \
ksym-64kb-sk-stream-error \
ksym-64kb-sk-stream-kill-queues \
ksym-64kb-sk-stream-wait-connect \
ksym-64kb-sk-stream-wait-memory \
ksym-64kb-sk-tx-queue-get \
ksym-64kb-sk-wait-data \
ksym-64kb-skb-abort-seq-read \
ksym-64kb-skb-append \
ksym-64kb-skb-append-pagefrags \
ksym-64kb-skb-checksum \
ksym-64kb-skb-checksum-help \
ksym-64kb-skb-checksum-setup \
ksym-64kb-skb-checksum-trimmed \
ksym-64kb-skb-clone \
ksym-64kb-skb-clone-sk \
ksym-64kb-skb-coalesce-rx-frag \
ksym-64kb-skb-complete-tx-timestamp \
ksym-64kb-skb-complete-wifi-ack \
ksym-64kb-skb-condense \
ksym-64kb-skb-copy \
ksym-64kb-skb-copy-and-crc32c-datagram-iter \
ksym-64kb-skb-copy-and-csum-bits \
ksym-64kb-skb-copy-and-csum-datagram-msg \
ksym-64kb-skb-copy-and-csum-dev \
ksym-64kb-skb-copy-bits \
ksym-64kb-skb-copy-datagram-from-iter \
ksym-64kb-skb-copy-datagram-from-iter-full \
ksym-64kb-skb-copy-datagram-iter \
ksym-64kb-skb-copy-expand \
ksym-64kb-skb-copy-header \
ksym-64kb-skb-copy-seq-read \
ksym-64kb-skb-copy-ubufs \
ksym-64kb-skb-cow-data \
ksym-64kb-skb-cow-data-for-xdp \
ksym-64kb-skb-crc32c \
ksym-64kb-skb-crc32c-csum-help \
ksym-64kb-skb-csum-hwoffload-help \
ksym-64kb-skb-dequeue \
ksym-64kb-skb-dequeue-tail \
ksym-64kb-skb-dump \
ksym-64kb-skb-ensure-writable \
ksym-64kb-skb-ensure-writable-head-tail \
ksym-64kb-skb-errqueue-purge \
ksym-64kb-skb-eth-gso-segment \
ksym-64kb-skb-eth-pop \
ksym-64kb-skb-eth-push \
ksym-64kb-skb-expand-head \
ksym-64kb-skb-ext-add \
ksym-64kb-skb-find-text \
ksym-64kb-skb-flow-dissect-ct \
ksym-64kb-skb-flow-dissect-hash \
ksym-64kb-skb-flow-dissect-meta \
ksym-64kb-skb-flow-dissect-tunnel-info \
ksym-64kb-skb-flow-dissector-init \
ksym-64kb-skb-flow-get-icmp-tci \
ksym-64kb-skb-flow-get-ports \
ksym-64kb-skb-free-datagram \
ksym-64kb-skb-get-hash-perturb \
ksym-64kb-skb-gso-validate-mac-len \
ksym-64kb-skb-gso-validate-network-len \
ksym-64kb-skb-headers-offset-update \
ksym-64kb-skb-kill-datagram \
ksym-64kb-skb-mac-gso-segment \
ksym-64kb-skb-morph \
ksym-64kb-skb-mpls-dec-ttl \
ksym-64kb-skb-mpls-pop \
ksym-64kb-skb-mpls-push \
ksym-64kb-skb-mpls-update-lse \
ksym-64kb-skb-orphan-partial \
ksym-64kb-skb-page-frag-refill \
ksym-64kb-skb-partial-csum-set \
ksym-64kb-skb-pp-cow-data \
ksym-64kb-skb-prepare-seq-read \
ksym-64kb-skb-pull \
ksym-64kb-skb-pull-data \
ksym-64kb-skb-pull-rcsum \
ksym-64kb-skb-push \
ksym-64kb-skb-put \
ksym-64kb-skb-queue-head \
ksym-64kb-skb-queue-purge-reason \
ksym-64kb-skb-queue-tail \
ksym-64kb-skb-realloc-headroom \
ksym-64kb-skb-recv-datagram \
ksym-64kb-skb-scrub-packet \
ksym-64kb-skb-segment \
ksym-64kb-skb-segment-list \
ksym-64kb-skb-send-sock-locked \
ksym-64kb-skb-send-sock-locked-with-flags \
ksym-64kb-skb-seq-read \
ksym-64kb-skb-set-owner-w \
ksym-64kb-skb-splice-bits \
ksym-64kb-skb-splice-from-iter \
ksym-64kb-skb-split \
ksym-64kb-skb-store-bits \
ksym-64kb-skb-to-sgvec \
ksym-64kb-skb-to-sgvec-nomark \
ksym-64kb-skb-trim \
ksym-64kb-skb-try-coalesce \
ksym-64kb-skb-tstamp-tx \
ksym-64kb-skb-tunnel-check-pmtu \
ksym-64kb-skb-tx-error \
ksym-64kb-skb-unlink \
ksym-64kb-skb-vlan-pop \
ksym-64kb-skb-vlan-push \
ksym-64kb-skb-vlan-untag \
ksym-64kb-skb-zerocopy \
ksym-64kb-skb-zerocopy-headlen \
ksym-64kb-skb-zerocopy-iter-stream \
ksym-64kb-skcipher-alloc-instance-simple \
ksym-64kb-skcipher-register-instance \
ksym-64kb-skcipher-walk-aead-decrypt \
ksym-64kb-skcipher-walk-aead-encrypt \
ksym-64kb-skcipher-walk-done \
ksym-64kb-skcipher-walk-virt \
ksym-64kb-skip-spaces \
ksym-64kb-sky1-base-pinctrl-probe \
ksym-64kb-sl811h-driver \
ksym-64kb-slab-build-skb \
ksym-64kb-slash-name \
ksym-64kb-slhc-compress \
ksym-64kb-slhc-free \
ksym-64kb-slhc-init \
ksym-64kb-slhc-remember \
ksym-64kb-slhc-toss \
ksym-64kb-slhc-uncompress \
ksym-64kb-slim-alloc-txn-tid \
ksym-64kb-slim-ctrl-clk-pause \
ksym-64kb-slim-device-report-present \
ksym-64kb-slim-do-transfer \
ksym-64kb-slim-driver-unregister \
ksym-64kb-slim-free-txn-tid \
ksym-64kb-slim-get-device \
ksym-64kb-slim-get-logical-addr \
ksym-64kb-slim-msg-response \
ksym-64kb-slim-read \
ksym-64kb-slim-readb \
ksym-64kb-slim-register-controller \
ksym-64kb-slim-report-absent \
ksym-64kb-slim-stream-allocate \
ksym-64kb-slim-stream-disable \
ksym-64kb-slim-stream-enable \
ksym-64kb-slim-stream-free \
ksym-64kb-slim-stream-prepare \
ksym-64kb-slim-stream-unprepare \
ksym-64kb-slim-unregister-controller \
ksym-64kb-slim-write \
ksym-64kb-slim-writeb \
ksym-64kb-slim-xfer-msg \
ksym-64kb-slimbus-bus \
ksym-64kb-sm-register-device \
ksym-64kb-sm3 \
ksym-64kb-sm3-final \
ksym-64kb-sm3-init \
ksym-64kb-sm3-update \
ksym-64kb-sm4-ce-cbc-enc \
ksym-64kb-sm4-ce-crypt-block \
ksym-64kb-sm4-ce-expand-key \
ksym-64kb-sm4-crypt-block \
ksym-64kb-sm4-expandkey \
ksym-64kb-smb-compression-compress-chained \
ksym-64kb-smb-compression-decompress \
ksym-64kb-smb-lz77-compress \
ksym-64kb-smb-lz77-decompress \
ksym-64kb-smc-proto \
ksym-64kb-smc-proto6 \
ksym-64kb-smp-ata-check-ready-type \
ksym-64kb-smp-call-function \
ksym-64kb-smp-call-function-any \
ksym-64kb-smp-call-function-many \
ksym-64kb-smp-call-function-single \
ksym-64kb-smp-call-function-single-async \
ksym-64kb-smp-call-on-cpu \
ksym-64kb-smpboot-register-percpu-thread \
ksym-64kb-smpboot-unregister-percpu-thread \
ksym-64kb-sms-board-event \
ksym-64kb-sms-board-led-feedback \
ksym-64kb-sms-board-lna-control \
ksym-64kb-sms-board-load-modules \
ksym-64kb-sms-board-power \
ksym-64kb-sms-board-setup \
ksym-64kb-sms-get-board \
ksym-64kb-smsc-phy-config-init \
ksym-64kb-smsc-phy-config-intr \
ksym-64kb-smsc-phy-get-tunable \
ksym-64kb-smsc-phy-handle-interrupt \
ksym-64kb-smsc-phy-probe \
ksym-64kb-smsc-phy-set-tunable \
ksym-64kb-smsclient-sendrequest \
ksym-64kb-smscore-get-board-id \
ksym-64kb-smscore-get-device-mode \
ksym-64kb-smscore-getbuffer \
ksym-64kb-smscore-onresponse \
ksym-64kb-smscore-putbuffer \
ksym-64kb-smscore-register-client \
ksym-64kb-smscore-register-device \
ksym-64kb-smscore-register-hotplug \
ksym-64kb-smscore-registry-getmode \
ksym-64kb-smscore-set-board-id \
ksym-64kb-smscore-start-device \
ksym-64kb-smscore-translate-msg \
ksym-64kb-smscore-unregister-client \
ksym-64kb-smscore-unregister-device \
ksym-64kb-smscore-unregister-hotplug \
ksym-64kb-smsendian-handle-message-header \
ksym-64kb-smsendian-handle-rx-message \
ksym-64kb-smsendian-handle-tx-message \
ksym-64kb-snd-ac97-bus \
ksym-64kb-snd-ac97-get-short-name \
ksym-64kb-snd-ac97-mixer \
ksym-64kb-snd-ac97-pcm-assign \
ksym-64kb-snd-ac97-pcm-close \
ksym-64kb-snd-ac97-pcm-double-rate-rules \
ksym-64kb-snd-ac97-pcm-open \
ksym-64kb-snd-ac97-read \
ksym-64kb-snd-ac97-reset \
ksym-64kb-snd-ac97-resume \
ksym-64kb-snd-ac97-set-rate \
ksym-64kb-snd-ac97-suspend \
ksym-64kb-snd-ac97-tune-hardware \
ksym-64kb-snd-ac97-update \
ksym-64kb-snd-ac97-update-bits \
ksym-64kb-snd-ac97-update-power \
ksym-64kb-snd-ac97-write \
ksym-64kb-snd-ac97-write-cache \
ksym-64kb-snd-ak4113-build \
ksym-64kb-snd-ak4113-check-rate-and-errors \
ksym-64kb-snd-ak4113-create \
ksym-64kb-snd-ak4113-external-rate \
ksym-64kb-snd-ak4113-reg-write \
ksym-64kb-snd-ak4113-reinit \
ksym-64kb-snd-ak4113-resume \
ksym-64kb-snd-ak4113-suspend \
ksym-64kb-snd-ak4114-build \
ksym-64kb-snd-ak4114-check-rate-and-errors \
ksym-64kb-snd-ak4114-create \
ksym-64kb-snd-ak4114-external-rate \
ksym-64kb-snd-ak4114-reg-write \
ksym-64kb-snd-ak4114-reinit \
ksym-64kb-snd-ak4114-resume \
ksym-64kb-snd-ak4114-suspend \
ksym-64kb-snd-akm4xxx-build-controls \
ksym-64kb-snd-akm4xxx-init \
ksym-64kb-snd-akm4xxx-reset \
ksym-64kb-snd-akm4xxx-write \
ksym-64kb-snd-amd-acp-find-config \
ksym-64kb-snd-array-free \
ksym-64kb-snd-array-new \
ksym-64kb-snd-card-add-dev-attr \
ksym-64kb-snd-card-disconnect \
ksym-64kb-snd-card-disconnect-sync \
ksym-64kb-snd-card-file-add \
ksym-64kb-snd-card-file-remove \
ksym-64kb-snd-card-free \
ksym-64kb-snd-card-free-on-error \
ksym-64kb-snd-card-free-when-closed \
ksym-64kb-snd-card-new \
ksym-64kb-snd-card-ref \
ksym-64kb-snd-card-register \
ksym-64kb-snd-card-rw-proc-new \
ksym-64kb-snd-card-set-id \
ksym-64kb-snd-component-add \
ksym-64kb-snd-compr-free-pages \
ksym-64kb-snd-compr-malloc-pages \
ksym-64kb-snd-compr-stop-error \
ksym-64kb-snd-compr-task-finished \
ksym-64kb-snd-compress-new \
ksym-64kb-snd-ctl-activate-id \
ksym-64kb-snd-ctl-add \
ksym-64kb-snd-ctl-add-followers \
ksym-64kb-snd-ctl-add-vmaster-hook \
ksym-64kb-snd-ctl-apply-vmaster-followers \
ksym-64kb-snd-ctl-boolean-mono-info \
ksym-64kb-snd-ctl-boolean-stereo-info \
ksym-64kb-snd-ctl-disconnect-layer \
ksym-64kb-snd-ctl-enum-info \
ksym-64kb-snd-ctl-find-id \
ksym-64kb-snd-ctl-find-numid \
ksym-64kb-snd-ctl-free-one \
ksym-64kb-snd-ctl-get-preferred-subdevice \
ksym-64kb-snd-ctl-make-virtual-master \
ksym-64kb-snd-ctl-new1 \
ksym-64kb-snd-ctl-notify \
ksym-64kb-snd-ctl-notify-one \
ksym-64kb-snd-ctl-register-ioctl \
ksym-64kb-snd-ctl-register-ioctl-compat \
ksym-64kb-snd-ctl-register-layer \
ksym-64kb-snd-ctl-remove \
ksym-64kb-snd-ctl-remove-id \
ksym-64kb-snd-ctl-rename \
ksym-64kb-snd-ctl-rename-id \
ksym-64kb-snd-ctl-replace \
ksym-64kb-snd-ctl-request-layer \
ksym-64kb-snd-ctl-sync-vmaster \
ksym-64kb-snd-ctl-unregister-ioctl \
ksym-64kb-snd-ctl-unregister-ioctl-compat \
ksym-64kb-snd-device-alloc \
ksym-64kb-snd-device-disconnect \
ksym-64kb-snd-device-free \
ksym-64kb-snd-device-new \
ksym-64kb-snd-device-register \
ksym-64kb-snd-devm-alloc-dir-pages \
ksym-64kb-snd-devm-card-new \
ksym-64kb-snd-dma-alloc-dir-pages \
ksym-64kb-snd-dma-alloc-pages-fallback \
ksym-64kb-snd-dma-buffer-mmap \
ksym-64kb-snd-dma-buffer-sync \
ksym-64kb-snd-dma-free-pages \
ksym-64kb-snd-dmaengine-pcm-close \
ksym-64kb-snd-dmaengine-pcm-close-release-chan \
ksym-64kb-snd-dmaengine-pcm-get-chan \
ksym-64kb-snd-dmaengine-pcm-open \
ksym-64kb-snd-dmaengine-pcm-pointer \
ksym-64kb-snd-dmaengine-pcm-pointer-no-residue \
ksym-64kb-snd-dmaengine-pcm-prepare-slave-config \
ksym-64kb-snd-dmaengine-pcm-refine-runtime-hwparams \
ksym-64kb-snd-dmaengine-pcm-register \
ksym-64kb-snd-dmaengine-pcm-request-channel \
ksym-64kb-snd-dmaengine-pcm-set-config-from-dai-data \
ksym-64kb-snd-dmaengine-pcm-sync-stop \
ksym-64kb-snd-dmaengine-pcm-trigger \
ksym-64kb-snd-dmaengine-pcm-unregister \
ksym-64kb-snd-ecards-limit \
ksym-64kb-snd-fasync-free \
ksym-64kb-snd-fasync-helper \
ksym-64kb-snd-fw-transaction \
ksym-64kb-snd-hda-activate-path \
ksym-64kb-snd-hda-add-imux-item \
ksym-64kb-snd-hda-add-new-ctls \
ksym-64kb-snd-hda-add-new-path \
ksym-64kb-snd-hda-add-verbs \
ksym-64kb-snd-hda-add-vmaster-hook \
ksym-64kb-snd-hda-apply-fixup \
ksym-64kb-snd-hda-apply-pincfgs \
ksym-64kb-snd-hda-apply-verbs \
ksym-64kb-snd-hda-attach-beep-device \
ksym-64kb-snd-hda-bus-type \
ksym-64kb-snd-hda-check-amp-caps \
ksym-64kb-snd-hda-check-amp-list-power \
ksym-64kb-snd-hda-codec-amp-init \
ksym-64kb-snd-hda-codec-amp-init-stereo \
ksym-64kb-snd-hda-codec-amp-stereo \
ksym-64kb-snd-hda-codec-amp-update \
ksym-64kb-snd-hda-codec-build-controls \
ksym-64kb-snd-hda-codec-cleanup \
ksym-64kb-snd-hda-codec-cleanup-for-unbind \
ksym-64kb-snd-hda-codec-configure \
ksym-64kb-snd-hda-codec-device-init \
ksym-64kb-snd-hda-codec-device-new \
ksym-64kb-snd-hda-codec-eapd-power-filter \
ksym-64kb-snd-hda-codec-get-pin-target \
ksym-64kb-snd-hda-codec-get-pincfg \
ksym-64kb-snd-hda-codec-load-dsp-cleanup \
ksym-64kb-snd-hda-codec-load-dsp-prepare \
ksym-64kb-snd-hda-codec-load-dsp-trigger \
ksym-64kb-snd-hda-codec-new \
ksym-64kb-snd-hda-codec-parse-pcms \
ksym-64kb-snd-hda-codec-pcm-new \
ksym-64kb-snd-hda-codec-prepare \
ksym-64kb-snd-hda-codec-register \
ksym-64kb-snd-hda-codec-set-gpio \
ksym-64kb-snd-hda-codec-set-name \
ksym-64kb-snd-hda-codec-set-pin-target \
ksym-64kb-snd-hda-codec-set-pincfg \
ksym-64kb-snd-hda-codec-set-power-save \
ksym-64kb-snd-hda-codec-set-power-to-all \
ksym-64kb-snd-hda-codec-setup-stream \
ksym-64kb-snd-hda-codec-unregister \
ksym-64kb-snd-hda-codec-update-widgets \
ksym-64kb-snd-hda-correct-pin-ctl \
ksym-64kb-snd-hda-create-dig-out-ctls \
ksym-64kb-snd-hda-create-spdif-in-ctls \
ksym-64kb-snd-hda-create-spdif-share-sw \
ksym-64kb-snd-hda-ctl-add \
ksym-64kb-snd-hda-detach-beep-device \
ksym-64kb-snd-hda-enable-beep-device \
ksym-64kb-snd-hda-enum-helper-info \
ksym-64kb-snd-hda-ext-driver-register \
ksym-64kb-snd-hda-ext-driver-unregister \
ksym-64kb-snd-hda-find-mixer-ctl \
ksym-64kb-snd-hda-gen-add-kctl \
ksym-64kb-snd-hda-gen-add-micmute-led-cdev \
ksym-64kb-snd-hda-gen-add-mute-led-cdev \
ksym-64kb-snd-hda-gen-build-controls \
ksym-64kb-snd-hda-gen-build-pcms \
ksym-64kb-snd-hda-gen-check-power-status \
ksym-64kb-snd-hda-gen-fix-pin-power \
ksym-64kb-snd-hda-gen-hp-automute \
ksym-64kb-snd-hda-gen-init \
ksym-64kb-snd-hda-gen-line-automute \
ksym-64kb-snd-hda-gen-mic-autoswitch \
ksym-64kb-snd-hda-gen-parse-auto-config \
ksym-64kb-snd-hda-gen-path-power-filter \
ksym-64kb-snd-hda-gen-remove \
ksym-64kb-snd-hda-gen-shutup-speakers \
ksym-64kb-snd-hda-gen-spec-init \
ksym-64kb-snd-hda-gen-stream-pm \
ksym-64kb-snd-hda-gen-update-outputs \
ksym-64kb-snd-hda-get-bool-hint \
ksym-64kb-snd-hda-get-conn-index \
ksym-64kb-snd-hda-get-conn-list \
ksym-64kb-snd-hda-get-connections \
ksym-64kb-snd-hda-get-default-vref \
ksym-64kb-snd-hda-get-dev-select \
ksym-64kb-snd-hda-get-hint \
ksym-64kb-snd-hda-get-input-pin-attr \
ksym-64kb-snd-hda-get-int-hint \
ksym-64kb-snd-hda-get-num-devices \
ksym-64kb-snd-hda-get-path-from-idx \
ksym-64kb-snd-hda-get-path-idx \
ksym-64kb-snd-hda-get-pin-label \
ksym-64kb-snd-hda-hdmi-acomp-init \
ksym-64kb-snd-hda-hdmi-acomp-master-bind \
ksym-64kb-snd-hda-hdmi-acomp-master-unbind \
ksym-64kb-snd-hda-hdmi-acomp-pin-eld-notify \
ksym-64kb-snd-hda-hdmi-check-presence-and-report \
ksym-64kb-snd-hda-hdmi-generic-alloc \
ksym-64kb-snd-hda-hdmi-generic-build-controls \
ksym-64kb-snd-hda-hdmi-generic-build-pcms \
ksym-64kb-snd-hda-hdmi-generic-init \
ksym-64kb-snd-hda-hdmi-generic-init-per-pins \
ksym-64kb-snd-hda-hdmi-generic-pcm-cleanup \
ksym-64kb-snd-hda-hdmi-generic-pcm-prepare \
ksym-64kb-snd-hda-hdmi-generic-probe \
ksym-64kb-snd-hda-hdmi-generic-remove \
ksym-64kb-snd-hda-hdmi-generic-resume \
ksym-64kb-snd-hda-hdmi-generic-spec-free \
ksym-64kb-snd-hda-hdmi-generic-suspend \
ksym-64kb-snd-hda-hdmi-generic-unsol-event \
ksym-64kb-snd-hda-hdmi-parse-codec \
ksym-64kb-snd-hda-hdmi-pin-id-to-pin-index \
ksym-64kb-snd-hda-hdmi-setup-audio-infoframe \
ksym-64kb-snd-hda-hdmi-setup-drm-audio-ops \
ksym-64kb-snd-hda-hdmi-setup-stream \
ksym-64kb-snd-hda-hdmi-simple-build-controls \
ksym-64kb-snd-hda-hdmi-simple-build-pcms \
ksym-64kb-snd-hda-hdmi-simple-init \
ksym-64kb-snd-hda-hdmi-simple-pcm-open \
ksym-64kb-snd-hda-hdmi-simple-probe \
ksym-64kb-snd-hda-hdmi-simple-remove \
ksym-64kb-snd-hda-hdmi-simple-unsol-event \
ksym-64kb-snd-hda-input-mux-info \
ksym-64kb-snd-hda-input-mux-put \
ksym-64kb-snd-hda-jack-add-kctl-mst \
ksym-64kb-snd-hda-jack-add-kctls \
ksym-64kb-snd-hda-jack-bind-keymap \
ksym-64kb-snd-hda-jack-detect-enable \
ksym-64kb-snd-hda-jack-detect-enable-callback-mst \
ksym-64kb-snd-hda-jack-detect-state-mst \
ksym-64kb-snd-hda-jack-pin-sense \
ksym-64kb-snd-hda-jack-poll-all \
ksym-64kb-snd-hda-jack-report-sync \
ksym-64kb-snd-hda-jack-set-button-state \
ksym-64kb-snd-hda-jack-set-dirty-all \
ksym-64kb-snd-hda-jack-set-gating-jack \
ksym-64kb-snd-hda-jack-tbl-get-from-tag \
ksym-64kb-snd-hda-jack-tbl-get-mst \
ksym-64kb-snd-hda-jack-unsol-event \
ksym-64kb-snd-hda-load-patch \
ksym-64kb-snd-hda-lock-devices \
ksym-64kb-snd-hda-mixer-amp-switch-get \
ksym-64kb-snd-hda-mixer-amp-switch-get-beep \
ksym-64kb-snd-hda-mixer-amp-switch-info \
ksym-64kb-snd-hda-mixer-amp-switch-put \
ksym-64kb-snd-hda-mixer-amp-switch-put-beep \
ksym-64kb-snd-hda-mixer-amp-tlv \
ksym-64kb-snd-hda-mixer-amp-volume-get \
ksym-64kb-snd-hda-mixer-amp-volume-info \
ksym-64kb-snd-hda-mixer-amp-volume-put \
ksym-64kb-snd-hda-multi-out-analog-cleanup \
ksym-64kb-snd-hda-multi-out-analog-open \
ksym-64kb-snd-hda-multi-out-analog-prepare \
ksym-64kb-snd-hda-multi-out-dig-cleanup \
ksym-64kb-snd-hda-multi-out-dig-close \
ksym-64kb-snd-hda-multi-out-dig-open \
ksym-64kb-snd-hda-multi-out-dig-prepare \
ksym-64kb-snd-hda-override-amp-caps \
ksym-64kb-snd-hda-override-conn-list \
ksym-64kb-snd-hda-parse-pin-defcfg \
ksym-64kb-snd-hda-pick-fixup \
ksym-64kb-snd-hda-pick-pin-fixup \
ksym-64kb-snd-hda-sequence-write \
ksym-64kb-snd-hda-set-dev-select \
ksym-64kb-snd-hda-set-power-save \
ksym-64kb-snd-hda-set-vmaster-tlv \
ksym-64kb-snd-hda-shutup-pins \
ksym-64kb-snd-hda-spdif-ctls-assign \
ksym-64kb-snd-hda-spdif-ctls-unassign \
ksym-64kb-snd-hda-spdif-out-of-nid \
ksym-64kb-snd-hda-sync-vmaster-hook \
ksym-64kb-snd-hda-unlock-devices \
ksym-64kb-snd-hdac-acomp-exit \
ksym-64kb-snd-hdac-acomp-get-eld \
ksym-64kb-snd-hdac-acomp-init \
ksym-64kb-snd-hdac-acomp-register-notifier \
ksym-64kb-snd-hdac-add-chmap-ctls \
ksym-64kb-snd-hdac-aligned-read \
ksym-64kb-snd-hdac-aligned-write \
ksym-64kb-snd-hdac-bus-alloc-stream-pages \
ksym-64kb-snd-hdac-bus-enter-link-reset \
ksym-64kb-snd-hdac-bus-exec-verb-unlocked \
ksym-64kb-snd-hdac-bus-exit \
ksym-64kb-snd-hdac-bus-exit-link-reset \
ksym-64kb-snd-hdac-bus-free-stream-pages \
ksym-64kb-snd-hdac-bus-get-response \
ksym-64kb-snd-hdac-bus-handle-stream-irq \
ksym-64kb-snd-hdac-bus-init \
ksym-64kb-snd-hdac-bus-init-chip \
ksym-64kb-snd-hdac-bus-init-cmd-io \
ksym-64kb-snd-hdac-bus-link-power \
ksym-64kb-snd-hdac-bus-parse-capabilities \
ksym-64kb-snd-hdac-bus-reset-link \
ksym-64kb-snd-hdac-bus-send-cmd \
ksym-64kb-snd-hdac-bus-stop-chip \
ksym-64kb-snd-hdac-bus-stop-cmd-io \
ksym-64kb-snd-hdac-bus-update-rirb \
ksym-64kb-snd-hdac-channel-allocation \
ksym-64kb-snd-hdac-check-power-state \
ksym-64kb-snd-hdac-chmap-to-spk-mask \
ksym-64kb-snd-hdac-codec-link-down \
ksym-64kb-snd-hdac-codec-link-up \
ksym-64kb-snd-hdac-codec-modalias \
ksym-64kb-snd-hdac-codec-read \
ksym-64kb-snd-hdac-codec-write \
ksym-64kb-snd-hdac-device-exit \
ksym-64kb-snd-hdac-device-init \
ksym-64kb-snd-hdac-device-register \
ksym-64kb-snd-hdac-device-set-chip-name \
ksym-64kb-snd-hdac-device-unregister \
ksym-64kb-snd-hdac-display-power \
ksym-64kb-snd-hdac-dsp-cleanup \
ksym-64kb-snd-hdac-dsp-prepare \
ksym-64kb-snd-hdac-dsp-trigger \
ksym-64kb-snd-hdac-ext-bus-device-remove \
ksym-64kb-snd-hdac-ext-bus-exit \
ksym-64kb-snd-hdac-ext-bus-get-hlink-by-addr \
ksym-64kb-snd-hdac-ext-bus-get-hlink-by-id \
ksym-64kb-snd-hdac-ext-bus-get-hlink-by-name \
ksym-64kb-snd-hdac-ext-bus-get-ml-capabilities \
ksym-64kb-snd-hdac-ext-bus-init \
ksym-64kb-snd-hdac-ext-bus-link-clear-stream-id \
ksym-64kb-snd-hdac-ext-bus-link-get \
ksym-64kb-snd-hdac-ext-bus-link-power \
ksym-64kb-snd-hdac-ext-bus-link-power-down \
ksym-64kb-snd-hdac-ext-bus-link-power-down-all \
ksym-64kb-snd-hdac-ext-bus-link-power-up \
ksym-64kb-snd-hdac-ext-bus-link-power-up-all \
ksym-64kb-snd-hdac-ext-bus-link-put \
ksym-64kb-snd-hdac-ext-bus-link-set-stream-id \
ksym-64kb-snd-hdac-ext-bus-ppcap-enable \
ksym-64kb-snd-hdac-ext-bus-ppcap-int-enable \
ksym-64kb-snd-hdac-ext-cstream-assign \
ksym-64kb-snd-hdac-ext-host-stream-setup \
ksym-64kb-snd-hdac-ext-link-free-all \
ksym-64kb-snd-hdac-ext-stream-assign \
ksym-64kb-snd-hdac-ext-stream-clear \
ksym-64kb-snd-hdac-ext-stream-decouple \
ksym-64kb-snd-hdac-ext-stream-decouple-locked \
ksym-64kb-snd-hdac-ext-stream-free-all \
ksym-64kb-snd-hdac-ext-stream-init-all \
ksym-64kb-snd-hdac-ext-stream-release \
ksym-64kb-snd-hdac-ext-stream-reset \
ksym-64kb-snd-hdac-ext-stream-setup \
ksym-64kb-snd-hdac-ext-stream-start \
ksym-64kb-snd-hdac-get-active-channels \
ksym-64kb-snd-hdac-get-ch-alloc-from-ca \
ksym-64kb-snd-hdac-get-connections \
ksym-64kb-snd-hdac-get-stream \
ksym-64kb-snd-hdac-get-stream-stripe-ctl \
ksym-64kb-snd-hdac-get-sub-nodes \
ksym-64kb-snd-hdac-is-supported-format \
ksym-64kb-snd-hdac-override-parm \
ksym-64kb-snd-hdac-power-down \
ksym-64kb-snd-hdac-power-down-pm \
ksym-64kb-snd-hdac-power-up \
ksym-64kb-snd-hdac-power-up-pm \
ksym-64kb-snd-hdac-print-channel-allocation \
ksym-64kb-snd-hdac-query-supported-pcm \
ksym-64kb-snd-hdac-read \
ksym-64kb-snd-hdac-read-parm-uncached \
ksym-64kb-snd-hdac-refresh-widgets \
ksym-64kb-snd-hdac-register-chmap-ops \
ksym-64kb-snd-hdac-regmap-add-vendor-verb \
ksym-64kb-snd-hdac-regmap-exit \
ksym-64kb-snd-hdac-regmap-init \
ksym-64kb-snd-hdac-regmap-read-raw \
ksym-64kb-snd-hdac-regmap-sync \
ksym-64kb-snd-hdac-regmap-update-raw \
ksym-64kb-snd-hdac-regmap-update-raw-once \
ksym-64kb-snd-hdac-regmap-write-raw \
ksym-64kb-snd-hdac-set-codec-wakeup \
ksym-64kb-snd-hdac-setup-channel-mapping \
ksym-64kb-snd-hdac-spdif-stream-format \
ksym-64kb-snd-hdac-spk-to-chmap \
ksym-64kb-snd-hdac-stop-streams \
ksym-64kb-snd-hdac-stop-streams-and-chip \
ksym-64kb-snd-hdac-stream-assign \
ksym-64kb-snd-hdac-stream-cleanup \
ksym-64kb-snd-hdac-stream-drsm-enable \
ksym-64kb-snd-hdac-stream-format \
ksym-64kb-snd-hdac-stream-format-bits \
ksym-64kb-snd-hdac-stream-init \
ksym-64kb-snd-hdac-stream-release \
ksym-64kb-snd-hdac-stream-release-locked \
ksym-64kb-snd-hdac-stream-reset \
ksym-64kb-snd-hdac-stream-set-dpibr \
ksym-64kb-snd-hdac-stream-set-lpib \
ksym-64kb-snd-hdac-stream-set-params \
ksym-64kb-snd-hdac-stream-set-spib \
ksym-64kb-snd-hdac-stream-setup \
ksym-64kb-snd-hdac-stream-setup-periods \
ksym-64kb-snd-hdac-stream-spbcap-enable \
ksym-64kb-snd-hdac-stream-start \
ksym-64kb-snd-hdac-stream-stop \
ksym-64kb-snd-hdac-stream-sync \
ksym-64kb-snd-hdac-stream-sync-trigger \
ksym-64kb-snd-hdac-stream-timecounter-init \
ksym-64kb-snd-hdac-stream-wait-drsm \
ksym-64kb-snd-hdac-sync-audio-rate \
ksym-64kb-snd-hdac-sync-power-state \
ksym-64kb-snd-hwdep-new \
ksym-64kb-snd-hwparams-to-dma-slave-config \
ksym-64kb-snd-i2c-bus-create \
ksym-64kb-snd-i2c-device-create \
ksym-64kb-snd-i2c-device-free \
ksym-64kb-snd-i2c-probeaddr \
ksym-64kb-snd-i2c-readbytes \
ksym-64kb-snd-i2c-sendbytes \
ksym-64kb-snd-ice1712-akm4xxx-build-controls \
ksym-64kb-snd-ice1712-akm4xxx-free \
ksym-64kb-snd-ice1712-akm4xxx-init \
ksym-64kb-snd-info-create-card-entry \
ksym-64kb-snd-info-create-module-entry \
ksym-64kb-snd-info-free-entry \
ksym-64kb-snd-info-get-line \
ksym-64kb-snd-info-get-str \
ksym-64kb-snd-info-register \
ksym-64kb-snd-intel-acpi-dsp-driver-probe \
ksym-64kb-snd-intel-dsp-driver-probe \
ksym-64kb-snd-interval-list \
ksym-64kb-snd-interval-ranges \
ksym-64kb-snd-interval-ratnum \
ksym-64kb-snd-interval-refine \
ksym-64kb-snd-jack-add-new-kctl \
ksym-64kb-snd-jack-new \
ksym-64kb-snd-jack-report \
ksym-64kb-snd-jack-set-key \
ksym-64kb-snd-kill-fasync \
ksym-64kb-snd-lookup-minor-data \
ksym-64kb-snd-lookup-oss-minor-data \
ksym-64kb-snd-major \
ksym-64kb-snd-midi-channel-alloc-set \
ksym-64kb-snd-midi-channel-free-set \
ksym-64kb-snd-midi-channel-set-clear \
ksym-64kb-snd-midi-event-decode \
ksym-64kb-snd-midi-event-encode-byte \
ksym-64kb-snd-midi-event-free \
ksym-64kb-snd-midi-event-new \
ksym-64kb-snd-midi-event-no-status \
ksym-64kb-snd-midi-event-reset-decode \
ksym-64kb-snd-midi-event-reset-encode \
ksym-64kb-snd-midi-process-event \
ksym-64kb-snd-mixer-oss-ioctl-card \
ksym-64kb-snd-mixer-oss-notify-callback \
ksym-64kb-snd-mpu401-uart-interrupt \
ksym-64kb-snd-mpu401-uart-interrupt-tx \
ksym-64kb-snd-mpu401-uart-new \
ksym-64kb-snd-opl3-create \
ksym-64kb-snd-opl3-find-patch \
ksym-64kb-snd-opl3-hwdep-new \
ksym-64kb-snd-opl3-init \
ksym-64kb-snd-opl3-interrupt \
ksym-64kb-snd-opl3-load-patch \
ksym-64kb-snd-opl3-new \
ksym-64kb-snd-opl3-regmap \
ksym-64kb-snd-opl3-reset \
ksym-64kb-snd-opl3-timer-new \
ksym-64kb-snd-oss-info-register \
ksym-64kb-snd-parse-eld \
ksym-64kb-snd-pci-quirk-lookup \
ksym-64kb-snd-pci-quirk-lookup-id \
ksym-64kb-snd-pcm-2-1-chmaps \
ksym-64kb-snd-pcm-add-chmap-ctls \
ksym-64kb-snd-pcm-alt-chmaps \
ksym-64kb-snd-pcm-create-iec958-consumer \
ksym-64kb-snd-pcm-create-iec958-consumer-default \
ksym-64kb-snd-pcm-create-iec958-consumer-hw-params \
ksym-64kb-snd-pcm-debug-name \
ksym-64kb-snd-pcm-fill-iec958-consumer \
ksym-64kb-snd-pcm-fill-iec958-consumer-hw-params \
ksym-64kb-snd-pcm-format-big-endian \
ksym-64kb-snd-pcm-format-linear \
ksym-64kb-snd-pcm-format-little-endian \
ksym-64kb-snd-pcm-format-name \
ksym-64kb-snd-pcm-format-physical-width \
ksym-64kb-snd-pcm-format-set-silence \
ksym-64kb-snd-pcm-format-signed \
ksym-64kb-snd-pcm-format-silence-64 \
ksym-64kb-snd-pcm-format-size \
ksym-64kb-snd-pcm-format-unsigned \
ksym-64kb-snd-pcm-format-width \
ksym-64kb-snd-pcm-get-state \
ksym-64kb-snd-pcm-hw-constraint-eld \
ksym-64kb-snd-pcm-hw-constraint-integer \
ksym-64kb-snd-pcm-hw-constraint-list \
ksym-64kb-snd-pcm-hw-constraint-mask64 \
ksym-64kb-snd-pcm-hw-constraint-minmax \
ksym-64kb-snd-pcm-hw-constraint-msbits \
ksym-64kb-snd-pcm-hw-constraint-pow2 \
ksym-64kb-snd-pcm-hw-constraint-ranges \
ksym-64kb-snd-pcm-hw-constraint-ratdens \
ksym-64kb-snd-pcm-hw-constraint-ratnums \
ksym-64kb-snd-pcm-hw-constraint-step \
ksym-64kb-snd-pcm-hw-limit-rates \
ksym-64kb-snd-pcm-hw-param-first \
ksym-64kb-snd-pcm-hw-param-last \
ksym-64kb-snd-pcm-hw-param-value \
ksym-64kb-snd-pcm-hw-params-bits \
ksym-64kb-snd-pcm-hw-refine \
ksym-64kb-snd-pcm-hw-rule-add \
ksym-64kb-snd-pcm-hw-rule-noresample \
ksym-64kb-snd-pcm-kernel-ioctl \
ksym-64kb-snd-pcm-lib-default-mmap \
ksym-64kb-snd-pcm-lib-free-pages \
ksym-64kb-snd-pcm-lib-ioctl \
ksym-64kb-snd-pcm-lib-malloc-pages \
ksym-64kb-snd-pcm-lib-preallocate-free-for-all \
ksym-64kb-snd-pcm-lib-preallocate-pages \
ksym-64kb-snd-pcm-lib-preallocate-pages-for-all \
ksym-64kb-snd-pcm-mmap-data \
ksym-64kb-snd-pcm-new \
ksym-64kb-snd-pcm-new-internal \
ksym-64kb-snd-pcm-new-stream \
ksym-64kb-snd-pcm-notify \
ksym-64kb-snd-pcm-open-substream \
ksym-64kb-snd-pcm-period-elapsed \
ksym-64kb-snd-pcm-period-elapsed-under-stream-lock \
ksym-64kb-snd-pcm-rate-bit-to-rate \
ksym-64kb-snd-pcm-rate-mask-intersect \
ksym-64kb-snd-pcm-rate-to-rate-bit \
ksym-64kb-snd-pcm-release-substream \
ksym-64kb-snd-pcm-runtime-buffer-set-silence \
ksym-64kb-snd-pcm-set-managed-buffer \
ksym-64kb-snd-pcm-set-managed-buffer-all \
ksym-64kb-snd-pcm-set-ops \
ksym-64kb-snd-pcm-set-state \
ksym-64kb-snd-pcm-set-sync-per-card \
ksym-64kb-snd-pcm-std-chmaps \
ksym-64kb-snd-pcm-stop \
ksym-64kb-snd-pcm-stop-xrun \
ksym-64kb-snd-pcm-stream-lock \
ksym-64kb-snd-pcm-stream-lock-irq \
ksym-64kb-snd-pcm-stream-unlock \
ksym-64kb-snd-pcm-stream-unlock-irq \
ksym-64kb-snd-pcm-stream-unlock-irqrestore \
ksym-64kb-snd-pcm-suspend-all \
ksym-64kb-snd-power-ref-and-wait \
ksym-64kb-snd-power-wait \
ksym-64kb-snd-print-eld-info \
ksym-64kb-snd-print-pcm-bits \
ksym-64kb-snd-pt2258-build-controls \
ksym-64kb-snd-pt2258-reset \
ksym-64kb-snd-rawmidi-drain-input \
ksym-64kb-snd-rawmidi-drain-output \
ksym-64kb-snd-rawmidi-drop-output \
ksym-64kb-snd-rawmidi-free \
ksym-64kb-snd-rawmidi-info-select \
ksym-64kb-snd-rawmidi-init \
ksym-64kb-snd-rawmidi-input-params \
ksym-64kb-snd-rawmidi-kernel-open \
ksym-64kb-snd-rawmidi-kernel-read \
ksym-64kb-snd-rawmidi-kernel-release \
ksym-64kb-snd-rawmidi-kernel-write \
ksym-64kb-snd-rawmidi-new \
ksym-64kb-snd-rawmidi-output-params \
ksym-64kb-snd-rawmidi-proceed \
ksym-64kb-snd-rawmidi-receive \
ksym-64kb-snd-rawmidi-set-ops \
ksym-64kb-snd-rawmidi-transmit \
ksym-64kb-snd-rawmidi-transmit-ack \
ksym-64kb-snd-rawmidi-transmit-empty \
ksym-64kb-snd-rawmidi-transmit-peek \
ksym-64kb-snd-refcount-init \
ksym-64kb-snd-refcount-put \
ksym-64kb-snd-refcount-sync \
ksym-64kb-snd-register-device \
ksym-64kb-snd-register-oss-device \
ksym-64kb-snd-request-card \
ksym-64kb-snd-seq-autoload-exit \
ksym-64kb-snd-seq-autoload-init \
ksym-64kb-snd-seq-create-kernel-client \
ksym-64kb-snd-seq-delete-kernel-client \
ksym-64kb-snd-seq-device-load-drivers \
ksym-64kb-snd-seq-device-new \
ksym-64kb-snd-seq-driver-unregister \
ksym-64kb-snd-seq-dump-var-event \
ksym-64kb-snd-seq-event-port-attach \
ksym-64kb-snd-seq-event-port-detach \
ksym-64kb-snd-seq-expand-var-event \
ksym-64kb-snd-seq-expand-var-event-at \
ksym-64kb-snd-seq-kernel-client-ctl \
ksym-64kb-snd-seq-kernel-client-dispatch \
ksym-64kb-snd-seq-kernel-client-enqueue \
ksym-64kb-snd-seq-kernel-client-get \
ksym-64kb-snd-seq-kernel-client-ioctl \
ksym-64kb-snd-seq-kernel-client-put \
ksym-64kb-snd-seq-kernel-client-write-poll \
ksym-64kb-snd-seq-root \
ksym-64kb-snd-seq-set-queue-tempo \
ksym-64kb-snd-seq-system-broadcast \
ksym-64kb-snd-sgbuf-get-addr \
ksym-64kb-snd-sgbuf-get-chunk-size \
ksym-64kb-snd-sgbuf-get-page \
ksym-64kb-snd-show-eld \
ksym-64kb-snd-soc-acpi-amd-acp63-sof-machines \
ksym-64kb-snd-soc-acpi-amd-acp70-sof-machines \
ksym-64kb-snd-soc-acpi-amd-rmb-sof-machines \
ksym-64kb-snd-soc-acpi-amd-sof-machines \
ksym-64kb-snd-soc-acpi-amd-vangogh-sof-machines \
ksym-64kb-snd-soc-acpi-codec-list \
ksym-64kb-snd-soc-acpi-find-machine \
ksym-64kb-snd-soc-acpi-find-package-from-hid \
ksym-64kb-snd-soc-acpi-sdw-link-slaves-found \
ksym-64kb-snd-soc-add-card-controls \
ksym-64kb-snd-soc-add-component \
ksym-64kb-snd-soc-add-component-controls \
ksym-64kb-snd-soc-add-dai-controls \
ksym-64kb-snd-soc-add-pcm-runtimes \
ksym-64kb-snd-soc-alloc-ac97-component \
ksym-64kb-snd-soc-bytes-get \
ksym-64kb-snd-soc-bytes-info \
ksym-64kb-snd-soc-bytes-info-ext \
ksym-64kb-snd-soc-bytes-put \
ksym-64kb-snd-soc-bytes-tlv-callback \
ksym-64kb-snd-soc-calc-bclk \
ksym-64kb-snd-soc-calc-frame-size \
ksym-64kb-snd-soc-card-add-dai-link \
ksym-64kb-snd-soc-card-get-kcontrol \
ksym-64kb-snd-soc-card-jack-new \
ksym-64kb-snd-soc-card-jack-new-pins \
ksym-64kb-snd-soc-card-remove-dai-link \
ksym-64kb-snd-soc-card-set-topology-name \
ksym-64kb-snd-soc-close-delayed-work \
ksym-64kb-snd-soc-cnew \
ksym-64kb-snd-soc-component-async-complete \
ksym-64kb-snd-soc-component-compr-ack \
ksym-64kb-snd-soc-component-compr-copy \
ksym-64kb-snd-soc-component-compr-free \
ksym-64kb-snd-soc-component-compr-get-caps \
ksym-64kb-snd-soc-component-compr-get-codec-caps \
ksym-64kb-snd-soc-component-compr-get-metadata \
ksym-64kb-snd-soc-component-compr-get-params \
ksym-64kb-snd-soc-component-compr-open \
ksym-64kb-snd-soc-component-compr-pointer \
ksym-64kb-snd-soc-component-compr-set-metadata \
ksym-64kb-snd-soc-component-compr-set-params \
ksym-64kb-snd-soc-component-compr-trigger \
ksym-64kb-snd-soc-component-exit-regmap \
ksym-64kb-snd-soc-component-get-jack-type \
ksym-64kb-snd-soc-component-get-kcontrol \
ksym-64kb-snd-soc-component-init-regmap \
ksym-64kb-snd-soc-component-initialize \
ksym-64kb-snd-soc-component-notify-control \
ksym-64kb-snd-soc-component-read \
ksym-64kb-snd-soc-component-read-field \
ksym-64kb-snd-soc-component-regmap-val-bytes \
ksym-64kb-snd-soc-component-set-jack \
ksym-64kb-snd-soc-component-set-pll \
ksym-64kb-snd-soc-component-set-sysclk \
ksym-64kb-snd-soc-component-test-bits \
ksym-64kb-snd-soc-component-update-bits \
ksym-64kb-snd-soc-component-update-bits-async \
ksym-64kb-snd-soc-component-write \
ksym-64kb-snd-soc-component-write-field \
ksym-64kb-snd-soc-copy-dai-args \
ksym-64kb-snd-soc-dai-action \
ksym-64kb-snd-soc-dai-active \
ksym-64kb-snd-soc-dai-compr-ack \
ksym-64kb-snd-soc-dai-compr-get-metadata \
ksym-64kb-snd-soc-dai-compr-get-params \
ksym-64kb-snd-soc-dai-compr-pointer \
ksym-64kb-snd-soc-dai-compr-set-metadata \
ksym-64kb-snd-soc-dai-compr-set-params \
ksym-64kb-snd-soc-dai-compr-shutdown \
ksym-64kb-snd-soc-dai-compr-startup \
ksym-64kb-snd-soc-dai-compr-trigger \
ksym-64kb-snd-soc-dai-digital-mute \
ksym-64kb-snd-soc-dai-get-channel-map \
ksym-64kb-snd-soc-dai-is-dummy \
ksym-64kb-snd-soc-dai-name-get \
ksym-64kb-snd-soc-dai-prepare \
ksym-64kb-snd-soc-dai-set-bclk-clk \
ksym-64kb-snd-soc-dai-set-bclk-ratio \
ksym-64kb-snd-soc-dai-set-channel-map \
ksym-64kb-snd-soc-dai-set-clkdiv \
ksym-64kb-snd-soc-dai-set-fmt \
ksym-64kb-snd-soc-dai-set-pll \
ksym-64kb-snd-soc-dai-set-sysclk \
ksym-64kb-snd-soc-dai-set-tdm-idle \
ksym-64kb-snd-soc-dai-set-tdm-slot \
ksym-64kb-snd-soc-dai-set-tristate \
ksym-64kb-snd-soc-daifmt-clock-provider-flipped \
ksym-64kb-snd-soc-daifmt-clock-provider-from-bitmap \
ksym-64kb-snd-soc-daifmt-parse-clock-provider-raw \
ksym-64kb-snd-soc-daifmt-parse-format \
ksym-64kb-snd-soc-dapm-add-routes \
ksym-64kb-snd-soc-dapm-clock-event \
ksym-64kb-snd-soc-dapm-dai-free-widgets \
ksym-64kb-snd-soc-dapm-dai-get-connected-widgets \
ksym-64kb-snd-soc-dapm-del-routes \
ksym-64kb-snd-soc-dapm-disable-pin \
ksym-64kb-snd-soc-dapm-disable-pin-unlocked \
ksym-64kb-snd-soc-dapm-enable-pin \
ksym-64kb-snd-soc-dapm-enable-pin-unlocked \
ksym-64kb-snd-soc-dapm-force-bias-level \
ksym-64kb-snd-soc-dapm-force-enable-pin \
ksym-64kb-snd-soc-dapm-force-enable-pin-unlocked \
ksym-64kb-snd-soc-dapm-free-widget \
ksym-64kb-snd-soc-dapm-get-bias-level \
ksym-64kb-snd-soc-dapm-get-component-pin-switch \
ksym-64kb-snd-soc-dapm-get-enum-double \
ksym-64kb-snd-soc-dapm-get-idle-bias \
ksym-64kb-snd-soc-dapm-get-pin-status \
ksym-64kb-snd-soc-dapm-get-pin-switch \
ksym-64kb-snd-soc-dapm-get-volsw \
ksym-64kb-snd-soc-dapm-ignore-suspend \
ksym-64kb-snd-soc-dapm-info-pin-switch \
ksym-64kb-snd-soc-dapm-init-bias-level \
ksym-64kb-snd-soc-dapm-kcontrol-get-value \
ksym-64kb-snd-soc-dapm-kcontrol-to-component \
ksym-64kb-snd-soc-dapm-kcontrol-to-dapm \
ksym-64kb-snd-soc-dapm-kcontrol-to-widget \
ksym-64kb-snd-soc-dapm-mixer-update-power \
ksym-64kb-snd-soc-dapm-mux-update-power \
ksym-64kb-snd-soc-dapm-new-control \
ksym-64kb-snd-soc-dapm-new-controls \
ksym-64kb-snd-soc-dapm-new-dai-widgets \
ksym-64kb-snd-soc-dapm-new-widgets \
ksym-64kb-snd-soc-dapm-pin-has-prefix \
ksym-64kb-snd-soc-dapm-pinctrl-event \
ksym-64kb-snd-soc-dapm-put-component-pin-switch \
ksym-64kb-snd-soc-dapm-put-enum-double \
ksym-64kb-snd-soc-dapm-put-pin-switch \
ksym-64kb-snd-soc-dapm-put-volsw \
ksym-64kb-snd-soc-dapm-regulator-event \
ksym-64kb-snd-soc-dapm-set-idle-bias \
ksym-64kb-snd-soc-dapm-stream-stop \
ksym-64kb-snd-soc-dapm-sync \
ksym-64kb-snd-soc-dapm-sync-unlocked \
ksym-64kb-snd-soc-dapm-to-card \
ksym-64kb-snd-soc-dapm-to-component \
ksym-64kb-snd-soc-dapm-to-dev \
ksym-64kb-snd-soc-dapm-widget-name-cmp \
ksym-64kb-snd-soc-debugfs-root \
ksym-64kb-snd-soc-dlc-is-dummy \
ksym-64kb-snd-soc-dlc-use-cpu-as-platform \
ksym-64kb-snd-soc-dpcm-get-substream \
ksym-64kb-snd-soc-dpcm-runtime-update \
ksym-64kb-snd-soc-dummy-dlc \
ksym-64kb-snd-soc-find-dai \
ksym-64kb-snd-soc-find-dai-with-mutex \
ksym-64kb-snd-soc-free-ac97-component \
ksym-64kb-snd-soc-get-dai-id \
ksym-64kb-snd-soc-get-dai-name \
ksym-64kb-snd-soc-get-dai-via-args \
ksym-64kb-snd-soc-get-dlc \
ksym-64kb-snd-soc-get-enum-double \
ksym-64kb-snd-soc-get-pcm-runtime \
ksym-64kb-snd-soc-get-stream-cpu \
ksym-64kb-snd-soc-get-strobe \
ksym-64kb-snd-soc-get-volsw \
ksym-64kb-snd-soc-get-volsw-sx \
ksym-64kb-snd-soc-get-xr-sx \
ksym-64kb-snd-soc-hda-codec-dai-ops \
ksym-64kb-snd-soc-info-enum-double \
ksym-64kb-snd-soc-info-volsw \
ksym-64kb-snd-soc-info-volsw-sx \
ksym-64kb-snd-soc-info-xr-sx \
ksym-64kb-snd-soc-jack-add-gpiods \
ksym-64kb-snd-soc-jack-add-gpios \
ksym-64kb-snd-soc-jack-add-pins \
ksym-64kb-snd-soc-jack-add-zones \
ksym-64kb-snd-soc-jack-free-gpios \
ksym-64kb-snd-soc-jack-get-type \
ksym-64kb-snd-soc-jack-notifier-register \
ksym-64kb-snd-soc-jack-notifier-unregister \
ksym-64kb-snd-soc-jack-report \
ksym-64kb-snd-soc-limit-volume \
ksym-64kb-snd-soc-link-compr-set-params \
ksym-64kb-snd-soc-link-compr-shutdown \
ksym-64kb-snd-soc-link-compr-startup \
ksym-64kb-snd-soc-lookup-component \
ksym-64kb-snd-soc-lookup-component-by-name \
ksym-64kb-snd-soc-lookup-component-nolocked \
ksym-64kb-snd-soc-new-ac97-component \
ksym-64kb-snd-soc-new-compress \
ksym-64kb-snd-soc-of-get-dai-link-codecs \
ksym-64kb-snd-soc-of-get-dai-link-cpus \
ksym-64kb-snd-soc-of-get-dai-name \
ksym-64kb-snd-soc-of-get-dlc \
ksym-64kb-snd-soc-of-get-slot-mask \
ksym-64kb-snd-soc-of-parse-audio-routing \
ksym-64kb-snd-soc-of-parse-audio-simple-widgets \
ksym-64kb-snd-soc-of-parse-aux-devs \
ksym-64kb-snd-soc-of-parse-card-name \
ksym-64kb-snd-soc-of-parse-ignore-suspend-widgets \
ksym-64kb-snd-soc-of-parse-node-prefix \
ksym-64kb-snd-soc-of-parse-pin-switches \
ksym-64kb-snd-soc-of-parse-tdm-slot \
ksym-64kb-snd-soc-of-put-dai-link-codecs \
ksym-64kb-snd-soc-of-put-dai-link-cpus \
ksym-64kb-snd-soc-params-to-bclk \
ksym-64kb-snd-soc-params-to-frame-size \
ksym-64kb-snd-soc-pm-ops \
ksym-64kb-snd-soc-poweroff \
ksym-64kb-snd-soc-put-enum-double \
ksym-64kb-snd-soc-put-strobe \
ksym-64kb-snd-soc-put-volsw \
ksym-64kb-snd-soc-put-volsw-sx \
ksym-64kb-snd-soc-put-xr-sx \
ksym-64kb-snd-soc-register-card \
ksym-64kb-snd-soc-register-component \
ksym-64kb-snd-soc-register-dai \
ksym-64kb-snd-soc-remove-pcm-runtime \
ksym-64kb-snd-soc-resume \
ksym-64kb-snd-soc-ret \
ksym-64kb-snd-soc-rtdcom-lookup \
ksym-64kb-snd-soc-runtime-action \
ksym-64kb-snd-soc-runtime-calc-hw \
ksym-64kb-snd-soc-runtime-set-dai-fmt \
ksym-64kb-snd-soc-set-ac97-ops \
ksym-64kb-snd-soc-set-ac97-ops-of-reset \
ksym-64kb-snd-soc-suspend \
ksym-64kb-snd-soc-tdm-params-to-bclk \
ksym-64kb-snd-soc-tplg-component-load \
ksym-64kb-snd-soc-tplg-component-remove \
ksym-64kb-snd-soc-tplg-widget-bind-event \
ksym-64kb-snd-soc-unregister-card \
ksym-64kb-snd-soc-unregister-component-by-driver \
ksym-64kb-snd-soc-unregister-dai \
ksym-64kb-snd-soc-usb-add-port \
ksym-64kb-snd-soc-usb-allocate-port \
ksym-64kb-snd-soc-usb-connect \
ksym-64kb-snd-soc-usb-disconnect \
ksym-64kb-snd-soc-usb-find-priv-data \
ksym-64kb-snd-soc-usb-find-supported-format \
ksym-64kb-snd-soc-usb-free-port \
ksym-64kb-snd-soc-usb-remove-port \
ksym-64kb-snd-soc-usb-setup-offload-jack \
ksym-64kb-snd-soc-usb-update-offload-route \
ksym-64kb-snd-sof-boot-dsp-firmware \
ksym-64kb-snd-sof-complete \
ksym-64kb-snd-sof-create-page-table \
ksym-64kb-snd-sof-dbg-init \
ksym-64kb-snd-sof-dbg-memory-info-init \
ksym-64kb-snd-sof-debugfs-add-region-item-iomem \
ksym-64kb-snd-sof-debugfs-buf-item \
ksym-64kb-snd-sof-device-probe \
ksym-64kb-snd-sof-device-probe-completed \
ksym-64kb-snd-sof-device-remove \
ksym-64kb-snd-sof-device-shutdown \
ksym-64kb-snd-sof-dsp-dbg-dump \
ksym-64kb-snd-sof-dsp-only-d0i3-compatible-stream-active \
ksym-64kb-snd-sof-dsp-panic \
ksym-64kb-snd-sof-dsp-update-bits \
ksym-64kb-snd-sof-dsp-update-bits-forced \
ksym-64kb-snd-sof-dsp-update-bits-unlocked \
ksym-64kb-snd-sof-dsp-update-bits64 \
ksym-64kb-snd-sof-dsp-update-bits64-unlocked \
ksym-64kb-snd-sof-free-debug \
ksym-64kb-snd-sof-fw-unload \
ksym-64kb-snd-sof-handle-fw-exception \
ksym-64kb-snd-sof-ipc-free \
ksym-64kb-snd-sof-ipc-get-reply \
ksym-64kb-snd-sof-ipc-init \
ksym-64kb-snd-sof-ipc-reply \
ksym-64kb-snd-sof-load-firmware-memcpy \
ksym-64kb-snd-sof-load-firmware-raw \
ksym-64kb-snd-sof-load-topology \
ksym-64kb-snd-sof-pci-update-bits \
ksym-64kb-snd-sof-pcm-period-elapsed \
ksym-64kb-snd-sof-prepare \
ksym-64kb-snd-sof-resume \
ksym-64kb-snd-sof-run-firmware \
ksym-64kb-snd-sof-runtime-idle \
ksym-64kb-snd-sof-runtime-resume \
ksym-64kb-snd-sof-runtime-suspend \
ksym-64kb-snd-sof-suspend \
ksym-64kb-snd-tea575x-enum-freq-bands \
ksym-64kb-snd-tea575x-exit \
ksym-64kb-snd-tea575x-g-tuner \
ksym-64kb-snd-tea575x-hw-init \
ksym-64kb-snd-tea575x-init \
ksym-64kb-snd-tea575x-s-hw-freq-seek \
ksym-64kb-snd-tea575x-set-freq \
ksym-64kb-snd-timer-close \
ksym-64kb-snd-timer-continue \
ksym-64kb-snd-timer-global-free \
ksym-64kb-snd-timer-global-new \
ksym-64kb-snd-timer-global-register \
ksym-64kb-snd-timer-instance-free \
ksym-64kb-snd-timer-instance-new \
ksym-64kb-snd-timer-interrupt \
ksym-64kb-snd-timer-new \
ksym-64kb-snd-timer-notify \
ksym-64kb-snd-timer-open \
ksym-64kb-snd-timer-pause \
ksym-64kb-snd-timer-resolution \
ksym-64kb-snd-timer-start \
ksym-64kb-snd-timer-stop \
ksym-64kb-snd-timeri-timer-get \
ksym-64kb-snd-timeri-timer-put \
ksym-64kb-snd-ump-attach-legacy-rawmidi \
ksym-64kb-snd-ump-block-new \
ksym-64kb-snd-ump-convert-from-ump \
ksym-64kb-snd-ump-convert-to-ump \
ksym-64kb-snd-ump-endpoint-new \
ksym-64kb-snd-ump-parse-endpoint \
ksym-64kb-snd-ump-receive \
ksym-64kb-snd-ump-receive-ump-val \
ksym-64kb-snd-ump-switch-protocol \
ksym-64kb-snd-ump-transmit \
ksym-64kb-snd-ump-update-group-attrs \
ksym-64kb-snd-unregister-device \
ksym-64kb-snd-unregister-oss-device \
ksym-64kb-snd-usb-autoresume \
ksym-64kb-snd-usb-autosuspend \
ksym-64kb-snd-usb-endpoint-prepare \
ksym-64kb-snd-usb-find-csint-desc \
ksym-64kb-snd-usb-find-format \
ksym-64kb-snd-usb-find-substream-format \
ksym-64kb-snd-usb-find-suppported-substream \
ksym-64kb-snd-usb-hw-free \
ksym-64kb-snd-usb-hw-params \
ksym-64kb-snd-usb-lock-shutdown \
ksym-64kb-snd-usb-rediscover-devices \
ksym-64kb-snd-usb-register-platform-ops \
ksym-64kb-snd-usb-unlock-shutdown \
ksym-64kb-snd-usb-unregister-platform-ops \
ksym-64kb-snd-usbmidi-disconnect \
ksym-64kb-snd-usbmidi-input-start \
ksym-64kb-snd-usbmidi-input-stop \
ksym-64kb-snd-usbmidi-resume \
ksym-64kb-snd-usbmidi-suspend \
ksym-64kb-snd-use-lock-sync-helper \
ksym-64kb-snd-virmidi-new \
ksym-64kb-snd-vx-check-reg-bit \
ksym-64kb-snd-vx-create \
ksym-64kb-snd-vx-dsp-boot \
ksym-64kb-snd-vx-dsp-load \
ksym-64kb-snd-vx-free-firmware \
ksym-64kb-snd-vx-irq-handler \
ksym-64kb-snd-vx-load-boot-image \
ksym-64kb-snd-vx-resume \
ksym-64kb-snd-vx-setup-firmware \
ksym-64kb-snd-vx-suspend \
ksym-64kb-snd-vx-threaded-irq-handler \
ksym-64kb-snprintf \
ksym-64kb-soc-ac97-ops \
ksym-64kb-soc-attr-read-machine \
ksym-64kb-soc-codec-dev-max98373 \
ksym-64kb-soc-codec-dev-max98373-sdw \
ksym-64kb-soc-device-match \
ksym-64kb-soc-device-register \
ksym-64kb-soc-device-unregister \
ksym-64kb-soc-hda-ext-bus-ops \
ksym-64kb-sock-alloc \
ksym-64kb-sock-alloc-file \
ksym-64kb-sock-alloc-send-pskb \
ksym-64kb-sock-bind-add \
ksym-64kb-sock-bindtoindex \
ksym-64kb-sock-cmsg-send \
ksym-64kb-sock-common-getsockopt \
ksym-64kb-sock-common-recvmsg \
ksym-64kb-sock-common-setsockopt \
ksym-64kb-sock-copy-user-timeval \
ksym-64kb-sock-create \
ksym-64kb-sock-create-kern \
ksym-64kb-sock-create-lite \
ksym-64kb-sock-dequeue-err-skb \
ksym-64kb-sock-diag-check-cookie \
ksym-64kb-sock-diag-destroy \
ksym-64kb-sock-diag-put-filterinfo \
ksym-64kb-sock-diag-put-meminfo \
ksym-64kb-sock-diag-register \
ksym-64kb-sock-diag-register-inet-compat \
ksym-64kb-sock-diag-save-cookie \
ksym-64kb-sock-diag-unregister \
ksym-64kb-sock-diag-unregister-inet-compat \
ksym-64kb-sock-edemux \
ksym-64kb-sock-efree \
ksym-64kb-sock-from-file \
ksym-64kb-sock-gen-put \
ksym-64kb-sock-get-timeout \
ksym-64kb-sock-gettstamp \
ksym-64kb-sock-init-data \
ksym-64kb-sock-init-data-uid \
ksym-64kb-sock-inuse-get \
ksym-64kb-sock-ioctl-inout \
ksym-64kb-sock-kfree-s \
ksym-64kb-sock-kmalloc \
ksym-64kb-sock-kmemdup \
ksym-64kb-sock-kzfree-s \
ksym-64kb-sock-load-diag-module \
ksym-64kb-sock-map-close \
ksym-64kb-sock-map-destroy \
ksym-64kb-sock-map-unhash \
ksym-64kb-sock-no-accept \
ksym-64kb-sock-no-bind \
ksym-64kb-sock-no-connect \
ksym-64kb-sock-no-getname \
ksym-64kb-sock-no-ioctl \
ksym-64kb-sock-no-linger \
ksym-64kb-sock-no-listen \
ksym-64kb-sock-no-mmap \
ksym-64kb-sock-no-recvmsg \
ksym-64kb-sock-no-sendmsg \
ksym-64kb-sock-no-sendmsg-locked \
ksym-64kb-sock-no-shutdown \
ksym-64kb-sock-no-socketpair \
ksym-64kb-sock-pfree \
ksym-64kb-sock-prot-inuse-get \
ksym-64kb-sock-queue-err-skb \
ksym-64kb-sock-queue-rcv-skb-reason \
ksym-64kb-sock-recv-errqueue \
ksym-64kb-sock-recvmsg \
ksym-64kb-sock-register \
ksym-64kb-sock-release \
ksym-64kb-sock-rfree \
ksym-64kb-sock-sendmsg \
ksym-64kb-sock-set-keepalive \
ksym-64kb-sock-set-mark \
ksym-64kb-sock-set-priority \
ksym-64kb-sock-set-rcvbuf \
ksym-64kb-sock-set-reuseaddr \
ksym-64kb-sock-set-reuseport \
ksym-64kb-sock-set-sndtimeo \
ksym-64kb-sock-setsockopt \
ksym-64kb-sock-unregister \
ksym-64kb-sock-wake-async \
ksym-64kb-sock-wfree \
ksym-64kb-sock-wmalloc \
ksym-64kb-sockaddr-to-str \
ksym-64kb-sockfd-lookup \
ksym-64kb-sockopt-capable \
ksym-64kb-sockopt-lock-sock \
ksym-64kb-sockopt-ns-capable \
ksym-64kb-sockopt-release-sock \
ksym-64kb-sof-block-read \
ksym-64kb-sof-block-write \
ksym-64kb-sof-compressed-ops \
ksym-64kb-sof-create-ipc-file-profile \
ksym-64kb-sof-dai-get-bclk \
ksym-64kb-sof-dai-get-mclk \
ksym-64kb-sof-dai-get-tdm-slots \
ksym-64kb-sof-debug-check-flag \
ksym-64kb-sof-imx-ops \
ksym-64kb-sof-io-read \
ksym-64kb-sof-io-read64 \
ksym-64kb-sof-io-write \
ksym-64kb-sof-io-write64 \
ksym-64kb-sof-ipc-msg-data \
ksym-64kb-sof-ipc-set-get-data \
ksym-64kb-sof-ipc-tx-message \
ksym-64kb-sof-ipc-tx-message-no-pm \
ksym-64kb-sof-ipc3-do-rx-work \
ksym-64kb-sof-machine-register \
ksym-64kb-sof-machine-unregister \
ksym-64kb-sof-mailbox-read \
ksym-64kb-sof-mailbox-write \
ksym-64kb-sof-of-pm \
ksym-64kb-sof-of-probe \
ksym-64kb-sof-of-remove \
ksym-64kb-sof-of-shutdown \
ksym-64kb-sof-pcm-dai-link-fixup \
ksym-64kb-sof-print-oops-and-stack \
ksym-64kb-sof-set-fw-state \
ksym-64kb-sof-set-stream-data-offset \
ksym-64kb-sof-stream-pcm-close \
ksym-64kb-sof-stream-pcm-open \
ksym-64kb-sof-widget-free \
ksym-64kb-sof-widget-setup \
ksym-64kb-sof-xtensa-arch-ops \
ksym-64kb-softnet-data \
ksym-64kb-software-node-find-by-name \
ksym-64kb-software-node-fwnode \
ksym-64kb-software-node-register \
ksym-64kb-software-node-register-node-group \
ksym-64kb-software-node-unregister \
ksym-64kb-software-node-unregister-node-group \
ksym-64kb-sonet-copy-stats \
ksym-64kb-sonet-subtract-stats \
ksym-64kb-sophgo-pinctrl-probe \
ksym-64kb-sort \
ksym-64kb-sort-nonatomic \
ksym-64kb-sort-r \
ksym-64kb-sort-r-nonatomic \
ksym-64kb-sound-class \
ksym-64kb-sound-debugfs-root \
ksym-64kb-sp8870-attach \
ksym-64kb-sp887x-attach \
ksym-64kb-sparse-keymap-entry-from-keycode \
ksym-64kb-sparse-keymap-entry-from-scancode \
ksym-64kb-sparse-keymap-report-entry \
ksym-64kb-sparse-keymap-report-event \
ksym-64kb-sparse-keymap-setup \
ksym-64kb-spc-emulate-evpd-83 \
ksym-64kb-spc-emulate-inquiry-std \
ksym-64kb-spc-emulate-report-luns \
ksym-64kb-spc-parse-cdb \
ksym-64kb-spi-add-device \
ksym-64kb-spi-alloc-device \
ksym-64kb-spi-async \
ksym-64kb-spi-attach-transport \
ksym-64kb-spi-bitbang-cleanup \
ksym-64kb-spi-bitbang-init \
ksym-64kb-spi-bitbang-setup \
ksym-64kb-spi-bitbang-setup-transfer \
ksym-64kb-spi-bitbang-start \
ksym-64kb-spi-bitbang-stop \
ksym-64kb-spi-bus-lock \
ksym-64kb-spi-bus-type \
ksym-64kb-spi-bus-unlock \
ksym-64kb-spi-controller-dma-map-mem-op-data \
ksym-64kb-spi-controller-dma-unmap-mem-op-data \
ksym-64kb-spi-controller-resume \
ksym-64kb-spi-controller-suspend \
ksym-64kb-spi-delay-exec \
ksym-64kb-spi-delay-to-ns \
ksym-64kb-spi-display-xfer-agreement \
ksym-64kb-spi-dv-device \
ksym-64kb-spi-finalize-current-message \
ksym-64kb-spi-finalize-current-transfer \
ksym-64kb-spi-get-device-id \
ksym-64kb-spi-get-device-match-data \
ksym-64kb-spi-get-next-queued-message \
ksym-64kb-spi-mem-adjust-op-freq \
ksym-64kb-spi-mem-adjust-op-size \
ksym-64kb-spi-mem-calc-op-duration \
ksym-64kb-spi-mem-default-supports-op \
ksym-64kb-spi-mem-dirmap-create \
ksym-64kb-spi-mem-dirmap-destroy \
ksym-64kb-spi-mem-dirmap-read \
ksym-64kb-spi-mem-dirmap-write \
ksym-64kb-spi-mem-driver-register-with-owner \
ksym-64kb-spi-mem-driver-unregister \
ksym-64kb-spi-mem-exec-op \
ksym-64kb-spi-mem-get-name \
ksym-64kb-spi-mem-poll-status \
ksym-64kb-spi-mem-supports-op \
ksym-64kb-spi-new-ancillary-device \
ksym-64kb-spi-new-device \
ksym-64kb-spi-nor-scan \
ksym-64kb-spi-offload-trigger-disable \
ksym-64kb-spi-offload-trigger-enable \
ksym-64kb-spi-offload-trigger-get-priv \
ksym-64kb-spi-offload-trigger-validate \
ksym-64kb-spi-optimize-message \
ksym-64kb-spi-populate-ppr-msg \
ksym-64kb-spi-populate-sync-msg \
ksym-64kb-spi-populate-tag-msg \
ksym-64kb-spi-populate-width-msg \
ksym-64kb-spi-print-msg \
ksym-64kb-spi-register-controller \
ksym-64kb-spi-release-transport \
ksym-64kb-spi-schedule-dv-device \
ksym-64kb-spi-setup \
ksym-64kb-spi-split-transfers-maxsize \
ksym-64kb-spi-split-transfers-maxwords \
ksym-64kb-spi-sync \
ksym-64kb-spi-sync-locked \
ksym-64kb-spi-take-timestamp-post \
ksym-64kb-spi-take-timestamp-pre \
ksym-64kb-spi-target-abort \
ksym-64kb-spi-test-execute-msg \
ksym-64kb-spi-test-run-test \
ksym-64kb-spi-test-run-tests \
ksym-64kb-spi-transfer-cs-change-delay-exec \
ksym-64kb-spi-unoptimize-message \
ksym-64kb-spi-unregister-controller \
ksym-64kb-spi-unregister-device \
ksym-64kb-spi-write-then-read \
ksym-64kb-splice-direct-to-actor \
ksym-64kb-splice-file-range \
ksym-64kb-splice-to-pipe \
ksym-64kb-split-key-done \
ksym-64kb-split-page \
ksym-64kb-spmi-command-reset \
ksym-64kb-spmi-command-shutdown \
ksym-64kb-spmi-command-sleep \
ksym-64kb-spmi-command-wakeup \
ksym-64kb-spmi-controller-add \
ksym-64kb-spmi-controller-alloc \
ksym-64kb-spmi-controller-remove \
ksym-64kb-spmi-device-add \
ksym-64kb-spmi-device-alloc \
ksym-64kb-spmi-device-remove \
ksym-64kb-spmi-ext-register-read \
ksym-64kb-spmi-ext-register-readl \
ksym-64kb-spmi-ext-register-write \
ksym-64kb-spmi-ext-register-writel \
ksym-64kb-spmi-find-device-by-of-node \
ksym-64kb-spmi-register-read \
ksym-64kb-spmi-register-write \
ksym-64kb-spmi-register-zero-write \
ksym-64kb-sprd-clk-probe \
ksym-64kb-sprd-clk-regmap-init \
ksym-64kb-sprd-comp-ops \
ksym-64kb-sprd-div-helper-recalc-rate \
ksym-64kb-sprd-div-helper-set-rate \
ksym-64kb-sprd-div-ops \
ksym-64kb-sprd-gate-ops \
ksym-64kb-sprd-mcdt-chan-dma-disable \
ksym-64kb-sprd-mcdt-chan-dma-enable \
ksym-64kb-sprd-mcdt-chan-int-disable \
ksym-64kb-sprd-mcdt-chan-int-enable \
ksym-64kb-sprd-mcdt-chan-read \
ksym-64kb-sprd-mcdt-chan-write \
ksym-64kb-sprd-mcdt-free-chan \
ksym-64kb-sprd-mcdt-request-chan \
ksym-64kb-sprd-mux-helper-get-parent \
ksym-64kb-sprd-mux-helper-set-parent \
ksym-64kb-sprd-mux-ops \
ksym-64kb-sprd-pinctrl-core-probe \
ksym-64kb-sprd-pinctrl-remove \
ksym-64kb-sprd-pinctrl-shutdown \
ksym-64kb-sprd-pll-ops \
ksym-64kb-sprd-pll-sc-gate-ops \
ksym-64kb-sprd-pmic-detect-charger-type \
ksym-64kb-sprd-sc-gate-ops \
ksym-64kb-sprint-oid \
ksym-64kb-sprint-symbol \
ksym-64kb-sprint-symbol-build-id \
ksym-64kb-sprint-symbol-no-offset \
ksym-64kb-sprintf \
ksym-64kb-sps30-probe \
ksym-64kb-srcu-barrier \
ksym-64kb-srcu-batches-completed \
ksym-64kb-srcu-expedite-current \
ksym-64kb-srcu-init-notifier-head \
ksym-64kb-srcu-notifier-call-chain \
ksym-64kb-srcu-notifier-chain-register \
ksym-64kb-srcu-notifier-chain-unregister \
ksym-64kb-srcu-torture-stats-print \
ksym-64kb-srcutorture-get-gp-data \
ksym-64kb-srgb-eotf \
ksym-64kb-srgb-inv-eotf \
ksym-64kb-srp-attach-transport \
ksym-64kb-srp-parse-tmo \
ksym-64kb-srp-reconnect-rport \
ksym-64kb-srp-release-transport \
ksym-64kb-srp-remove-host \
ksym-64kb-srp-rport-add \
ksym-64kb-srp-rport-del \
ksym-64kb-srp-rport-get \
ksym-64kb-srp-rport-put \
ksym-64kb-srp-start-tl-fail-timers \
ksym-64kb-srp-stop-rport-timers \
ksym-64kb-srp-timed-out \
ksym-64kb-srp-tmo-valid \
ksym-64kb-ssam-client-bind \
ksym-64kb-ssam-client-link \
ksym-64kb-ssam-controller-device \
ksym-64kb-ssam-controller-event-disable \
ksym-64kb-ssam-controller-event-enable \
ksym-64kb-ssam-controller-get \
ksym-64kb-ssam-controller-put \
ksym-64kb-ssam-controller-statelock \
ksym-64kb-ssam-controller-stateunlock \
ksym-64kb-ssam-device-add \
ksym-64kb-ssam-device-alloc \
ksym-64kb-ssam-device-driver-unregister \
ksym-64kb-ssam-device-get-match \
ksym-64kb-ssam-device-get-match-data \
ksym-64kb-ssam-device-id-match \
ksym-64kb-ssam-device-remove \
ksym-64kb-ssam-device-type \
ksym-64kb-ssam-get-controller \
ksym-64kb-ssam-notifier-register \
ksym-64kb-ssam-remove-clients \
ksym-64kb-ssam-request-do-sync \
ksym-64kb-ssam-request-do-sync-with-buffer \
ksym-64kb-ssam-request-sync-alloc \
ksym-64kb-ssam-request-sync-free \
ksym-64kb-ssam-request-sync-init \
ksym-64kb-ssam-request-sync-submit \
ksym-64kb-ssam-request-write-data \
ksym-64kb-ssb-admatch-base \
ksym-64kb-ssb-admatch-size \
ksym-64kb-ssb-bus-may-powerdown \
ksym-64kb-ssb-bus-powerup \
ksym-64kb-ssb-bus-resume \
ksym-64kb-ssb-bus-sdiobus-register \
ksym-64kb-ssb-bus-suspend \
ksym-64kb-ssb-bus-unregister \
ksym-64kb-ssb-chipco-gpio-control \
ksym-64kb-ssb-clockspeed \
ksym-64kb-ssb-commit-settings \
ksym-64kb-ssb-device-disable \
ksym-64kb-ssb-device-enable \
ksym-64kb-ssb-device-is-enabled \
ksym-64kb-ssb-dma-translation \
ksym-64kb-ssb-driver-unregister \
ksym-64kb-ssb-pcicore-dev-irqvecs-enable \
ksym-64kb-ssb-pcihost-register \
ksym-64kb-ssb-pmu-set-ldo-paref \
ksym-64kb-ssb-pmu-set-ldo-voltage \
ksym-64kb-ssb-pmu-spuravoid-pllupdate \
ksym-64kb-ssb-set-devtypedata \
ksym-64kb-sscanf \
ksym-64kb-ssd130x-probe \
ksym-64kb-ssd130x-remove \
ksym-64kb-ssd130x-shutdown \
ksym-64kb-ssd130x-variants \
ksym-64kb-ssh-packet-get \
ksym-64kb-ssh-packet-put \
ksym-64kb-ssm2602-probe \
ksym-64kb-ssm2602-regmap-config \
ksym-64kb-st-accel-common-probe \
ksym-64kb-st-accel-get-settings \
ksym-64kb-st-lsm6dsx-pm-ops \
ksym-64kb-st-lsm6dsx-probe \
ksym-64kb-st-lsm9ds0-probe \
ksym-64kb-st-magn-common-probe \
ksym-64kb-st-magn-get-settings \
ksym-64kb-st-nci-disable-se \
ksym-64kb-st-nci-discover-se \
ksym-64kb-st-nci-enable-se \
ksym-64kb-st-nci-hci-cmd-received \
ksym-64kb-st-nci-hci-event-received \
ksym-64kb-st-nci-hci-load-session \
ksym-64kb-st-nci-probe \
ksym-64kb-st-nci-remove \
ksym-64kb-st-nci-se-deinit \
ksym-64kb-st-nci-se-init \
ksym-64kb-st-nci-se-io \
ksym-64kb-st-nci-vendor-cmds-init \
ksym-64kb-st-press-common-probe \
ksym-64kb-st-press-get-settings \
ksym-64kb-st-sensors-allocate-trigger \
ksym-64kb-st-sensors-debugfs-reg-access \
ksym-64kb-st-sensors-dev-name-probe \
ksym-64kb-st-sensors-get-settings-index \
ksym-64kb-st-sensors-i2c-configure \
ksym-64kb-st-sensors-init-sensor \
ksym-64kb-st-sensors-power-enable \
ksym-64kb-st-sensors-read-info-raw \
ksym-64kb-st-sensors-set-axis-enable \
ksym-64kb-st-sensors-set-dataready-irq \
ksym-64kb-st-sensors-set-enable \
ksym-64kb-st-sensors-set-fullscale-by-gain \
ksym-64kb-st-sensors-set-odr \
ksym-64kb-st-sensors-spi-configure \
ksym-64kb-st-sensors-sysfs-sampling-frequency-avail \
ksym-64kb-st-sensors-sysfs-scale-avail \
ksym-64kb-st-sensors-trigger-handler \
ksym-64kb-st-sensors-validate-device \
ksym-64kb-st-sensors-verify-id \
ksym-64kb-st-thermal-pm-ops \
ksym-64kb-st-thermal-register \
ksym-64kb-st-thermal-unregister \
ksym-64kb-st-uvis25-pm-ops \
ksym-64kb-st-uvis25-probe \
ksym-64kb-st21nfca-apdu-reader-event-received \
ksym-64kb-st21nfca-connectivity-event-received \
ksym-64kb-st21nfca-dep-deinit \
ksym-64kb-st21nfca-dep-event-received \
ksym-64kb-st21nfca-dep-init \
ksym-64kb-st21nfca-hci-disable-se \
ksym-64kb-st21nfca-hci-discover-se \
ksym-64kb-st21nfca-hci-enable-se \
ksym-64kb-st21nfca-hci-loopback-event-received \
ksym-64kb-st21nfca-hci-probe \
ksym-64kb-st21nfca-hci-remove \
ksym-64kb-st21nfca-hci-se-io \
ksym-64kb-st21nfca-im-send-atr-req \
ksym-64kb-st21nfca-im-send-dep-req \
ksym-64kb-st21nfca-se-deinit \
ksym-64kb-st21nfca-se-init \
ksym-64kb-st21nfca-tm-send-dep-res \
ksym-64kb-st21nfca-vendor-cmds-init \
ksym-64kb-st33zp24-pm-resume \
ksym-64kb-st33zp24-pm-suspend \
ksym-64kb-st33zp24-probe \
ksym-64kb-st33zp24-remove \
ksym-64kb-st7567-config \
ksym-64kb-st7571-config \
ksym-64kb-st7571-probe \
ksym-64kb-st7571-remove \
ksym-64kb-st95hf-spi-recv-echo-res \
ksym-64kb-st95hf-spi-recv-response \
ksym-64kb-st95hf-spi-send \
ksym-64kb-stable-page-flags \
ksym-64kb-stack-depot-fetch \
ksym-64kb-stack-depot-get-extra-bits \
ksym-64kb-stack-depot-init \
ksym-64kb-stack-depot-print \
ksym-64kb-stack-depot-put \
ksym-64kb-stack-depot-save \
ksym-64kb-stack-depot-save-flags \
ksym-64kb-stack-depot-set-extra-bits \
ksym-64kb-stack-depot-snprint \
ksym-64kb-stack-trace-print \
ksym-64kb-stack-trace-save \
ksym-64kb-stack-trace-save-tsk \
ksym-64kb-stack-trace-snprint \
ksym-64kb-starget-for-each-device \
ksym-64kb-start-creating \
ksym-64kb-start-creating-dentry \
ksym-64kb-start-creating-killable \
ksym-64kb-start-creating-noperm \
ksym-64kb-start-creating-path \
ksym-64kb-start-creating-user-path \
ksym-64kb-start-poll-synchronize-rcu \
ksym-64kb-start-poll-synchronize-rcu-expedited \
ksym-64kb-start-poll-synchronize-rcu-expedited-full \
ksym-64kb-start-poll-synchronize-rcu-full \
ksym-64kb-start-poll-synchronize-srcu \
ksym-64kb-start-removing \
ksym-64kb-start-removing-dentry \
ksym-64kb-start-removing-killable \
ksym-64kb-start-removing-noperm \
ksym-64kb-start-renaming \
ksym-64kb-start-renaming-dentry \
ksym-64kb-start-renaming-two-dentries \
ksym-64kb-start-tty \
ksym-64kb-static-dev-dax \
ksym-64kb-static-key-count \
ksym-64kb-static-key-disable \
ksym-64kb-static-key-disable-cpuslocked \
ksym-64kb-static-key-enable \
ksym-64kb-static-key-enable-cpuslocked \
ksym-64kb-static-key-fast-inc-not-disabled \
ksym-64kb-static-key-initialized \
ksym-64kb-static-key-slow-dec \
ksym-64kb-static-key-slow-inc \
ksym-64kb-stb0899-attach \
ksym-64kb-stb6000-attach \
ksym-64kb-stb6100-attach \
ksym-64kb-stm-data-write \
ksym-64kb-stm-register-device \
ksym-64kb-stm-register-protocol \
ksym-64kb-stm-source-register-device \
ksym-64kb-stm-source-unregister-device \
ksym-64kb-stm-source-write \
ksym-64kb-stm-unregister-device \
ksym-64kb-stm-unregister-protocol \
ksym-64kb-stm32-dfsdm-get-buff-cb \
ksym-64kb-stm32-dfsdm-release-buff-cb \
ksym-64kb-stm32-dfsdm-start-dfsdm \
ksym-64kb-stm32-dfsdm-stop-dfsdm \
ksym-64kb-stm32-firewall-controller-register \
ksym-64kb-stm32-firewall-controller-unregister \
ksym-64kb-stm32-firewall-get-firewall \
ksym-64kb-stm32-firewall-get-grant-all-access \
ksym-64kb-stm32-firewall-grant-access \
ksym-64kb-stm32-firewall-grant-access-by-id \
ksym-64kb-stm32-firewall-populate-bus \
ksym-64kb-stm32-firewall-release-access \
ksym-64kb-stm32-firewall-release-access-by-id \
ksym-64kb-stm32-pctl-probe \
ksym-64kb-stm32-pinctrl-resume \
ksym-64kb-stm32-pinctrl-suspend \
ksym-64kb-stm32-timers-dma-burst-read \
ksym-64kb-stmfx-function-disable \
ksym-64kb-stmfx-function-enable \
ksym-64kb-stmmac-axi-blen-to-mask \
ksym-64kb-stmmac-dvr-probe \
ksym-64kb-stmmac-dvr-remove \
ksym-64kb-stmmac-get-mac-addr \
ksym-64kb-stmmac-get-phy-intf-sel \
ksym-64kb-stmmac-get-platform-resources \
ksym-64kb-stmmac-mdio-lock \
ksym-64kb-stmmac-mdio-unlock \
ksym-64kb-stmmac-pci-plat-resume \
ksym-64kb-stmmac-pci-plat-suspend \
ksym-64kb-stmmac-plat-dat-alloc \
ksym-64kb-stmmac-pltfr-find-clk \
ksym-64kb-stmmac-pltfr-pm-ops \
ksym-64kb-stmmac-pltfr-probe \
ksym-64kb-stmmac-pltfr-remove \
ksym-64kb-stmmac-resume \
ksym-64kb-stmmac-set-clk-tx-rate \
ksym-64kb-stmmac-set-mac-addr \
ksym-64kb-stmmac-simple-pm-ops \
ksym-64kb-stmmac-suspend \
ksym-64kb-stmp-reset-block \
ksym-64kb-stop-core-cpuslocked \
ksym-64kb-stop-machine \
ksym-64kb-stop-tty \
ksym-64kb-store-cdrom-address \
ksym-64kb-stp-proto-register \
ksym-64kb-stp-proto-unregister \
ksym-64kb-stpcpy \
ksym-64kb-stratix10-svc-add-async-client \
ksym-64kb-stratix10-svc-allocate-memory \
ksym-64kb-stratix10-svc-async-done \
ksym-64kb-stratix10-svc-async-poll \
ksym-64kb-stratix10-svc-async-send \
ksym-64kb-stratix10-svc-done \
ksym-64kb-stratix10-svc-free-channel \
ksym-64kb-stratix10-svc-free-memory \
ksym-64kb-stratix10-svc-remove-async-client \
ksym-64kb-stratix10-svc-request-channel-byname \
ksym-64kb-stratix10-svc-send \
ksym-64kb-strcasecmp \
ksym-64kb-strcat \
ksym-64kb-strchr \
ksym-64kb-strchrnul \
ksym-64kb-strcmp \
ksym-64kb-strcpy \
ksym-64kb-strcspn \
ksym-64kb-stream-open \
ksym-64kb-strim \
ksym-64kb-string-escape-mem \
ksym-64kb-string-get-size \
ksym-64kb-string-unescape \
ksym-64kb-strlcat \
ksym-64kb-strlen \
ksym-64kb-strncasecmp \
ksym-64kb-strncat \
ksym-64kb-strnchr \
ksym-64kb-strncmp \
ksym-64kb-strncpy-from-user \
ksym-64kb-strndup-user \
ksym-64kb-strnlen \
ksym-64kb-strnlen-user \
ksym-64kb-strnstr \
ksym-64kb-strp-check-rcv \
ksym-64kb-strp-data-ready \
ksym-64kb-strp-done \
ksym-64kb-strp-init \
ksym-64kb-strp-process \
ksym-64kb-strp-stop \
ksym-64kb-strp-unpause \
ksym-64kb-strpbrk \
ksym-64kb-strrchr \
ksym-64kb-strreplace \
ksym-64kb-strsep \
ksym-64kb-strspn \
ksym-64kb-strstr \
ksym-64kb-stutter-wait \
ksym-64kb-stv0288-attach \
ksym-64kb-stv0297-attach \
ksym-64kb-stv0299-attach \
ksym-64kb-stv0367cab-attach \
ksym-64kb-stv0367ddb-attach \
ksym-64kb-stv0367ter-attach \
ksym-64kb-stv0900-attach \
ksym-64kb-stv090x-attach \
ksym-64kb-stv0910-attach \
ksym-64kb-stv6110-attach \
ksym-64kb-stv6110x-attach \
ksym-64kb-stv6111-attach \
ksym-64kb-subdev-8255-cb-init \
ksym-64kb-subdev-8255-io-init \
ksym-64kb-subdev-8255-mm-init \
ksym-64kb-subdev-8255-regbase \
ksym-64kb-submit-bio \
ksym-64kb-submit-bio-noacct \
ksym-64kb-submit-bio-wait \
ksym-64kb-subsys-interface-register \
ksym-64kb-subsys-interface-unregister \
ksym-64kb-subsys-system-register \
ksym-64kb-subsys-virtual-register \
ksym-64kb-sun4i-dclk-create \
ksym-64kb-sun4i-dclk-free \
ksym-64kb-sun4i-lvds-init \
ksym-64kb-sun4i-rgb-init \
ksym-64kb-sun4i-tcon-enable-vblank \
ksym-64kb-sun4i-tcon-mode-set \
ksym-64kb-sun4i-tcon-of-table \
ksym-64kb-sun4i-usb-phy-set-squelch-detect \
ksym-64kb-sun8i-adda-pr-regmap-init \
ksym-64kb-sun8i-tcon-top-de-config \
ksym-64kb-sun8i-tcon-top-of-table \
ksym-64kb-sun8i-tcon-top-set-hdmi-src \
ksym-64kb-sungem-phy-probe \
ksym-64kb-sunrpc-cache-lookup-rcu \
ksym-64kb-sunrpc-cache-notify \
ksym-64kb-sunrpc-cache-register-pipefs \
ksym-64kb-sunrpc-cache-requests-count \
ksym-64kb-sunrpc-cache-requests-snapshot \
ksym-64kb-sunrpc-cache-unhash \
ksym-64kb-sunrpc-cache-unregister-pipefs \
ksym-64kb-sunrpc-cache-upcall \
ksym-64kb-sunrpc-cache-upcall-warn \
ksym-64kb-sunrpc-cache-update \
ksym-64kb-sunrpc-destroy-cache-detail \
ksym-64kb-sunrpc-get-pool-mode \
ksym-64kb-sunrpc-init-cache-detail \
ksym-64kb-sunrpc-net-id \
ksym-64kb-sunrpc-set-pool-mode \
ksym-64kb-sunxi-ccu-get-mmc-timing-mode \
ksym-64kb-sunxi-ccu-set-mmc-timing-mode \
ksym-64kb-sunxi-rsb-driver-register \
ksym-64kb-sunxi-sram-claim \
ksym-64kb-sunxi-sram-release \
ksym-64kb-super-setup-bdi \
ksym-64kb-super-setup-bdi-name \
ksym-64kb-surface-hid-device-add \
ksym-64kb-surface-hid-device-destroy \
ksym-64kb-surface-hid-pm-ops \
ksym-64kb-suspend-set-ops \
ksym-64kb-suspend-valid-only-mem \
ksym-64kb-svc-addsock \
ksym-64kb-svc-age-temp-xprts-now \
ksym-64kb-svc-auth-flavor \
ksym-64kb-svc-auth-register \
ksym-64kb-svc-auth-unregister \
ksym-64kb-svc-bind \
ksym-64kb-svc-create \
ksym-64kb-svc-create-pooled \
ksym-64kb-svc-destroy \
ksym-64kb-svc-encode-result-payload \
ksym-64kb-svc-exit-thread \
ksym-64kb-svc-fill-symlink-pathname \
ksym-64kb-svc-find-listener \
ksym-64kb-svc-find-xprt \
ksym-64kb-svc-generic-init-request \
ksym-64kb-svc-generic-rpcbind-set \
ksym-64kb-svc-max-payload \
ksym-64kb-svc-new-thread \
ksym-64kb-svc-pool-stats-open \
ksym-64kb-svc-pool-wake-idle-thread \
ksym-64kb-svc-print-addr \
ksym-64kb-svc-proc-register \
ksym-64kb-svc-proc-unregister \
ksym-64kb-svc-recv \
ksym-64kb-svc-reg-xprt-class \
ksym-64kb-svc-reserve \
ksym-64kb-svc-rqst-replace-page \
ksym-64kb-svc-seq-show \
ksym-64kb-svc-set-client \
ksym-64kb-svc-set-num-threads \
ksym-64kb-svc-set-pool-threads \
ksym-64kb-svc-unreg-xprt-class \
ksym-64kb-svc-wake-up \
ksym-64kb-svc-xprt-close \
ksym-64kb-svc-xprt-copy-addrs \
ksym-64kb-svc-xprt-create \
ksym-64kb-svc-xprt-create-from-sa \
ksym-64kb-svc-xprt-deferred-close \
ksym-64kb-svc-xprt-destroy-all \
ksym-64kb-svc-xprt-enqueue \
ksym-64kb-svc-xprt-init \
ksym-64kb-svc-xprt-names \
ksym-64kb-svc-xprt-put \
ksym-64kb-svc-xprt-received \
ksym-64kb-svcauth-gss-flavor \
ksym-64kb-svcauth-gss-register-pseudoflavor \
ksym-64kb-svcauth-map-clnt-to-svc-cred-local \
ksym-64kb-svcauth-unix-purge \
ksym-64kb-svcauth-unix-set-client \
ksym-64kb-sw842-compress \
ksym-64kb-sw842-decompress \
ksym-64kb-swake-up-all \
ksym-64kb-swake-up-locked \
ksym-64kb-swake-up-one \
ksym-64kb-switchdev-bridge-port-offload \
ksym-64kb-switchdev-bridge-port-replay \
ksym-64kb-switchdev-bridge-port-unoffload \
ksym-64kb-switchdev-deferred-process \
ksym-64kb-switchdev-handle-fdb-event-to-device \
ksym-64kb-switchdev-handle-port-attr-set \
ksym-64kb-switchdev-handle-port-obj-add \
ksym-64kb-switchdev-handle-port-obj-add-foreign \
ksym-64kb-switchdev-handle-port-obj-del \
ksym-64kb-switchdev-handle-port-obj-del-foreign \
ksym-64kb-switchdev-port-attr-set \
ksym-64kb-switchdev-port-obj-act-is-deferred \
ksym-64kb-switchdev-port-obj-add \
ksym-64kb-switchdev-port-obj-del \
ksym-64kb-switchtec-class \
ksym-64kb-swnode-gpio-undefined \
ksym-64kb-swphy-read-reg \
ksym-64kb-swphy-validate-state \
ksym-64kb-sx-common-events \
ksym-64kb-sx-common-probe \
ksym-64kb-sx-common-read-event-config \
ksym-64kb-sx-common-read-proximity \
ksym-64kb-sx-common-write-event-config \
ksym-64kb-symbol-put-addr \
ksym-64kb-sync-blockdev \
ksym-64kb-sync-blockdev-nowait \
ksym-64kb-sync-blockdev-range \
ksym-64kb-sync-dirty-buffer \
ksym-64kb-sync-file-create \
ksym-64kb-sync-file-get-fence \
ksym-64kb-sync-filesystem \
ksym-64kb-sync-inode-metadata \
ksym-64kb-sync-inodes-sb \
ksym-64kb-sync-page-io \
ksym-64kb-synchronize-hardirq \
ksym-64kb-synchronize-irq \
ksym-64kb-synchronize-net \
ksym-64kb-synchronize-rcu \
ksym-64kb-synchronize-rcu-expedited \
ksym-64kb-synchronize-rcu-tasks \
ksym-64kb-synchronize-rcu-tasks-rude \
ksym-64kb-synchronize-srcu \
ksym-64kb-synchronize-srcu-expedited \
ksym-64kb-synproxy-init-timestamp-cookie \
ksym-64kb-synproxy-net-id \
ksym-64kb-synproxy-parse-options \
ksym-64kb-synproxy-recv-client-ack \
ksym-64kb-synproxy-recv-client-ack-ipv6 \
ksym-64kb-synproxy-send-client-synack \
ksym-64kb-synproxy-send-client-synack-ipv6 \
ksym-64kb-synth-event-add-field \
ksym-64kb-synth-event-add-field-str \
ksym-64kb-synth-event-add-fields \
ksym-64kb-synth-event-add-next-val \
ksym-64kb-synth-event-add-val \
ksym-64kb-synth-event-cmd-init \
ksym-64kb-synth-event-create \
ksym-64kb-synth-event-delete \
ksym-64kb-synth-event-gen-cmd-array-start \
ksym-64kb-synth-event-trace \
ksym-64kb-synth-event-trace-array \
ksym-64kb-synth-event-trace-end \
ksym-64kb-synth-event-trace-start \
ksym-64kb-sys-copyarea \
ksym-64kb-sys-fillrect \
ksym-64kb-sys-imageblit \
ksym-64kb-sys-tz \
ksym-64kb-syscon-node-to-regmap \
ksym-64kb-syscon-regmap-lookup-by-compatible \
ksym-64kb-syscon-regmap-lookup-by-phandle \
ksym-64kb-syscon-regmap-lookup-by-phandle-args \
ksym-64kb-syscon-regmap-lookup-by-phandle-optional \
ksym-64kb-sysconfig-probe \
ksym-64kb-syscore-resume \
ksym-64kb-syscore-suspend \
ksym-64kb-sysctl-devconf-inherit-init-net \
ksym-64kb-sysctl-fb-tunnels-only-for-init-net \
ksym-64kb-sysctl-long-vals \
ksym-64kb-sysctl-nf-log-all-netns \
ksym-64kb-sysctl-rmem-max \
ksym-64kb-sysctl-vals \
ksym-64kb-sysctl-wmem-max \
ksym-64kb-sysfb-disable \
ksym-64kb-sysfb-handles-screen-info \
ksym-64kb-sysfb-primary-display \
ksym-64kb-sysfs-add-file-to-group \
ksym-64kb-sysfs-add-link-to-group \
ksym-64kb-sysfs-bin-attr-simple-read \
ksym-64kb-sysfs-break-active-protection \
ksym-64kb-sysfs-chmod-file \
ksym-64kb-sysfs-create-bin-file \
ksym-64kb-sysfs-create-file-ns \
ksym-64kb-sysfs-create-files \
ksym-64kb-sysfs-create-group \
ksym-64kb-sysfs-create-groups \
ksym-64kb-sysfs-create-link \
ksym-64kb-sysfs-create-link-nowarn \
ksym-64kb-sysfs-create-mount-point \
ksym-64kb-sysfs-emit \
ksym-64kb-sysfs-emit-at \
ksym-64kb-sysfs-format-mac \
ksym-64kb-sysfs-group-change-owner \
ksym-64kb-sysfs-groups-change-owner \
ksym-64kb-sysfs-merge-group \
ksym-64kb-sysfs-notify \
ksym-64kb-sysfs-remove-bin-file \
ksym-64kb-sysfs-remove-file-from-group \
ksym-64kb-sysfs-remove-file-ns \
ksym-64kb-sysfs-remove-file-self \
ksym-64kb-sysfs-remove-files \
ksym-64kb-sysfs-remove-group \
ksym-64kb-sysfs-remove-groups \
ksym-64kb-sysfs-remove-link \
ksym-64kb-sysfs-remove-link-from-group \
ksym-64kb-sysfs-remove-mount-point \
ksym-64kb-sysfs-rename-link-ns \
ksym-64kb-sysfs-streq \
ksym-64kb-sysfs-unbreak-active-protection \
ksym-64kb-sysfs-unmerge-group \
ksym-64kb-sysfs-update-group \
ksym-64kb-sysfs-update-groups \
ksym-64kb-sysrq-mask \
ksym-64kb-sysrq-toggle-support \
ksym-64kb-system-bh-highpri-wq \
ksym-64kb-system-bh-wq \
ksym-64kb-system-cpucaps \
ksym-64kb-system-dfl-long-wq \
ksym-64kb-system-dfl-wq \
ksym-64kb-system-entering-hibernation \
ksym-64kb-system-freezable-power-efficient-wq \
ksym-64kb-system-freezable-wq \
ksym-64kb-system-highpri-wq \
ksym-64kb-system-long-wq \
ksym-64kb-system-percpu-wq \
ksym-64kb-system-power-efficient-wq \
ksym-64kb-system-state \
ksym-64kb-system-unbound-wq \
ksym-64kb-system-wq \
ksym-64kb-t3-l2e-free \
ksym-64kb-t3-l2t-get \
ksym-64kb-t3-l2t-send-slow \
ksym-64kb-t3-register-cpl-handler \
ksym-64kb-t4-cleanup-clip-tbl \
ksym-64kb-tag-pages-for-writeback \
ksym-64kb-take-dentry-name-snapshot \
ksym-64kb-tap-create-cdev \
ksym-64kb-tap-del-queues \
ksym-64kb-tap-destroy-cdev \
ksym-64kb-tap-free-minor \
ksym-64kb-tap-get-minor \
ksym-64kb-tap-get-ptr-ring \
ksym-64kb-tap-get-socket \
ksym-64kb-tap-handle-frame \
ksym-64kb-tap-queue-resize \
ksym-64kb-taprio-offload-free \
ksym-64kb-taprio-offload-get \
ksym-64kb-target-alloc-cmd-counter \
ksym-64kb-target-alloc-sgl \
ksym-64kb-target-backend-unregister \
ksym-64kb-target-cmd-init-cdb \
ksym-64kb-target-cmd-parse-cdb \
ksym-64kb-target-complete-cmd \
ksym-64kb-target-complete-cmd-with-length \
ksym-64kb-target-complete-cmd-with-sense \
ksym-64kb-target-configure-unmap-from-bdev \
ksym-64kb-target-configure-write-atomic-from-bdev \
ksym-64kb-target-depend-item \
ksym-64kb-target-execute-cmd \
ksym-64kb-target-free-cmd-counter \
ksym-64kb-target-free-sgl \
ksym-64kb-target-get-sess-cmd \
ksym-64kb-target-init-cmd \
ksym-64kb-target-lun-is-rdonly \
ksym-64kb-target-nacl-find-deve \
ksym-64kb-target-put-nacl \
ksym-64kb-target-put-sess-cmd \
ksym-64kb-target-register-template \
ksym-64kb-target-remove-session \
ksym-64kb-target-send-busy \
ksym-64kb-target-set-cmd-data-length \
ksym-64kb-target-setup-session \
ksym-64kb-target-show-cmd \
ksym-64kb-target-show-dynamic-sessions \
ksym-64kb-target-stop-cmd-counter \
ksym-64kb-target-stop-session \
ksym-64kb-target-submit \
ksym-64kb-target-submit-cmd \
ksym-64kb-target-submit-prep \
ksym-64kb-target-submit-tmr \
ksym-64kb-target-to-linux-sector \
ksym-64kb-target-tpg-has-node-acl \
ksym-64kb-target-undepend-item \
ksym-64kb-target-unregister-template \
ksym-64kb-target-wait-for-cmds \
ksym-64kb-target-wait-for-sess-cmds \
ksym-64kb-tas2781-hda-remove \
ksym-64kb-tas2781-load-calibration \
ksym-64kb-tas2781-save-calibration \
ksym-64kb-tascodec-init \
ksym-64kb-tasdev-chn-switch \
ksym-64kb-tasdev-fct-efi-guid \
ksym-64kb-tasdevice-amp-getvol \
ksym-64kb-tasdevice-amp-putvol \
ksym-64kb-tasdevice-calbin-remove \
ksym-64kb-tasdevice-config-get \
ksym-64kb-tasdevice-config-info-remove \
ksym-64kb-tasdevice-config-put \
ksym-64kb-tasdevice-dev-bulk-read \
ksym-64kb-tasdevice-dev-bulk-write \
ksym-64kb-tasdevice-dev-read \
ksym-64kb-tasdevice-dev-update-bits \
ksym-64kb-tasdevice-dev-write \
ksym-64kb-tasdevice-digital-getvol \
ksym-64kb-tasdevice-digital-putvol \
ksym-64kb-tasdevice-dsp-parser \
ksym-64kb-tasdevice-dsp-remove \
ksym-64kb-tasdevice-get-profile-id \
ksym-64kb-tasdevice-info-config \
ksym-64kb-tasdevice-info-profile \
ksym-64kb-tasdevice-info-programs \
ksym-64kb-tasdevice-init \
ksym-64kb-tasdevice-kzalloc \
ksym-64kb-tasdevice-prmg-load \
ksym-64kb-tasdevice-program-get \
ksym-64kb-tasdevice-program-put \
ksym-64kb-tasdevice-rca-parser \
ksym-64kb-tasdevice-remove \
ksym-64kb-tasdevice-reset \
ksym-64kb-tasdevice-select-cfg-blk \
ksym-64kb-tasdevice-select-tuningprm-cfg \
ksym-64kb-tasdevice-set-profile-id \
ksym-64kb-tasdevice-tuning-switch \
ksym-64kb-task-active-pid-ns \
ksym-64kb-task-cls-state \
ksym-64kb-task-cputime-adjusted \
ksym-64kb-task-user-regset-view \
ksym-64kb-tasklet-init \
ksym-64kb-tasklet-kill \
ksym-64kb-tasklet-setup \
ksym-64kb-tasklet-unlock \
ksym-64kb-tasklet-unlock-spin-wait \
ksym-64kb-tasklet-unlock-wait \
ksym-64kb-tb-configfs-register-group \
ksym-64kb-tb-configfs-unregister-group \
ksym-64kb-tb-property-add-data \
ksym-64kb-tb-property-add-dir \
ksym-64kb-tb-property-add-immediate \
ksym-64kb-tb-property-add-text \
ksym-64kb-tb-property-copy-dir \
ksym-64kb-tb-property-create-dir \
ksym-64kb-tb-property-find \
ksym-64kb-tb-property-free-dir \
ksym-64kb-tb-property-get-next \
ksym-64kb-tb-property-merge-dir \
ksym-64kb-tb-property-remove \
ksym-64kb-tb-register-property-dir \
ksym-64kb-tb-register-protocol-handler \
ksym-64kb-tb-register-service-driver \
ksym-64kb-tb-ring-alloc-rx \
ksym-64kb-tb-ring-alloc-tx \
ksym-64kb-tb-ring-flush \
ksym-64kb-tb-ring-free \
ksym-64kb-tb-ring-poll \
ksym-64kb-tb-ring-poll-complete \
ksym-64kb-tb-ring-start \
ksym-64kb-tb-ring-stop \
ksym-64kb-tb-ring-throttling \
ksym-64kb-tb-service-properties-changed \
ksym-64kb-tb-service-type \
ksym-64kb-tb-unregister-property-dir \
ksym-64kb-tb-unregister-protocol-handler \
ksym-64kb-tb-unregister-service-driver \
ksym-64kb-tb-xdomain-alloc-in-hopid \
ksym-64kb-tb-xdomain-alloc-out-hopid \
ksym-64kb-tb-xdomain-disable-paths \
ksym-64kb-tb-xdomain-enable-paths \
ksym-64kb-tb-xdomain-find-by-route \
ksym-64kb-tb-xdomain-find-by-uuid \
ksym-64kb-tb-xdomain-lane-bonding-disable \
ksym-64kb-tb-xdomain-lane-bonding-enable \
ksym-64kb-tb-xdomain-release-in-hopid \
ksym-64kb-tb-xdomain-release-out-hopid \
ksym-64kb-tb-xdomain-request \
ksym-64kb-tb-xdomain-response \
ksym-64kb-tb-xdomain-type \
ksym-64kb-tc-cleanup-offload-action \
ksym-64kb-tc-setup-cb-add \
ksym-64kb-tc-setup-cb-call \
ksym-64kb-tc-setup-cb-destroy \
ksym-64kb-tc-setup-cb-reoffload \
ksym-64kb-tc-setup-cb-replace \
ksym-64kb-tc-setup-offload-action \
ksym-64kb-tc-skb-ext-tc \
ksym-64kb-tc-skb-ext-tc-disable \
ksym-64kb-tc-skb-ext-tc-enable \
ksym-64kb-tcf-action-check-ctrlact \
ksym-64kb-tcf-action-exec \
ksym-64kb-tcf-action-set-ctrlact \
ksym-64kb-tcf-action-update-hw-stats \
ksym-64kb-tcf-action-update-stats \
ksym-64kb-tcf-block-get \
ksym-64kb-tcf-block-get-ext \
ksym-64kb-tcf-block-lookup \
ksym-64kb-tcf-block-netif-keep-dst \
ksym-64kb-tcf-block-put \
ksym-64kb-tcf-block-put-ext \
ksym-64kb-tcf-chain-get-by-act \
ksym-64kb-tcf-chain-put-by-act \
ksym-64kb-tcf-classify \
ksym-64kb-tcf-dev-queue-xmit \
ksym-64kb-tcf-em-register \
ksym-64kb-tcf-em-tree-destroy \
ksym-64kb-tcf-em-tree-dump \
ksym-64kb-tcf-em-tree-validate \
ksym-64kb-tcf-em-unregister \
ksym-64kb-tcf-exts-change \
ksym-64kb-tcf-exts-destroy \
ksym-64kb-tcf-exts-dump \
ksym-64kb-tcf-exts-dump-stats \
ksym-64kb-tcf-exts-init-ex \
ksym-64kb-tcf-exts-num-actions \
ksym-64kb-tcf-exts-terse-dump \
ksym-64kb-tcf-exts-validate \
ksym-64kb-tcf-exts-validate-ex \
ksym-64kb-tcf-frag-xmit-count \
ksym-64kb-tcf-generic-walker \
ksym-64kb-tcf-get-next-chain \
ksym-64kb-tcf-get-next-proto \
ksym-64kb-tcf-idr-check-alloc \
ksym-64kb-tcf-idr-cleanup \
ksym-64kb-tcf-idr-create \
ksym-64kb-tcf-idr-create-from-flags \
ksym-64kb-tcf-idr-release \
ksym-64kb-tcf-idr-search \
ksym-64kb-tcf-idrinfo-destroy \
ksym-64kb-tcf-qevent-destroy \
ksym-64kb-tcf-qevent-dump \
ksym-64kb-tcf-qevent-handle \
ksym-64kb-tcf-qevent-init \
ksym-64kb-tcf-qevent-validate-change \
ksym-64kb-tcf-queue-work \
ksym-64kb-tcf-register-action \
ksym-64kb-tcf-sw-enabled-key \
ksym-64kb-tcf-unregister-action \
ksym-64kb-tcp-abort \
ksym-64kb-tcp-bpf-sendmsg-redir \
ksym-64kb-tcp-bpf-update-proto \
ksym-64kb-tcp-close \
ksym-64kb-tcp-cong-avoid-ai \
ksym-64kb-tcp-connect \
ksym-64kb-tcp-enter-cwr \
ksym-64kb-tcp-get-info \
ksym-64kb-tcp-gro-complete \
ksym-64kb-tcp-have-smc \
ksym-64kb-tcp-is-ulp-esp \
ksym-64kb-tcp-memory-per-cpu-fw-alloc \
ksym-64kb-tcp-memory-pressure \
ksym-64kb-tcp-mss-to-mtu \
ksym-64kb-tcp-parse-options \
ksym-64kb-tcp-plb-check-rehash \
ksym-64kb-tcp-plb-update-state \
ksym-64kb-tcp-plb-update-state-upon-rto \
ksym-64kb-tcp-poll \
ksym-64kb-tcp-prot \
ksym-64kb-tcp-rate-check-app-limited \
ksym-64kb-tcp-read-done \
ksym-64kb-tcp-read-sock \
ksym-64kb-tcp-recv-skb \
ksym-64kb-tcp-register-congestion-control \
ksym-64kb-tcp-register-ulp \
ksym-64kb-tcp-reno-cong-avoid \
ksym-64kb-tcp-reno-ssthresh \
ksym-64kb-tcp-reno-undo-cwnd \
ksym-64kb-tcp-sendmsg \
ksym-64kb-tcp-sendmsg-locked \
ksym-64kb-tcp-slow-start \
ksym-64kb-tcp-sock-set-cork \
ksym-64kb-tcp-sock-set-keepcnt \
ksym-64kb-tcp-sock-set-keepidle \
ksym-64kb-tcp-sock-set-keepintvl \
ksym-64kb-tcp-sock-set-nodelay \
ksym-64kb-tcp-sock-set-quickack \
ksym-64kb-tcp-sock-set-syncnt \
ksym-64kb-tcp-sock-set-user-timeout \
ksym-64kb-tcp-stream-memory-free \
ksym-64kb-tcp-unregister-congestion-control \
ksym-64kb-tcp-unregister-ulp \
ksym-64kb-tcp-vegas-cwnd-event \
ksym-64kb-tcp-vegas-cwnd-event-tx-start \
ksym-64kb-tcp-vegas-get-info \
ksym-64kb-tcp-vegas-init \
ksym-64kb-tcp-vegas-pkts-acked \
ksym-64kb-tcp-vegas-state \
ksym-64kb-tcp-wfree \
ksym-64kb-tcpci-get-tcpm-port \
ksym-64kb-tcpci-irq \
ksym-64kb-tcpci-register-port \
ksym-64kb-tcpci-unregister-port \
ksym-64kb-tcpm-cc-change \
ksym-64kb-tcpm-pd-hard-reset \
ksym-64kb-tcpm-pd-receive \
ksym-64kb-tcpm-pd-transmit-complete \
ksym-64kb-tcpm-port-clean \
ksym-64kb-tcpm-port-error-recovery \
ksym-64kb-tcpm-port-is-toggling \
ksym-64kb-tcpm-register-port \
ksym-64kb-tcpm-sink-frs \
ksym-64kb-tcpm-sourcing-vbus \
ksym-64kb-tcpm-tcpc-reset \
ksym-64kb-tcpm-unregister-port \
ksym-64kb-tcpm-vbus-change \
ksym-64kb-tcpv6-prot \
ksym-64kb-tda10021-attach \
ksym-64kb-tda10023-attach \
ksym-64kb-tda10045-attach \
ksym-64kb-tda10046-attach \
ksym-64kb-tda10048-attach \
ksym-64kb-tda10086-attach \
ksym-64kb-tda18218-attach \
ksym-64kb-tda18271-attach \
ksym-64kb-tda18271c2dd-attach \
ksym-64kb-tda665x-attach \
ksym-64kb-tda8083-attach \
ksym-64kb-tda8261-attach \
ksym-64kb-tda826x-attach \
ksym-64kb-tda827x-attach \
ksym-64kb-tda829x-attach \
ksym-64kb-tda829x-probe \
ksym-64kb-tda9887-attach \
ksym-64kb-tea5761-attach \
ksym-64kb-tea5761-autodetection \
ksym-64kb-tea5767-attach \
ksym-64kb-tea5767-autodetection \
ksym-64kb-team-mode-register \
ksym-64kb-team-mode-unregister \
ksym-64kb-team-modeop-port-change-dev-addr \
ksym-64kb-team-modeop-port-enter \
ksym-64kb-team-option-inst-set-change \
ksym-64kb-team-options-change-check \
ksym-64kb-team-options-register \
ksym-64kb-team-options-unregister \
ksym-64kb-tee-bnxt-copy-coredump \
ksym-64kb-tee-bnxt-fw-load \
ksym-64kb-tee-bus-type \
ksym-64kb-tee-client-close-context \
ksym-64kb-tee-client-close-session \
ksym-64kb-tee-client-driver-unregister \
ksym-64kb-tee-client-get-version \
ksym-64kb-tee-client-invoke-func \
ksym-64kb-tee-client-open-context \
ksym-64kb-tee-client-open-session \
ksym-64kb-tee-client-system-session \
ksym-64kb-tee-device-alloc \
ksym-64kb-tee-device-get \
ksym-64kb-tee-device-put \
ksym-64kb-tee-device-put-all-dma-heaps \
ksym-64kb-tee-device-register \
ksym-64kb-tee-device-register-dma-heap \
ksym-64kb-tee-device-set-dev-groups \
ksym-64kb-tee-device-unregister \
ksym-64kb-tee-dyn-shm-alloc-helper \
ksym-64kb-tee-dyn-shm-free-helper \
ksym-64kb-tee-get-drvdata \
ksym-64kb-tee-protmem-static-pool-alloc \
ksym-64kb-tee-session-calc-client-uuid \
ksym-64kb-tee-shm-alloc-dma-mem \
ksym-64kb-tee-shm-alloc-kernel-buf \
ksym-64kb-tee-shm-alloc-priv-buf \
ksym-64kb-tee-shm-free \
ksym-64kb-tee-shm-get-from-id \
ksym-64kb-tee-shm-get-pa \
ksym-64kb-tee-shm-get-va \
ksym-64kb-tee-shm-pool-alloc-res-mem \
ksym-64kb-tee-shm-put \
ksym-64kb-tee-shm-register-fd \
ksym-64kb-tee-shm-register-kernel-buf \
ksym-64kb-teedev-close-context \
ksym-64kb-teedev-ctx-get \
ksym-64kb-teedev-ctx-put \
ksym-64kb-teedev-open \
ksym-64kb-tegra-ahb-enable-smmu \
ksym-64kb-tegra-asoc-machine-init \
ksym-64kb-tegra-asoc-machine-probe \
ksym-64kb-tegra-bpmp-free-mrq \
ksym-64kb-tegra-bpmp-get \
ksym-64kb-tegra-bpmp-get-with-id \
ksym-64kb-tegra-bpmp-mrq-is-supported \
ksym-64kb-tegra-bpmp-mrq-return \
ksym-64kb-tegra-bpmp-put \
ksym-64kb-tegra-bpmp-request-mrq \
ksym-64kb-tegra-bpmp-transfer \
ksym-64kb-tegra-bpmp-transfer-atomic \
ksym-64kb-tegra-dfll-register \
ksym-64kb-tegra-dfll-resume \
ksym-64kb-tegra-dfll-runtime-resume \
ksym-64kb-tegra-dfll-runtime-suspend \
ksym-64kb-tegra-dfll-suspend \
ksym-64kb-tegra-dfll-unregister \
ksym-64kb-tegra-fuse-readl \
ksym-64kb-tegra-ivc-align \
ksym-64kb-tegra-ivc-cleanup \
ksym-64kb-tegra-ivc-init \
ksym-64kb-tegra-ivc-notified \
ksym-64kb-tegra-ivc-read-advance \
ksym-64kb-tegra-ivc-read-get-next-frame \
ksym-64kb-tegra-ivc-reset \
ksym-64kb-tegra-ivc-total-queue-size \
ksym-64kb-tegra-ivc-write-advance \
ksym-64kb-tegra-ivc-write-get-next-frame \
ksym-64kb-tegra-mc-get-carveout-info \
ksym-64kb-tegra-mc-get-emem-device-count \
ksym-64kb-tegra-mc-probe-device \
ksym-64kb-tegra-mc-write-emem-configuration \
ksym-64kb-tegra-mipi-disable \
ksym-64kb-tegra-mipi-enable \
ksym-64kb-tegra-mipi-finish-calibration \
ksym-64kb-tegra-mipi-free \
ksym-64kb-tegra-mipi-request \
ksym-64kb-tegra-mipi-start-calibration \
ksym-64kb-tegra-pcm-close \
ksym-64kb-tegra-pcm-hw-params \
ksym-64kb-tegra-pcm-new \
ksym-64kb-tegra-pcm-open \
ksym-64kb-tegra-pcm-platform-register \
ksym-64kb-tegra-pcm-platform-register-with-chan-names \
ksym-64kb-tegra-pcm-platform-unregister \
ksym-64kb-tegra-pcm-pointer \
ksym-64kb-tegra-phy-xusb-utmi-pad-power-down \
ksym-64kb-tegra-phy-xusb-utmi-pad-power-on \
ksym-64kb-tegra-phy-xusb-utmi-port-reset \
ksym-64kb-tegra-pinctrl-probe \
ksym-64kb-tegra-pmc-io-pad-power-disable \
ksym-64kb-tegra-pmc-io-pad-power-enable \
ksym-64kb-tegra-pmc-powergate-power-off \
ksym-64kb-tegra-pmc-powergate-power-on \
ksym-64kb-tegra-pmc-powergate-remove-clamping \
ksym-64kb-tegra-pmc-powergate-sequence-power-up \
ksym-64kb-tegra-read-ram-code \
ksym-64kb-tegra-sku-info \
ksym-64kb-tegra-xusb-padctl-disable-phy-sleepwalk \
ksym-64kb-tegra-xusb-padctl-disable-phy-wake \
ksym-64kb-tegra-xusb-padctl-enable-phy-sleepwalk \
ksym-64kb-tegra-xusb-padctl-enable-phy-wake \
ksym-64kb-tegra-xusb-padctl-get \
ksym-64kb-tegra-xusb-padctl-get-port-number \
ksym-64kb-tegra-xusb-padctl-get-usb3-companion \
ksym-64kb-tegra-xusb-padctl-hsic-set-idle \
ksym-64kb-tegra-xusb-padctl-legacy-probe \
ksym-64kb-tegra-xusb-padctl-legacy-remove \
ksym-64kb-tegra-xusb-padctl-put \
ksym-64kb-tegra-xusb-padctl-remote-wake-detected \
ksym-64kb-tegra-xusb-padctl-set-vbus-override \
ksym-64kb-tegra-xusb-padctl-usb3-save-context \
ksym-64kb-tegra-xusb-padctl-usb3-set-lfps-detect \
ksym-64kb-tegra124-xusb-padctl-soc \
ksym-64kb-tegra186-xusb-padctl-soc \
ksym-64kb-tegra194-miscreg-mask-serror \
ksym-64kb-tegra194-xusb-padctl-soc \
ksym-64kb-tegra210-clk-emc-attach \
ksym-64kb-tegra210-clk-emc-detach \
ksym-64kb-tegra210-clk-emc-dll-enable \
ksym-64kb-tegra210-clk-emc-dll-update-setting \
ksym-64kb-tegra210-clk-emc-update-setting \
ksym-64kb-tegra210-plle-hw-sequence-is-enabled \
ksym-64kb-tegra210-plle-hw-sequence-start \
ksym-64kb-tegra210-put-utmipll-in-iddq \
ksym-64kb-tegra210-put-utmipll-out-iddq \
ksym-64kb-tegra210-sata-pll-hw-control-enable \
ksym-64kb-tegra210-sata-pll-hw-sequence-start \
ksym-64kb-tegra210-set-sata-pll-seq-sw \
ksym-64kb-tegra210-xusb-padctl-soc \
ksym-64kb-tegra210-xusb-pll-hw-control-enable \
ksym-64kb-tegra210-xusb-pll-hw-sequence-start \
ksym-64kb-tegra234-xusb-padctl-soc \
ksym-64kb-test-taint \
ksym-64kb-textsearch-destroy \
ksym-64kb-textsearch-find-continuous \
ksym-64kb-textsearch-prepare \
ksym-64kb-textsearch-register \
ksym-64kb-textsearch-unregister \
ksym-64kb-thaw-super \
ksym-64kb-thermal-acpi-active-trip-temp \
ksym-64kb-thermal-acpi-critical-trip-temp \
ksym-64kb-thermal-acpi-hot-trip-temp \
ksym-64kb-thermal-acpi-passive-trip-temp \
ksym-64kb-thermal-add-hwmon-sysfs \
ksym-64kb-thermal-cooling-device-register \
ksym-64kb-thermal-cooling-device-unregister \
ksym-64kb-thermal-cooling-device-update \
ksym-64kb-thermal-genl-cpu-capability-event \
ksym-64kb-thermal-of-cooling-device-register \
ksym-64kb-thermal-remove-hwmon-sysfs \
ksym-64kb-thermal-trip-is-bound-to-cdev \
ksym-64kb-thermal-tripless-zone-device-register \
ksym-64kb-thermal-zone-device \
ksym-64kb-thermal-zone-device-critical \
ksym-64kb-thermal-zone-device-disable \
ksym-64kb-thermal-zone-device-enable \
ksym-64kb-thermal-zone-device-id \
ksym-64kb-thermal-zone-device-priv \
ksym-64kb-thermal-zone-device-register-with-trips \
ksym-64kb-thermal-zone-device-type \
ksym-64kb-thermal-zone-device-unregister \
ksym-64kb-thermal-zone-device-update \
ksym-64kb-thermal-zone-for-each-trip \
ksym-64kb-thermal-zone-get-crit-temp \
ksym-64kb-thermal-zone-get-offset \
ksym-64kb-thermal-zone-get-slope \
ksym-64kb-thermal-zone-get-temp \
ksym-64kb-thermal-zone-get-zone-by-name \
ksym-64kb-thermal-zone-set-trip-temp \
ksym-64kb-this-cpu-has-cap \
ksym-64kb-thp-get-unmapped-area \
ksym-64kb-ti-lmu-common-get-brt-res \
ksym-64kb-ti-lmu-common-get-ramp-params \
ksym-64kb-ti-lmu-common-set-brightness \
ksym-64kb-ti-lmu-common-set-ramp \
ksym-64kb-tick-broadcast-control \
ksym-64kb-tick-broadcast-oneshot-control \
ksym-64kb-tick-nohz-dep-clear-cpu \
ksym-64kb-tick-nohz-dep-clear-task \
ksym-64kb-tick-nohz-dep-set-cpu \
ksym-64kb-tick-nohz-dep-set-task \
ksym-64kb-tick-nohz-full-mask \
ksym-64kb-tick-nohz-full-running \
ksym-64kb-tick-nohz-is-active \
ksym-64kb-tifm-add-adapter \
ksym-64kb-tifm-alloc-adapter \
ksym-64kb-tifm-alloc-device \
ksym-64kb-tifm-eject \
ksym-64kb-tifm-free-adapter \
ksym-64kb-tifm-free-device \
ksym-64kb-tifm-has-ms-pif \
ksym-64kb-tifm-map-sg \
ksym-64kb-tifm-queue-work \
ksym-64kb-tifm-register-driver \
ksym-64kb-tifm-remove-adapter \
ksym-64kb-tifm-unmap-sg \
ksym-64kb-tifm-unregister-driver \
ksym-64kb-time64-to-tm \
ksym-64kb-timecounter-init \
ksym-64kb-timecounter-read \
ksym-64kb-timekeeping-clocksource-has-base \
ksym-64kb-timer-delete \
ksym-64kb-timer-delete-sync \
ksym-64kb-timer-delete-sync-try \
ksym-64kb-timer-init-key \
ksym-64kb-timer-of-cleanup \
ksym-64kb-timer-of-init \
ksym-64kb-timer-reduce \
ksym-64kb-timer-shutdown \
ksym-64kb-timer-shutdown-sync \
ksym-64kb-timer-unstable-counter-workaround \
ksym-64kb-timerqueue-add \
ksym-64kb-timerqueue-del \
ksym-64kb-timerqueue-iterate-next \
ksym-64kb-timerqueue-linked-add \
ksym-64kb-timespec64-add-safe \
ksym-64kb-timespec64-to-jiffies \
ksym-64kb-timestamp-truncate \
ksym-64kb-tipc-dump-done \
ksym-64kb-tipc-dump-start \
ksym-64kb-tipc-nl-sk-walk \
ksym-64kb-tipc-sk-fill-sock-diag \
ksym-64kb-tls-alert-recv \
ksym-64kb-tls-client-hello-anon \
ksym-64kb-tls-client-hello-psk \
ksym-64kb-tls-client-hello-x509 \
ksym-64kb-tls-device-sk-destruct \
ksym-64kb-tls-encrypt-skb \
ksym-64kb-tls-get-record \
ksym-64kb-tls-get-record-type \
ksym-64kb-tls-handshake-cancel \
ksym-64kb-tls-handshake-close \
ksym-64kb-tls-offload-tx-resync-request \
ksym-64kb-tls-server-hello-psk \
ksym-64kb-tls-server-hello-x509 \
ksym-64kb-tls-validate-xmit-skb \
ksym-64kb-tlv320aic23-probe \
ksym-64kb-tlv320aic23-regmap \
ksym-64kb-tmc-alloc-sg-table \
ksym-64kb-tmc-etr-get-buffer \
ksym-64kb-tmc-etr-get-catu-device \
ksym-64kb-tmc-etr-remove-catu-ops \
ksym-64kb-tmc-etr-set-catu-ops \
ksym-64kb-tmc-free-sg-table \
ksym-64kb-tmc-sg-table-get-data \
ksym-64kb-tmc-sg-table-sync-data-range \
ksym-64kb-tmc-sg-table-sync-table \
ksym-64kb-tmio-mmc-disable-mmc-irqs \
ksym-64kb-tmio-mmc-do-data-irq \
ksym-64kb-tmio-mmc-enable-mmc-irqs \
ksym-64kb-tmio-mmc-host-alloc \
ksym-64kb-tmio-mmc-host-probe \
ksym-64kb-tmio-mmc-host-remove \
ksym-64kb-tmio-mmc-host-runtime-resume \
ksym-64kb-tmio-mmc-host-runtime-suspend \
ksym-64kb-tmio-mmc-irq \
ksym-64kb-tnum-strn \
ksym-64kb-to-cxl-dax-region \
ksym-64kb-to-cxl-decoder \
ksym-64kb-to-cxl-endpoint-decoder \
ksym-64kb-to-cxl-nvdimm \
ksym-64kb-to-cxl-nvdimm-bridge \
ksym-64kb-to-cxl-pmem-region \
ksym-64kb-to-cxl-port \
ksym-64kb-to-cxl-root-decoder \
ksym-64kb-to-cxl-switch-decoder \
ksym-64kb-to-cxlfs \
ksym-64kb-to-drm-sched-fence \
ksym-64kb-to-hisi-sas-port \
ksym-64kb-to-nd-btt \
ksym-64kb-to-nd-dax \
ksym-64kb-to-nd-desc \
ksym-64kb-to-nd-pfn \
ksym-64kb-to-nd-region \
ksym-64kb-to-ndd \
ksym-64kb-to-nfit-uuid \
ksym-64kb-to-nvdimm \
ksym-64kb-to-nvdimm-bus \
ksym-64kb-to-nvdimm-bus-dev \
ksym-64kb-to-of-pinfo \
ksym-64kb-to-pdrv-policy-node \
ksym-64kb-to-software-node \
ksym-64kb-topology-clear-scale-freq-source \
ksym-64kb-topology-set-scale-freq-source \
ksym-64kb-topology-update-hw-pressure \
ksym-64kb-torture-cleanup-begin \
ksym-64kb-torture-cleanup-end \
ksym-64kb-torture-hrtimeout-jiffies \
ksym-64kb-torture-hrtimeout-ms \
ksym-64kb-torture-hrtimeout-ns \
ksym-64kb-torture-hrtimeout-s \
ksym-64kb-torture-hrtimeout-us \
ksym-64kb-torture-init-begin \
ksym-64kb-torture-init-end \
ksym-64kb-torture-kthread-stopping \
ksym-64kb-torture-must-stop \
ksym-64kb-torture-must-stop-irq \
ksym-64kb-torture-num-online-cpus \
ksym-64kb-torture-offline \
ksym-64kb-torture-online \
ksym-64kb-torture-onoff-failures \
ksym-64kb-torture-onoff-init \
ksym-64kb-torture-onoff-stats \
ksym-64kb-torture-random \
ksym-64kb-torture-sched-set-normal \
ksym-64kb-torture-sched-setaffinity \
ksym-64kb-torture-shuffle-init \
ksym-64kb-torture-shuffle-task-register \
ksym-64kb-torture-shutdown-absorb \
ksym-64kb-torture-shutdown-init \
ksym-64kb-torture-stutter-init \
ksym-64kb-touch-atime \
ksym-64kb-touch-buffer \
ksym-64kb-touch-overlay-get-touchscreen-abs \
ksym-64kb-touch-overlay-map \
ksym-64kb-touch-overlay-mapped-touchscreen \
ksym-64kb-touch-overlay-process-contact \
ksym-64kb-touch-overlay-sync-frame \
ksym-64kb-touch-softlockup-watchdog \
ksym-64kb-touchscreen-parse-properties \
ksym-64kb-touchscreen-report-pos \
ksym-64kb-touchscreen-set-mt-pos \
ksym-64kb-tpm-buf-append \
ksym-64kb-tpm-buf-append-hmac-session \
ksym-64kb-tpm-buf-append-name \
ksym-64kb-tpm-buf-append-u16 \
ksym-64kb-tpm-buf-append-u32 \
ksym-64kb-tpm-buf-append-u8 \
ksym-64kb-tpm-buf-destroy \
ksym-64kb-tpm-buf-init \
ksym-64kb-tpm-buf-init-sized \
ksym-64kb-tpm-buf-length \
ksym-64kb-tpm-buf-read-u16 \
ksym-64kb-tpm-buf-read-u32 \
ksym-64kb-tpm-buf-read-u8 \
ksym-64kb-tpm-buf-reset \
ksym-64kb-tpm-buf-reset-sized \
ksym-64kb-tpm-calc-ordinal-duration \
ksym-64kb-tpm-chip-alloc \
ksym-64kb-tpm-chip-bootstrap \
ksym-64kb-tpm-chip-register \
ksym-64kb-tpm-chip-start \
ksym-64kb-tpm-chip-stop \
ksym-64kb-tpm-chip-unregister \
ksym-64kb-tpm-crb-ffa-init \
ksym-64kb-tpm-crb-ffa-start \
ksym-64kb-tpm-default-chip \
ksym-64kb-tpm-get-random \
ksym-64kb-tpm-get-timeouts \
ksym-64kb-tpm-is-tpm2 \
ksym-64kb-tpm-pcr-extend \
ksym-64kb-tpm-pcr-read \
ksym-64kb-tpm-pm-resume \
ksym-64kb-tpm-pm-suspend \
ksym-64kb-tpm-put-ops \
ksym-64kb-tpm-tis-core-init \
ksym-64kb-tpm-tis-remove \
ksym-64kb-tpm-tis-resume \
ksym-64kb-tpm-transmit-cmd \
ksym-64kb-tpm-try-get-ops \
ksym-64kb-tpm1-do-selftest \
ksym-64kb-tpm1-getcap \
ksym-64kb-tpm2-find-hash-alg \
ksym-64kb-tpm2-flush-context \
ksym-64kb-tpm2-get-cc-attrs-tbl \
ksym-64kb-tpm2-get-tpm-pt \
ksym-64kb-tpm2-probe \
ksym-64kb-tpmm-chip-alloc \
ksym-64kb-tps65010-config-vdcdc2 \
ksym-64kb-tps65010-config-vregs1 \
ksym-64kb-tps65010-set-gpio-out-value \
ksym-64kb-tps65010-set-led \
ksym-64kb-tps65010-set-low-pwr \
ksym-64kb-tps65010-set-vbus-draw \
ksym-64kb-tps65010-set-vib \
ksym-64kb-tps65013-set-low-pwr \
ksym-64kb-tps65224-volatile-table \
ksym-64kb-tps6594-device-init \
ksym-64kb-tps6594-volatile-table \
ksym-64kb-trace-add-event-call \
ksym-64kb-trace-array-destroy \
ksym-64kb-trace-array-get-by-name \
ksym-64kb-trace-array-init-printk \
ksym-64kb-trace-array-printk \
ksym-64kb-trace-array-put \
ksym-64kb-trace-array-set-clr-event \
ksym-64kb-trace-clock \
ksym-64kb-trace-clock-global \
ksym-64kb-trace-clock-jiffies \
ksym-64kb-trace-clock-local \
ksym-64kb-trace-define-field \
ksym-64kb-trace-dump-stack \
ksym-64kb-trace-event-buffer-commit \
ksym-64kb-trace-event-buffer-lock-reserve \
ksym-64kb-trace-event-buffer-reserve \
ksym-64kb-trace-event-ignore-this-pid \
ksym-64kb-trace-event-printf \
ksym-64kb-trace-event-raw-init \
ksym-64kb-trace-event-reg \
ksym-64kb-trace-get-event-file \
ksym-64kb-trace-handle-return \
ksym-64kb-trace-output-call \
ksym-64kb-trace-print-array-seq \
ksym-64kb-trace-print-bitmask-seq \
ksym-64kb-trace-print-flags-seq \
ksym-64kb-trace-print-hex-dump-seq \
ksym-64kb-trace-print-hex-seq \
ksym-64kb-trace-print-symbols-seq \
ksym-64kb-trace-printk-init-buffers \
ksym-64kb-trace-put-event-file \
ksym-64kb-trace-raw-output-prep \
ksym-64kb-trace-remove-event-call \
ksym-64kb-trace-seq-acquire \
ksym-64kb-trace-seq-bitmask \
ksym-64kb-trace-seq-bitmask-list \
ksym-64kb-trace-seq-bprintf \
ksym-64kb-trace-seq-hex-dump \
ksym-64kb-trace-seq-path \
ksym-64kb-trace-seq-printf \
ksym-64kb-trace-seq-putc \
ksym-64kb-trace-seq-putmem \
ksym-64kb-trace-seq-putmem-hex \
ksym-64kb-trace-seq-puts \
ksym-64kb-trace-seq-to-user \
ksym-64kb-trace-seq-vprintf \
ksym-64kb-trace-set-clr-event \
ksym-64kb-trace-vbprintk \
ksym-64kb-trace-vprintk \
ksym-64kb-tracefs-create-file \
ksym-64kb-tracepoint-probe-register \
ksym-64kb-tracepoint-probe-register-prio \
ksym-64kb-tracepoint-probe-register-prio-may-exist \
ksym-64kb-tracepoint-probe-unregister \
ksym-64kb-tracepoint-srcu \
ksym-64kb-tracing-cond-snapshot-data \
ksym-64kb-tracing-is-on \
ksym-64kb-tracing-off \
ksym-64kb-tracing-on \
ksym-64kb-tracing-snapshot \
ksym-64kb-tracing-snapshot-alloc \
ksym-64kb-tracing-snapshot-cond \
ksym-64kb-tracing-snapshot-cond-disable \
ksym-64kb-tracing-snapshot-cond-enable \
ksym-64kb-transport-add-device \
ksym-64kb-transport-alloc-session \
ksym-64kb-transport-alloc-session-tags \
ksym-64kb-transport-backend-register \
ksym-64kb-transport-class-register \
ksym-64kb-transport-class-unregister \
ksym-64kb-transport-configure-device \
ksym-64kb-transport-copy-sense-to-cmd \
ksym-64kb-transport-deregister-session \
ksym-64kb-transport-deregister-session-configfs \
ksym-64kb-transport-destroy-device \
ksym-64kb-transport-free-session \
ksym-64kb-transport-generic-free-cmd \
ksym-64kb-transport-generic-handle-tmr \
ksym-64kb-transport-generic-new-cmd \
ksym-64kb-transport-generic-request-failure \
ksym-64kb-transport-init-session \
ksym-64kb-transport-kmap-data-sg \
ksym-64kb-transport-kunmap-data-sg \
ksym-64kb-transport-lookup-cmd-lun \
ksym-64kb-transport-lookup-tmr-lun \
ksym-64kb-transport-register-session \
ksym-64kb-transport-remove-device \
ksym-64kb-transport-send-check-condition-and-sense \
ksym-64kb-transport-set-vpd-assoc \
ksym-64kb-transport-set-vpd-ident \
ksym-64kb-transport-set-vpd-ident-type \
ksym-64kb-transport-set-vpd-proto-id \
ksym-64kb-transport-setup-device \
ksym-64kb-transport-wait-for-tasks \
ksym-64kb-truncate-inode-pages \
ksym-64kb-truncate-inode-pages-final \
ksym-64kb-truncate-inode-pages-range \
ksym-64kb-truncate-pagecache \
ksym-64kb-truncate-pagecache-range \
ksym-64kb-truncate-setsize \
ksym-64kb-try-lookup-noperm \
ksym-64kb-try-module-get \
ksym-64kb-try-offline-node \
ksym-64kb-try-test-sas-gpio-gp-bit \
ksym-64kb-try-to-free-buffers \
ksym-64kb-try-to-writeback-inodes-sb \
ksym-64kb-try-wait-for-completion \
ksym-64kb-ts2020-attach \
ksym-64kb-ts3a227e-enable-jack-detect \
ksym-64kb-tsa-serial-connect \
ksym-64kb-tsa-serial-disconnect \
ksym-64kb-tsa-serial-get-byphandle \
ksym-64kb-tsa-serial-get-info \
ksym-64kb-tsa-serial-get-num \
ksym-64kb-tsa-serial-put \
ksym-64kb-tsc200x-groups \
ksym-64kb-tsc200x-pm-ops \
ksym-64kb-tsc200x-probe \
ksym-64kb-tsc200x-regmap-config \
ksym-64kb-tsm-register \
ksym-64kb-tsm-report-register \
ksym-64kb-tsm-report-unregister \
ksym-64kb-tsm-unregister \
ksym-64kb-tso-build-data \
ksym-64kb-tso-build-hdr \
ksym-64kb-tso-dma-map-cleanup \
ksym-64kb-tso-dma-map-count \
ksym-64kb-tso-dma-map-init \
ksym-64kb-tso-dma-map-next \
ksym-64kb-tso-start \
ksym-64kb-ttm-backup-bytes-avail \
ksym-64kb-ttm-bo-access \
ksym-64kb-ttm-bo-eviction-valuable \
ksym-64kb-ttm-bo-fini \
ksym-64kb-ttm-bo-init-reserved \
ksym-64kb-ttm-bo-init-validate \
ksym-64kb-ttm-bo-kmap \
ksym-64kb-ttm-bo-kmap-try-from-panic \
ksym-64kb-ttm-bo-kunmap \
ksym-64kb-ttm-bo-lru-cursor-fini \
ksym-64kb-ttm-bo-lru-cursor-first \
ksym-64kb-ttm-bo-lru-cursor-init \
ksym-64kb-ttm-bo-lru-cursor-next \
ksym-64kb-ttm-bo-mem-space \
ksym-64kb-ttm-bo-mmap-obj \
ksym-64kb-ttm-bo-move-accel-cleanup \
ksym-64kb-ttm-bo-move-memcpy \
ksym-64kb-ttm-bo-move-sync-cleanup \
ksym-64kb-ttm-bo-move-to-lru-tail \
ksym-64kb-ttm-bo-pin \
ksym-64kb-ttm-bo-populate \
ksym-64kb-ttm-bo-set-bulk-move \
ksym-64kb-ttm-bo-setup-export \
ksym-64kb-ttm-bo-shrink \
ksym-64kb-ttm-bo-shrink-avoid-wait \
ksym-64kb-ttm-bo-shrink-suitable \
ksym-64kb-ttm-bo-unmap-virtual \
ksym-64kb-ttm-bo-unpin \
ksym-64kb-ttm-bo-validate \
ksym-64kb-ttm-bo-vm-access \
ksym-64kb-ttm-bo-vm-close \
ksym-64kb-ttm-bo-vm-dummy-page \
ksym-64kb-ttm-bo-vm-fault \
ksym-64kb-ttm-bo-vm-fault-reserved \
ksym-64kb-ttm-bo-vm-open \
ksym-64kb-ttm-bo-vm-reserve \
ksym-64kb-ttm-bo-vmap \
ksym-64kb-ttm-bo-vunmap \
ksym-64kb-ttm-bo-wait-ctx \
ksym-64kb-ttm-device-clear-dma-mappings \
ksym-64kb-ttm-device-fini \
ksym-64kb-ttm-device-init \
ksym-64kb-ttm-device-prepare-hibernation \
ksym-64kb-ttm-device-swapout \
ksym-64kb-ttm-eu-backoff-reservation \
ksym-64kb-ttm-eu-fence-buffer-objects \
ksym-64kb-ttm-eu-reserve-buffers \
ksym-64kb-ttm-glob \
ksym-64kb-ttm-io-prot \
ksym-64kb-ttm-kmap-iter-iomap-init \
ksym-64kb-ttm-kmap-iter-tt-init \
ksym-64kb-ttm-lru-bulk-move-fini \
ksym-64kb-ttm-lru-bulk-move-init \
ksym-64kb-ttm-lru-bulk-move-tail \
ksym-64kb-ttm-lru-walk-for-evict \
ksym-64kb-ttm-move-memcpy \
ksym-64kb-ttm-pool-alloc \
ksym-64kb-ttm-pool-debugfs \
ksym-64kb-ttm-pool-fini \
ksym-64kb-ttm-pool-free \
ksym-64kb-ttm-pool-init \
ksym-64kb-ttm-range-man-fini-nocheck \
ksym-64kb-ttm-range-man-init-nocheck \
ksym-64kb-ttm-resource-fini \
ksym-64kb-ttm-resource-free \
ksym-64kb-ttm-resource-init \
ksym-64kb-ttm-resource-manager-create-debugfs \
ksym-64kb-ttm-resource-manager-debug \
ksym-64kb-ttm-resource-manager-evict-all \
ksym-64kb-ttm-resource-manager-init \
ksym-64kb-ttm-resource-manager-usage \
ksym-64kb-ttm-sg-tt-init \
ksym-64kb-ttm-tt-fini \
ksym-64kb-ttm-tt-init \
ksym-64kb-ttm-tt-pages-limit \
ksym-64kb-ttm-tt-restore \
ksym-64kb-ttm-tt-setup-backup \
ksym-64kb-ttpci-budget-debiread \
ksym-64kb-ttpci-budget-debiwrite \
ksym-64kb-ttpci-budget-deinit \
ksym-64kb-ttpci-budget-init \
ksym-64kb-ttpci-budget-init-hooks \
ksym-64kb-ttpci-budget-irq10-handler \
ksym-64kb-ttpci-budget-set-video-port \
ksym-64kb-ttpci-eeprom-decode-mac \
ksym-64kb-ttpci-eeprom-parse-mac \
ksym-64kb-ttusbdecfe-dvbs-attach \
ksym-64kb-ttusbdecfe-dvbt-attach \
ksym-64kb-tty-buffer-lock-exclusive \
ksym-64kb-tty-buffer-request-room \
ksym-64kb-tty-buffer-set-limit \
ksym-64kb-tty-buffer-space-avail \
ksym-64kb-tty-buffer-unlock-exclusive \
ksym-64kb-tty-chars-in-buffer \
ksym-64kb-tty-check-change \
ksym-64kb-tty-dev-name-to-number \
ksym-64kb-tty-devnum \
ksym-64kb-tty-do-resize \
ksym-64kb-tty-driver-flush-buffer \
ksym-64kb-tty-driver-kref-put \
ksym-64kb-tty-encode-baud-rate \
ksym-64kb-tty-find-polling-driver \
ksym-64kb-tty-flip-buffer-push \
ksym-64kb-tty-get-char-size \
ksym-64kb-tty-get-frame-size \
ksym-64kb-tty-get-icount \
ksym-64kb-tty-get-pgrp \
ksym-64kb-tty-get-tiocm \
ksym-64kb-tty-hangup \
ksym-64kb-tty-hung-up-p \
ksym-64kb-tty-init-termios \
ksym-64kb-tty-kclose \
ksym-64kb-tty-kopen-exclusive \
ksym-64kb-tty-kopen-shared \
ksym-64kb-tty-kref-put \
ksym-64kb-tty-ldisc-deref \
ksym-64kb-tty-ldisc-flush \
ksym-64kb-tty-ldisc-receive-buf \
ksym-64kb-tty-ldisc-ref \
ksym-64kb-tty-ldisc-ref-wait \
ksym-64kb-tty-lock \
ksym-64kb-tty-mode-ioctl \
ksym-64kb-tty-name \
ksym-64kb-tty-perform-flush \
ksym-64kb-tty-port-alloc-xmit-buf \
ksym-64kb-tty-port-block-til-ready \
ksym-64kb-tty-port-carrier-raised \
ksym-64kb-tty-port-close \
ksym-64kb-tty-port-close-end \
ksym-64kb-tty-port-close-start \
ksym-64kb-tty-port-default-client-ops \
ksym-64kb-tty-port-destroy \
ksym-64kb-tty-port-free-xmit-buf \
ksym-64kb-tty-port-hangup \
ksym-64kb-tty-port-init \
ksym-64kb-tty-port-install \
ksym-64kb-tty-port-link-device \
ksym-64kb-tty-port-link-wq \
ksym-64kb-tty-port-lower-dtr-rts \
ksym-64kb-tty-port-open \
ksym-64kb-tty-port-put \
ksym-64kb-tty-port-raise-dtr-rts \
ksym-64kb-tty-port-register-device \
ksym-64kb-tty-port-register-device-attr \
ksym-64kb-tty-port-register-device-attr-serdev \
ksym-64kb-tty-port-tty-get \
ksym-64kb-tty-port-tty-set \
ksym-64kb-tty-port-tty-wakeup \
ksym-64kb-tty-port-unregister-device \
ksym-64kb-tty-prepare-flip-string \
ksym-64kb-tty-put-char \
ksym-64kb-tty-register-device \
ksym-64kb-tty-register-device-attr \
ksym-64kb-tty-register-driver \
ksym-64kb-tty-register-ldisc \
ksym-64kb-tty-release-struct \
ksym-64kb-tty-save-termios \
ksym-64kb-tty-set-ldisc \
ksym-64kb-tty-set-termios \
ksym-64kb-tty-standard-install \
ksym-64kb-tty-std-termios \
ksym-64kb-tty-termios-baud-rate \
ksym-64kb-tty-termios-copy-hw \
ksym-64kb-tty-termios-encode-baud-rate \
ksym-64kb-tty-termios-hw-change \
ksym-64kb-tty-termios-input-baud-rate \
ksym-64kb-tty-unlock \
ksym-64kb-tty-unregister-device \
ksym-64kb-tty-unregister-driver \
ksym-64kb-tty-unregister-ldisc \
ksym-64kb-tty-unthrottle \
ksym-64kb-tty-vhangup \
ksym-64kb-tty-wait-until-sent \
ksym-64kb-tty-wakeup \
ksym-64kb-tty-write-room \
ksym-64kb-tua6100-attach \
ksym-64kb-tun-get-socket \
ksym-64kb-tun-get-tx-ring \
ksym-64kb-tun-ptr-free \
ksym-64kb-tuner-count \
ksym-64kb-tuners \
ksym-64kb-tveeprom-hauppauge-analog \
ksym-64kb-tveeprom-read \
ksym-64kb-twofish-setkey \
ksym-64kb-typec-altmode-attention \
ksym-64kb-typec-altmode-enter \
ksym-64kb-typec-altmode-exit \
ksym-64kb-typec-altmode-get-partner \
ksym-64kb-typec-altmode-get-plug \
ksym-64kb-typec-altmode-notify \
ksym-64kb-typec-altmode-put-plug \
ksym-64kb-typec-altmode-set-ops \
ksym-64kb-typec-altmode-state-update \
ksym-64kb-typec-altmode-unregister-driver \
ksym-64kb-typec-altmode-update-active \
ksym-64kb-typec-altmode-vdm \
ksym-64kb-typec-altmode2port \
ksym-64kb-typec-bus \
ksym-64kb-typec-cable-altmode-enter \
ksym-64kb-typec-cable-altmode-exit \
ksym-64kb-typec-cable-altmode-vdm \
ksym-64kb-typec-cable-get \
ksym-64kb-typec-cable-is-active \
ksym-64kb-typec-cable-put \
ksym-64kb-typec-cable-set-identity \
ksym-64kb-typec-cable-set-svdm-version \
ksym-64kb-typec-find-orientation \
ksym-64kb-typec-find-port-data-role \
ksym-64kb-typec-find-port-power-role \
ksym-64kb-typec-find-power-role \
ksym-64kb-typec-find-pwr-opmode \
ksym-64kb-typec-get-cable-svdm-version \
ksym-64kb-typec-get-data-role \
ksym-64kb-typec-get-drvdata \
ksym-64kb-typec-get-fw-cap \
ksym-64kb-typec-get-negotiated-svdm-version \
ksym-64kb-typec-get-orientation \
ksym-64kb-typec-match-altmode \
ksym-64kb-typec-mode-selection-delete \
ksym-64kb-typec-mode-selection-start \
ksym-64kb-typec-mux-get-drvdata \
ksym-64kb-typec-mux-put \
ksym-64kb-typec-mux-register \
ksym-64kb-typec-mux-set \
ksym-64kb-typec-mux-set-drvdata \
ksym-64kb-typec-mux-unregister \
ksym-64kb-typec-partner-altmode-dev-type \
ksym-64kb-typec-partner-register-altmode \
ksym-64kb-typec-partner-set-identity \
ksym-64kb-typec-partner-set-num-altmodes \
ksym-64kb-typec-partner-set-pd-revision \
ksym-64kb-typec-partner-set-svdm-version \
ksym-64kb-typec-partner-set-usb-mode \
ksym-64kb-typec-partner-set-usb-power-delivery \
ksym-64kb-typec-partner-usb-power-delivery-register \
ksym-64kb-typec-plug-altmode-dev-type \
ksym-64kb-typec-plug-register-altmode \
ksym-64kb-typec-plug-set-num-altmodes \
ksym-64kb-typec-port-altmode-dev-type \
ksym-64kb-typec-port-register-altmode \
ksym-64kb-typec-port-register-altmodes \
ksym-64kb-typec-port-register-cable-ops \
ksym-64kb-typec-port-set-usb-mode \
ksym-64kb-typec-port-set-usb-power-delivery \
ksym-64kb-typec-register-cable \
ksym-64kb-typec-register-partner \
ksym-64kb-typec-register-plug \
ksym-64kb-typec-register-port \
ksym-64kb-typec-retimer-get-drvdata \
ksym-64kb-typec-retimer-put \
ksym-64kb-typec-retimer-register \
ksym-64kb-typec-retimer-set \
ksym-64kb-typec-retimer-unregister \
ksym-64kb-typec-set-data-role \
ksym-64kb-typec-set-mode \
ksym-64kb-typec-set-orientation \
ksym-64kb-typec-set-pwr-opmode \
ksym-64kb-typec-set-pwr-role \
ksym-64kb-typec-set-vconn-role \
ksym-64kb-typec-switch-get-drvdata \
ksym-64kb-typec-switch-put \
ksym-64kb-typec-switch-register \
ksym-64kb-typec-switch-set \
ksym-64kb-typec-switch-set-drvdata \
ksym-64kb-typec-switch-unregister \
ksym-64kb-typec-unregister-altmode \
ksym-64kb-typec-unregister-cable \
ksym-64kb-typec-unregister-partner \
ksym-64kb-typec-unregister-plug \
ksym-64kb-typec-unregister-port \
ksym-64kb-u-audio-get-capture-srate \
ksym-64kb-u-audio-get-mute \
ksym-64kb-u-audio-get-playback-srate \
ksym-64kb-u-audio-get-volume \
ksym-64kb-u-audio-set-capture-srate \
ksym-64kb-u-audio-set-mute \
ksym-64kb-u-audio-set-playback-srate \
ksym-64kb-u-audio-set-volume \
ksym-64kb-u-audio-start-capture \
ksym-64kb-u-audio-start-playback \
ksym-64kb-u-audio-stop-capture \
ksym-64kb-u-audio-stop-playback \
ksym-64kb-u-audio-suspend \
ksym-64kb-u-boot-env-parse \
ksym-64kb-uacce-alloc \
ksym-64kb-uacce-register \
ksym-64kb-uacce-remove \
ksym-64kb-uart-add-one-port \
ksym-64kb-uart-console-device \
ksym-64kb-uart-console-write \
ksym-64kb-uart-get-baud-rate \
ksym-64kb-uart-get-divisor \
ksym-64kb-uart-get-rs485-mode \
ksym-64kb-uart-handle-cts-change \
ksym-64kb-uart-handle-dcd-change \
ksym-64kb-uart-insert-char \
ksym-64kb-uart-match-port \
ksym-64kb-uart-parse-earlycon \
ksym-64kb-uart-parse-options \
ksym-64kb-uart-read-and-validate-port-properties \
ksym-64kb-uart-read-port-properties \
ksym-64kb-uart-register-driver \
ksym-64kb-uart-remove-one-port \
ksym-64kb-uart-resume-port \
ksym-64kb-uart-set-options \
ksym-64kb-uart-suspend-port \
ksym-64kb-uart-try-toggle-sysrq \
ksym-64kb-uart-unregister-driver \
ksym-64kb-uart-update-timeout \
ksym-64kb-uart-write-wakeup \
ksym-64kb-uart-xchar-out \
ksym-64kb-ubi-close-volume \
ksym-64kb-ubi-do-get-device-info \
ksym-64kb-ubi-get-device-info \
ksym-64kb-ubi-get-volume-info \
ksym-64kb-ubi-is-mapped \
ksym-64kb-ubi-leb-change \
ksym-64kb-ubi-leb-erase \
ksym-64kb-ubi-leb-map \
ksym-64kb-ubi-leb-read \
ksym-64kb-ubi-leb-read-sg \
ksym-64kb-ubi-leb-unmap \
ksym-64kb-ubi-leb-write \
ksym-64kb-ubi-open-volume \
ksym-64kb-ubi-open-volume-nm \
ksym-64kb-ubi-open-volume-path \
ksym-64kb-ubi-register-volume-notifier \
ksym-64kb-ubi-sync \
ksym-64kb-ubi-unregister-volume-notifier \
ksym-64kb-ucc-fast-disable \
ksym-64kb-ucc-fast-dump-regs \
ksym-64kb-ucc-fast-enable \
ksym-64kb-ucc-fast-free \
ksym-64kb-ucc-fast-get-qe-cr-subblock \
ksym-64kb-ucc-fast-init \
ksym-64kb-ucc-fast-transmit-on-demand \
ksym-64kb-ucc-mux-set-grant-tsa-bkpt \
ksym-64kb-ucc-of-parse-tdm \
ksym-64kb-ucc-set-qe-mux-mii-mng \
ksym-64kb-ucc-tdm-init \
ksym-64kb-ucs2-as-utf8 \
ksym-64kb-ucs2-strlen \
ksym-64kb-ucs2-strncmp \
ksym-64kb-ucs2-strnlen \
ksym-64kb-ucs2-strscpy \
ksym-64kb-ucs2-strsize \
ksym-64kb-ucs2-utf8size \
ksym-64kb-ucsi-connector-change \
ksym-64kb-ucsi-create \
ksym-64kb-ucsi-destroy \
ksym-64kb-ucsi-get-drvdata \
ksym-64kb-ucsi-notify-common \
ksym-64kb-ucsi-register \
ksym-64kb-ucsi-resume \
ksym-64kb-ucsi-send-command \
ksym-64kb-ucsi-set-drvdata \
ksym-64kb-ucsi-suspend \
ksym-64kb-ucsi-sync-control-common \
ksym-64kb-ucsi-unregister \
ksym-64kb-ucsi-write-message-out-command \
ksym-64kb-udc-basic-init \
ksym-64kb-udc-enable-dev-setup-interrupts \
ksym-64kb-udc-irq \
ksym-64kb-udc-mask-unused-interrupts \
ksym-64kb-udc-probe \
ksym-64kb-udc-remove \
ksym-64kb-udp-bpf-update-proto \
ksym-64kb-udp-encap-disable \
ksym-64kb-udp-encap-enable \
ksym-64kb-udp-flow-hashrnd \
ksym-64kb-udp-memory-per-cpu-fw-alloc \
ksym-64kb-udp-prot \
ksym-64kb-udp-sendmsg \
ksym-64kb-udp-set-csum \
ksym-64kb-udp-sock-create4 \
ksym-64kb-udp-sock-create6 \
ksym-64kb-udp-tun-rx-dst \
ksym-64kb-udp-tunnel-drop-rx-port \
ksym-64kb-udp-tunnel-dst-lookup \
ksym-64kb-udp-tunnel-nic-ops \
ksym-64kb-udp-tunnel-notify-add-rx-port \
ksym-64kb-udp-tunnel-notify-del-rx-port \
ksym-64kb-udp-tunnel-push-rx-port \
ksym-64kb-udp-tunnel-sock-release \
ksym-64kb-udp-tunnel-update-gro-lookup \
ksym-64kb-udp-tunnel-update-gro-rcv \
ksym-64kb-udp-tunnel-xmit-skb \
ksym-64kb-udp-tunnel6-dst-lookup \
ksym-64kb-udp-tunnel6-xmit-skb \
ksym-64kb-udp4-hwcsum \
ksym-64kb-udp4-lib-lookup \
ksym-64kb-udp6-lib-lookup \
ksym-64kb-udp6-set-csum \
ksym-64kb-udpv6-encap-enable \
ksym-64kb-udpv6-sendmsg \
ksym-64kb-ufshcd-alloc-host \
ksym-64kb-ufshcd-apply-tx-eq-settings \
ksym-64kb-ufshcd-auto-hibern8-update \
ksym-64kb-ufshcd-change-power-mode \
ksym-64kb-ufshcd-clkgate-delay-set \
ksym-64kb-ufshcd-config-pwr-mode \
ksym-64kb-ufshcd-delay-us \
ksym-64kb-ufshcd-disable-irq \
ksym-64kb-ufshcd-dme-configure-adapt \
ksym-64kb-ufshcd-dme-enable \
ksym-64kb-ufshcd-dme-get-attr \
ksym-64kb-ufshcd-dme-reset \
ksym-64kb-ufshcd-dme-rmw \
ksym-64kb-ufshcd-dme-set-attr \
ksym-64kb-ufshcd-dump-regs \
ksym-64kb-ufshcd-dwc-dme-set-attrs \
ksym-64kb-ufshcd-dwc-link-startup-notify \
ksym-64kb-ufshcd-enable-irq \
ksym-64kb-ufshcd-fixup-dev-quirks \
ksym-64kb-ufshcd-force-error-recovery \
ksym-64kb-ufshcd-get-vreg \
ksym-64kb-ufshcd-hba-enable \
ksym-64kb-ufshcd-hba-stop \
ksym-64kb-ufshcd-hold \
ksym-64kb-ufshcd-init \
ksym-64kb-ufshcd-init-host-params \
ksym-64kb-ufshcd-is-hba-active \
ksym-64kb-ufshcd-link-recovery \
ksym-64kb-ufshcd-make-hba-operational \
ksym-64kb-ufshcd-mcq-config-esi \
ksym-64kb-ufshcd-mcq-config-mac \
ksym-64kb-ufshcd-mcq-enable \
ksym-64kb-ufshcd-mcq-enable-esi \
ksym-64kb-ufshcd-mcq-make-queues-operational \
ksym-64kb-ufshcd-mcq-poll-cqe-lock \
ksym-64kb-ufshcd-mcq-queue-cfg-addr \
ksym-64kb-ufshcd-mcq-read-cqis \
ksym-64kb-ufshcd-mcq-write-cqis \
ksym-64kb-ufshcd-negotiate-pwr-params \
ksym-64kb-ufshcd-opp-config-clks \
ksym-64kb-ufshcd-parse-gear-limits \
ksym-64kb-ufshcd-pltfrm-init \
ksym-64kb-ufshcd-pltfrm-remove \
ksym-64kb-ufshcd-pm-qos-update \
ksym-64kb-ufshcd-populate-vreg \
ksym-64kb-ufshcd-release \
ksym-64kb-ufshcd-remove \
ksym-64kb-ufshcd-resume-complete \
ksym-64kb-ufshcd-runtime-resume \
ksym-64kb-ufshcd-runtime-suspend \
ksym-64kb-ufshcd-suspend-prepare \
ksym-64kb-ufshcd-system-freeze \
ksym-64kb-ufshcd-system-restore \
ksym-64kb-ufshcd-system-resume \
ksym-64kb-ufshcd-system-suspend \
ksym-64kb-ufshcd-system-thaw \
ksym-64kb-ufshcd-uic-change-pwr-mode \
ksym-64kb-ufshcd-uic-hibern8-enter \
ksym-64kb-ufshcd-uic-hibern8-exit \
ksym-64kb-ufshcd-update-evt-hist \
ksym-64kb-ufshcd-us-to-ahit \
ksym-64kb-uhci-check-and-reset-hc \
ksym-64kb-uhci-reset-hc \
ksym-64kb-uio-event-notify \
ksym-64kb-uio-unregister-device \
ksym-64kb-ulpi-read \
ksym-64kb-ulpi-register-interface \
ksym-64kb-ulpi-unregister-driver \
ksym-64kb-ulpi-unregister-interface \
ksym-64kb-ulpi-viewport-access-ops \
ksym-64kb-ulpi-write \
ksym-64kb-unix-domain-find \
ksym-64kb-unix-inq-len \
ksym-64kb-unix-outq-len \
ksym-64kb-unix-peer-get \
ksym-64kb-unload-nls \
ksym-64kb-unlock-buffer \
ksym-64kb-unlock-new-inode \
ksym-64kb-unlock-page \
ksym-64kb-unlock-system-sleep \
ksym-64kb-unlock-two-nondirectories \
ksym-64kb-unmap-mapping-pages \
ksym-64kb-unmap-mapping-range \
ksym-64kb-unpack \
ksym-64kb-unpack-fields-u16 \
ksym-64kb-unpack-fields-u8 \
ksym-64kb-unpin-folio \
ksym-64kb-unpin-folios \
ksym-64kb-unpin-user-folio \
ksym-64kb-unpin-user-page \
ksym-64kb-unpin-user-page-range-dirty-lock \
ksym-64kb-unpin-user-pages \
ksym-64kb-unpin-user-pages-dirty-lock \
ksym-64kb-unpoison-memory \
ksym-64kb-unregister-acpi-bus-type \
ksym-64kb-unregister-acpi-hed-notifier \
ksym-64kb-unregister-acpi-notifier \
ksym-64kb-unregister-asymmetric-key-parser \
ksym-64kb-unregister-atmdevice-notifier \
ksym-64kb-unregister-binfmt \
ksym-64kb-unregister-blkdev \
ksym-64kb-unregister-blocking-lsm-notifier \
ksym-64kb-unregister-c-can-dev \
ksym-64kb-unregister-candev \
ksym-64kb-unregister-cdrom \
ksym-64kb-unregister-chrdev-region \
ksym-64kb-unregister-console \
ksym-64kb-unregister-dcbevent-notifier \
ksym-64kb-unregister-die-notifier \
ksym-64kb-unregister-dpll-notifier \
ksym-64kb-unregister-fib-notifier \
ksym-64kb-unregister-filesystem \
ksym-64kb-unregister-firmware-config-sysctl \
ksym-64kb-unregister-framebuffer \
ksym-64kb-unregister-ftrace-direct \
ksym-64kb-unregister-ftrace-export \
ksym-64kb-unregister-ftrace-function \
ksym-64kb-unregister-gadget-item \
ksym-64kb-unregister-hdlc-device \
ksym-64kb-unregister-hdlc-protocol \
ksym-64kb-unregister-hw-breakpoint \
ksym-64kb-unregister-ife-op \
ksym-64kb-unregister-inet6addr-notifier \
ksym-64kb-unregister-inet6addr-validator-notifier \
ksym-64kb-unregister-inetaddr-notifier \
ksym-64kb-unregister-inetaddr-validator-notifier \
ksym-64kb-unregister-ip-vs-app \
ksym-64kb-unregister-ip-vs-pe \
ksym-64kb-unregister-ip-vs-scheduler \
ksym-64kb-unregister-key-type \
ksym-64kb-unregister-keyboard-notifier \
ksym-64kb-unregister-kprobe \
ksym-64kb-unregister-kprobes \
ksym-64kb-unregister-kretprobe \
ksym-64kb-unregister-kretprobes \
ksym-64kb-unregister-md-submodule \
ksym-64kb-unregister-memory-notifier \
ksym-64kb-unregister-module-notifier \
ksym-64kb-unregister-mt-adistance-algorithm \
ksym-64kb-unregister-mtd-chip-driver \
ksym-64kb-unregister-mtd-user \
ksym-64kb-unregister-net-sysctl-table \
ksym-64kb-unregister-netdev \
ksym-64kb-unregister-netdevice-many \
ksym-64kb-unregister-netdevice-notifier \
ksym-64kb-unregister-netdevice-notifier-dev-net \
ksym-64kb-unregister-netdevice-notifier-net \
ksym-64kb-unregister-netdevice-queue \
ksym-64kb-unregister-netevent-notifier \
ksym-64kb-unregister-nexthop-notifier \
ksym-64kb-unregister-nfs-version \
ksym-64kb-unregister-nls \
ksym-64kb-unregister-node-notifier \
ksym-64kb-unregister-nvdimm-pmu \
ksym-64kb-unregister-oom-notifier \
ksym-64kb-unregister-pernet-device \
ksym-64kb-unregister-pernet-subsys \
ksym-64kb-unregister-pfn-address-space \
ksym-64kb-unregister-platform-power-off \
ksym-64kb-unregister-pm-notifier \
ksym-64kb-unregister-pppox-proto \
ksym-64kb-unregister-pstore-device \
ksym-64kb-unregister-pstore-zone \
ksym-64kb-unregister-qdisc \
ksym-64kb-unregister-quota-format \
ksym-64kb-unregister-random-vmfork-notifier \
ksym-64kb-unregister-reboot-notifier \
ksym-64kb-unregister-restart-handler \
ksym-64kb-unregister-rpmsg-driver \
ksym-64kb-unregister-sja1000dev \
ksym-64kb-unregister-snap-client \
ksym-64kb-unregister-sound-dsp \
ksym-64kb-unregister-sound-mixer \
ksym-64kb-unregister-sound-special \
ksym-64kb-unregister-switchdev-blocking-notifier \
ksym-64kb-unregister-switchdev-notifier \
ksym-64kb-unregister-sys-off-handler \
ksym-64kb-unregister-syscore \
ksym-64kb-unregister-sysctl-table \
ksym-64kb-unregister-sysrq-key \
ksym-64kb-unregister-tcf-proto-ops \
ksym-64kb-unregister-trace-event \
ksym-64kb-unregister-tracepoint-module-notifier \
ksym-64kb-unregister-virtio-device \
ksym-64kb-unregister-virtio-driver \
ksym-64kb-unregister-vmap-purge-notifier \
ksym-64kb-unregister-vmcore-cb \
ksym-64kb-unregister-vt-notifier \
ksym-64kb-unregister-wide-hw-breakpoint \
ksym-64kb-unshare-fs-struct \
ksym-64kb-uobj-destroy \
ksym-64kb-up \
ksym-64kb-up-read \
ksym-64kb-up-write \
ksym-64kb-update-devfreq \
ksym-64kb-update-region \
ksym-64kb-uprobe-register \
ksym-64kb-uprobe-unregister-nosync \
ksym-64kb-uprobe-unregister-sync \
ksym-64kb-usb-acpi-port-lpm-incapable \
ksym-64kb-usb-acpi-power-manageable \
ksym-64kb-usb-acpi-set-power-state \
ksym-64kb-usb-add-config \
ksym-64kb-usb-add-config-only \
ksym-64kb-usb-add-function \
ksym-64kb-usb-add-gadget \
ksym-64kb-usb-add-gadget-udc \
ksym-64kb-usb-add-gadget-udc-release \
ksym-64kb-usb-add-hcd \
ksym-64kb-usb-add-phy \
ksym-64kb-usb-add-phy-dev \
ksym-64kb-usb-alloc-coherent \
ksym-64kb-usb-alloc-dev \
ksym-64kb-usb-alloc-noncoherent \
ksym-64kb-usb-alloc-streams \
ksym-64kb-usb-alloc-urb \
ksym-64kb-usb-altnum-to-altsetting \
ksym-64kb-usb-amd-dev-put \
ksym-64kb-usb-amd-hang-symptom-quirk \
ksym-64kb-usb-amd-prefetch-quirk \
ksym-64kb-usb-amd-pt-check-port \
ksym-64kb-usb-amd-quirk-pll-check \
ksym-64kb-usb-amd-quirk-pll-disable \
ksym-64kb-usb-amd-quirk-pll-enable \
ksym-64kb-usb-anchor-empty \
ksym-64kb-usb-anchor-resume-wakeups \
ksym-64kb-usb-anchor-suspend-wakeups \
ksym-64kb-usb-anchor-urb \
ksym-64kb-usb-asmedia-modifyflowcontrol \
ksym-64kb-usb-assign-descriptors \
ksym-64kb-usb-autopm-get-interface \
ksym-64kb-usb-autopm-get-interface-async \
ksym-64kb-usb-autopm-get-interface-no-resume \
ksym-64kb-usb-autopm-put-interface \
ksym-64kb-usb-autopm-put-interface-async \
ksym-64kb-usb-autopm-put-interface-no-suspend \
ksym-64kb-usb-block-urb \
ksym-64kb-usb-bulk-msg \
ksym-64kb-usb-bulk-msg-killable \
ksym-64kb-usb-bus-idr \
ksym-64kb-usb-bus-idr-lock \
ksym-64kb-usb-bus-start-enum \
ksym-64kb-usb-cache-string \
ksym-64kb-usb-calc-bus-time \
ksym-64kb-usb-cdc-wdm-register \
ksym-64kb-usb-check-bulk-endpoints \
ksym-64kb-usb-check-int-endpoints \
ksym-64kb-usb-choose-configuration \
ksym-64kb-usb-clear-halt \
ksym-64kb-usb-composite-overwrite-options \
ksym-64kb-usb-composite-probe \
ksym-64kb-usb-composite-setup-continue \
ksym-64kb-usb-composite-unregister \
ksym-64kb-usb-control-msg \
ksym-64kb-usb-control-msg-recv \
ksym-64kb-usb-control-msg-send \
ksym-64kb-usb-copy-descriptors \
ksym-64kb-usb-create-hcd \
ksym-64kb-usb-create-shared-hcd \
ksym-64kb-usb-cypress-load-firmware \
ksym-64kb-usb-debug-root \
ksym-64kb-usb-decode-ctrl \
ksym-64kb-usb-decode-interval \
ksym-64kb-usb-del-gadget \
ksym-64kb-usb-del-gadget-udc \
ksym-64kb-usb-deregister \
ksym-64kb-usb-deregister-dev \
ksym-64kb-usb-deregister-device-driver \
ksym-64kb-usb-descriptor-fillbuf \
ksym-64kb-usb-device-match-id \
ksym-64kb-usb-disable-autosuspend \
ksym-64kb-usb-disable-lpm \
ksym-64kb-usb-disable-ltm \
ksym-64kb-usb-disable-xhci-ports \
ksym-64kb-usb-disabled \
ksym-64kb-usb-driver-claim-interface \
ksym-64kb-usb-driver-release-interface \
ksym-64kb-usb-driver-set-configuration \
ksym-64kb-usb-dynids-lock \
ksym-64kb-usb-enable-autosuspend \
ksym-64kb-usb-enable-intel-xhci-ports \
ksym-64kb-usb-enable-lpm \
ksym-64kb-usb-enable-ltm \
ksym-64kb-usb-endpoint-is-hs-isoc-double \
ksym-64kb-usb-endpoint-max-periodic-payload \
ksym-64kb-usb-ep-alloc-request \
ksym-64kb-usb-ep-autoconfig \
ksym-64kb-usb-ep-autoconfig-release \
ksym-64kb-usb-ep-autoconfig-reset \
ksym-64kb-usb-ep-autoconfig-ss \
ksym-64kb-usb-ep-clear-halt \
ksym-64kb-usb-ep-dequeue \
ksym-64kb-usb-ep-disable \
ksym-64kb-usb-ep-enable \
ksym-64kb-usb-ep-fifo-flush \
ksym-64kb-usb-ep-fifo-status \
ksym-64kb-usb-ep-free-request \
ksym-64kb-usb-ep-queue \
ksym-64kb-usb-ep-set-halt \
ksym-64kb-usb-ep-set-maxpacket-limit \
ksym-64kb-usb-ep-set-wedge \
ksym-64kb-usb-ep-type-string \
ksym-64kb-usb-ep0-reinit \
ksym-64kb-usb-find-alt-setting \
ksym-64kb-usb-find-common-endpoints \
ksym-64kb-usb-find-common-endpoints-reverse \
ksym-64kb-usb-find-interface \
ksym-64kb-usb-for-each-dev \
ksym-64kb-usb-free-all-descriptors \
ksym-64kb-usb-free-coherent \
ksym-64kb-usb-free-noncoherent \
ksym-64kb-usb-free-streams \
ksym-64kb-usb-free-urb \
ksym-64kb-usb-func-wakeup \
ksym-64kb-usb-function-activate \
ksym-64kb-usb-function-deactivate \
ksym-64kb-usb-function-register \
ksym-64kb-usb-function-unregister \
ksym-64kb-usb-gadget-activate \
ksym-64kb-usb-gadget-check-config \
ksym-64kb-usb-gadget-clear-selfpowered \
ksym-64kb-usb-gadget-connect \
ksym-64kb-usb-gadget-deactivate \
ksym-64kb-usb-gadget-disconnect \
ksym-64kb-usb-gadget-ep-match-desc \
ksym-64kb-usb-gadget-frame-number \
ksym-64kb-usb-gadget-get-string \
ksym-64kb-usb-gadget-giveback-request \
ksym-64kb-usb-gadget-map-request \
ksym-64kb-usb-gadget-map-request-by-dev \
ksym-64kb-usb-gadget-register-driver-owner \
ksym-64kb-usb-gadget-set-remote-wakeup \
ksym-64kb-usb-gadget-set-selfpowered \
ksym-64kb-usb-gadget-set-state \
ksym-64kb-usb-gadget-udc-reset \
ksym-64kb-usb-gadget-unmap-request \
ksym-64kb-usb-gadget-unmap-request-by-dev \
ksym-64kb-usb-gadget-unregister-driver \
ksym-64kb-usb-gadget-vbus-connect \
ksym-64kb-usb-gadget-vbus-disconnect \
ksym-64kb-usb-gadget-vbus-draw \
ksym-64kb-usb-gadget-wakeup \
ksym-64kb-usb-gen-phy-init \
ksym-64kb-usb-gen-phy-shutdown \
ksym-64kb-usb-get-current-frame-number \
ksym-64kb-usb-get-descriptor \
ksym-64kb-usb-get-dev \
ksym-64kb-usb-get-dr-mode \
ksym-64kb-usb-get-from-anchor \
ksym-64kb-usb-get-function \
ksym-64kb-usb-get-function-instance \
ksym-64kb-usb-get-gadget-udc-name \
ksym-64kb-usb-get-hcd \
ksym-64kb-usb-get-intf \
ksym-64kb-usb-get-maximum-speed \
ksym-64kb-usb-get-maximum-ssp-rate \
ksym-64kb-usb-get-phy \
ksym-64kb-usb-get-role-switch-default-mode \
ksym-64kb-usb-get-status \
ksym-64kb-usb-get-urb \
ksym-64kb-usb-gstrings-attach \
ksym-64kb-usb-hc-died \
ksym-64kb-usb-hcd-amd-remote-wakeup-quirk \
ksym-64kb-usb-hcd-check-unlink-urb \
ksym-64kb-usb-hcd-end-port-resume \
ksym-64kb-usb-hcd-giveback-urb \
ksym-64kb-usb-hcd-irq \
ksym-64kb-usb-hcd-is-primary-hcd \
ksym-64kb-usb-hcd-link-urb-to-ep \
ksym-64kb-usb-hcd-map-urb-for-dma \
ksym-64kb-usb-hcd-pci-pm-ops \
ksym-64kb-usb-hcd-pci-probe \
ksym-64kb-usb-hcd-pci-remove \
ksym-64kb-usb-hcd-pci-shutdown \
ksym-64kb-usb-hcd-platform-shutdown \
ksym-64kb-usb-hcd-poll-rh-status \
ksym-64kb-usb-hcd-resume-root-hub \
ksym-64kb-usb-hcd-setup-local-mem \
ksym-64kb-usb-hcd-start-port-resume \
ksym-64kb-usb-hcd-unlink-urb-from-ep \
ksym-64kb-usb-hcd-unmap-urb-for-dma \
ksym-64kb-usb-hcd-unmap-urb-setup-for-dma \
ksym-64kb-usb-hub-claim-port \
ksym-64kb-usb-hub-clear-tt-buffer \
ksym-64kb-usb-hub-find-child \
ksym-64kb-usb-hub-release-port \
ksym-64kb-usb-ifnum-to-if \
ksym-64kb-usb-init-urb \
ksym-64kb-usb-initialize-gadget \
ksym-64kb-usb-interface-id \
ksym-64kb-usb-interrupt-msg \
ksym-64kb-usb-intf-get-dma-device \
ksym-64kb-usb-kill-anchored-urbs \
ksym-64kb-usb-kill-urb \
ksym-64kb-usb-led-activity \
ksym-64kb-usb-lock-device-for-reset \
ksym-64kb-usb-match-id \
ksym-64kb-usb-match-one-id \
ksym-64kb-usb-mon-deregister \
ksym-64kb-usb-mon-register \
ksym-64kb-usb-of-get-companion-dev \
ksym-64kb-usb-of-get-connect-type \
ksym-64kb-usb-of-get-device-node \
ksym-64kb-usb-of-get-interface-node \
ksym-64kb-usb-of-has-combined-node \
ksym-64kb-usb-offload-check \
ksym-64kb-usb-offload-get \
ksym-64kb-usb-offload-put \
ksym-64kb-usb-offload-set-pm-locked \
ksym-64kb-usb-os-desc-prepare-interf-dir \
ksym-64kb-usb-otg-descriptor-alloc \
ksym-64kb-usb-otg-descriptor-init \
ksym-64kb-usb-otg-state-string \
ksym-64kb-usb-phy-gen-create-phy \
ksym-64kb-usb-phy-generic-register \
ksym-64kb-usb-phy-generic-unregister \
ksym-64kb-usb-phy-get-charger-current \
ksym-64kb-usb-phy-roothub-alloc \
ksym-64kb-usb-phy-roothub-alloc-usb3-phy \
ksym-64kb-usb-phy-roothub-calibrate \
ksym-64kb-usb-phy-roothub-exit \
ksym-64kb-usb-phy-roothub-init \
ksym-64kb-usb-phy-roothub-notify-connect \
ksym-64kb-usb-phy-roothub-notify-disconnect \
ksym-64kb-usb-phy-roothub-power-off \
ksym-64kb-usb-phy-roothub-power-on \
ksym-64kb-usb-phy-roothub-resume \
ksym-64kb-usb-phy-roothub-set-mode \
ksym-64kb-usb-phy-roothub-suspend \
ksym-64kb-usb-phy-set-charger-current \
ksym-64kb-usb-phy-set-charger-state \
ksym-64kb-usb-phy-set-event \
ksym-64kb-usb-pipe-type-check \
ksym-64kb-usb-poison-anchored-urbs \
ksym-64kb-usb-poison-urb \
ksym-64kb-usb-power-delivery-link-device \
ksym-64kb-usb-power-delivery-register \
ksym-64kb-usb-power-delivery-register-capabilities \
ksym-64kb-usb-power-delivery-unlink-device \
ksym-64kb-usb-power-delivery-unregister \
ksym-64kb-usb-power-delivery-unregister-capabilities \
ksym-64kb-usb-put-dev \
ksym-64kb-usb-put-function \
ksym-64kb-usb-put-function-instance \
ksym-64kb-usb-put-hcd \
ksym-64kb-usb-put-intf \
ksym-64kb-usb-put-phy \
ksym-64kb-usb-queue-reset-device \
ksym-64kb-usb-register-dev \
ksym-64kb-usb-register-device-driver \
ksym-64kb-usb-register-driver \
ksym-64kb-usb-register-notify \
ksym-64kb-usb-remove-function \
ksym-64kb-usb-remove-hcd \
ksym-64kb-usb-remove-phy \
ksym-64kb-usb-reset-configuration \
ksym-64kb-usb-reset-device \
ksym-64kb-usb-reset-endpoint \
ksym-64kb-usb-role-string \
ksym-64kb-usb-role-switch-find-by-fwnode \
ksym-64kb-usb-role-switch-get \
ksym-64kb-usb-role-switch-get-drvdata \
ksym-64kb-usb-role-switch-get-role \
ksym-64kb-usb-role-switch-put \
ksym-64kb-usb-role-switch-register \
ksym-64kb-usb-role-switch-set-drvdata \
ksym-64kb-usb-role-switch-set-role \
ksym-64kb-usb-role-switch-unregister \
ksym-64kb-usb-root-hub-lost-power \
ksym-64kb-usb-scuttle-anchored-urbs \
ksym-64kb-usb-serial-claim-interface \
ksym-64kb-usb-serial-deregister-drivers \
ksym-64kb-usb-serial-generic-chars-in-buffer \
ksym-64kb-usb-serial-generic-close \
ksym-64kb-usb-serial-generic-get-icount \
ksym-64kb-usb-serial-generic-open \
ksym-64kb-usb-serial-generic-process-read-urb \
ksym-64kb-usb-serial-generic-read-bulk-callback \
ksym-64kb-usb-serial-generic-resume \
ksym-64kb-usb-serial-generic-submit-read-urbs \
ksym-64kb-usb-serial-generic-throttle \
ksym-64kb-usb-serial-generic-tiocmiwait \
ksym-64kb-usb-serial-generic-unthrottle \
ksym-64kb-usb-serial-generic-wait-until-sent \
ksym-64kb-usb-serial-generic-write \
ksym-64kb-usb-serial-generic-write-bulk-callback \
ksym-64kb-usb-serial-generic-write-start \
ksym-64kb-usb-serial-handle-dcd-change \
ksym-64kb-usb-serial-port-softint \
ksym-64kb-usb-serial-resume \
ksym-64kb-usb-serial-suspend \
ksym-64kb-usb-set-configuration \
ksym-64kb-usb-set-device-state \
ksym-64kb-usb-set-interface \
ksym-64kb-usb-set-wireless-status \
ksym-64kb-usb-sg-cancel \
ksym-64kb-usb-sg-init \
ksym-64kb-usb-sg-wait \
ksym-64kb-usb-show-dynids \
ksym-64kb-usb-speed-string \
ksym-64kb-usb-state-string \
ksym-64kb-usb-stor-Bulk-reset \
ksym-64kb-usb-stor-Bulk-transport \
ksym-64kb-usb-stor-CB-reset \
ksym-64kb-usb-stor-CB-transport \
ksym-64kb-usb-stor-access-xfer-buf \
ksym-64kb-usb-stor-adjust-quirks \
ksym-64kb-usb-stor-bulk-srb \
ksym-64kb-usb-stor-bulk-transfer-buf \
ksym-64kb-usb-stor-bulk-transfer-sg \
ksym-64kb-usb-stor-clear-halt \
ksym-64kb-usb-stor-control-msg \
ksym-64kb-usb-stor-ctrl-transfer \
ksym-64kb-usb-stor-disconnect \
ksym-64kb-usb-stor-host-template-init \
ksym-64kb-usb-stor-post-reset \
ksym-64kb-usb-stor-pre-reset \
ksym-64kb-usb-stor-probe1 \
ksym-64kb-usb-stor-probe2 \
ksym-64kb-usb-stor-reset-resume \
ksym-64kb-usb-stor-resume \
ksym-64kb-usb-stor-sense-invalidCDB \
ksym-64kb-usb-stor-set-xfer-buf \
ksym-64kb-usb-stor-suspend \
ksym-64kb-usb-stor-transparent-scsi-command \
ksym-64kb-usb-store-new-id \
ksym-64kb-usb-string \
ksym-64kb-usb-string-id \
ksym-64kb-usb-string-ids-n \
ksym-64kb-usb-string-ids-tab \
ksym-64kb-usb-submit-urb \
ksym-64kb-usb-udc-vbus-handler \
ksym-64kb-usb-unanchor-urb \
ksym-64kb-usb-unlink-urb \
ksym-64kb-usb-unlocked-disable-lpm \
ksym-64kb-usb-unlocked-enable-lpm \
ksym-64kb-usb-unpoison-anchored-urbs \
ksym-64kb-usb-unpoison-urb \
ksym-64kb-usb-unregister-notify \
ksym-64kb-usb-urb-ep-type-check \
ksym-64kb-usb-validate-langid \
ksym-64kb-usb-wait-anchor-empty-timeout \
ksym-64kb-usb-wakeup-enabled-descendants \
ksym-64kb-usb-wakeup-notification \
ksym-64kb-usb-wwan-chars-in-buffer \
ksym-64kb-usb-wwan-close \
ksym-64kb-usb-wwan-dtr-rts \
ksym-64kb-usb-wwan-open \
ksym-64kb-usb-wwan-port-probe \
ksym-64kb-usb-wwan-port-remove \
ksym-64kb-usb-wwan-resume \
ksym-64kb-usb-wwan-suspend \
ksym-64kb-usb-wwan-tiocmget \
ksym-64kb-usb-wwan-tiocmset \
ksym-64kb-usb-wwan-write \
ksym-64kb-usb-wwan-write-room \
ksym-64kb-usb4-usb3-port-match \
ksym-64kb-usbatm-usb-disconnect \
ksym-64kb-usbatm-usb-probe \
ksym-64kb-usbip-alloc-iso-desc-pdu \
ksym-64kb-usbip-debug-flag \
ksym-64kb-usbip-dump-header \
ksym-64kb-usbip-dump-urb \
ksym-64kb-usbip-event-add \
ksym-64kb-usbip-event-happened \
ksym-64kb-usbip-header-correct-endian \
ksym-64kb-usbip-in-eh \
ksym-64kb-usbip-pack-pdu \
ksym-64kb-usbip-pad-iso \
ksym-64kb-usbip-recv \
ksym-64kb-usbip-recv-iso \
ksym-64kb-usbip-recv-xbuff \
ksym-64kb-usbip-start-eh \
ksym-64kb-usbip-stop-eh \
ksym-64kb-usbnet-cdc-bind \
ksym-64kb-usbnet-cdc-status \
ksym-64kb-usbnet-cdc-unbind \
ksym-64kb-usbnet-cdc-update-filter \
ksym-64kb-usbnet-cdc-zte-rx-fixup \
ksym-64kb-usbnet-change-mtu \
ksym-64kb-usbnet-defer-kevent \
ksym-64kb-usbnet-device-suggests-idle \
ksym-64kb-usbnet-disconnect \
ksym-64kb-usbnet-ether-cdc-bind \
ksym-64kb-usbnet-generic-cdc-bind \
ksym-64kb-usbnet-get-drvinfo \
ksym-64kb-usbnet-get-endpoints \
ksym-64kb-usbnet-get-ethernet-addr \
ksym-64kb-usbnet-get-link \
ksym-64kb-usbnet-get-link-ksettings-internal \
ksym-64kb-usbnet-get-link-ksettings-mii \
ksym-64kb-usbnet-get-msglevel \
ksym-64kb-usbnet-link-change \
ksym-64kb-usbnet-manage-power \
ksym-64kb-usbnet-mii-ioctl \
ksym-64kb-usbnet-nway-reset \
ksym-64kb-usbnet-open \
ksym-64kb-usbnet-pause-rx \
ksym-64kb-usbnet-probe \
ksym-64kb-usbnet-purge-paused-rxq \
ksym-64kb-usbnet-read-cmd \
ksym-64kb-usbnet-read-cmd-nopm \
ksym-64kb-usbnet-resume \
ksym-64kb-usbnet-resume-rx \
ksym-64kb-usbnet-set-link-ksettings-mii \
ksym-64kb-usbnet-set-msglevel \
ksym-64kb-usbnet-set-rx-mode \
ksym-64kb-usbnet-skb-return \
ksym-64kb-usbnet-start-xmit \
ksym-64kb-usbnet-status-start \
ksym-64kb-usbnet-status-stop \
ksym-64kb-usbnet-stop \
ksym-64kb-usbnet-suspend \
ksym-64kb-usbnet-tx-timeout \
ksym-64kb-usbnet-unlink-rx-urbs \
ksym-64kb-usbnet-update-max-qlen \
ksym-64kb-usbnet-write-cmd \
ksym-64kb-usbnet-write-cmd-async \
ksym-64kb-usbnet-write-cmd-nopm \
ksym-64kb-user-describe \
ksym-64kb-user-destroy \
ksym-64kb-user-free-preparse \
ksym-64kb-user-path-at \
ksym-64kb-user-preparse \
ksym-64kb-user-read \
ksym-64kb-user-revoke \
ksym-64kb-user-update \
ksym-64kb-usermodehelper-read-lock-wait \
ksym-64kb-usermodehelper-read-trylock \
ksym-64kb-usermodehelper-read-unlock \
ksym-64kb-usleep-range-state \
ksym-64kb-utf16s-to-utf8s \
ksym-64kb-utf32-to-utf8 \
ksym-64kb-utf8-casefold \
ksym-64kb-utf8-casefold-hash \
ksym-64kb-utf8-data-table \
ksym-64kb-utf8-load \
ksym-64kb-utf8-normalize \
ksym-64kb-utf8-parse-version \
ksym-64kb-utf8-strncasecmp \
ksym-64kb-utf8-strncasecmp-folded \
ksym-64kb-utf8-strncmp \
ksym-64kb-utf8-to-utf32 \
ksym-64kb-utf8-unload \
ksym-64kb-utf8-validate \
ksym-64kb-utf8s-to-utf16s \
ksym-64kb-uuid-gen \
ksym-64kb-uuid-is-valid \
ksym-64kb-uuid-null \
ksym-64kb-uuid-parse \
ksym-64kb-uvc-format-by-guid \
ksym-64kb-uverbs-copy-to \
ksym-64kb-uverbs-copy-to-struct-or-zero \
ksym-64kb-uverbs-destroy-def-handler \
ksym-64kb-uverbs-fd-class \
ksym-64kb-uverbs-finalize-object \
ksym-64kb-uverbs-finalize-uobj-create \
ksym-64kb-uverbs-get-buffer-desc \
ksym-64kb-uverbs-get-cleared-udata \
ksym-64kb-uverbs-get-flags32 \
ksym-64kb-uverbs-get-flags64 \
ksym-64kb-uverbs-get-uobject-from-file \
ksym-64kb-uverbs-idr-class \
ksym-64kb-uverbs-try-lock-object \
ksym-64kb-uverbs-uobject-fd-release \
ksym-64kb-uverbs-uobject-put \
ksym-64kb-uverbs-uobject-release \
ksym-64kb-v4l-bound-align-image \
ksym-64kb-v4l-disable-media-source \
ksym-64kb-v4l-enable-media-source \
ksym-64kb-v4l-printk-ioctl \
ksym-64kb-v4l-vb2q-enable-media-source \
ksym-64kb-v4l2-apply-frmsize-constraints \
ksym-64kb-v4l2-async-connection-unique \
ksym-64kb-v4l2-async-nf-cleanup \
ksym-64kb-v4l2-async-nf-init \
ksym-64kb-v4l2-async-nf-register \
ksym-64kb-v4l2-async-nf-unregister \
ksym-64kb-v4l2-async-subdev-endpoint-add \
ksym-64kb-v4l2-async-subdev-nf-init \
ksym-64kb-v4l2-async-unregister-subdev \
ksym-64kb-v4l2-calc-aspect-ratio \
ksym-64kb-v4l2-calc-timeperframe \
ksym-64kb-v4l2-compat-ioctl32 \
ksym-64kb-v4l2-create-fwnode-links \
ksym-64kb-v4l2-create-fwnode-links-to-pad \
ksym-64kb-v4l2-ctrl-activate \
ksym-64kb-v4l2-ctrl-add-handler \
ksym-64kb-v4l2-ctrl-auto-cluster \
ksym-64kb-v4l2-ctrl-cluster \
ksym-64kb-v4l2-ctrl-fill \
ksym-64kb-v4l2-ctrl-find \
ksym-64kb-v4l2-ctrl-g-ctrl \
ksym-64kb-v4l2-ctrl-g-ctrl-int64 \
ksym-64kb-v4l2-ctrl-get-int-menu \
ksym-64kb-v4l2-ctrl-get-menu \
ksym-64kb-v4l2-ctrl-get-name \
ksym-64kb-v4l2-ctrl-handler-free \
ksym-64kb-v4l2-ctrl-handler-init-class \
ksym-64kb-v4l2-ctrl-handler-log-status \
ksym-64kb-v4l2-ctrl-handler-setup \
ksym-64kb-v4l2-ctrl-log-status \
ksym-64kb-v4l2-ctrl-merge \
ksym-64kb-v4l2-ctrl-new-custom \
ksym-64kb-v4l2-ctrl-new-fwnode-properties \
ksym-64kb-v4l2-ctrl-new-int-menu \
ksym-64kb-v4l2-ctrl-new-std \
ksym-64kb-v4l2-ctrl-new-std-compound \
ksym-64kb-v4l2-ctrl-new-std-menu \
ksym-64kb-v4l2-ctrl-new-std-menu-items \
ksym-64kb-v4l2-ctrl-notify \
ksym-64kb-v4l2-ctrl-poll \
ksym-64kb-v4l2-ctrl-query-fill \
ksym-64kb-v4l2-ctrl-radio-filter \
ksym-64kb-v4l2-ctrl-replace \
ksym-64kb-v4l2-ctrl-request-complete \
ksym-64kb-v4l2-ctrl-request-hdl-ctrl-find \
ksym-64kb-v4l2-ctrl-request-hdl-find \
ksym-64kb-v4l2-ctrl-request-setup \
ksym-64kb-v4l2-ctrl-sub-ev-ops \
ksym-64kb-v4l2-ctrl-subdev-log-status \
ksym-64kb-v4l2-ctrl-subdev-subscribe-event \
ksym-64kb-v4l2-ctrl-subscribe-event \
ksym-64kb-v4l2-ctrl-type-op-equal \
ksym-64kb-v4l2-ctrl-type-op-init \
ksym-64kb-v4l2-ctrl-type-op-log \
ksym-64kb-v4l2-ctrl-type-op-validate \
ksym-64kb-v4l2-debugfs-if-alloc \
ksym-64kb-v4l2-debugfs-if-free \
ksym-64kb-v4l2-debugfs-root \
ksym-64kb-v4l2-detect-cvt \
ksym-64kb-v4l2-detect-gtf \
ksym-64kb-v4l2-device-disconnect \
ksym-64kb-v4l2-device-put \
ksym-64kb-v4l2-device-register \
ksym-64kb-v4l2-device-set-name \
ksym-64kb-v4l2-device-unregister \
ksym-64kb-v4l2-device-unregister-subdev \
ksym-64kb-v4l2-dv-timings-aspect-ratio \
ksym-64kb-v4l2-dv-timings-presets \
ksym-64kb-v4l2-enum-dv-timings-cap \
ksym-64kb-v4l2-event-dequeue \
ksym-64kb-v4l2-event-pending \
ksym-64kb-v4l2-event-queue \
ksym-64kb-v4l2-event-queue-fh \
ksym-64kb-v4l2-event-subdev-unsubscribe \
ksym-64kb-v4l2-event-subscribe \
ksym-64kb-v4l2-event-unsubscribe \
ksym-64kb-v4l2-event-unsubscribe-all \
ksym-64kb-v4l2-event-wake-all \
ksym-64kb-v4l2-fh-add \
ksym-64kb-v4l2-fh-del \
ksym-64kb-v4l2-fh-exit \
ksym-64kb-v4l2-fh-init \
ksym-64kb-v4l2-fh-is-singular \
ksym-64kb-v4l2-fh-open \
ksym-64kb-v4l2-fh-release \
ksym-64kb-v4l2-field-names \
ksym-64kb-v4l2-fill-pixfmt \
ksym-64kb-v4l2-fill-pixfmt-mp \
ksym-64kb-v4l2-fill-pixfmt-mp-aligned \
ksym-64kb-v4l2-find-dv-timings-cap \
ksym-64kb-v4l2-find-dv-timings-cea861-vic \
ksym-64kb-v4l2-format-info \
ksym-64kb-v4l2-fraction-to-interval \
ksym-64kb-v4l2-fwnode-connector-add-link \
ksym-64kb-v4l2-fwnode-connector-free \
ksym-64kb-v4l2-fwnode-connector-parse \
ksym-64kb-v4l2-fwnode-device-parse \
ksym-64kb-v4l2-fwnode-endpoint-alloc-parse \
ksym-64kb-v4l2-fwnode-endpoint-free \
ksym-64kb-v4l2-fwnode-endpoint-parse \
ksym-64kb-v4l2-fwnode-parse-link \
ksym-64kb-v4l2-fwnode-put-link \
ksym-64kb-v4l2-g-ctrl \
ksym-64kb-v4l2-g-ext-ctrls \
ksym-64kb-v4l2-g-parm-cap \
ksym-64kb-v4l2-get-active-data-lanes \
ksym-64kb-v4l2-get-edid-phys-addr \
ksym-64kb-v4l2-get-link-freq \
ksym-64kb-v4l2-h264-build-b-ref-lists \
ksym-64kb-v4l2-h264-build-p-ref-list \
ksym-64kb-v4l2-h264-init-reflist-builder \
ksym-64kb-v4l2-hdmi-rx-colorimetry \
ksym-64kb-v4l2-i2c-new-subdev \
ksym-64kb-v4l2-i2c-new-subdev-board \
ksym-64kb-v4l2-i2c-subdev-addr \
ksym-64kb-v4l2-i2c-subdev-init \
ksym-64kb-v4l2-i2c-subdev-set-name \
ksym-64kb-v4l2-i2c-tuner-addrs \
ksym-64kb-v4l2-isp-params-validate-buffer \
ksym-64kb-v4l2-isp-params-validate-buffer-size \
ksym-64kb-v4l2-jpeg-parse-header \
ksym-64kb-v4l2-jpeg-ref-table-chroma-ac-ht \
ksym-64kb-v4l2-jpeg-ref-table-chroma-dc-ht \
ksym-64kb-v4l2-jpeg-ref-table-chroma-qt \
ksym-64kb-v4l2-jpeg-ref-table-luma-ac-ht \
ksym-64kb-v4l2-jpeg-ref-table-luma-dc-ht \
ksym-64kb-v4l2-jpeg-ref-table-luma-qt \
ksym-64kb-v4l2-jpeg-zigzag-scan-index \
ksym-64kb-v4l2-link-freq-to-bitmap \
ksym-64kb-v4l2-m2m-buf-copy-metadata \
ksym-64kb-v4l2-m2m-buf-done-and-job-finish \
ksym-64kb-v4l2-m2m-buf-queue \
ksym-64kb-v4l2-m2m-buf-remove \
ksym-64kb-v4l2-m2m-buf-remove-by-buf \
ksym-64kb-v4l2-m2m-buf-remove-by-idx \
ksym-64kb-v4l2-m2m-create-bufs \
ksym-64kb-v4l2-m2m-ctx-init \
ksym-64kb-v4l2-m2m-ctx-release \
ksym-64kb-v4l2-m2m-decoder-cmd \
ksym-64kb-v4l2-m2m-dqbuf \
ksym-64kb-v4l2-m2m-encoder-cmd \
ksym-64kb-v4l2-m2m-expbuf \
ksym-64kb-v4l2-m2m-fop-mmap \
ksym-64kb-v4l2-m2m-fop-poll \
ksym-64kb-v4l2-m2m-get \
ksym-64kb-v4l2-m2m-get-curr-priv \
ksym-64kb-v4l2-m2m-get-vq \
ksym-64kb-v4l2-m2m-init \
ksym-64kb-v4l2-m2m-ioctl-create-bufs \
ksym-64kb-v4l2-m2m-ioctl-decoder-cmd \
ksym-64kb-v4l2-m2m-ioctl-dqbuf \
ksym-64kb-v4l2-m2m-ioctl-encoder-cmd \
ksym-64kb-v4l2-m2m-ioctl-expbuf \
ksym-64kb-v4l2-m2m-ioctl-prepare-buf \
ksym-64kb-v4l2-m2m-ioctl-qbuf \
ksym-64kb-v4l2-m2m-ioctl-querybuf \
ksym-64kb-v4l2-m2m-ioctl-remove-bufs \
ksym-64kb-v4l2-m2m-ioctl-reqbufs \
ksym-64kb-v4l2-m2m-ioctl-stateless-decoder-cmd \
ksym-64kb-v4l2-m2m-ioctl-stateless-try-decoder-cmd \
ksym-64kb-v4l2-m2m-ioctl-streamoff \
ksym-64kb-v4l2-m2m-ioctl-streamon \
ksym-64kb-v4l2-m2m-ioctl-try-decoder-cmd \
ksym-64kb-v4l2-m2m-ioctl-try-encoder-cmd \
ksym-64kb-v4l2-m2m-job-finish \
ksym-64kb-v4l2-m2m-last-buf \
ksym-64kb-v4l2-m2m-last-buffer-done \
ksym-64kb-v4l2-m2m-mmap \
ksym-64kb-v4l2-m2m-next-buf \
ksym-64kb-v4l2-m2m-poll \
ksym-64kb-v4l2-m2m-prepare-buf \
ksym-64kb-v4l2-m2m-put \
ksym-64kb-v4l2-m2m-qbuf \
ksym-64kb-v4l2-m2m-querybuf \
ksym-64kb-v4l2-m2m-register-media-controller \
ksym-64kb-v4l2-m2m-release \
ksym-64kb-v4l2-m2m-reqbufs \
ksym-64kb-v4l2-m2m-request-queue \
ksym-64kb-v4l2-m2m-resume \
ksym-64kb-v4l2-m2m-streamoff \
ksym-64kb-v4l2-m2m-streamon \
ksym-64kb-v4l2-m2m-suspend \
ksym-64kb-v4l2-m2m-try-schedule \
ksym-64kb-v4l2-m2m-unregister-media-controller \
ksym-64kb-v4l2-m2m-update-start-streaming-state \
ksym-64kb-v4l2-m2m-update-stop-streaming-state \
ksym-64kb-v4l2-match-dv-timings \
ksym-64kb-v4l2-mc-create-media-graph \
ksym-64kb-v4l2-norm-to-name \
ksym-64kb-v4l2-num-edid-blocks \
ksym-64kb-v4l2-phys-addr-for-input \
ksym-64kb-v4l2-phys-addr-validate \
ksym-64kb-v4l2-pipeline-link-notify \
ksym-64kb-v4l2-pipeline-pm-get \
ksym-64kb-v4l2-pipeline-pm-put \
ksym-64kb-v4l2-print-dv-timings \
ksym-64kb-v4l2-prio-change \
ksym-64kb-v4l2-prio-check \
ksym-64kb-v4l2-prio-close \
ksym-64kb-v4l2-prio-init \
ksym-64kb-v4l2-prio-max \
ksym-64kb-v4l2-prio-open \
ksym-64kb-v4l2-query-ext-ctrl \
ksym-64kb-v4l2-query-ext-ctrl-to-v4l2-queryctrl \
ksym-64kb-v4l2-queryctrl \
ksym-64kb-v4l2-querymenu \
ksym-64kb-v4l2-s-ctrl \
ksym-64kb-v4l2-s-ext-ctrls \
ksym-64kb-v4l2-s-parm-cap \
ksym-64kb-v4l2-set-edid-phys-addr \
ksym-64kb-v4l2-simplify-fraction \
ksym-64kb-v4l2-spi-new-subdev \
ksym-64kb-v4l2-spi-subdev-init \
ksym-64kb-v4l2-src-change-event-subdev-subscribe \
ksym-64kb-v4l2-src-change-event-subscribe \
ksym-64kb-v4l2-subdev-call-wrappers \
ksym-64kb-v4l2-subdev-cleanup \
ksym-64kb-v4l2-subdev-disable-streams \
ksym-64kb-v4l2-subdev-enable-streams \
ksym-64kb-v4l2-subdev-get-fmt \
ksym-64kb-v4l2-subdev-get-frame-desc-passthrough \
ksym-64kb-v4l2-subdev-get-frame-interval \
ksym-64kb-v4l2-subdev-get-fwnode-pad-1-to-1 \
ksym-64kb-v4l2-subdev-get-privacy-led \
ksym-64kb-v4l2-subdev-has-pad-interdep \
ksym-64kb-v4l2-subdev-init \
ksym-64kb-v4l2-subdev-is-streaming \
ksym-64kb-v4l2-subdev-link-validate \
ksym-64kb-v4l2-subdev-link-validate-default \
ksym-64kb-v4l2-subdev-notify-event \
ksym-64kb-v4l2-subdev-put-privacy-led \
ksym-64kb-v4l2-subdev-routing-find-opposite-end \
ksym-64kb-v4l2-subdev-routing-validate \
ksym-64kb-v4l2-subdev-s-stream-helper \
ksym-64kb-v4l2-subdev-set-routing \
ksym-64kb-v4l2-subdev-set-routing-with-fmt \
ksym-64kb-v4l2-subdev-state-get-opposite-stream-format \
ksym-64kb-v4l2-subdev-state-xlate-streams \
ksym-64kb-v4l2-translate-cmd \
ksym-64kb-v4l2-try-ext-ctrls \
ksym-64kb-v4l2-type-names \
ksym-64kb-v4l2-valid-dv-timings \
ksym-64kb-v4l2-video-std-construct \
ksym-64kb-v4l2-video-std-frame-period \
ksym-64kb-v4l2-vp9-adapt-coef-probs \
ksym-64kb-v4l2-vp9-adapt-noncoef-probs \
ksym-64kb-v4l2-vp9-default-probs \
ksym-64kb-v4l2-vp9-fw-update-probs \
ksym-64kb-v4l2-vp9-kf-partition-probs \
ksym-64kb-v4l2-vp9-kf-uv-mode-prob \
ksym-64kb-v4l2-vp9-kf-y-mode-prob \
ksym-64kb-v4l2-vp9-reset-frame-ctx \
ksym-64kb-v4l2-vp9-seg-feat-enabled \
ksym-64kb-v9fs-get-default-trans \
ksym-64kb-v9fs-get-trans-by-name \
ksym-64kb-v9fs-put-trans \
ksym-64kb-v9fs-register-trans \
ksym-64kb-v9fs-unregister-trans \
ksym-64kb-validate-slab-cache \
ksym-64kb-validate-usercopy-range \
ksym-64kb-validate-xmit-skb-list \
ksym-64kb-validate-xmit-xfrm \
ksym-64kb-vb2-buffer-done \
ksym-64kb-vb2-buffer-in-use \
ksym-64kb-vb2-common-vm-ops \
ksym-64kb-vb2-core-create-bufs \
ksym-64kb-vb2-core-dqbuf \
ksym-64kb-vb2-core-expbuf \
ksym-64kb-vb2-core-poll \
ksym-64kb-vb2-core-prepare-buf \
ksym-64kb-vb2-core-qbuf \
ksym-64kb-vb2-core-querybuf \
ksym-64kb-vb2-core-queue-init \
ksym-64kb-vb2-core-queue-release \
ksym-64kb-vb2-core-remove-bufs \
ksym-64kb-vb2-core-reqbufs \
ksym-64kb-vb2-core-streamoff \
ksym-64kb-vb2-core-streamon \
ksym-64kb-vb2-create-bufs \
ksym-64kb-vb2-create-framevec \
ksym-64kb-vb2-destroy-framevec \
ksym-64kb-vb2-discard-done \
ksym-64kb-vb2-dma-contig-memops \
ksym-64kb-vb2-dma-contig-set-max-seg-size \
ksym-64kb-vb2-dma-sg-memops \
ksym-64kb-vb2-dqbuf \
ksym-64kb-vb2-dvb-alloc-frontend \
ksym-64kb-vb2-dvb-dealloc-frontends \
ksym-64kb-vb2-dvb-find-frontend \
ksym-64kb-vb2-dvb-get-frontend \
ksym-64kb-vb2-dvb-register-bus \
ksym-64kb-vb2-dvb-unregister-bus \
ksym-64kb-vb2-expbuf \
ksym-64kb-vb2-find-buffer \
ksym-64kb-vb2-fop-mmap \
ksym-64kb-vb2-fop-poll \
ksym-64kb-vb2-fop-read \
ksym-64kb-vb2-fop-release \
ksym-64kb-vb2-fop-write \
ksym-64kb-vb2-ioctl-create-bufs \
ksym-64kb-vb2-ioctl-dqbuf \
ksym-64kb-vb2-ioctl-expbuf \
ksym-64kb-vb2-ioctl-prepare-buf \
ksym-64kb-vb2-ioctl-qbuf \
ksym-64kb-vb2-ioctl-querybuf \
ksym-64kb-vb2-ioctl-remove-bufs \
ksym-64kb-vb2-ioctl-reqbufs \
ksym-64kb-vb2-ioctl-streamoff \
ksym-64kb-vb2-ioctl-streamon \
ksym-64kb-vb2-mmap \
ksym-64kb-vb2-plane-cookie \
ksym-64kb-vb2-plane-vaddr \
ksym-64kb-vb2-poll \
ksym-64kb-vb2-prepare-buf \
ksym-64kb-vb2-qbuf \
ksym-64kb-vb2-querybuf \
ksym-64kb-vb2-queue-change-type \
ksym-64kb-vb2-queue-error \
ksym-64kb-vb2-queue-init \
ksym-64kb-vb2-queue-init-name \
ksym-64kb-vb2-queue-release \
ksym-64kb-vb2-read \
ksym-64kb-vb2-reqbufs \
ksym-64kb-vb2-request-buffer-cnt \
ksym-64kb-vb2-request-object-is-buffer \
ksym-64kb-vb2-request-queue \
ksym-64kb-vb2-request-validate \
ksym-64kb-vb2-streamoff \
ksym-64kb-vb2-streamon \
ksym-64kb-vb2-thread-start \
ksym-64kb-vb2-thread-stop \
ksym-64kb-vb2-verify-memory-type \
ksym-64kb-vb2-video-unregister-device \
ksym-64kb-vb2-vmalloc-memops \
ksym-64kb-vb2-wait-for-all-buffers \
ksym-64kb-vb2-write \
ksym-64kb-vbg-err \
ksym-64kb-vbg-err-ratelimited \
ksym-64kb-vbg-get-gdev \
ksym-64kb-vbg-hgcm-call \
ksym-64kb-vbg-hgcm-connect \
ksym-64kb-vbg-hgcm-disconnect \
ksym-64kb-vbg-info \
ksym-64kb-vbg-put-gdev \
ksym-64kb-vbg-status-code-to-errno \
ksym-64kb-vbg-warn \
ksym-64kb-vbin-printf \
ksym-64kb-vc-cons \
ksym-64kb-vc-font-pitch \
ksym-64kb-vc-font-size \
ksym-64kb-vcalloc-noprof \
ksym-64kb-vcap-add-rule \
ksym-64kb-vcap-addr-keysets \
ksym-64kb-vcap-admin-rule-count \
ksym-64kb-vcap-alloc-rule \
ksym-64kb-vcap-chain-id-to-lookup \
ksym-64kb-vcap-chain-offset \
ksym-64kb-vcap-copy-rule \
ksym-64kb-vcap-debugfs \
ksym-64kb-vcap-del-rule \
ksym-64kb-vcap-del-rules \
ksym-64kb-vcap-enable-lookups \
ksym-64kb-vcap-filter-rule-keys \
ksym-64kb-vcap-find-actionfield \
ksym-64kb-vcap-find-admin \
ksym-64kb-vcap-find-keystream-keysets \
ksym-64kb-vcap-free-rule \
ksym-64kb-vcap-get-rule \
ksym-64kb-vcap-get-rule-count-by-cookie \
ksym-64kb-vcap-is-last-chain \
ksym-64kb-vcap-is-next-lookup \
ksym-64kb-vcap-keyfield-name \
ksym-64kb-vcap-keyfieldset \
ksym-64kb-vcap-keyset-list-add \
ksym-64kb-vcap-keyset-name \
ksym-64kb-vcap-lookup-keyfield \
ksym-64kb-vcap-lookup-rule-by-cookie \
ksym-64kb-vcap-mod-rule \
ksym-64kb-vcap-netbytes-copy \
ksym-64kb-vcap-port-debugfs \
ksym-64kb-vcap-rule-add-action-bit \
ksym-64kb-vcap-rule-add-action-u32 \
ksym-64kb-vcap-rule-add-action-u72 \
ksym-64kb-vcap-rule-add-key-bit \
ksym-64kb-vcap-rule-add-key-u128 \
ksym-64kb-vcap-rule-add-key-u32 \
ksym-64kb-vcap-rule-add-key-u48 \
ksym-64kb-vcap-rule-add-key-u72 \
ksym-64kb-vcap-rule-find-keysets \
ksym-64kb-vcap-rule-get-counter \
ksym-64kb-vcap-rule-get-key-u32 \
ksym-64kb-vcap-rule-mod-action-u32 \
ksym-64kb-vcap-rule-mod-key-u32 \
ksym-64kb-vcap-rule-rem-key \
ksym-64kb-vcap-rule-set-counter \
ksym-64kb-vcap-rule-set-counter-id \
ksym-64kb-vcap-select-min-rule-keyset \
ksym-64kb-vcap-set-rule-set-actionset \
ksym-64kb-vcap-set-rule-set-keyset \
ksym-64kb-vcap-set-tc-exterr \
ksym-64kb-vcap-tc-flower-handler-arp-usage \
ksym-64kb-vcap-tc-flower-handler-cvlan-usage \
ksym-64kb-vcap-tc-flower-handler-ethaddr-usage \
ksym-64kb-vcap-tc-flower-handler-ip-usage \
ksym-64kb-vcap-tc-flower-handler-ipv4-usage \
ksym-64kb-vcap-tc-flower-handler-ipv6-usage \
ksym-64kb-vcap-tc-flower-handler-portnum-usage \
ksym-64kb-vcap-tc-flower-handler-tcp-usage \
ksym-64kb-vcap-tc-flower-handler-vlan-usage \
ksym-64kb-vcap-val-rule \
ksym-64kb-vcc-hash \
ksym-64kb-vcc-insert-socket \
ksym-64kb-vcc-process-recv-queue \
ksym-64kb-vcc-release-async \
ksym-64kb-vcc-sklist-lock \
ksym-64kb-vchan-dma-desc-free-list \
ksym-64kb-vchan-find-desc \
ksym-64kb-vchan-init \
ksym-64kb-vchan-tx-desc-free \
ksym-64kb-vchan-tx-submit \
ksym-64kb-vchiq-add-connected-callback \
ksym-64kb-vchiq-bulk-receive \
ksym-64kb-vchiq-bulk-transmit \
ksym-64kb-vchiq-close-service \
ksym-64kb-vchiq-connect \
ksym-64kb-vchiq-driver-register \
ksym-64kb-vchiq-driver-unregister \
ksym-64kb-vchiq-get-peer-version \
ksym-64kb-vchiq-get-service-userdata \
ksym-64kb-vchiq-initialise \
ksym-64kb-vchiq-mmal-component-disable \
ksym-64kb-vchiq-mmal-component-enable \
ksym-64kb-vchiq-mmal-component-finalise \
ksym-64kb-vchiq-mmal-component-init \
ksym-64kb-vchiq-mmal-finalise \
ksym-64kb-vchiq-mmal-init \
ksym-64kb-vchiq-mmal-port-connect-tunnel \
ksym-64kb-vchiq-mmal-port-disable \
ksym-64kb-vchiq-mmal-port-enable \
ksym-64kb-vchiq-mmal-port-parameter-get \
ksym-64kb-vchiq-mmal-port-parameter-set \
ksym-64kb-vchiq-mmal-port-set-format \
ksym-64kb-vchiq-mmal-submit-buffer \
ksym-64kb-vchiq-mmal-version \
ksym-64kb-vchiq-msg-hold \
ksym-64kb-vchiq-msg-queue-push \
ksym-64kb-vchiq-open-service \
ksym-64kb-vchiq-queue-kernel-message \
ksym-64kb-vchiq-release-message \
ksym-64kb-vchiq-release-service \
ksym-64kb-vchiq-shutdown \
ksym-64kb-vchiq-use-service \
ksym-64kb-vdpa-get-config \
ksym-64kb-vdpa-mgmtdev-register \
ksym-64kb-vdpa-mgmtdev-unregister \
ksym-64kb-vdpa-register-device \
ksym-64kb-vdpa-set-config \
ksym-64kb-vdpa-set-status \
ksym-64kb-vdpa-unregister-device \
ksym-64kb-vdpa-unregister-driver \
ksym-64kb-vdpasim-create \
ksym-64kb-vdpasim-schedule-work \
ksym-64kb-venus-close-common \
ksym-64kb-venus-helper-acquire-buf-ref \
ksym-64kb-venus-helper-alloc-dpb-bufs \
ksym-64kb-venus-helper-buffers-done \
ksym-64kb-venus-helper-change-dpb-owner \
ksym-64kb-venus-helper-check-codec \
ksym-64kb-venus-helper-check-format \
ksym-64kb-venus-helper-find-buf \
ksym-64kb-venus-helper-free-dpb-bufs \
ksym-64kb-venus-helper-get-bufreq \
ksym-64kb-venus-helper-get-framesz \
ksym-64kb-venus-helper-get-framesz-raw \
ksym-64kb-venus-helper-get-opb-size \
ksym-64kb-venus-helper-get-out-fmts \
ksym-64kb-venus-helper-get-profile-level \
ksym-64kb-venus-helper-get-ts-metadata \
ksym-64kb-venus-helper-init-instance \
ksym-64kb-venus-helper-intbufs-alloc \
ksym-64kb-venus-helper-intbufs-free \
ksym-64kb-venus-helper-intbufs-realloc \
ksym-64kb-venus-helper-m2m-device-run \
ksym-64kb-venus-helper-m2m-job-abort \
ksym-64kb-venus-helper-process-initial-cap-bufs \
ksym-64kb-venus-helper-process-initial-out-bufs \
ksym-64kb-venus-helper-queue-dpb-bufs \
ksym-64kb-venus-helper-release-buf-ref \
ksym-64kb-venus-helper-session-init \
ksym-64kb-venus-helper-set-bufsize \
ksym-64kb-venus-helper-set-color-format \
ksym-64kb-venus-helper-set-dyn-bufmode \
ksym-64kb-venus-helper-set-format-constraints \
ksym-64kb-venus-helper-set-input-resolution \
ksym-64kb-venus-helper-set-multistream \
ksym-64kb-venus-helper-set-num-bufs \
ksym-64kb-venus-helper-set-output-resolution \
ksym-64kb-venus-helper-set-profile-level \
ksym-64kb-venus-helper-set-raw-format \
ksym-64kb-venus-helper-set-stride \
ksym-64kb-venus-helper-set-work-mode \
ksym-64kb-venus-helper-unregister-bufs \
ksym-64kb-venus-helper-vb2-buf-init \
ksym-64kb-venus-helper-vb2-buf-prepare \
ksym-64kb-venus-helper-vb2-buf-queue \
ksym-64kb-venus-helper-vb2-queue-error \
ksym-64kb-venus-helper-vb2-start-streaming \
ksym-64kb-venus-helper-vb2-stop-streaming \
ksym-64kb-verbose-torout-sleep \
ksym-64kb-verify-pkcs7-signature \
ksym-64kb-verify-signature \
ksym-64kb-verify-spi-info \
ksym-64kb-versal-pm-aes-dec-final \
ksym-64kb-versal-pm-aes-dec-update \
ksym-64kb-versal-pm-aes-enc-final \
ksym-64kb-versal-pm-aes-enc-update \
ksym-64kb-versal-pm-aes-init \
ksym-64kb-versal-pm-aes-key-write \
ksym-64kb-versal-pm-aes-key-zero \
ksym-64kb-versal-pm-aes-op-init \
ksym-64kb-versal-pm-aes-update-aad \
ksym-64kb-ves1820-attach \
ksym-64kb-ves1x93-attach \
ksym-64kb-vesa-modes \
ksym-64kb-vfio-assign-device-set \
ksym-64kb-vfio-combine-iova-ranges \
ksym-64kb-vfio-device-put-registration \
ksym-64kb-vfio-device-set-open-count \
ksym-64kb-vfio-device-try-get-registration \
ksym-64kb-vfio-dma-rw \
ksym-64kb-vfio-file-enforced-coherent \
ksym-64kb-vfio-file-has-dev \
ksym-64kb-vfio-file-iommu-group \
ksym-64kb-vfio-file-is-group \
ksym-64kb-vfio-file-is-valid \
ksym-64kb-vfio-file-set-kvm \
ksym-64kb-vfio-find-device-in-devset \
ksym-64kb-vfio-info-add-capability \
ksym-64kb-vfio-info-cap-add \
ksym-64kb-vfio-info-cap-shift \
ksym-64kb-vfio-mig-get-next-state \
ksym-64kb-vfio-pci-config-rw-single \
ksym-64kb-vfio-pci-core-aer-err-detected \
ksym-64kb-vfio-pci-core-close-device \
ksym-64kb-vfio-pci-core-disable \
ksym-64kb-vfio-pci-core-do-io-rw \
ksym-64kb-vfio-pci-core-enable \
ksym-64kb-vfio-pci-core-err-handlers \
ksym-64kb-vfio-pci-core-fill-phys-vec \
ksym-64kb-vfio-pci-core-finish-enable \
ksym-64kb-vfio-pci-core-get-dmabuf-phys \
ksym-64kb-vfio-pci-core-init-dev \
ksym-64kb-vfio-pci-core-ioctl \
ksym-64kb-vfio-pci-core-ioctl-feature \
ksym-64kb-vfio-pci-core-ioread16 \
ksym-64kb-vfio-pci-core-ioread32 \
ksym-64kb-vfio-pci-core-ioread64 \
ksym-64kb-vfio-pci-core-ioread8 \
ksym-64kb-vfio-pci-core-iowrite16 \
ksym-64kb-vfio-pci-core-iowrite32 \
ksym-64kb-vfio-pci-core-iowrite64 \
ksym-64kb-vfio-pci-core-iowrite8 \
ksym-64kb-vfio-pci-core-match \
ksym-64kb-vfio-pci-core-match-token-uuid \
ksym-64kb-vfio-pci-core-mmap \
ksym-64kb-vfio-pci-core-range-intersect-range \
ksym-64kb-vfio-pci-core-read \
ksym-64kb-vfio-pci-core-register-dev-region \
ksym-64kb-vfio-pci-core-register-device \
ksym-64kb-vfio-pci-core-release-dev \
ksym-64kb-vfio-pci-core-request \
ksym-64kb-vfio-pci-core-sriov-configure \
ksym-64kb-vfio-pci-core-unregister-device \
ksym-64kb-vfio-pci-core-write \
ksym-64kb-vfio-pci-dma-buf-iommufd-map \
ksym-64kb-vfio-pci-ioctl-get-region-info \
ksym-64kb-vfio-pci-vmf-insert-pfn \
ksym-64kb-vfio-pin-pages \
ksym-64kb-vfio-platform-close-device \
ksym-64kb-vfio-platform-init-common \
ksym-64kb-vfio-platform-ioctl \
ksym-64kb-vfio-platform-ioctl-get-region-info \
ksym-64kb-vfio-platform-mmap \
ksym-64kb-vfio-platform-open-device \
ksym-64kb-vfio-platform-read \
ksym-64kb-vfio-platform-release-common \
ksym-64kb-vfio-platform-unregister-reset \
ksym-64kb-vfio-platform-write \
ksym-64kb-vfio-register-emulated-iommu-dev \
ksym-64kb-vfio-register-group-dev \
ksym-64kb-vfio-register-iommu-driver \
ksym-64kb-vfio-set-irqs-validate-and-prepare \
ksym-64kb-vfio-unpin-pages \
ksym-64kb-vfio-unregister-group-dev \
ksym-64kb-vfio-unregister-iommu-driver \
ksym-64kb-vfio-virqfd-disable \
ksym-64kb-vfio-virqfd-enable \
ksym-64kb-vfio-virqfd-flush-thread \
ksym-64kb-vfree \
ksym-64kb-vfs-cancel-lock \
ksym-64kb-vfs-clone-file-range \
ksym-64kb-vfs-copy-file-range \
ksym-64kb-vfs-create \
ksym-64kb-vfs-create-mount \
ksym-64kb-vfs-dedupe-file-range \
ksym-64kb-vfs-dedupe-file-range-one \
ksym-64kb-vfs-dup-fs-context \
ksym-64kb-vfs-fadvise \
ksym-64kb-vfs-fallocate \
ksym-64kb-vfs-fileattr-get \
ksym-64kb-vfs-fileattr-set \
ksym-64kb-vfs-fsync \
ksym-64kb-vfs-fsync-range \
ksym-64kb-vfs-get-acl \
ksym-64kb-vfs-get-fsid \
ksym-64kb-vfs-get-link \
ksym-64kb-vfs-get-tree \
ksym-64kb-vfs-getattr \
ksym-64kb-vfs-getattr-nosec \
ksym-64kb-vfs-getxattr \
ksym-64kb-vfs-inode-has-locks \
ksym-64kb-vfs-iocb-iter-read \
ksym-64kb-vfs-iocb-iter-write \
ksym-64kb-vfs-iter-read \
ksym-64kb-vfs-iter-write \
ksym-64kb-vfs-kern-mount \
ksym-64kb-vfs-link \
ksym-64kb-vfs-listxattr \
ksym-64kb-vfs-llseek \
ksym-64kb-vfs-lock-file \
ksym-64kb-vfs-mkdir \
ksym-64kb-vfs-mknod \
ksym-64kb-vfs-mkobj \
ksym-64kb-vfs-parse-fs-param \
ksym-64kb-vfs-parse-fs-param-source \
ksym-64kb-vfs-parse-fs-qstr \
ksym-64kb-vfs-parse-monolithic-sep \
ksym-64kb-vfs-path-lookup \
ksym-64kb-vfs-path-parent-lookup \
ksym-64kb-vfs-pressure-ratio \
ksym-64kb-vfs-readlink \
ksym-64kb-vfs-remove-acl \
ksym-64kb-vfs-removexattr \
ksym-64kb-vfs-rename \
ksym-64kb-vfs-rmdir \
ksym-64kb-vfs-set-acl \
ksym-64kb-vfs-setlease \
ksym-64kb-vfs-setpos \
ksym-64kb-vfs-setxattr \
ksym-64kb-vfs-splice-read \
ksym-64kb-vfs-statfs \
ksym-64kb-vfs-symlink \
ksym-64kb-vfs-test-lock \
ksym-64kb-vfs-truncate \
ksym-64kb-vfs-unlink \
ksym-64kb-vfs-utimes \
ksym-64kb-vfsgid-in-group-p \
ksym-64kb-vfsmount-to-propagation-flags \
ksym-64kb-vga-client-register \
ksym-64kb-vga-default-device \
ksym-64kb-vga-get \
ksym-64kb-vga-put \
ksym-64kb-vga-remove-vgacon \
ksym-64kb-vga-set-legacy-decoding \
ksym-64kb-vhost-add-used \
ksym-64kb-vhost-add-used-and-signal \
ksym-64kb-vhost-add-used-and-signal-n \
ksym-64kb-vhost-add-used-n \
ksym-64kb-vhost-chr-poll \
ksym-64kb-vhost-chr-read-iter \
ksym-64kb-vhost-chr-write-iter \
ksym-64kb-vhost-clear-msg \
ksym-64kb-vhost-dequeue-msg \
ksym-64kb-vhost-dev-check-owner \
ksym-64kb-vhost-dev-cleanup \
ksym-64kb-vhost-dev-flush \
ksym-64kb-vhost-dev-has-owner \
ksym-64kb-vhost-dev-init \
ksym-64kb-vhost-dev-ioctl \
ksym-64kb-vhost-dev-reset-owner \
ksym-64kb-vhost-dev-reset-owner-prepare \
ksym-64kb-vhost-dev-set-owner \
ksym-64kb-vhost-dev-stop \
ksym-64kb-vhost-disable-notify \
ksym-64kb-vhost-discard-vq-desc \
ksym-64kb-vhost-enable-notify \
ksym-64kb-vhost-enqueue-msg \
ksym-64kb-vhost-exceeds-weight \
ksym-64kb-vhost-get-vq-desc \
ksym-64kb-vhost-get-vq-desc-n \
ksym-64kb-vhost-init-device-iotlb \
ksym-64kb-vhost-iotlb-add-range \
ksym-64kb-vhost-iotlb-add-range-ctx \
ksym-64kb-vhost-iotlb-alloc \
ksym-64kb-vhost-iotlb-del-range \
ksym-64kb-vhost-iotlb-free \
ksym-64kb-vhost-iotlb-init \
ksym-64kb-vhost-iotlb-itree-first \
ksym-64kb-vhost-iotlb-itree-next \
ksym-64kb-vhost-iotlb-map-free \
ksym-64kb-vhost-iotlb-reset \
ksym-64kb-vhost-log-access-ok \
ksym-64kb-vhost-log-write \
ksym-64kb-vhost-new-msg \
ksym-64kb-vhost-poll-init \
ksym-64kb-vhost-poll-queue \
ksym-64kb-vhost-poll-start \
ksym-64kb-vhost-poll-stop \
ksym-64kb-vhost-set-backend-features \
ksym-64kb-vhost-signal \
ksym-64kb-vhost-task-create \
ksym-64kb-vhost-task-start \
ksym-64kb-vhost-task-stop \
ksym-64kb-vhost-task-wake \
ksym-64kb-vhost-vq-access-ok \
ksym-64kb-vhost-vq-avail-empty \
ksym-64kb-vhost-vq-has-work \
ksym-64kb-vhost-vq-init-access \
ksym-64kb-vhost-vq-is-setup \
ksym-64kb-vhost-vq-work-queue \
ksym-64kb-vhost-vring-ioctl \
ksym-64kb-vhost-work-init \
ksym-64kb-vhost-worker-ioctl \
ksym-64kb-viai2c-init \
ksym-64kb-viai2c-irq-xfer \
ksym-64kb-viai2c-wait-bus-not-busy \
ksym-64kb-viai2c-xfer \
ksym-64kb-vid-from-reg \
ksym-64kb-vid-is-dsa-8021q \
ksym-64kb-vid-which-vrm \
ksym-64kb-video-devdata \
ksym-64kb-video-device-alloc \
ksym-64kb-video-device-pipeline \
ksym-64kb-video-device-pipeline-alloc-start \
ksym-64kb-video-device-pipeline-start \
ksym-64kb-video-device-pipeline-stop \
ksym-64kb-video-device-release \
ksym-64kb-video-device-release-empty \
ksym-64kb-video-firmware-drivers-only \
ksym-64kb-video-get-options \
ksym-64kb-video-ioctl2 \
ksym-64kb-video-unregister-device \
ksym-64kb-videomode-from-timing \
ksym-64kb-videomode-from-timings \
ksym-64kb-virtio-add-status \
ksym-64kb-virtio-break-device \
ksym-64kb-virtio-check-driver-offered-feature \
ksym-64kb-virtio-check-mem-acc-cb \
ksym-64kb-virtio-config-changed \
ksym-64kb-virtio-config-driver-disable \
ksym-64kb-virtio-config-driver-enable \
ksym-64kb-virtio-device-freeze \
ksym-64kb-virtio-device-reset-done \
ksym-64kb-virtio-device-reset-prepare \
ksym-64kb-virtio-device-restore \
ksym-64kb-virtio-dma-buf-attach \
ksym-64kb-virtio-dma-buf-export \
ksym-64kb-virtio-dma-buf-get-uuid \
ksym-64kb-virtio-max-dma-size \
ksym-64kb-virtio-pci-admin-dev-parts-get \
ksym-64kb-virtio-pci-admin-dev-parts-metadata-get \
ksym-64kb-virtio-pci-admin-dev-parts-set \
ksym-64kb-virtio-pci-admin-has-dev-parts \
ksym-64kb-virtio-pci-admin-mode-set \
ksym-64kb-virtio-pci-admin-obj-create \
ksym-64kb-virtio-pci-admin-obj-destroy \
ksym-64kb-virtio-pmem-host-ack \
ksym-64kb-virtio-require-restricted-mem-acc \
ksym-64kb-virtio-reset-device \
ksym-64kb-virtio-transport-connect \
ksym-64kb-virtio-transport-consume-skb-sent \
ksym-64kb-virtio-transport-deliver-tap-pkt \
ksym-64kb-virtio-transport-destruct \
ksym-64kb-virtio-transport-dgram-allow \
ksym-64kb-virtio-transport-dgram-bind \
ksym-64kb-virtio-transport-dgram-dequeue \
ksym-64kb-virtio-transport-dgram-enqueue \
ksym-64kb-virtio-transport-do-socket-init \
ksym-64kb-virtio-transport-get-credit \
ksym-64kb-virtio-transport-inc-tx-pkt \
ksym-64kb-virtio-transport-notify-buffer-size \
ksym-64kb-virtio-transport-notify-poll-in \
ksym-64kb-virtio-transport-notify-poll-out \
ksym-64kb-virtio-transport-notify-recv-init \
ksym-64kb-virtio-transport-notify-recv-post-dequeue \
ksym-64kb-virtio-transport-notify-recv-pre-block \
ksym-64kb-virtio-transport-notify-recv-pre-dequeue \
ksym-64kb-virtio-transport-notify-send-init \
ksym-64kb-virtio-transport-notify-send-post-enqueue \
ksym-64kb-virtio-transport-notify-send-pre-block \
ksym-64kb-virtio-transport-notify-send-pre-enqueue \
ksym-64kb-virtio-transport-notify-set-rcvlowat \
ksym-64kb-virtio-transport-purge-skbs \
ksym-64kb-virtio-transport-put-credit \
ksym-64kb-virtio-transport-read-skb \
ksym-64kb-virtio-transport-recv-pkt \
ksym-64kb-virtio-transport-release \
ksym-64kb-virtio-transport-seqpacket-dequeue \
ksym-64kb-virtio-transport-seqpacket-enqueue \
ksym-64kb-virtio-transport-seqpacket-has-data \
ksym-64kb-virtio-transport-shutdown \
ksym-64kb-virtio-transport-stream-dequeue \
ksym-64kb-virtio-transport-stream-enqueue \
ksym-64kb-virtio-transport-stream-has-data \
ksym-64kb-virtio-transport-stream-has-space \
ksym-64kb-virtio-transport-stream-is-active \
ksym-64kb-virtio-transport-stream-rcvhiwat \
ksym-64kb-virtio-transport-unsent-bytes \
ksym-64kb-virtqueue-add-inbuf \
ksym-64kb-virtqueue-add-inbuf-cache-clean \
ksym-64kb-virtqueue-add-inbuf-ctx \
ksym-64kb-virtqueue-add-inbuf-premapped \
ksym-64kb-virtqueue-add-outbuf \
ksym-64kb-virtqueue-add-outbuf-premapped \
ksym-64kb-virtqueue-add-sgs \
ksym-64kb-virtqueue-detach-unused-buf \
ksym-64kb-virtqueue-disable-cb \
ksym-64kb-virtqueue-dma-dev \
ksym-64kb-virtqueue-enable-cb \
ksym-64kb-virtqueue-enable-cb-delayed \
ksym-64kb-virtqueue-enable-cb-prepare \
ksym-64kb-virtqueue-get-avail-addr \
ksym-64kb-virtqueue-get-buf \
ksym-64kb-virtqueue-get-buf-ctx \
ksym-64kb-virtqueue-get-desc-addr \
ksym-64kb-virtqueue-get-used-addr \
ksym-64kb-virtqueue-get-vring \
ksym-64kb-virtqueue-get-vring-size \
ksym-64kb-virtqueue-is-broken \
ksym-64kb-virtqueue-kick \
ksym-64kb-virtqueue-kick-prepare \
ksym-64kb-virtqueue-map-alloc-coherent \
ksym-64kb-virtqueue-map-free-coherent \
ksym-64kb-virtqueue-map-mapping-error \
ksym-64kb-virtqueue-map-need-sync \
ksym-64kb-virtqueue-map-page-attrs \
ksym-64kb-virtqueue-map-single-attrs \
ksym-64kb-virtqueue-map-sync-single-range-for-cpu \
ksym-64kb-virtqueue-map-sync-single-range-for-device \
ksym-64kb-virtqueue-notify \
ksym-64kb-virtqueue-poll \
ksym-64kb-virtqueue-reset \
ksym-64kb-virtqueue-resize \
ksym-64kb-virtqueue-unmap-page-attrs \
ksym-64kb-virtqueue-unmap-single-attrs \
ksym-64kb-visitor128 \
ksym-64kb-visitor32 \
ksym-64kb-visitor64 \
ksym-64kb-visitorl \
ksym-64kb-vivaldi-attribute-groups \
ksym-64kb-vivaldi-feature-mapping \
ksym-64kb-vivaldi-function-row-physmap-show \
ksym-64kb-vlan-dev-real-dev \
ksym-64kb-vlan-dev-vlan-id \
ksym-64kb-vlan-dev-vlan-proto \
ksym-64kb-vlan-filter-drop-vids \
ksym-64kb-vlan-filter-push-vids \
ksym-64kb-vlan-for-each \
ksym-64kb-vlan-ioctl-set \
ksym-64kb-vlan-uses-dev \
ksym-64kb-vlan-vid-add \
ksym-64kb-vlan-vid-del \
ksym-64kb-vlan-vids-add-by-dev \
ksym-64kb-vlan-vids-del-by-dev \
ksym-64kb-vli-cmp \
ksym-64kb-vli-from-be64 \
ksym-64kb-vli-from-le64 \
ksym-64kb-vli-is-zero \
ksym-64kb-vli-mod-inv \
ksym-64kb-vli-mod-mult-slow \
ksym-64kb-vli-num-bits \
ksym-64kb-vli-sub \
ksym-64kb-vm-event-states \
ksym-64kb-vm-get-page-prot \
ksym-64kb-vm-insert-page \
ksym-64kb-vm-insert-pages \
ksym-64kb-vm-iomap-memory \
ksym-64kb-vm-map-pages \
ksym-64kb-vm-map-pages-zero \
ksym-64kb-vm-map-ram \
ksym-64kb-vm-memory-committed \
ksym-64kb-vm-mmap \
ksym-64kb-vm-munmap \
ksym-64kb-vm-node-stat \
ksym-64kb-vm-unmap-aliases \
ksym-64kb-vm-unmap-ram \
ksym-64kb-vm-zone-stat \
ksym-64kb-vma-alloc-folio-noprof \
ksym-64kb-vma-set-file \
ksym-64kb-vmalloc-32-noprof \
ksym-64kb-vmalloc-32-user-noprof \
ksym-64kb-vmalloc-array-noprof \
ksym-64kb-vmalloc-huge-node-noprof \
ksym-64kb-vmalloc-node-noprof \
ksym-64kb-vmalloc-noprof \
ksym-64kb-vmalloc-to-page \
ksym-64kb-vmalloc-to-pfn \
ksym-64kb-vmalloc-user-noprof \
ksym-64kb-vmap \
ksym-64kb-vmbus-alloc-ring \
ksym-64kb-vmbus-allocate-mmio \
ksym-64kb-vmbus-close \
ksym-64kb-vmbus-connect-ring \
ksym-64kb-vmbus-connection \
ksym-64kb-vmbus-device-unregister \
ksym-64kb-vmbus-devs \
ksym-64kb-vmbus-disconnect-ring \
ksym-64kb-vmbus-driver-unregister \
ksym-64kb-vmbus-establish-gpadl \
ksym-64kb-vmbus-free-mmio \
ksym-64kb-vmbus-free-ring \
ksym-64kb-vmbus-hvsock-device-unregister \
ksym-64kb-vmbus-initiate-unload \
ksym-64kb-vmbus-is-confidential \
ksym-64kb-vmbus-isr \
ksym-64kb-vmbus-next-request-id \
ksym-64kb-vmbus-open \
ksym-64kb-vmbus-prep-negotiate-resp \
ksym-64kb-vmbus-proto-version \
ksym-64kb-vmbus-recvpacket \
ksym-64kb-vmbus-recvpacket-raw \
ksym-64kb-vmbus-request-addr \
ksym-64kb-vmbus-request-addr-match \
ksym-64kb-vmbus-send-modifychannel \
ksym-64kb-vmbus-send-tl-connect-request \
ksym-64kb-vmbus-sendpacket \
ksym-64kb-vmbus-sendpacket-getid \
ksym-64kb-vmbus-sendpacket-mpb-desc \
ksym-64kb-vmbus-set-chn-rescind-callback \
ksym-64kb-vmbus-set-event \
ksym-64kb-vmbus-set-sc-create-callback \
ksym-64kb-vmbus-set-skip-unload \
ksym-64kb-vmbus-setevent \
ksym-64kb-vmbus-teardown-gpadl \
ksym-64kb-vmci-context-get-priv-flags \
ksym-64kb-vmci-datagram-create-handle \
ksym-64kb-vmci-datagram-create-handle-priv \
ksym-64kb-vmci-datagram-destroy-handle \
ksym-64kb-vmci-datagram-send \
ksym-64kb-vmci-doorbell-create \
ksym-64kb-vmci-doorbell-destroy \
ksym-64kb-vmci-event-subscribe \
ksym-64kb-vmci-event-unsubscribe \
ksym-64kb-vmci-get-context-id \
ksym-64kb-vmci-is-context-owner \
ksym-64kb-vmci-qpair-alloc \
ksym-64kb-vmci-qpair-consume-buf-ready \
ksym-64kb-vmci-qpair-consume-free-space \
ksym-64kb-vmci-qpair-dequev \
ksym-64kb-vmci-qpair-detach \
ksym-64kb-vmci-qpair-enquev \
ksym-64kb-vmci-qpair-get-consume-indexes \
ksym-64kb-vmci-qpair-get-produce-indexes \
ksym-64kb-vmci-qpair-peekv \
ksym-64kb-vmci-qpair-produce-buf-ready \
ksym-64kb-vmci-qpair-produce-free-space \
ksym-64kb-vmci-register-vsock-callback \
ksym-64kb-vmci-send-datagram \
ksym-64kb-vmcore-add-device-dump \
ksym-64kb-vmemdup-user \
ksym-64kb-vmf-insert-folio-pmd \
ksym-64kb-vmf-insert-mixed \
ksym-64kb-vmf-insert-page-mkwrite \
ksym-64kb-vmf-insert-pfn \
ksym-64kb-vmf-insert-pfn-pmd \
ksym-64kb-vmf-insert-pfn-prot \
ksym-64kb-vnic-dev-get-pdev \
ksym-64kb-vnic-dev-get-res \
ksym-64kb-vnic-dev-get-res-count \
ksym-64kb-vnic-dev-register \
ksym-64kb-vnic-dev-unregister \
ksym-64kb-vop-component-ops \
ksym-64kb-vop2-component-ops \
ksym-64kb-vp-legacy-config-vector \
ksym-64kb-vp-legacy-get-driver-features \
ksym-64kb-vp-legacy-get-features \
ksym-64kb-vp-legacy-get-queue-enable \
ksym-64kb-vp-legacy-get-queue-size \
ksym-64kb-vp-legacy-get-status \
ksym-64kb-vp-legacy-probe \
ksym-64kb-vp-legacy-queue-vector \
ksym-64kb-vp-legacy-remove \
ksym-64kb-vp-legacy-set-features \
ksym-64kb-vp-legacy-set-queue-address \
ksym-64kb-vp-legacy-set-status \
ksym-64kb-vp-modern-avq-index \
ksym-64kb-vp-modern-avq-num \
ksym-64kb-vp-modern-config-vector \
ksym-64kb-vp-modern-generation \
ksym-64kb-vp-modern-get-driver-extended-features \
ksym-64kb-vp-modern-get-extended-features \
ksym-64kb-vp-modern-get-num-queues \
ksym-64kb-vp-modern-get-queue-enable \
ksym-64kb-vp-modern-get-queue-reset \
ksym-64kb-vp-modern-get-queue-size \
ksym-64kb-vp-modern-get-status \
ksym-64kb-vp-modern-map-vq-notify \
ksym-64kb-vp-modern-probe \
ksym-64kb-vp-modern-queue-address \
ksym-64kb-vp-modern-queue-vector \
ksym-64kb-vp-modern-remove \
ksym-64kb-vp-modern-set-extended-features \
ksym-64kb-vp-modern-set-queue-enable \
ksym-64kb-vp-modern-set-queue-reset \
ksym-64kb-vp-modern-set-queue-size \
ksym-64kb-vp-modern-set-status \
ksym-64kb-vp3054-i2c-probe \
ksym-64kb-vp3054-i2c-remove \
ksym-64kb-vpanic \
ksym-64kb-vprintk \
ksym-64kb-vprintk-default \
ksym-64kb-vprintk-emit \
ksym-64kb-vpu-get-plat-device \
ksym-64kb-vpu-get-vdec-hw-capa \
ksym-64kb-vpu-get-venc-hw-capa \
ksym-64kb-vpu-ipi-register \
ksym-64kb-vpu-ipi-send \
ksym-64kb-vpu-load-firmware \
ksym-64kb-vpu-mapping-dm-addr \
ksym-64kb-vpu-wdt-reg-handler \
ksym-64kb-vq-meta-prefetch \
ksym-64kb-vrealloc-node-align-noprof \
ksym-64kb-vring-create-virtqueue \
ksym-64kb-vring-create-virtqueue-map \
ksym-64kb-vring-del-virtqueue \
ksym-64kb-vring-interrupt \
ksym-64kb-vring-new-virtqueue \
ksym-64kb-vring-notification-data \
ksym-64kb-vring-transport-features \
ksym-64kb-vringh-complete-iotlb \
ksym-64kb-vringh-complete-kern \
ksym-64kb-vringh-complete-multi-user \
ksym-64kb-vringh-complete-user \
ksym-64kb-vringh-getdesc-iotlb \
ksym-64kb-vringh-getdesc-kern \
ksym-64kb-vringh-getdesc-user \
ksym-64kb-vringh-init-iotlb \
ksym-64kb-vringh-init-iotlb-va \
ksym-64kb-vringh-init-kern \
ksym-64kb-vringh-init-user \
ksym-64kb-vringh-iov-pull-iotlb \
ksym-64kb-vringh-iov-pull-user \
ksym-64kb-vringh-iov-push-iotlb \
ksym-64kb-vringh-iov-push-user \
ksym-64kb-vringh-kiov-advance \
ksym-64kb-vringh-need-notify-iotlb \
ksym-64kb-vringh-need-notify-kern \
ksym-64kb-vringh-need-notify-user \
ksym-64kb-vringh-notify-disable-kern \
ksym-64kb-vringh-notify-disable-user \
ksym-64kb-vringh-notify-enable-kern \
ksym-64kb-vringh-notify-enable-user \
ksym-64kb-vringh-set-iotlb \
ksym-64kb-vsc73xx-is-addr-valid \
ksym-64kb-vsc73xx-probe \
ksym-64kb-vsc73xx-remove \
ksym-64kb-vsc73xx-shutdown \
ksym-64kb-vsc7514-regfields \
ksym-64kb-vsc7514-regmap \
ksym-64kb-vsc7514-vcap-props \
ksym-64kb-vscnprintf \
ksym-64kb-vsnprintf \
ksym-64kb-vsock-add-pending \
ksym-64kb-vsock-add-tap \
ksym-64kb-vsock-addr-bound \
ksym-64kb-vsock-addr-cast \
ksym-64kb-vsock-addr-equals-addr \
ksym-64kb-vsock-addr-init \
ksym-64kb-vsock-addr-unbind \
ksym-64kb-vsock-addr-validate \
ksym-64kb-vsock-assign-transport \
ksym-64kb-vsock-bind-table \
ksym-64kb-vsock-connected-table \
ksym-64kb-vsock-connectible-has-data \
ksym-64kb-vsock-connectible-recvmsg \
ksym-64kb-vsock-core-get-transport \
ksym-64kb-vsock-core-register \
ksym-64kb-vsock-core-unregister \
ksym-64kb-vsock-create-connected \
ksym-64kb-vsock-data-ready \
ksym-64kb-vsock-deliver-tap \
ksym-64kb-vsock-dgram-recvmsg \
ksym-64kb-vsock-enqueue-accept \
ksym-64kb-vsock-find-bound-socket \
ksym-64kb-vsock-find-bound-socket-net \
ksym-64kb-vsock-find-cid \
ksym-64kb-vsock-find-connected-socket \
ksym-64kb-vsock-find-connected-socket-net \
ksym-64kb-vsock-for-each-connected-socket \
ksym-64kb-vsock-insert-connected \
ksym-64kb-vsock-linger \
ksym-64kb-vsock-pending-to-accept \
ksym-64kb-vsock-remove-bound \
ksym-64kb-vsock-remove-connected \
ksym-64kb-vsock-remove-pending \
ksym-64kb-vsock-remove-sock \
ksym-64kb-vsock-remove-tap \
ksym-64kb-vsock-stream-has-data \
ksym-64kb-vsock-stream-has-space \
ksym-64kb-vsock-table-lock \
ksym-64kb-vsp1-du-atomic-begin \
ksym-64kb-vsp1-du-atomic-flush \
ksym-64kb-vsp1-du-atomic-update \
ksym-64kb-vsp1-du-disable \
ksym-64kb-vsp1-du-enable \
ksym-64kb-vsp1-du-init \
ksym-64kb-vsp1-du-map-sg \
ksym-64kb-vsp1-du-unmap-sg \
ksym-64kb-vsp1-isp-alloc-buffer \
ksym-64kb-vsp1-isp-free-buffer \
ksym-64kb-vsp1-isp-get-bus-master \
ksym-64kb-vsp1-isp-init \
ksym-64kb-vsp1-isp-job-prepare \
ksym-64kb-vsp1-isp-job-release \
ksym-64kb-vsp1-isp-job-run \
ksym-64kb-vsp1-isp-start-streaming \
ksym-64kb-vsp1-isp-stop-streaming \
ksym-64kb-vsprintf \
ksym-64kb-vsscanf \
ksym-64kb-vt-get-leds \
ksym-64kb-vtime-guest-enter \
ksym-64kb-vtime-guest-exit \
ksym-64kb-vunmap \
ksym-64kb-vxlan-dev-create \
ksym-64kb-vxlan-fdb-clear-offload \
ksym-64kb-vxlan-fdb-find-uc \
ksym-64kb-vxlan-fdb-replay \
ksym-64kb-vzalloc-node-noprof \
ksym-64kb-vzalloc-noprof \
ksym-64kb-w1-add-master-device \
ksym-64kb-w1-calc-crc8 \
ksym-64kb-w1-ds2780-eeprom-cmd \
ksym-64kb-w1-ds2780-io \
ksym-64kb-w1-ds2781-eeprom-cmd \
ksym-64kb-w1-ds2781-io \
ksym-64kb-w1-next-pullup \
ksym-64kb-w1-read-8 \
ksym-64kb-w1-read-block \
ksym-64kb-w1-register-family \
ksym-64kb-w1-remove-master-device \
ksym-64kb-w1-reset-bus \
ksym-64kb-w1-reset-resume-command \
ksym-64kb-w1-reset-select-slave \
ksym-64kb-w1-touch-bit \
ksym-64kb-w1-touch-block \
ksym-64kb-w1-triplet \
ksym-64kb-w1-unregister-family \
ksym-64kb-w1-write-8 \
ksym-64kb-w1-write-block \
ksym-64kb-w5100-ops-priv \
ksym-64kb-w5100-pm-ops \
ksym-64kb-w5100-probe \
ksym-64kb-w5100-remove \
ksym-64kb-wait-for-completion \
ksym-64kb-wait-for-completion-interruptible \
ksym-64kb-wait-for-completion-interruptible-timeout \
ksym-64kb-wait-for-completion-io \
ksym-64kb-wait-for-completion-io-timeout \
ksym-64kb-wait-for-completion-killable \
ksym-64kb-wait-for-completion-killable-timeout \
ksym-64kb-wait-for-completion-state \
ksym-64kb-wait-for-completion-timeout \
ksym-64kb-wait-for-device-probe \
ksym-64kb-wait-for-initramfs \
ksym-64kb-wait-for-key-construction \
ksym-64kb-wait-for-random-bytes \
ksym-64kb-wait-on-new-inode \
ksym-64kb-wait-on-page-writeback \
ksym-64kb-wait-woken \
ksym-64kb-wake-bit-function \
ksym-64kb-wake-up-all-idle-cpus \
ksym-64kb-wake-up-bit \
ksym-64kb-wake-up-process \
ksym-64kb-wake-up-var \
ksym-64kb-wakeme-after-rcu \
ksym-64kb-wakeup-source-register \
ksym-64kb-wakeup-source-unregister \
ksym-64kb-wakeup-sources-read-lock \
ksym-64kb-wakeup-sources-read-unlock \
ksym-64kb-wakeup-sources-walk-next \
ksym-64kb-wakeup-sources-walk-start \
ksym-64kb-walk-hmem-resources \
ksym-64kb-walk-iomem-res-desc \
ksym-64kb-walk-soft-reserve-res \
ksym-64kb-watchdog-hardlockup-miss-thresh \
ksym-64kb-watchdog-init-timeout \
ksym-64kb-watchdog-notify-pretimeout \
ksym-64kb-watchdog-register-device \
ksym-64kb-watchdog-register-governor \
ksym-64kb-watchdog-set-last-hw-keepalive \
ksym-64kb-watchdog-set-restart-priority \
ksym-64kb-watchdog-unregister-device \
ksym-64kb-watchdog-unregister-governor \
ksym-64kb-wb-writeout-inc \
ksym-64kb-wbc-account-cgroup-owner \
ksym-64kb-wbc-attach-fdatawrite-inode \
ksym-64kb-wbc-detach-inode \
ksym-64kb-wbt-disable-default \
ksym-64kb-wbt-enable-default \
ksym-64kb-wcd-bus-config \
ksym-64kb-wcd-clsh-ctrl-alloc \
ksym-64kb-wcd-clsh-ctrl-free \
ksym-64kb-wcd-clsh-ctrl-get-state \
ksym-64kb-wcd-clsh-ctrl-set-state \
ksym-64kb-wcd-clsh-set-hph-mode \
ksym-64kb-wcd-dt-parse-mbhc-data \
ksym-64kb-wcd-dt-parse-micbias-info \
ksym-64kb-wcd-get-micb-vout-ctl-val \
ksym-64kb-wcd-interrupt-callback \
ksym-64kb-wcd-mbhc-deinit \
ksym-64kb-wcd-mbhc-event-notify \
ksym-64kb-wcd-mbhc-get-hph-type \
ksym-64kb-wcd-mbhc-get-impedance \
ksym-64kb-wcd-mbhc-init \
ksym-64kb-wcd-mbhc-set-hph-type \
ksym-64kb-wcd-mbhc-start \
ksym-64kb-wcd-mbhc-stop \
ksym-64kb-wcd-mbhc-typec-report-plug \
ksym-64kb-wcd-mbhc-typec-report-unplug \
ksym-64kb-wcd-sdw-component-ops \
ksym-64kb-wcd-update-status \
ksym-64kb-wcd938x-sdw-free \
ksym-64kb-wcd938x-sdw-hw-params \
ksym-64kb-wcd938x-sdw-set-sdw-stream \
ksym-64kb-wcd939x-sdw-free \
ksym-64kb-wcd939x-sdw-hw-params \
ksym-64kb-wcd939x-sdw-set-sdw-stream \
ksym-64kb-wdev-chandef \
ksym-64kb-wdev-to-ieee80211-vif \
ksym-64kb-widget-in-list \
ksym-64kb-wiphy-apply-custom-regulatory \
ksym-64kb-wiphy-delayed-work-cancel \
ksym-64kb-wiphy-delayed-work-flush \
ksym-64kb-wiphy-delayed-work-pending \
ksym-64kb-wiphy-delayed-work-queue \
ksym-64kb-wiphy-delayed-work-timer \
ksym-64kb-wiphy-free \
ksym-64kb-wiphy-hrtimer-work-cancel \
ksym-64kb-wiphy-hrtimer-work-flush \
ksym-64kb-wiphy-hrtimer-work-pending \
ksym-64kb-wiphy-hrtimer-work-queue \
ksym-64kb-wiphy-hrtimer-work-timer \
ksym-64kb-wiphy-new-nm \
ksym-64kb-wiphy-read-of-freq-limits \
ksym-64kb-wiphy-register \
ksym-64kb-wiphy-rfkill-set-hw-state-reason \
ksym-64kb-wiphy-rfkill-start-polling \
ksym-64kb-wiphy-to-ieee80211-hw \
ksym-64kb-wiphy-unregister \
ksym-64kb-wiphy-work-cancel \
ksym-64kb-wiphy-work-flush \
ksym-64kb-wiphy-work-queue \
ksym-64kb-wireless-nlevent-flush \
ksym-64kb-wireless-send-event \
ksym-64kb-wl1251-alloc-hw \
ksym-64kb-wl1251-free-hw \
ksym-64kb-wl1251-init-ieee80211 \
ksym-64kb-wl1271-acx-init-mem-config \
ksym-64kb-wl1271-acx-pm-config \
ksym-64kb-wl1271-acx-set-ht-capabilities \
ksym-64kb-wl1271-acx-sleep-auth \
ksym-64kb-wl1271-cmd-configure \
ksym-64kb-wl1271-cmd-data-path \
ksym-64kb-wl1271-cmd-send \
ksym-64kb-wl1271-cmd-test \
ksym-64kb-wl1271-debugfs-update-stats \
ksym-64kb-wl1271-format-buffer \
ksym-64kb-wl1271-free-tx-id \
ksym-64kb-wl1271-tx-flush \
ksym-64kb-wl1271-tx-min-rate-get \
ksym-64kb-wl12xx-acx-mem-cfg \
ksym-64kb-wl12xx-cmd-build-probe-req \
ksym-64kb-wl12xx-debug-level \
ksym-64kb-wl12xx-is-dummy-packet \
ksym-64kb-wlcore-alloc-hw \
ksym-64kb-wlcore-boot-run-firmware \
ksym-64kb-wlcore-boot-upload-firmware \
ksym-64kb-wlcore-boot-upload-nvs \
ksym-64kb-wlcore-calc-packet-alignment \
ksym-64kb-wlcore-cmd-generic-cfg \
ksym-64kb-wlcore-cmd-wait-for-event-or-timeout \
ksym-64kb-wlcore-disable-interrupts \
ksym-64kb-wlcore-disable-interrupts-nosync \
ksym-64kb-wlcore-enable-interrupts \
ksym-64kb-wlcore-event-ba-rx-constraint \
ksym-64kb-wlcore-event-beacon-loss \
ksym-64kb-wlcore-event-channel-switch \
ksym-64kb-wlcore-event-dummy-packet \
ksym-64kb-wlcore-event-fw-logger \
ksym-64kb-wlcore-event-inactive-sta \
ksym-64kb-wlcore-event-max-tx-failure \
ksym-64kb-wlcore-event-roc-complete \
ksym-64kb-wlcore-event-rssi-trigger \
ksym-64kb-wlcore-event-sched-scan-completed \
ksym-64kb-wlcore-event-soft-gemini-sense \
ksym-64kb-wlcore-free-hw \
ksym-64kb-wlcore-get-native-channel-type \
ksym-64kb-wlcore-probe \
ksym-64kb-wlcore-remove \
ksym-64kb-wlcore-scan-sched-scan-results \
ksym-64kb-wlcore-scan-sched-scan-ssid-list \
ksym-64kb-wlcore-set-key \
ksym-64kb-wlcore-set-partition \
ksym-64kb-wlcore-set-scan-chan-params \
ksym-64kb-wlcore-synchronize-interrupts \
ksym-64kb-wlcore-translate-addr \
ksym-64kb-wlcore-tx-complete \
ksym-64kb-wm-adsp-compr-copy \
ksym-64kb-wm-adsp-compr-free \
ksym-64kb-wm-adsp-compr-get-caps \
ksym-64kb-wm-adsp-compr-handle-irq \
ksym-64kb-wm-adsp-compr-open \
ksym-64kb-wm-adsp-compr-pointer \
ksym-64kb-wm-adsp-compr-set-params \
ksym-64kb-wm-adsp-compr-trigger \
ksym-64kb-wm-adsp-control-add \
ksym-64kb-wm-adsp-early-event \
ksym-64kb-wm-adsp-event \
ksym-64kb-wm-adsp-fw-enum \
ksym-64kb-wm-adsp-fw-get \
ksym-64kb-wm-adsp-fw-put \
ksym-64kb-wm-adsp-hibernate \
ksym-64kb-wm-adsp-power-down \
ksym-64kb-wm-adsp-power-up \
ksym-64kb-wm-adsp-read-ctl \
ksym-64kb-wm-adsp-run \
ksym-64kb-wm-adsp-stop \
ksym-64kb-wm-adsp-write-ctl \
ksym-64kb-wm-adsp1-event \
ksym-64kb-wm-adsp1-init \
ksym-64kb-wm-adsp2-bus-error \
ksym-64kb-wm-adsp2-component-probe \
ksym-64kb-wm-adsp2-component-remove \
ksym-64kb-wm-adsp2-init \
ksym-64kb-wm-adsp2-preloader-get \
ksym-64kb-wm-adsp2-preloader-put \
ksym-64kb-wm-adsp2-remove \
ksym-64kb-wm-adsp2-set-dspclk \
ksym-64kb-wm-halo-bus-error \
ksym-64kb-wm-halo-init \
ksym-64kb-wm-halo-wdt-expire \
ksym-64kb-wm-hubs-add-analogue-controls \
ksym-64kb-wm-hubs-add-analogue-routes \
ksym-64kb-wm-hubs-dcs-done \
ksym-64kb-wm-hubs-handle-analogue-pdata \
ksym-64kb-wm-hubs-hpl-mux \
ksym-64kb-wm-hubs-hpr-mux \
ksym-64kb-wm-hubs-set-bias-level \
ksym-64kb-wm-hubs-spkmix-tlv \
ksym-64kb-wm-hubs-update-class-w \
ksym-64kb-wm-hubs-vmid-ena \
ksym-64kb-wm1811-regmap-config \
ksym-64kb-wm8804-pm \
ksym-64kb-wm8804-probe \
ksym-64kb-wm8804-regmap-config \
ksym-64kb-wm8804-remove \
ksym-64kb-wm8903-mic-detect \
ksym-64kb-wm8958-mic-detect \
ksym-64kb-wm8958-regmap-config \
ksym-64kb-wm8962-mic-detect \
ksym-64kb-wm8994-base-regmap-config \
ksym-64kb-wm8994-irq-exit \
ksym-64kb-wm8994-irq-init \
ksym-64kb-wm8994-mic-detect \
ksym-64kb-wm8994-regmap-config \
ksym-64kb-wm9705-codec \
ksym-64kb-wm9712-codec \
ksym-64kb-wm9713-codec \
ksym-64kb-wm97xx-config-gpio \
ksym-64kb-wm97xx-get-gpio \
ksym-64kb-wm97xx-read-aux-adc \
ksym-64kb-wm97xx-reg-read \
ksym-64kb-wm97xx-reg-write \
ksym-64kb-wm97xx-register-mach-ops \
ksym-64kb-wm97xx-set-gpio \
ksym-64kb-wm97xx-set-suspend-mode \
ksym-64kb-wm97xx-unregister-mach-ops \
ksym-64kb-woken-wake-bit-function \
ksym-64kb-woken-wake-function \
ksym-64kb-work-busy \
ksym-64kb-work-on-cpu-key \
ksym-64kb-workqueue-congested \
ksym-64kb-workqueue-set-max-active \
ksym-64kb-would-dump \
ksym-64kb-wp-shared-mapping-range \
ksym-64kb-wpan-phy-find \
ksym-64kb-wpan-phy-for-each \
ksym-64kb-wpan-phy-free \
ksym-64kb-wpan-phy-new \
ksym-64kb-wpan-phy-register \
ksym-64kb-wpan-phy-unregister \
ksym-64kb-wrap-directory-iterator \
ksym-64kb-write-bytes-to-xdr-buf \
ksym-64kb-write-dirty-buffer \
ksym-64kb-write-dst \
ksym-64kb-write-inode-now \
ksym-64kb-writeback-inodes-sb \
ksym-64kb-writeback-inodes-sb-nr \
ksym-64kb-writeback-iter \
ksym-64kb-wsa-macro-set-spkr-mode \
ksym-64kb-ww-mutex-lock \
ksym-64kb-ww-mutex-lock-interruptible \
ksym-64kb-ww-mutex-trylock \
ksym-64kb-ww-mutex-unlock \
ksym-64kb-wwan-create-port \
ksym-64kb-wwan-port-get-drvdata \
ksym-64kb-wwan-port-rx \
ksym-64kb-wwan-port-txoff \
ksym-64kb-wwan-port-txon \
ksym-64kb-wwan-register-ops \
ksym-64kb-wwan-remove-port \
ksym-64kb-wwan-unregister-ops \
ksym-64kb-wx-change-mtu \
ksym-64kb-wx-check-flash-load \
ksym-64kb-wx-clean-all-rx-rings \
ksym-64kb-wx-clean-all-tx-rings \
ksym-64kb-wx-clear-hw-cntrs \
ksym-64kb-wx-clear-interrupt-scheme \
ksym-64kb-wx-configure \
ksym-64kb-wx-configure-rx \
ksym-64kb-wx-configure-vectors \
ksym-64kb-wx-configure-vf \
ksym-64kb-wx-control-hw \
ksym-64kb-wx-decode-ptype \
ksym-64kb-wx-disable-pcie-master \
ksym-64kb-wx-disable-rx \
ksym-64kb-wx-disable-rx-queue \
ksym-64kb-wx-disable-sec-rx-path \
ksym-64kb-wx-disable-sriov \
ksym-64kb-wx-disable-vf-rx-tx \
ksym-64kb-wx-enable-rx-queue \
ksym-64kb-wx-enable-sec-rx-path \
ksym-64kb-wx-fc-enable \
ksym-64kb-wx-features-check \
ksym-64kb-wx-fix-features \
ksym-64kb-wx-flush-sw-mac-table \
ksym-64kb-wx-free-irq \
ksym-64kb-wx-free-isb-resources \
ksym-64kb-wx-free-resources \
ksym-64kb-wx-get-channels \
ksym-64kb-wx-get-coalesce \
ksym-64kb-wx-get-drvinfo \
ksym-64kb-wx-get-ethtool-stats \
ksym-64kb-wx-get-fw-version-vf \
ksym-64kb-wx-get-link-ksettings \
ksym-64kb-wx-get-link-state-vf \
ksym-64kb-wx-get-mac-addr \
ksym-64kb-wx-get-mac-addr-vf \
ksym-64kb-wx-get-mac-stats \
ksym-64kb-wx-get-msglevel \
ksym-64kb-wx-get-pause-stats \
ksym-64kb-wx-get-pauseparam \
ksym-64kb-wx-get-pcie-msix-counts \
ksym-64kb-wx-get-ptp-stats \
ksym-64kb-wx-get-queues-vf \
ksym-64kb-wx-get-ringparam \
ksym-64kb-wx-get-rxfh \
ksym-64kb-wx-get-rxfh-fields \
ksym-64kb-wx-get-rxfh-key-size \
ksym-64kb-wx-get-sset-count \
ksym-64kb-wx-get-stats64 \
ksym-64kb-wx-get-strings \
ksym-64kb-wx-get-ts-info \
ksym-64kb-wx-get-wol \
ksym-64kb-wx-host-interface-command \
ksym-64kb-wx-hwtstamp-get \
ksym-64kb-wx-hwtstamp-set \
ksym-64kb-wx-init-eeprom-params \
ksym-64kb-wx-init-hw-vf \
ksym-64kb-wx-init-interrupt-scheme \
ksym-64kb-wx-init-mbx-params-vf \
ksym-64kb-wx-init-rx-addrs \
ksym-64kb-wx-intr-enable \
ksym-64kb-wx-irq-disable \
ksym-64kb-wx-mac-set-default-filter \
ksym-64kb-wx-misc-isb \
ksym-64kb-wx-mng-present \
ksym-64kb-wx-msg-task \
ksym-64kb-wx-msix-clean-rings \
ksym-64kb-wx-napi-disable-all \
ksym-64kb-wx-napi-enable-all \
ksym-64kb-wx-negotiate-api-version \
ksym-64kb-wx-negotiate-api-vf \
ksym-64kb-wx-nway-reset \
ksym-64kb-wx-pci-sriov-configure \
ksym-64kb-wx-phy-read-reg-mdi-c22 \
ksym-64kb-wx-phy-read-reg-mdi-c45 \
ksym-64kb-wx-phy-write-reg-mdi-c22 \
ksym-64kb-wx-phy-write-reg-mdi-c45 \
ksym-64kb-wx-ping-all-vfs-with-link-status \
ksym-64kb-wx-ptp-check-pps-event \
ksym-64kb-wx-ptp-init \
ksym-64kb-wx-ptp-reset \
ksym-64kb-wx-ptp-reset-cyclecounter \
ksym-64kb-wx-ptp-stop \
ksym-64kb-wx-ptp-suspend \
ksym-64kb-wx-read-ee-hostif \
ksym-64kb-wx-read-ee-hostif-buffer \
ksym-64kb-wx-request-msix-irqs-vf \
ksym-64kb-wx-reset-hw-vf \
ksym-64kb-wx-reset-interrupt-capability \
ksym-64kb-wx-reset-mac \
ksym-64kb-wx-reset-misc \
ksym-64kb-wx-reset-vf \
ksym-64kb-wx-rlpml-set-vf \
ksym-64kb-wx-rss-indir-size \
ksym-64kb-wx-service-event-complete \
ksym-64kb-wx-service-event-schedule \
ksym-64kb-wx-service-timer \
ksym-64kb-wx-set-all-vfs \
ksym-64kb-wx-set-channels \
ksym-64kb-wx-set-coalesce \
ksym-64kb-wx-set-ethtool-ops-vf \
ksym-64kb-wx-set-features \
ksym-64kb-wx-set-link-ksettings \
ksym-64kb-wx-set-mac \
ksym-64kb-wx-set-mac-vf \
ksym-64kb-wx-set-msglevel \
ksym-64kb-wx-set-pauseparam \
ksym-64kb-wx-set-rar-vf \
ksym-64kb-wx-set-ring \
ksym-64kb-wx-set-rx-mode \
ksym-64kb-wx-set-rx-mode-vf \
ksym-64kb-wx-set-rxfh \
ksym-64kb-wx-set-rxfh-fields \
ksym-64kb-wx-set-uc-addr-vf \
ksym-64kb-wx-set-vfta-vf \
ksym-64kb-wx-set-wol \
ksym-64kb-wx-setup-isb-resources \
ksym-64kb-wx-setup-resources \
ksym-64kb-wx-start-hw \
ksym-64kb-wx-stop-adapter \
ksym-64kb-wx-stop-adapter-vf \
ksym-64kb-wx-sw-init \
ksym-64kb-wx-update-mc-addr-list-vf \
ksym-64kb-wx-update-stats \
ksym-64kb-wx-update-xcast-mode-vf \
ksym-64kb-wx-vlan-rx-add-vid \
ksym-64kb-wx-vlan-rx-kill-vid \
ksym-64kb-wx-xmit-frame \
ksym-64kb-wxvf-close \
ksym-64kb-wxvf-init-service \
ksym-64kb-wxvf-open \
ksym-64kb-wxvf-remove \
ksym-64kb-wxvf-resume \
ksym-64kb-wxvf-shutdown \
ksym-64kb-wxvf-suspend \
ksym-64kb-wxvf-watchdog-update-link \
ksym-64kb-x509-cert-parse \
ksym-64kb-x509-decode-time \
ksym-64kb-x509-free-certificate \
ksym-64kb-x509-load-certificate-list \
ksym-64kb-xa-clear-mark \
ksym-64kb-xa-delete-node \
ksym-64kb-xa-destroy \
ksym-64kb-xa-erase \
ksym-64kb-xa-extract \
ksym-64kb-xa-find \
ksym-64kb-xa-find-after \
ksym-64kb-xa-get-mark \
ksym-64kb-xa-get-order \
ksym-64kb-xa-load \
ksym-64kb-xa-set-mark \
ksym-64kb-xa-store \
ksym-64kb-xa-store-range \
ksym-64kb-xas-clear-mark \
ksym-64kb-xas-create-range \
ksym-64kb-xas-destroy \
ksym-64kb-xas-find \
ksym-64kb-xas-find-conflict \
ksym-64kb-xas-find-marked \
ksym-64kb-xas-get-mark \
ksym-64kb-xas-get-order \
ksym-64kb-xas-init-marks \
ksym-64kb-xas-load \
ksym-64kb-xas-nomem \
ksym-64kb-xas-pause \
ksym-64kb-xas-set-mark \
ksym-64kb-xas-split \
ksym-64kb-xas-split-alloc \
ksym-64kb-xas-store \
ksym-64kb-xas-try-split \
ksym-64kb-xas-try-split-min-order \
ksym-64kb-xattr-full-name \
ksym-64kb-xattr-supports-user-prefix \
ksym-64kb-xc2028-attach \
ksym-64kb-xc4000-attach \
ksym-64kb-xc5000-attach \
ksym-64kb-xchacha20poly1305-decrypt \
ksym-64kb-xchacha20poly1305-encrypt \
ksym-64kb-xcv-init-hw \
ksym-64kb-xcv-setup-link \
ksym-64kb-xdma-disable-user-irq \
ksym-64kb-xdma-enable-user-irq \
ksym-64kb-xdma-get-user-irq \
ksym-64kb-xdp-attachment-setup \
ksym-64kb-xdp-build-skb-from-buff \
ksym-64kb-xdp-build-skb-from-frame \
ksym-64kb-xdp-build-skb-from-zc \
ksym-64kb-xdp-convert-zc-to-xdp-frame \
ksym-64kb-xdp-do-flush \
ksym-64kb-xdp-do-redirect \
ksym-64kb-xdp-do-redirect-frame \
ksym-64kb-xdp-features-clear-redirect-target \
ksym-64kb-xdp-features-clear-redirect-target-locked \
ksym-64kb-xdp-features-set-redirect-target \
ksym-64kb-xdp-features-set-redirect-target-locked \
ksym-64kb-xdp-master-redirect \
ksym-64kb-xdp-reg-mem-model \
ksym-64kb-xdp-reg-page-pool \
ksym-64kb-xdp-return-buff \
ksym-64kb-xdp-return-frag \
ksym-64kb-xdp-return-frame \
ksym-64kb-xdp-return-frame-bulk \
ksym-64kb-xdp-return-frame-rx-napi \
ksym-64kb-xdp-rxq-info-attach-page-pool \
ksym-64kb-xdp-rxq-info-is-reg \
ksym-64kb-xdp-rxq-info-reg-mem-model \
ksym-64kb-xdp-rxq-info-unreg \
ksym-64kb-xdp-rxq-info-unreg-mem-model \
ksym-64kb-xdp-rxq-info-unused \
ksym-64kb-xdp-set-features-flag \
ksym-64kb-xdp-set-features-flag-locked \
ksym-64kb-xdp-unreg-mem-model \
ksym-64kb-xdp-unreg-page-pool \
ksym-64kb-xdp-warn \
ksym-64kb-xdr-buf-from-iov \
ksym-64kb-xdr-buf-subsegment \
ksym-64kb-xdr-buf-to-bvec \
ksym-64kb-xdr-buf-to-sg \
ksym-64kb-xdr-buf-to-sg-alloc \
ksym-64kb-xdr-buf-trim \
ksym-64kb-xdr-decode-array2 \
ksym-64kb-xdr-decode-word \
ksym-64kb-xdr-encode-array2 \
ksym-64kb-xdr-encode-netobj \
ksym-64kb-xdr-encode-opaque \
ksym-64kb-xdr-encode-opaque-fixed \
ksym-64kb-xdr-encode-string \
ksym-64kb-xdr-encode-word \
ksym-64kb-xdr-enter-page \
ksym-64kb-xdr-finish-decode \
ksym-64kb-xdr-init-decode \
ksym-64kb-xdr-init-decode-pages \
ksym-64kb-xdr-init-encode \
ksym-64kb-xdr-init-encode-pages \
ksym-64kb-xdr-inline-decode \
ksym-64kb-xdr-inline-pages \
ksym-64kb-xdr-page-pos \
ksym-64kb-xdr-read-pages \
ksym-64kb-xdr-reserve-space \
ksym-64kb-xdr-reserve-space-vec \
ksym-64kb-xdr-restrict-buflen \
ksym-64kb-xdr-set-pagelen \
ksym-64kb-xdr-stream-decode-opaque-auth \
ksym-64kb-xdr-stream-decode-string-dup \
ksym-64kb-xdr-stream-encode-opaque-auth \
ksym-64kb-xdr-stream-move-subsegment \
ksym-64kb-xdr-stream-pos \
ksym-64kb-xdr-stream-subsegment \
ksym-64kb-xdr-stream-zero \
ksym-64kb-xdr-terminate-string \
ksym-64kb-xdr-truncate-decode \
ksym-64kb-xdr-truncate-encode \
ksym-64kb-xdr-write-pages \
ksym-64kb-xfer-to-guest-mode-handle-work \
ksym-64kb-xfrm-aalg-get-byid \
ksym-64kb-xfrm-aalg-get-byidx \
ksym-64kb-xfrm-aalg-get-byname \
ksym-64kb-xfrm-aead-get-byname \
ksym-64kb-xfrm-alloc-spi \
ksym-64kb-xfrm-audit-policy-add \
ksym-64kb-xfrm-audit-policy-delete \
ksym-64kb-xfrm-audit-state-add \
ksym-64kb-xfrm-audit-state-delete \
ksym-64kb-xfrm-audit-state-icvfail \
ksym-64kb-xfrm-audit-state-notfound \
ksym-64kb-xfrm-audit-state-notfound-simple \
ksym-64kb-xfrm-audit-state-replay \
ksym-64kb-xfrm-audit-state-replay-overflow \
ksym-64kb-xfrm-bpf-md-dst \
ksym-64kb-xfrm-calg-get-byid \
ksym-64kb-xfrm-calg-get-byname \
ksym-64kb-xfrm-count-pfkey-auth-supported \
ksym-64kb-xfrm-count-pfkey-enc-supported \
ksym-64kb-xfrm-dev-offload-ok \
ksym-64kb-xfrm-dev-policy-add \
ksym-64kb-xfrm-dev-policy-flush \
ksym-64kb-xfrm-dev-resume \
ksym-64kb-xfrm-dev-state-add \
ksym-64kb-xfrm-dev-state-delete \
ksym-64kb-xfrm-dev-state-flush \
ksym-64kb-xfrm-dst-ifdown \
ksym-64kb-xfrm-ealg-get-byid \
ksym-64kb-xfrm-ealg-get-byidx \
ksym-64kb-xfrm-ealg-get-byname \
ksym-64kb-xfrm-find-acq \
ksym-64kb-xfrm-find-acq-byseq \
ksym-64kb-xfrm-flush-gc \
ksym-64kb-xfrm-get-acqseq \
ksym-64kb-xfrm-if-register-cb \
ksym-64kb-xfrm-if-unregister-cb \
ksym-64kb-xfrm-init-replay \
ksym-64kb-xfrm-init-state \
ksym-64kb-xfrm-input \
ksym-64kb-xfrm-input-register-afinfo \
ksym-64kb-xfrm-input-resume \
ksym-64kb-xfrm-input-state-lookup \
ksym-64kb-xfrm-input-unregister-afinfo \
ksym-64kb-xfrm-local-error \
ksym-64kb-xfrm-lookup \
ksym-64kb-xfrm-lookup-route \
ksym-64kb-xfrm-lookup-with-ifid \
ksym-64kb-xfrm-migrate \
ksym-64kb-xfrm-migrate-state-find \
ksym-64kb-xfrm-msg-min \
ksym-64kb-xfrm-nat-keepalive-fini \
ksym-64kb-xfrm-nat-keepalive-init \
ksym-64kb-xfrm-output \
ksym-64kb-xfrm-output-resume \
ksym-64kb-xfrm-parse-spi \
ksym-64kb-xfrm-policy-alloc \
ksym-64kb-xfrm-policy-byid \
ksym-64kb-xfrm-policy-bysel-ctx \
ksym-64kb-xfrm-policy-delete \
ksym-64kb-xfrm-policy-destroy \
ksym-64kb-xfrm-policy-flush \
ksym-64kb-xfrm-policy-hash-rebuild \
ksym-64kb-xfrm-policy-insert \
ksym-64kb-xfrm-policy-register-afinfo \
ksym-64kb-xfrm-policy-unregister-afinfo \
ksym-64kb-xfrm-policy-walk \
ksym-64kb-xfrm-policy-walk-done \
ksym-64kb-xfrm-policy-walk-init \
ksym-64kb-xfrm-probe-algs \
ksym-64kb-xfrm-register-km \
ksym-64kb-xfrm-register-mode-cbs \
ksym-64kb-xfrm-register-type \
ksym-64kb-xfrm-register-type-offload \
ksym-64kb-xfrm-replay-seqhi \
ksym-64kb-xfrm-sad-getinfo \
ksym-64kb-xfrm-set-type-offload \
ksym-64kb-xfrm-spd-getinfo \
ksym-64kb-xfrm-state-add \
ksym-64kb-xfrm-state-afinfo-get-rcu \
ksym-64kb-xfrm-state-alloc \
ksym-64kb-xfrm-state-check-expire \
ksym-64kb-xfrm-state-delete \
ksym-64kb-xfrm-state-flush \
ksym-64kb-xfrm-state-free \
ksym-64kb-xfrm-state-insert \
ksym-64kb-xfrm-state-lookup \
ksym-64kb-xfrm-state-lookup-byaddr \
ksym-64kb-xfrm-state-lookup-byspi \
ksym-64kb-xfrm-state-migrate \
ksym-64kb-xfrm-state-migrate-create \
ksym-64kb-xfrm-state-migrate-install \
ksym-64kb-xfrm-state-mtu \
ksym-64kb-xfrm-state-register-afinfo \
ksym-64kb-xfrm-state-unregister-afinfo \
ksym-64kb-xfrm-state-update \
ksym-64kb-xfrm-state-walk \
ksym-64kb-xfrm-state-walk-done \
ksym-64kb-xfrm-state-walk-init \
ksym-64kb-xfrm-stateonly-find \
ksym-64kb-xfrm-trans-queue \
ksym-64kb-xfrm-trans-queue-net \
ksym-64kb-xfrm-unregister-km \
ksym-64kb-xfrm-unregister-mode-cbs \
ksym-64kb-xfrm-unregister-type \
ksym-64kb-xfrm-unregister-type-offload \
ksym-64kb-xfrm-user-policy \
ksym-64kb-xfrm4-gro-udp-encap-rcv \
ksym-64kb-xfrm4-protocol-deregister \
ksym-64kb-xfrm4-protocol-register \
ksym-64kb-xfrm4-rcv \
ksym-64kb-xfrm4-rcv-encap \
ksym-64kb-xfrm4-tunnel-check-size \
ksym-64kb-xfrm4-tunnel-deregister \
ksym-64kb-xfrm4-tunnel-register \
ksym-64kb-xfrm4-udp-encap-rcv \
ksym-64kb-xfrm6-input-addr \
ksym-64kb-xfrm6-protocol-deregister \
ksym-64kb-xfrm6-protocol-register \
ksym-64kb-xfrm6-rcv \
ksym-64kb-xfrm6-rcv-encap \
ksym-64kb-xfrm6-rcv-spi \
ksym-64kb-xfrm6-rcv-tnl \
ksym-64kb-xfrm6-tunnel-alloc-spi \
ksym-64kb-xfrm6-tunnel-check-size \
ksym-64kb-xfrm6-tunnel-deregister \
ksym-64kb-xfrm6-tunnel-register \
ksym-64kb-xfrm6-tunnel-spi-lookup \
ksym-64kb-xfrma-policy \
ksym-64kb-xgene-enet-phy-register \
ksym-64kb-xgene-mdio-rd-mac \
ksym-64kb-xgene-mdio-rgmii-read \
ksym-64kb-xgene-mdio-rgmii-write \
ksym-64kb-xgene-mdio-wr-mac \
ksym-64kb-xhci-add-endpoint \
ksym-64kb-xhci-check-bandwidth \
ksym-64kb-xhci-create-secondary-interrupter \
ksym-64kb-xhci-dbg-trace \
ksym-64kb-xhci-drop-endpoint \
ksym-64kb-xhci-ext-cap-init \
ksym-64kb-xhci-gen-setup \
ksym-64kb-xhci-get-endpoint-index \
ksym-64kb-xhci-get-ep-ctx \
ksym-64kb-xhci-hub-control \
ksym-64kb-xhci-init-driver \
ksym-64kb-xhci-initialize-ring-info \
ksym-64kb-xhci-msi-irq \
ksym-64kb-xhci-pci-common-probe \
ksym-64kb-xhci-pci-remove \
ksym-64kb-xhci-plat-pm-ops \
ksym-64kb-xhci-plat-probe \
ksym-64kb-xhci-plat-remove \
ksym-64kb-xhci-port-state-to-neutral \
ksym-64kb-xhci-portsc-readl \
ksym-64kb-xhci-portsc-writel \
ksym-64kb-xhci-remove-secondary-interrupter \
ksym-64kb-xhci-reset-bandwidth \
ksym-64kb-xhci-resume \
ksym-64kb-xhci-run \
ksym-64kb-xhci-shutdown \
ksym-64kb-xhci-sideband-add-endpoint \
ksym-64kb-xhci-sideband-check \
ksym-64kb-xhci-sideband-create-interrupter \
ksym-64kb-xhci-sideband-get-endpoint-buffer \
ksym-64kb-xhci-sideband-get-event-buffer \
ksym-64kb-xhci-sideband-interrupter-id \
ksym-64kb-xhci-sideband-notify-ep-ring-free \
ksym-64kb-xhci-sideband-register \
ksym-64kb-xhci-sideband-remove-endpoint \
ksym-64kb-xhci-sideband-remove-interrupter \
ksym-64kb-xhci-sideband-stop-endpoint \
ksym-64kb-xhci-sideband-unregister \
ksym-64kb-xhci-stop \
ksym-64kb-xhci-stop-endpoint-sync \
ksym-64kb-xhci-suspend \
ksym-64kb-xhci-update-hub-device \
ksym-64kb-xilinx-core-probe \
ksym-64kb-xilinx-vdma-channel-set-config \
ksym-64kb-xillybus-cleanup-chrdev \
ksym-64kb-xillybus-endpoint-discovery \
ksym-64kb-xillybus-endpoint-remove \
ksym-64kb-xillybus-find-inode \
ksym-64kb-xillybus-init-chrdev \
ksym-64kb-xillybus-init-endpoint \
ksym-64kb-xillybus-isr \
ksym-64kb-xlnx-get-crypto-dev-data \
ksym-64kb-xlnx-register-event \
ksym-64kb-xlnx-unregister-event \
ksym-64kb-xor-gen \
ksym-64kb-xp-alloc \
ksym-64kb-xp-alloc-batch \
ksym-64kb-xp-can-alloc \
ksym-64kb-xp-dma-map \
ksym-64kb-xp-dma-unmap \
ksym-64kb-xp-fill-cb \
ksym-64kb-xp-free \
ksym-64kb-xp-raw-get-ctx \
ksym-64kb-xp-raw-get-data \
ksym-64kb-xp-raw-get-dma \
ksym-64kb-xp-set-rxq-info \
ksym-64kb-xpcs-config-eee-mult-fact \
ksym-64kb-xpcs-create-fwnode \
ksym-64kb-xpcs-create-mdiodev \
ksym-64kb-xpcs-create-pcs-mdiodev \
ksym-64kb-xpcs-destroy \
ksym-64kb-xpcs-destroy-pcs \
ksym-64kb-xpcs-get-an-mode \
ksym-64kb-xpcs-to-phylink-pcs \
ksym-64kb-xprt-add-backlog \
ksym-64kb-xprt-add-backlog-noncongested \
ksym-64kb-xprt-adjust-cwnd \
ksym-64kb-xprt-alloc \
ksym-64kb-xprt-alloc-slot \
ksym-64kb-xprt-complete-rqst \
ksym-64kb-xprt-destroy-backchannel \
ksym-64kb-xprt-disconnect-done \
ksym-64kb-xprt-enqueue-bc-request \
ksym-64kb-xprt-find-transport-ident \
ksym-64kb-xprt-force-disconnect \
ksym-64kb-xprt-free \
ksym-64kb-xprt-free-slot \
ksym-64kb-xprt-get \
ksym-64kb-xprt-lock-connect \
ksym-64kb-xprt-lookup-rqst \
ksym-64kb-xprt-pin-rqst \
ksym-64kb-xprt-put \
ksym-64kb-xprt-reconnect-backoff \
ksym-64kb-xprt-reconnect-delay \
ksym-64kb-xprt-register-transport \
ksym-64kb-xprt-release-rqst-cong \
ksym-64kb-xprt-release-xprt \
ksym-64kb-xprt-release-xprt-cong \
ksym-64kb-xprt-request-get-cong \
ksym-64kb-xprt-reserve-xprt \
ksym-64kb-xprt-reserve-xprt-cong \
ksym-64kb-xprt-setup-backchannel \
ksym-64kb-xprt-svc-destroy-nullify-bc \
ksym-64kb-xprt-svc-shutdown-bc \
ksym-64kb-xprt-unlock-connect \
ksym-64kb-xprt-unpin-rqst \
ksym-64kb-xprt-unregister-transport \
ksym-64kb-xprt-update-rtt \
ksym-64kb-xprt-wait-for-buffer-space \
ksym-64kb-xprt-wait-for-reply-request-def \
ksym-64kb-xprt-wait-for-reply-request-rtt \
ksym-64kb-xprt-wake-pending-tasks \
ksym-64kb-xprt-wake-up-backlog \
ksym-64kb-xprt-write-space \
ksym-64kb-xprtiod-workqueue \
ksym-64kb-xrs7003e-info \
ksym-64kb-xrs7003f-info \
ksym-64kb-xrs7004e-info \
ksym-64kb-xrs7004f-info \
ksym-64kb-xrs700x-switch-alloc \
ksym-64kb-xrs700x-switch-register \
ksym-64kb-xrs700x-switch-remove \
ksym-64kb-xrs700x-switch-shutdown \
ksym-64kb-xsk-clear-rx-need-wakeup \
ksym-64kb-xsk-clear-tx-need-wakeup \
ksym-64kb-xsk-get-pool-from-qid \
ksym-64kb-xsk-set-rx-need-wakeup \
ksym-64kb-xsk-set-tx-need-wakeup \
ksym-64kb-xsk-tx-completed \
ksym-64kb-xsk-tx-peek-desc \
ksym-64kb-xsk-tx-peek-release-desc-batch \
ksym-64kb-xsk-tx-release \
ksym-64kb-xsk-uses-need-wakeup \
ksym-64kb-xspi-dirmap-write \
ksym-64kb-xt-alloc-entry-offsets \
ksym-64kb-xt-alloc-table-info \
ksym-64kb-xt-check-entry-offsets \
ksym-64kb-xt-check-hooks-match \
ksym-64kb-xt-check-hooks-target \
ksym-64kb-xt-check-match \
ksym-64kb-xt-check-proc-name \
ksym-64kb-xt-check-table-hooks \
ksym-64kb-xt-check-target \
ksym-64kb-xt-compat-add-offset \
ksym-64kb-xt-compat-calc-jump \
ksym-64kb-xt-compat-check-entry-offsets \
ksym-64kb-xt-compat-flush-offsets \
ksym-64kb-xt-compat-init-offsets \
ksym-64kb-xt-compat-lock \
ksym-64kb-xt-compat-match-from-user \
ksym-64kb-xt-compat-match-offset \
ksym-64kb-xt-compat-match-to-user \
ksym-64kb-xt-compat-target-from-user \
ksym-64kb-xt-compat-target-offset \
ksym-64kb-xt-compat-target-to-user \
ksym-64kb-xt-compat-unlock \
ksym-64kb-xt-copy-counters \
ksym-64kb-xt-counters-alloc \
ksym-64kb-xt-data-to-user \
ksym-64kb-xt-find-jump-offset \
ksym-64kb-xt-find-match \
ksym-64kb-xt-find-revision \
ksym-64kb-xt-find-table \
ksym-64kb-xt-find-table-lock \
ksym-64kb-xt-free-table-info \
ksym-64kb-xt-hook-ops-alloc \
ksym-64kb-xt-match-to-user \
ksym-64kb-xt-percpu-counter-alloc \
ksym-64kb-xt-percpu-counter-free \
ksym-64kb-xt-proto-fini \
ksym-64kb-xt-proto-init \
ksym-64kb-xt-rateest-lookup \
ksym-64kb-xt-rateest-put \
ksym-64kb-xt-recseq \
ksym-64kb-xt-register-match \
ksym-64kb-xt-register-matches \
ksym-64kb-xt-register-table \
ksym-64kb-xt-register-target \
ksym-64kb-xt-register-targets \
ksym-64kb-xt-register-template \
ksym-64kb-xt-replace-table \
ksym-64kb-xt-request-find-match \
ksym-64kb-xt-request-find-table-lock \
ksym-64kb-xt-request-find-target \
ksym-64kb-xt-table-unlock \
ksym-64kb-xt-target-to-user \
ksym-64kb-xt-tee-enabled \
ksym-64kb-xt-unregister-match \
ksym-64kb-xt-unregister-matches \
ksym-64kb-xt-unregister-table-exit \
ksym-64kb-xt-unregister-table-pre-exit \
ksym-64kb-xt-unregister-target \
ksym-64kb-xt-unregister-targets \
ksym-64kb-xt-unregister-template \
ksym-64kb-xvip-cleanup-resources \
ksym-64kb-xvip-clr-and-set \
ksym-64kb-xvip-clr-or-set \
ksym-64kb-xvip-enum-frame-size \
ksym-64kb-xvip-enum-mbus-code \
ksym-64kb-xvip-get-format-by-code \
ksym-64kb-xvip-get-format-by-fourcc \
ksym-64kb-xvip-init-resources \
ksym-64kb-xvip-of-get-format \
ksym-64kb-xvip-set-format-size \
ksym-64kb-xvtc-generator-start \
ksym-64kb-xvtc-generator-stop \
ksym-64kb-xvtc-of-get \
ksym-64kb-xvtc-put \
ksym-64kb-xxh32 \
ksym-64kb-xxh64 \
ksym-64kb-xxh64-digest \
ksym-64kb-xxh64-reset \
ksym-64kb-xxh64-update \
ksym-64kb-xz-dec-end \
ksym-64kb-xz-dec-init \
ksym-64kb-xz-dec-microlzma-alloc \
ksym-64kb-xz-dec-microlzma-end \
ksym-64kb-xz-dec-microlzma-reset \
ksym-64kb-xz-dec-microlzma-run \
ksym-64kb-xz-dec-reset \
ksym-64kb-xz-dec-run \
ksym-64kb-yield \
ksym-64kb-yield-to \
ksym-64kb-yoga-c630-ec-read16 \
ksym-64kb-yoga-c630-ec-read8 \
ksym-64kb-yoga-c630-ec-register-notify \
ksym-64kb-yoga-c630-ec-ucsi-get-version \
ksym-64kb-yoga-c630-ec-ucsi-read \
ksym-64kb-yoga-c630-ec-ucsi-write \
ksym-64kb-yoga-c630-ec-unregister-notify \
ksym-64kb-zap-special-vma-range \
ksym-64kb-zd1301-demod-get-dvb-frontend \
ksym-64kb-zd1301-demod-get-i2c-adapter \
ksym-64kb-zero-fill-bio \
ksym-64kb-zero-page-pfn \
ksym-64kb-zerocopy-sg-from-iter \
ksym-64kb-zgid \
ksym-64kb-zl10036-attach \
ksym-64kb-zl10039-attach \
ksym-64kb-zl10353-attach \
ksym-64kb-zl3073x-dev-probe \
ksym-64kb-zl3073x-devm-alloc \
ksym-64kb-zl3073x-regmap-config \
ksym-64kb-zlib-deflate \
ksym-64kb-zlib-deflate-dfltcc-enabled \
ksym-64kb-zlib-deflate-workspacesize \
ksym-64kb-zlib-deflateEnd \
ksym-64kb-zlib-deflateInit2 \
ksym-64kb-zlib-deflateReset \
ksym-64kb-zlib-inflate \
ksym-64kb-zlib-inflate-blob \
ksym-64kb-zlib-inflate-workspacesize \
ksym-64kb-zlib-inflateEnd \
ksym-64kb-zlib-inflateIncomp \
ksym-64kb-zlib-inflateInit2 \
ksym-64kb-zlib-inflateReset \
ksym-64kb-zone-device-page-init \
ksym-64kb-zpa2326-isreg-precious \
ksym-64kb-zpa2326-isreg-readable \
ksym-64kb-zpa2326-isreg-writeable \
ksym-64kb-zpa2326-pm-ops \
ksym-64kb-zpa2326-probe \
ksym-64kb-zpa2326-remove \
ksym-64kb-zs-compact \
ksym-64kb-zs-create-pool \
ksym-64kb-zs-destroy-pool \
ksym-64kb-zs-free \
ksym-64kb-zs-get-total-pages \
ksym-64kb-zs-huge-class-size \
ksym-64kb-zs-lookup-class-index \
ksym-64kb-zs-malloc \
ksym-64kb-zs-obj-read-begin \
ksym-64kb-zs-obj-read-end \
ksym-64kb-zs-obj-read-sg-begin \
ksym-64kb-zs-obj-read-sg-end \
ksym-64kb-zs-obj-write \
ksym-64kb-zs-pool-stats \
ksym-64kb-zstd-cctx-set-param \
ksym-64kb-zstd-cctx-workspace-bound \
ksym-64kb-zstd-cctx-workspace-bound-with-ext-seq-prod \
ksym-64kb-zstd-compress-bound \
ksym-64kb-zstd-compress-cctx \
ksym-64kb-zstd-compress-sequences-and-literals \
ksym-64kb-zstd-compress-stream \
ksym-64kb-zstd-compress-using-cdict \
ksym-64kb-zstd-create-cctx-advanced \
ksym-64kb-zstd-create-cdict-byreference \
ksym-64kb-zstd-create-dctx-advanced \
ksym-64kb-zstd-create-ddict-byreference \
ksym-64kb-zstd-cstream-workspace-bound \
ksym-64kb-zstd-cstream-workspace-bound-with-ext-seq-prod \
ksym-64kb-zstd-dctx-workspace-bound \
ksym-64kb-zstd-decompress-dctx \
ksym-64kb-zstd-decompress-stream \
ksym-64kb-zstd-decompress-using-ddict \
ksym-64kb-zstd-default-clevel \
ksym-64kb-zstd-dstream-workspace-bound \
ksym-64kb-zstd-end-stream \
ksym-64kb-zstd-find-frame-compressed-size \
ksym-64kb-zstd-flush-stream \
ksym-64kb-zstd-free-cctx \
ksym-64kb-zstd-free-cdict \
ksym-64kb-zstd-free-dctx \
ksym-64kb-zstd-free-ddict \
ksym-64kb-zstd-get-cparams \
ksym-64kb-zstd-get-error-code \
ksym-64kb-zstd-get-error-name \
ksym-64kb-zstd-get-frame-header \
ksym-64kb-zstd-get-params \
ksym-64kb-zstd-init-cctx \
ksym-64kb-zstd-init-cstream \
ksym-64kb-zstd-init-dctx \
ksym-64kb-zstd-init-dstream \
ksym-64kb-zstd-is-error \
ksym-64kb-zstd-max-clevel \
ksym-64kb-zstd-min-clevel \
ksym-64kb-zstd-register-sequence-producer \
ksym-64kb-zstd-reset-cstream \
ksym-64kb-zstd-reset-dstream \
ksym-64kb-zynqmp-pm-aes-engine \
ksym-64kb-zynqmp-pm-bootmode-read \
ksym-64kb-zynqmp-pm-bootmode-write \
ksym-64kb-zynqmp-pm-clock-disable \
ksym-64kb-zynqmp-pm-clock-enable \
ksym-64kb-zynqmp-pm-clock-getdivider \
ksym-64kb-zynqmp-pm-clock-getparent \
ksym-64kb-zynqmp-pm-clock-getstate \
ksym-64kb-zynqmp-pm-clock-setdivider \
ksym-64kb-zynqmp-pm-clock-setparent \
ksym-64kb-zynqmp-pm-efuse-access \
ksym-64kb-zynqmp-pm-feature \
ksym-64kb-zynqmp-pm-force-pwrdwn \
ksym-64kb-zynqmp-pm-fpga-get-config-status \
ksym-64kb-zynqmp-pm-fpga-get-status \
ksym-64kb-zynqmp-pm-fpga-load \
ksym-64kb-zynqmp-pm-get-api-version \
ksym-64kb-zynqmp-pm-get-chipid \
ksym-64kb-zynqmp-pm-get-family-info \
ksym-64kb-zynqmp-pm-get-node-status \
ksym-64kb-zynqmp-pm-get-pll-frac-data \
ksym-64kb-zynqmp-pm-get-pll-frac-mode \
ksym-64kb-zynqmp-pm-get-rpu-mode \
ksym-64kb-zynqmp-pm-get-rpu-node-status \
ksym-64kb-zynqmp-pm-get-ufs-calibration-values \
ksym-64kb-zynqmp-pm-is-function-supported \
ksym-64kb-zynqmp-pm-is-mphy-tx-rx-config-ready \
ksym-64kb-zynqmp-pm-is-sram-init-done \
ksym-64kb-zynqmp-pm-load-pdi \
ksym-64kb-zynqmp-pm-ospi-mux-select \
ksym-64kb-zynqmp-pm-pinctrl-get-config \
ksym-64kb-zynqmp-pm-pinctrl-release \
ksym-64kb-zynqmp-pm-pinctrl-request \
ksym-64kb-zynqmp-pm-pinctrl-set-config \
ksym-64kb-zynqmp-pm-pinctrl-set-function \
ksym-64kb-zynqmp-pm-query-data \
ksym-64kb-zynqmp-pm-read-ggs \
ksym-64kb-zynqmp-pm-read-pggs \
ksym-64kb-zynqmp-pm-register-notifier \
ksym-64kb-zynqmp-pm-release-node \
ksym-64kb-zynqmp-pm-request-node \
ksym-64kb-zynqmp-pm-request-wake \
ksym-64kb-zynqmp-pm-reset-assert \
ksym-64kb-zynqmp-pm-reset-get-status \
ksym-64kb-zynqmp-pm-sd-dll-reset \
ksym-64kb-zynqmp-pm-sec-mask-write-reg \
ksym-64kb-zynqmp-pm-sec-read-reg \
ksym-64kb-zynqmp-pm-set-gem-config \
ksym-64kb-zynqmp-pm-set-pll-frac-data \
ksym-64kb-zynqmp-pm-set-pll-frac-mode \
ksym-64kb-zynqmp-pm-set-requirement \
ksym-64kb-zynqmp-pm-set-rpu-mode \
ksym-64kb-zynqmp-pm-set-sd-config \
ksym-64kb-zynqmp-pm-set-sd-tapdelay \
ksym-64kb-zynqmp-pm-set-sram-bypass \
ksym-64kb-zynqmp-pm-set-suspend-mode \
ksym-64kb-zynqmp-pm-set-tapdelay-bypass \
ksym-64kb-zynqmp-pm-set-tcm-config \
ksym-64kb-zynqmp-pm-sha-hash \
ksym-64kb-zynqmp-pm-write-ggs \
ksym-64kb-zynqmp-pm-write-pggs \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
awk \
coreutils \
distribution-release \
kmod-zstd \
modutils \
suse-kernel-rpm-scriptlets \
suse-module-tools"

inherit rpm
