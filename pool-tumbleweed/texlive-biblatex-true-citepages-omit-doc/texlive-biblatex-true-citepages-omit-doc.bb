SUMMARY = "Documentation for texlive-biblatex-true-citepages-omit"
DESCRIPTION = "This package includes the documentation for texlive-biblatex-true-citepages-omit"
LICENSE = "LPPL-1.0"

PV = "2026.226.2.0.0svn76790"

RPM_NAME = "texlive-biblatex-true-citepages-omit-doc-2026.226.2.0.0svn76790-61.2.noarch.rpm"
RPM_HASH = "5b003a94639ad06a2b5281a1f5240b6fb9b7727bac3734c401f1e3694f8ebc6a9f76f6d5d619e87a1fbda9b43ae9384406a8937344d80251914bef2b54044b9c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "texlive-biblatex-true-citepages-omit-doc"

RDEPENDS:${PN} += ""

inherit rpm
