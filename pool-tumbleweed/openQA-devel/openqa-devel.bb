SUMMARY = "Development package pulling in all build+test dependencies"
DESCRIPTION = "Development package pulling in all build+test dependencies."
LICENSE = "GPL-2.0-or-later"

PV = "5.1788605562.29b45941"

RPM_NAME = "openQA-devel-5.1788605562.29b45941-1.1.aarch64.rpm"
RPM_HASH = "d2bd83f0b983c4d8506618d0aa98170e3822cf5d92668cfb03d87cb3c7cd7c8a32e3212ed26437f3438a6d9d5882427e6fa3dd3c4366207a52a7cfecf43d3da0"

RPROVIDES:${PN} += "openQA-devel"

RDEPENDS:${PN} += "ShellCheck \
bsdtar \
chromedriver \
curl \
file \
git-core \
hostname \
jq \
make \
npm \
ntp-daemon \
openQA-client \
openssh-clients \
openssh-common \
optipng \
os-autoinst \
pandoc \
perl \
perl-App--cpanminus \
perl-Archive--Zip \
perl-BSD--Resource \
perl-CSS--Minifier--XS \
perl-CSS--Sass \
perl-Capture--Tiny \
perl-Carp \
perl-Carp--Always \
perl-Code--TidyAll \
perl-CommonMark \
perl-Config--IniFiles \
perl-Cpanel--JSON--XS \
perl-CryptX \
perl-Cwd \
perl-DBD--Pg \
perl-DBI \
perl-DBIx--Class \
perl-DBIx--Class--DeploymentHandler \
perl-DBIx--Class--DynamicDefault \
perl-DBIx--Class--OptimisticLocking \
perl-DBIx--Class--ResultClass--HashRefInflator \
perl-DBIx--Class--Schema--Config \
perl-DBIx--Class--Storage--Statistics \
perl-Data--Dump \
perl-Data--Dumper \
perl-Date--Format \
perl-DateTime \
perl-DateTime--Duration \
perl-DateTime--Format--Pg \
perl-Devel--Cover \
perl-Devel--Cover--Report--Codecovbash \
perl-Digest--MD5 \
perl-Exporter \
perl-Fcntl \
perl-Feature--Compat--Try \
perl-File--Basename \
perl-File--Copy \
perl-File--Copy--Recursive \
perl-File--Map \
perl-File--Path \
perl-File--Spec \
perl-Filesys--Df \
perl-FindBin \
perl-Getopt--Long \
perl-Getopt--Long--Descriptive \
perl-HTTP--Status \
perl-IO--Handle \
perl-IO--Interactive \
perl-IPC--Run \
perl-JSON--Validator \
perl-JavaScript--Minifier--XS \
perl-LWP--UserAgent \
perl-MCP \
perl-Minion \
perl-Minion--Backend--SQLite \
perl-Module--Load--Conditional \
perl-Module--Pluggable \
perl-Mojo--Base \
perl-Mojo--ByteStream \
perl-Mojo--IOLoop \
perl-Mojo--IOLoop--ReadWriteProcess \
perl-Mojo--JSON \
perl-Mojo--Pg \
perl-Mojo--RabbitMQ--Client \
perl-Mojo--SQLite \
perl-Mojo--URL \
perl-Mojo--Util \
perl-Mojolicious \
perl-Mojolicious--Commands \
perl-Mojolicious--Plugin \
perl-Mojolicious--Plugin--AssetPack \
perl-Mojolicious--Plugin--OAuth2 \
perl-Mojolicious--Static \
perl-Net--OpenID--Consumer \
perl-POSIX \
perl-Perl--Critic \
perl-Perl--Critic--Community \
perl-Perl--Tidy \
perl-Pod--Markdown \
perl-Pod--POM \
perl-Regexp--Common \
perl-SQL--Translator \
perl-Scalar--Util \
perl-Selenium--Remote--Driver \
perl-Selenium--Remote--WDKeys \
perl-Sort--Versions \
perl-Storable \
perl-TAP--Harness--JUnit \
perl-Test--CheckGitStatus \
perl-Test--Compile \
perl-Test--Exception \
perl-Test--Fatal \
perl-Test--Mock--Time \
perl-Test--MockModule \
perl-Test--MockObject \
perl-Test--Mojo \
perl-Test--Most \
perl-Test--Output \
perl-Test--Perl--Critic \
perl-Test--Pod \
perl-Test--Warnings \
perl-Text--Diff \
perl-Text--Glob \
perl-Time--HiRes \
perl-Time--Moment \
perl-Time--ParseDate \
perl-Time--Piece \
perl-Time--Seconds \
perl-URI--Escape \
perl-YAML--PP \
perl-YAML--XS \
perl-aliased \
perl-base \
perl-constant \
perl-diagnostics \
perl-strict \
perl-warnings \
postgresql-devel \
postgresql-server \
psmisc \
python3-argparse-manpage \
python3-base \
python3-gitlint \
python3-requests \
python3-ruff \
python3-setuptools \
python3-typer \
python3-weasyprint \
python3-yamllint \
qemu \
rsync \
shfmt \
sqlite3 \
sudo \
tar \
xorg-x11-fonts"

inherit rpm
