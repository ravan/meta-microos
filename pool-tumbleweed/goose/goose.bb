SUMMARY = "Extensible open source AI agent that automates engineering tasks"
DESCRIPTION = "goose is an extensible open source AI agent that goes beyond code suggestions: \
it installs, executes, edits and tests with any large language model, and \
drives external tools over the Model Context Protocol. \
 \
This package ships the command line agent. The 'code mode' and local inference \
features are not enabled: both need a build-time download of a prebuilt V8 or \
llama.cpp, which an offline distribution build cannot do. Telemetry reporting \
is not compiled in either."
LICENSE = "Apache-2.0 & BSD-2-Clause & BSD-3-Clause & CC0-1.0 & CDLA-Permissive-2.0 & ISC & LGPL-3.0-or-later & MIT & MIT-0 & MPL-2.0 & Unicode-3.0 & Zlib & bzip2-1.0.6"

PV = "1.50.0"

RPM_NAME = "goose-1.50.0-1.1.aarch64.rpm"
RPM_HASH = "71d54467146136628b125ed42b1728f7d546b13b9693f33193b13ead39f0381a065594dab9939230a104b1162db5d3825be9b01a77080bf65c7f7e4a65dfc3e7"

RPROVIDES:${PN} += "bundled-aws-lc \
bundled-libzstd \
bundled-oniguruma \
bundled-rust-crate-adler2 \
bundled-rust-crate-aead \
bundled-rust-crate-aes \
bundled-rust-crate-agent-client-protocol \
bundled-rust-crate-agent-client-protocol-derive \
bundled-rust-crate-agent-client-protocol-http \
bundled-rust-crate-agent-client-protocol-schema \
bundled-rust-crate-ahash \
bundled-rust-crate-aho-corasick \
bundled-rust-crate-alloc-no-stdlib \
bundled-rust-crate-alloc-stdlib \
bundled-rust-crate-allocator-api2 \
bundled-rust-crate-ansi-colours \
bundled-rust-crate-anstream \
bundled-rust-crate-anstyle \
bundled-rust-crate-anstyle-parse \
bundled-rust-crate-anstyle-query \
bundled-rust-crate-anyhow \
bundled-rust-crate-arboard \
bundled-rust-crate-arc-swap \
bundled-rust-crate-arrayvec \
bundled-rust-crate-asn1-rs \
bundled-rust-crate-asn1-rs-derive \
bundled-rust-crate-asn1-rs-impl \
bundled-rust-crate-async-channel \
bundled-rust-crate-async-compression \
bundled-rust-crate-async-io \
bundled-rust-crate-async-lock \
bundled-rust-crate-async-process \
bundled-rust-crate-async-signal \
bundled-rust-crate-async-stream \
bundled-rust-crate-async-stream-impl \
bundled-rust-crate-async-task \
bundled-rust-crate-async-trait \
bundled-rust-crate-async-utility \
bundled-rust-crate-async-wsocket \
bundled-rust-crate-atoi \
bundled-rust-crate-atomic-waker \
bundled-rust-crate-autocfg \
bundled-rust-crate-aws-config \
bundled-rust-crate-aws-credential-types \
bundled-rust-crate-aws-lc-rs \
bundled-rust-crate-aws-lc-sys \
bundled-rust-crate-aws-runtime \
bundled-rust-crate-aws-sdk-bedrockruntime \
bundled-rust-crate-aws-sdk-sagemakerruntime \
bundled-rust-crate-aws-sdk-sso \
bundled-rust-crate-aws-sdk-ssooidc \
bundled-rust-crate-aws-sdk-sts \
bundled-rust-crate-aws-sigv4 \
bundled-rust-crate-aws-smithy-async \
bundled-rust-crate-aws-smithy-eventstream \
bundled-rust-crate-aws-smithy-http \
bundled-rust-crate-aws-smithy-json \
bundled-rust-crate-aws-smithy-observability \
bundled-rust-crate-aws-smithy-query \
bundled-rust-crate-aws-smithy-runtime \
bundled-rust-crate-aws-smithy-runtime-api \
bundled-rust-crate-aws-smithy-runtime-api-macros \
bundled-rust-crate-aws-smithy-schema \
bundled-rust-crate-aws-smithy-types \
bundled-rust-crate-aws-smithy-xml \
bundled-rust-crate-aws-types \
bundled-rust-crate-axum \
bundled-rust-crate-axum-core \
bundled-rust-crate-axum-macros \
bundled-rust-crate-axum-server \
bundled-rust-crate-base64 \
bundled-rust-crate-base64-simd \
bundled-rust-crate-base64ct \
bundled-rust-crate-bat \
bundled-rust-crate-bech32 \
bundled-rust-crate-bincode \
bundled-rust-crate-bip39 \
bundled-rust-crate-bit-field \
bundled-rust-crate-bit-set \
bundled-rust-crate-bit-vec \
bundled-rust-crate-bitcoin-consensus-encoding \
bundled-rust-crate-bitcoin-hashes \
bundled-rust-crate-bitcoin-internals \
bundled-rust-crate-bitcoin-io \
bundled-rust-crate-bitflags \
bundled-rust-crate-blake3 \
bundled-rust-crate-block-buffer \
bundled-rust-crate-block-padding \
bundled-rust-crate-blocking \
bundled-rust-crate-borrow-or-share \
bundled-rust-crate-brotli \
bundled-rust-crate-brotli-decompressor \
bundled-rust-crate-bs58 \
bundled-rust-crate-bstr \
bundled-rust-crate-bumpalo \
bundled-rust-crate-bytecount \
bundled-rust-crate-bytemuck \
bundled-rust-crate-byteorder \
bundled-rust-crate-byteorder-lite \
bundled-rust-crate-bytes \
bundled-rust-crate-bytes-utils \
bundled-rust-crate-bytesize \
bundled-rust-crate-bzip2 \
bundled-rust-crate-calendrical-calculations \
bundled-rust-crate-cbc \
bundled-rust-crate-cc \
bundled-rust-crate-cfb \
bundled-rust-crate-cfg-aliases \
bundled-rust-crate-cfg-if \
bundled-rust-crate-chacha20 \
bundled-rust-crate-chacha20poly1305 \
bundled-rust-crate-chrono \
bundled-rust-crate-chrono-tz \
bundled-rust-crate-cipher \
bundled-rust-crate-clap \
bundled-rust-crate-clap-builder \
bundled-rust-crate-clap-complete \
bundled-rust-crate-clap-complete-nushell \
bundled-rust-crate-clap-derive \
bundled-rust-crate-clap-lex \
bundled-rust-crate-clap-mangen \
bundled-rust-crate-cliclack \
bundled-rust-crate-clircle \
bundled-rust-crate-cmake \
bundled-rust-crate-cmov \
bundled-rust-crate-cmpv2 \
bundled-rust-crate-cms \
bundled-rust-crate-color-quant \
bundled-rust-crate-colorchoice \
bundled-rust-crate-comfy-table \
bundled-rust-crate-compression-codecs \
bundled-rust-crate-compression-core \
bundled-rust-crate-concurrent-queue \
bundled-rust-crate-console \
bundled-rust-crate-const-oid \
bundled-rust-crate-constant-time-eq \
bundled-rust-crate-content-inspector \
bundled-rust-crate-convert-case \
bundled-rust-crate-cookie \
bundled-rust-crate-cookie-store \
bundled-rust-crate-core-maths \
bundled-rust-crate-cpubits \
bundled-rust-crate-cpufeatures \
bundled-rust-crate-crc \
bundled-rust-crate-crc-catalog \
bundled-rust-crate-crc32fast \
bundled-rust-crate-critical-section \
bundled-rust-crate-crmf \
bundled-rust-crate-croner \
bundled-rust-crate-crossbeam-channel \
bundled-rust-crate-crossbeam-deque \
bundled-rust-crate-crossbeam-epoch \
bundled-rust-crate-crossbeam-queue \
bundled-rust-crate-crossbeam-utils \
bundled-rust-crate-crypto-common \
bundled-rust-crate-ctutils \
bundled-rust-crate-darling \
bundled-rust-crate-darling-core \
bundled-rust-crate-darling-macro \
bundled-rust-crate-data-encoding \
bundled-rust-crate-dbus \
bundled-rust-crate-dbus-secret-service \
bundled-rust-crate-defmt \
bundled-rust-crate-defmt-macros \
bundled-rust-crate-defmt-parser \
bundled-rust-crate-der \
bundled-rust-crate-der-derive \
bundled-rust-crate-der-parser \
bundled-rust-crate-deranged \
bundled-rust-crate-derive-builder \
bundled-rust-crate-derive-builder-core \
bundled-rust-crate-derive-builder-macro \
bundled-rust-crate-derive-more \
bundled-rust-crate-derive-more-impl \
bundled-rust-crate-digest \
bundled-rust-crate-dirs \
bundled-rust-crate-dirs-sys \
bundled-rust-crate-displaydoc \
bundled-rust-crate-document-features \
bundled-rust-crate-docx-rs \
bundled-rust-crate-dotenvy \
bundled-rust-crate-dunce \
bundled-rust-crate-dyn-clone \
bundled-rust-crate-ecb \
bundled-rust-crate-either \
bundled-rust-crate-email-address \
bundled-rust-crate-encoding-rs \
bundled-rust-crate-endian-type \
bundled-rust-crate-equivalent \
bundled-rust-crate-errno \
bundled-rust-crate-etcetera \
bundled-rust-crate-event-listener \
bundled-rust-crate-event-listener-strategy \
bundled-rust-crate-exr \
bundled-rust-crate-fancy-regex \
bundled-rust-crate-faster-hex \
bundled-rust-crate-fastrand \
bundled-rust-crate-fax \
bundled-rust-crate-fdeflate \
bundled-rust-crate-filetime \
bundled-rust-crate-find-msvc-tools \
bundled-rust-crate-fixedbitset \
bundled-rust-crate-flagset \
bundled-rust-crate-flate2 \
bundled-rust-crate-fluent-uri \
bundled-rust-crate-flume \
bundled-rust-crate-fnv \
bundled-rust-crate-foldhash \
bundled-rust-crate-form-urlencoded \
bundled-rust-crate-fraction \
bundled-rust-crate-fs-err \
bundled-rust-crate-fs-extra \
bundled-rust-crate-fs2 \
bundled-rust-crate-futures \
bundled-rust-crate-futures-channel \
bundled-rust-crate-futures-concurrency \
bundled-rust-crate-futures-core \
bundled-rust-crate-futures-executor \
bundled-rust-crate-futures-intrusive \
bundled-rust-crate-futures-io \
bundled-rust-crate-futures-lite \
bundled-rust-crate-futures-macro \
bundled-rust-crate-futures-sink \
bundled-rust-crate-futures-task \
bundled-rust-crate-futures-util \
bundled-rust-crate-generic-array \
bundled-rust-crate-gethostname \
bundled-rust-crate-getrandom \
bundled-rust-crate-gif \
bundled-rust-crate-globset \
bundled-rust-crate-goose \
bundled-rust-crate-goose-acp-macros \
bundled-rust-crate-goose-agent \
bundled-rust-crate-goose-cli \
bundled-rust-crate-goose-context-management \
bundled-rust-crate-goose-download-manager \
bundled-rust-crate-goose-mcp \
bundled-rust-crate-goose-provider-types \
bundled-rust-crate-goose-providers \
bundled-rust-crate-goose-sdk-types \
bundled-rust-crate-h2 \
bundled-rust-crate-half \
bundled-rust-crate-hash32 \
bundled-rust-crate-hashbrown \
bundled-rust-crate-hashlink \
bundled-rust-crate-heapless \
bundled-rust-crate-heck \
bundled-rust-crate-hex \
bundled-rust-crate-hex-conservative \
bundled-rust-crate-hkdf \
bundled-rust-crate-hmac \
bundled-rust-crate-home \
bundled-rust-crate-html5gum \
bundled-rust-crate-http \
bundled-rust-crate-http-body \
bundled-rust-crate-http-body-util \
bundled-rust-crate-httparse \
bundled-rust-crate-httpdate \
bundled-rust-crate-hybrid-array \
bundled-rust-crate-hyper \
bundled-rust-crate-hyper-rustls \
bundled-rust-crate-hyper-util \
bundled-rust-crate-iana-time-zone \
bundled-rust-crate-icu-calendar \
bundled-rust-crate-icu-calendar-data \
bundled-rust-crate-icu-collections \
bundled-rust-crate-icu-locale \
bundled-rust-crate-icu-locale-core \
bundled-rust-crate-icu-locale-data \
bundled-rust-crate-icu-normalizer \
bundled-rust-crate-icu-normalizer-data \
bundled-rust-crate-icu-properties \
bundled-rust-crate-icu-properties-data \
bundled-rust-crate-icu-provider \
bundled-rust-crate-ident-case \
bundled-rust-crate-idna \
bundled-rust-crate-idna-adapter \
bundled-rust-crate-ignore \
bundled-rust-crate-image \
bundled-rust-crate-imagesize \
bundled-rust-crate-include-dir \
bundled-rust-crate-include-dir-macros \
bundled-rust-crate-indexmap \
bundled-rust-crate-indicatif \
bundled-rust-crate-indoc \
bundled-rust-crate-inout \
bundled-rust-crate-ipnet \
bundled-rust-crate-is-docker \
bundled-rust-crate-is-terminal-polyfill \
bundled-rust-crate-is-wsl \
bundled-rust-crate-itertools \
bundled-rust-crate-itoa \
bundled-rust-crate-jetscii \
bundled-rust-crate-jiff \
bundled-rust-crate-jiff-core \
bundled-rust-crate-jiff-static \
bundled-rust-crate-jobserver \
bundled-rust-crate-jpeg-decoder \
bundled-rust-crate-jsonschema \
bundled-rust-crate-jsonschema-regex \
bundled-rust-crate-jsonschema-value \
bundled-rust-crate-jsonwebtoken \
bundled-rust-crate-keyring \
bundled-rust-crate-lazy-static \
bundled-rust-crate-lebe \
bundled-rust-crate-libbz2-rs-sys \
bundled-rust-crate-libc \
bundled-rust-crate-libdbus-sys \
bundled-rust-crate-libm \
bundled-rust-crate-libsqlite3-sys \
bundled-rust-crate-linux-raw-sys \
bundled-rust-crate-litemap \
bundled-rust-crate-litrs \
bundled-rust-crate-lock-api \
bundled-rust-crate-log \
bundled-rust-crate-lopdf \
bundled-rust-crate-lru \
bundled-rust-crate-lru-slab \
bundled-rust-crate-matchers \
bundled-rust-crate-matchit \
bundled-rust-crate-md-5 \
bundled-rust-crate-memchr \
bundled-rust-crate-memo-map \
bundled-rust-crate-micromap \
bundled-rust-crate-mime \
bundled-rust-crate-mime-guess \
bundled-rust-crate-minijinja \
bundled-rust-crate-minimal-lexical \
bundled-rust-crate-miniz-oxide \
bundled-rust-crate-mio \
bundled-rust-crate-moxcms \
bundled-rust-crate-multiversion-no-op \
bundled-rust-crate-nanoid \
bundled-rust-crate-negentropy \
bundled-rust-crate-nibble-vec \
bundled-rust-crate-nix \
bundled-rust-crate-nom \
bundled-rust-crate-nostr \
bundled-rust-crate-nostr-database \
bundled-rust-crate-nostr-gossip \
bundled-rust-crate-nostr-sdk \
bundled-rust-crate-nu-ansi-term \
bundled-rust-crate-num \
bundled-rust-crate-num-bigint \
bundled-rust-crate-num-cmp \
bundled-rust-crate-num-complex \
bundled-rust-crate-num-conv \
bundled-rust-crate-num-derive \
bundled-rust-crate-num-integer \
bundled-rust-crate-num-iter \
bundled-rust-crate-num-rational \
bundled-rust-crate-num-traits \
bundled-rust-crate-oauth2 \
bundled-rust-crate-oid-registry \
bundled-rust-crate-once-cell \
bundled-rust-crate-onig \
bundled-rust-crate-onig-sys \
bundled-rust-crate-opaque-debug \
bundled-rust-crate-opaquerr \
bundled-rust-crate-open \
bundled-rust-crate-openssl-probe \
bundled-rust-crate-opentelemetry \
bundled-rust-crate-opentelemetry-appender-tracing \
bundled-rust-crate-opentelemetry-http \
bundled-rust-crate-opentelemetry-otlp \
bundled-rust-crate-opentelemetry-proto \
bundled-rust-crate-opentelemetry-sdk \
bundled-rust-crate-opentelemetry-stdout \
bundled-rust-crate-option-ext \
bundled-rust-crate-outref \
bundled-rust-crate-parking \
bundled-rust-crate-parking-lot \
bundled-rust-crate-parking-lot-core \
bundled-rust-crate-paste \
bundled-rust-crate-pastey \
bundled-rust-crate-path-abs \
bundled-rust-crate-pem \
bundled-rust-crate-pem-rfc7468 \
bundled-rust-crate-percent-encoding \
bundled-rust-crate-phf \
bundled-rust-crate-phf-generator \
bundled-rust-crate-phf-macros \
bundled-rust-crate-phf-shared \
bundled-rust-crate-pin-project \
bundled-rust-crate-pin-project-internal \
bundled-rust-crate-pin-project-lite \
bundled-rust-crate-pin-utils \
bundled-rust-crate-piper \
bundled-rust-crate-pkg-config \
bundled-rust-crate-png \
bundled-rust-crate-polling \
bundled-rust-crate-poly1305 \
bundled-rust-crate-portable-atomic \
bundled-rust-crate-potential-utf \
bundled-rust-crate-powerfmt \
bundled-rust-crate-ppv-lite86 \
bundled-rust-crate-prettyplease \
bundled-rust-crate-proc-macro2 \
bundled-rust-crate-process-wrap \
bundled-rust-crate-prost \
bundled-rust-crate-prost-derive \
bundled-rust-crate-psl-types \
bundled-rust-crate-publicsuffix \
bundled-rust-crate-pulp \
bundled-rust-crate-pulp-wasm-simd-flag \
bundled-rust-crate-pxfm \
bundled-rust-crate-quick-error \
bundled-rust-crate-quick-xml \
bundled-rust-crate-quinn \
bundled-rust-crate-quinn-proto \
bundled-rust-crate-quinn-udp \
bundled-rust-crate-quote \
bundled-rust-crate-radix-trie \
bundled-rust-crate-rand \
bundled-rust-crate-rand-chacha \
bundled-rust-crate-rand-core \
bundled-rust-crate-rand-pcg \
bundled-rust-crate-rangemap \
bundled-rust-crate-rayon \
bundled-rust-crate-rayon-core \
bundled-rust-crate-rcgen \
bundled-rust-crate-reborrow \
bundled-rust-crate-ref-cast \
bundled-rust-crate-ref-cast-impl \
bundled-rust-crate-referencing \
bundled-rust-crate-regex \
bundled-rust-crate-regex-automata \
bundled-rust-crate-regex-lite \
bundled-rust-crate-regex-syntax \
bundled-rust-crate-reqwest \
bundled-rust-crate-rgb \
bundled-rust-crate-ring \
bundled-rust-crate-rmcp \
bundled-rust-crate-rmcp-macros \
bundled-rust-crate-roff \
bundled-rust-crate-rustc-hash \
bundled-rust-crate-rustc-version \
bundled-rust-crate-rusticata-macros \
bundled-rust-crate-rustix \
bundled-rust-crate-rustls \
bundled-rust-crate-rustls-native-certs \
bundled-rust-crate-rustls-pki-types \
bundled-rust-crate-rustls-platform-verifier \
bundled-rust-crate-rustls-webpki \
bundled-rust-crate-rustversion \
bundled-rust-crate-rustyline \
bundled-rust-crate-ryu \
bundled-rust-crate-ryu-js \
bundled-rust-crate-same-file \
bundled-rust-crate-schemars \
bundled-rust-crate-schemars-derive \
bundled-rust-crate-scopeguard \
bundled-rust-crate-secp256k1 \
bundled-rust-crate-secp256k1-sys \
bundled-rust-crate-semver \
bundled-rust-crate-serde \
bundled-rust-crate-serde-core \
bundled-rust-crate-serde-derive \
bundled-rust-crate-serde-derive-internals \
bundled-rust-crate-serde-json \
bundled-rust-crate-serde-json-canonicalizer \
bundled-rust-crate-serde-path-to-error \
bundled-rust-crate-serde-spanned \
bundled-rust-crate-serde-urlencoded \
bundled-rust-crate-serde-with \
bundled-rust-crate-serde-with-macros \
bundled-rust-crate-serde-yaml \
bundled-rust-crate-sha1 \
bundled-rust-crate-sha2 \
bundled-rust-crate-sharded-slab \
bundled-rust-crate-shell-words \
bundled-rust-crate-shellexpand \
bundled-rust-crate-shlex \
bundled-rust-crate-signal-hook-registry \
bundled-rust-crate-signature \
bundled-rust-crate-sigstore-bundle \
bundled-rust-crate-sigstore-crypto \
bundled-rust-crate-sigstore-merkle \
bundled-rust-crate-sigstore-rekor \
bundled-rust-crate-sigstore-trust-root \
bundled-rust-crate-sigstore-tsa \
bundled-rust-crate-sigstore-tuf \
bundled-rust-crate-sigstore-types \
bundled-rust-crate-sigstore-verify \
bundled-rust-crate-simd-adler32 \
bundled-rust-crate-simdutf8 \
bundled-rust-crate-simple-asn1 \
bundled-rust-crate-siphasher \
bundled-rust-crate-slab \
bundled-rust-crate-smallvec \
bundled-rust-crate-smawk \
bundled-rust-crate-smithy-transport-reqwest \
bundled-rust-crate-socket2 \
bundled-rust-crate-spin \
bundled-rust-crate-spki \
bundled-rust-crate-sqlx \
bundled-rust-crate-sqlx-core \
bundled-rust-crate-sqlx-macros \
bundled-rust-crate-sqlx-macros-core \
bundled-rust-crate-sqlx-mysql \
bundled-rust-crate-sqlx-postgres \
bundled-rust-crate-sqlx-sqlite \
bundled-rust-crate-sse-stream \
bundled-rust-crate-stable-deref-trait \
bundled-rust-crate-std-prelude \
bundled-rust-crate-streaming-iterator \
bundled-rust-crate-stringprep \
bundled-rust-crate-strsim \
bundled-rust-crate-strum \
bundled-rust-crate-strum-macros \
bundled-rust-crate-subtle \
bundled-rust-crate-symlink \
bundled-rust-crate-syn \
bundled-rust-crate-sync-wrapper \
bundled-rust-crate-synstructure \
bundled-rust-crate-syntect \
bundled-rust-crate-sys-info \
bundled-rust-crate-tar \
bundled-rust-crate-tempfile \
bundled-rust-crate-terminal-colorsaurus \
bundled-rust-crate-terminal-trx \
bundled-rust-crate-textwrap \
bundled-rust-crate-thiserror \
bundled-rust-crate-thiserror-impl \
bundled-rust-crate-thousands \
bundled-rust-crate-thread-local \
bundled-rust-crate-tiff \
bundled-rust-crate-tiktoken-rs \
bundled-rust-crate-time \
bundled-rust-crate-time-core \
bundled-rust-crate-time-macros \
bundled-rust-crate-tinystr \
bundled-rust-crate-tinyvec \
bundled-rust-crate-tinyvec-macros \
bundled-rust-crate-tls-codec \
bundled-rust-crate-tls-codec-derive \
bundled-rust-crate-tokio \
bundled-rust-crate-tokio-cron-scheduler \
bundled-rust-crate-tokio-happy-eyeballs \
bundled-rust-crate-tokio-macros \
bundled-rust-crate-tokio-rustls \
bundled-rust-crate-tokio-socks \
bundled-rust-crate-tokio-stream \
bundled-rust-crate-tokio-tungstenite \
bundled-rust-crate-tokio-util \
bundled-rust-crate-toml \
bundled-rust-crate-toml-datetime \
bundled-rust-crate-toml-parser \
bundled-rust-crate-toml-writer \
bundled-rust-crate-tower \
bundled-rust-crate-tower-http \
bundled-rust-crate-tower-layer \
bundled-rust-crate-tower-service \
bundled-rust-crate-tracing \
bundled-rust-crate-tracing-appender \
bundled-rust-crate-tracing-attributes \
bundled-rust-crate-tracing-core \
bundled-rust-crate-tracing-futures \
bundled-rust-crate-tracing-log \
bundled-rust-crate-tracing-opentelemetry \
bundled-rust-crate-tracing-serde \
bundled-rust-crate-tracing-subscriber \
bundled-rust-crate-tree-sitter \
bundled-rust-crate-tree-sitter-go \
bundled-rust-crate-tree-sitter-java \
bundled-rust-crate-tree-sitter-javascript \
bundled-rust-crate-tree-sitter-kotlin-ng \
bundled-rust-crate-tree-sitter-language \
bundled-rust-crate-tree-sitter-python \
bundled-rust-crate-tree-sitter-ruby \
bundled-rust-crate-tree-sitter-rust \
bundled-rust-crate-tree-sitter-swift \
bundled-rust-crate-tree-sitter-typescript \
bundled-rust-crate-try-lock \
bundled-rust-crate-tungstenite \
bundled-rust-crate-typed-path \
bundled-rust-crate-typenum \
bundled-rust-crate-umya-spreadsheet \
bundled-rust-crate-unicase \
bundled-rust-crate-unicode-bidi \
bundled-rust-crate-unicode-general-category \
bundled-rust-crate-unicode-ident \
bundled-rust-crate-unicode-linebreak \
bundled-rust-crate-unicode-normalization \
bundled-rust-crate-unicode-properties \
bundled-rust-crate-unicode-segmentation \
bundled-rust-crate-unicode-width \
bundled-rust-crate-unicode-xid \
bundled-rust-crate-unit-prefix \
bundled-rust-crate-universal-hash \
bundled-rust-crate-universal-time \
bundled-rust-crate-unsafe-libyaml \
bundled-rust-crate-untrusted \
bundled-rust-crate-url \
bundled-rust-crate-urlencoding \
bundled-rust-crate-utf-8 \
bundled-rust-crate-utf8-iter \
bundled-rust-crate-utf8parse \
bundled-rust-crate-uuid \
bundled-rust-crate-uuid-simd \
bundled-rust-crate-v-escape-base \
bundled-rust-crate-v-htmlescape \
bundled-rust-crate-vcpkg \
bundled-rust-crate-version-check \
bundled-rust-crate-vsimd \
bundled-rust-crate-walkdir \
bundled-rust-crate-want \
bundled-rust-crate-web-time \
bundled-rust-crate-webbrowser \
bundled-rust-crate-webpki-roots \
bundled-rust-crate-weezl \
bundled-rust-crate-which \
bundled-rust-crate-whoami \
bundled-rust-crate-winnow \
bundled-rust-crate-writeable \
bundled-rust-crate-x11rb \
bundled-rust-crate-x11rb-protocol \
bundled-rust-crate-x509-cert \
bundled-rust-crate-x509-parser \
bundled-rust-crate-x509-tsp \
bundled-rust-crate-xmlparser \
bundled-rust-crate-xterm-color \
bundled-rust-crate-yasna \
bundled-rust-crate-yoke \
bundled-rust-crate-yoke-derive \
bundled-rust-crate-zerocopy \
bundled-rust-crate-zerocopy-derive \
bundled-rust-crate-zerofrom \
bundled-rust-crate-zerofrom-derive \
bundled-rust-crate-zeroize \
bundled-rust-crate-zeroize-derive \
bundled-rust-crate-zerotrie \
bundled-rust-crate-zerovec \
bundled-rust-crate-zerovec-derive \
bundled-rust-crate-zip \
bundled-rust-crate-zlib-rs \
bundled-rust-crate-zmij \
bundled-rust-crate-zopfli \
bundled-rust-crate-zstd \
bundled-rust-crate-zstd-safe \
bundled-rust-crate-zstd-sys \
bundled-rust-crate-zune-core \
bundled-rust-crate-zune-inflate \
bundled-rust-crate-zune-jpeg \
bundled-sqlite3 \
goose"

RDEPENDS:${PN} += "libc.so.6 \
libdbus-1.so.3 \
libgcc-s.so.1 \
libm.so.6"

inherit rpm
