SUMMARY = "Translations for package libKF6Notifications6"
DESCRIPTION = "Provides translations for the 'libKF6Notifications6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.28.0"

RPM_NAME = "libKF6Notifications6-lang-6.28.0-1.1.noarch.rpm"
RPM_HASH = "058e54c747fd023b9a52aed2409b16db94a5e19f32aac9319456c54ee06ce89b565a2bc4a07635142d91a644b876dc2b165962e2ef6702094a58723f80ce71c4"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6Notifications6-lang \
libKF6Notifications6-lang-all \
locale-libKF6Notifications6-af \
locale-libKF6Notifications6-ar \
locale-libKF6Notifications6-as \
locale-libKF6Notifications6-ast \
locale-libKF6Notifications6-az \
locale-libKF6Notifications6-be \
locale-libKF6Notifications6-be@latin \
locale-libKF6Notifications6-bg \
locale-libKF6Notifications6-bn \
locale-libKF6Notifications6-bn-IN \
locale-libKF6Notifications6-br \
locale-libKF6Notifications6-bs \
locale-libKF6Notifications6-ca \
locale-libKF6Notifications6-ca@valencia \
locale-libKF6Notifications6-cs \
locale-libKF6Notifications6-cy \
locale-libKF6Notifications6-da \
locale-libKF6Notifications6-de \
locale-libKF6Notifications6-el \
locale-libKF6Notifications6-en-GB \
locale-libKF6Notifications6-eo \
locale-libKF6Notifications6-es \
locale-libKF6Notifications6-et \
locale-libKF6Notifications6-eu \
locale-libKF6Notifications6-fa \
locale-libKF6Notifications6-fi \
locale-libKF6Notifications6-fr \
locale-libKF6Notifications6-ga \
locale-libKF6Notifications6-gd \
locale-libKF6Notifications6-gl \
locale-libKF6Notifications6-gu \
locale-libKF6Notifications6-he \
locale-libKF6Notifications6-hi \
locale-libKF6Notifications6-hr \
locale-libKF6Notifications6-hu \
locale-libKF6Notifications6-ia \
locale-libKF6Notifications6-id \
locale-libKF6Notifications6-is \
locale-libKF6Notifications6-it \
locale-libKF6Notifications6-ja \
locale-libKF6Notifications6-ka \
locale-libKF6Notifications6-kk \
locale-libKF6Notifications6-km \
locale-libKF6Notifications6-kn \
locale-libKF6Notifications6-ko \
locale-libKF6Notifications6-lt \
locale-libKF6Notifications6-lv \
locale-libKF6Notifications6-mai \
locale-libKF6Notifications6-mk \
locale-libKF6Notifications6-ml \
locale-libKF6Notifications6-mr \
locale-libKF6Notifications6-ms \
locale-libKF6Notifications6-nb \
locale-libKF6Notifications6-nds \
locale-libKF6Notifications6-ne \
locale-libKF6Notifications6-nl \
locale-libKF6Notifications6-nn \
locale-libKF6Notifications6-oc \
locale-libKF6Notifications6-or \
locale-libKF6Notifications6-pa \
locale-libKF6Notifications6-pl \
locale-libKF6Notifications6-pt \
locale-libKF6Notifications6-pt-BR \
locale-libKF6Notifications6-ro \
locale-libKF6Notifications6-ru \
locale-libKF6Notifications6-si \
locale-libKF6Notifications6-sk \
locale-libKF6Notifications6-sl \
locale-libKF6Notifications6-sq \
locale-libKF6Notifications6-sr \
locale-libKF6Notifications6-sr@ijekavian \
locale-libKF6Notifications6-sr@ijekavianlatin \
locale-libKF6Notifications6-sr@latin \
locale-libKF6Notifications6-sv \
locale-libKF6Notifications6-ta \
locale-libKF6Notifications6-te \
locale-libKF6Notifications6-th \
locale-libKF6Notifications6-tr \
locale-libKF6Notifications6-ug \
locale-libKF6Notifications6-uk \
locale-libKF6Notifications6-vi \
locale-libKF6Notifications6-wa \
locale-libKF6Notifications6-zh-CN \
locale-libKF6Notifications6-zh-HK \
locale-libKF6Notifications6-zh-TW"

RDEPENDS:${PN} += "libKF6Notifications6"

inherit rpm
