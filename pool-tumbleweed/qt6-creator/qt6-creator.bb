SUMMARY = "Integrated Development Environment targeting Qt apps"
DESCRIPTION = "Qt Creator is an integrated development environment (IDE) designed to \
facilitate development with the Qt application framework."
LICENSE = "BSD-3-Clause & GPL-3.0-only & GPL-3.0-with-Qt-Company-Qt-exception-1.1 & (LGPL-2.1-only | LGPL-3.0-only) & LGPL-3.0-only"

PV = "20.0.1"

RPM_NAME = "qt6-creator-20.0.1-1.3.aarch64.rpm"
RPM_HASH = "39adc552d1be0285794791629a22154982ba6469cd0e53b3797d1cfaa653308db8020d3e52c001823b7a847d5c36e5af1c8a898f52f403e3e99dddc78c700445"

RPROVIDES:${PN} += "libAcpClient.so \
libAcpLib.so.20 \
libAdvancedDockingSystem.so.20 \
libAggregation.so.20 \
libAndroid.so \
libAnt.so \
libAppStatisticsMonitor.so \
libAutoTest.so \
libAutotoolsProjectManager.so \
libAxivion.so \
libBareMetal.so \
libBazaar.so \
libBeautifier.so \
libBinEditor.so \
libBoot2Qt.so \
libCMakeProjectManager.so \
libCPlusPlus.so.20 \
libCVS.so \
libCargo.so \
libClangCodeModel.so \
libClangTools.so \
libClassView.so \
libClearCase.so \
libCmdBridgeClient.so.20 \
libCoco.so \
libCodePaster.so \
libCompilationDatabaseProjectManager.so \
libCompilerExplorer.so \
libConan.so \
libCopilot.so \
libCore.so \
libCppEditor.so \
libCppcheck.so \
libCtfVisualizer.so \
libDebugger.so \
libDesigner.so \
libDevContainer.so.20 \
libDevContainerPlugin.so \
libDiffEditor.so \
libDocker.so \
libDotnet.so \
libEffectComposer.so \
libEmacsKeys.so \
libExtensionManager.so \
libExtensionSystem.so.20 \
libFakeVim.so \
libFossil.so \
libGLSL.so.20 \
libGLSLEditor.so \
libGNProjectManager.so \
libGenericProjectManager.so \
libGit.so \
libGitLab.so \
libGradle.so \
libHelloWorld.so \
libHelp.so \
libImageViewer.so \
libIncrediBuild.so \
libIos.so \
libKSyntaxHighlighting.so.20 \
libLanguageClient.so \
libLanguageServerProtocol.so.20 \
libLanguageUtils.so.20 \
libLearning.so \
libLua.so \
libLuaLanguageClient.so \
libMacros.so \
libMcpServerLib.so.20 \
libMcuSupport.so \
libMercurial.so \
libMesonProjectManager.so \
libModelEditor.so \
libModeling.so.20 \
libMultiPropertyEditor.so \
libNanotrace.so.20 \
libNim.so \
libPerfProfiler.so \
libPerforce.so \
libProParser.so.20 \
libProjectExplorer.so \
libPython.so \
libQbsProjectManager.so \
libQmakeProjectManager.so \
libQmlDebug.so.20 \
libQmlDesigner.so \
libQmlDesignerCore.so.20 \
libQmlEditorWidgets.so.20 \
libQmlJS.so.20 \
libQmlJSEditor.so \
libQmlJSTools.so \
libQmlPreview.so \
libQmlProfiler.so \
libQmlProjectManager.so \
libQnx.so \
libQtApplicationManagerIntegration.so \
libQtSupport.so \
libQtTaskTree.so.20 \
libRemoteLinux.so \
libResourceEditor.so \
libSafeRenderer.so \
libScreenRecorder.so \
libScxmlEditor.so \
libSerialTerminal.so \
libSilverSearcher.so \
libSqlite.so.20 \
libSquish.so \
libSubversion.so \
libSwift.so \
libTerminal.so \
libTerminalLib.so.20 \
libTextEditor.so \
libTodo.so \
libTracing.so.20 \
libUtils.so.20 \
libValgrind.so \
libVcpkg.so \
libVcsBase.so \
libWebAssembly.so \
libWelcome.so \
libZenMode.so \
libcomponentsplugin.so \
libmcpserver.so \
libptracepreload.so.20 \
libqlitehtml.so.20 \
libqmlpreviewplugin.so \
libqt5-creator \
libqtkeychain.so.20 \
libqtquickplugin.so \
qt-creator \
qt5-creator \
qt6-creator"

RDEPENDS:${PN} += "/sbin/ldconfig \
hicolor-icon-theme \
ld-linux-aarch64.so.1 \
libQt6Charts.so.6 \
libQt6Concurrent.so.6 \
libQt6Core.so.6 \
libQt6DBus.so.6 \
libQt6Designer.so.6 \
libQt6DesignerComponents.so.6 \
libQt6Gui.so.6 \
libQt6Help.so.6 \
libQt6HttpServer.so.6 \
libQt6Network.so.6 \
libQt6PrintSupport.so.6 \
libQt6Qml.so.6 \
libQt6Quick.so.6 \
libQt6Quick3D.so.6 \
libQt6Quick3DAssetImport.so.6 \
libQt6Quick3DAssetUtils.so.6 \
libQt6Quick3DParticles.so.6 \
libQt6Quick3DRuntimeRender.so.6 \
libQt6Quick3DUtils.so.6 \
libQt6QuickWidgets.so.6 \
libQt6SerialPort.so.6 \
libQt6Sql.so.6 \
libQt6Svg.so.6 \
libQt6SvgWidgets.so.6 \
libQt6Test.so.6 \
libQt6Widgets.so.6 \
libQt6Xml.so.6 \
libarchive.so.13 \
libc.so.6 \
libdw.so.1 \
libelf.so.1 \
libgcc-s.so.1 \
libglib-2.0.so.0 \
libm.so.6 \
libstdc++.so.6 \
libyaml-cpp.so.0.9 \
libzstd.so.1 \
qt6-sql-sqlite \
qt6qmlimport-Qt.labs.platform \
qt6qmlimport-Qt.labs.qmlmodels \
qt6qmlimport-QtCharts \
qt6qmlimport-QtCore \
qt6qmlimport-QtGraphs \
qt6qmlimport-QtQml \
qt6qmlimport-QtQml.Models \
qt6qmlimport-QtQuick \
qt6qmlimport-QtQuick.2 \
qt6qmlimport-QtQuick.Controls \
qt6qmlimport-QtQuick.Controls.2 \
qt6qmlimport-QtQuick.Controls.6 \
qt6qmlimport-QtQuick.Controls.Basic \
qt6qmlimport-QtQuick.Controls.impl \
qt6qmlimport-QtQuick.Dialogs \
qt6qmlimport-QtQuick.Layouts \
qt6qmlimport-QtQuick.Layouts.1 \
qt6qmlimport-QtQuick.Shapes \
qt6qmlimport-QtQuick.Templates \
qt6qmlimport-QtQuick.Templates.2 \
qt6qmlimport-QtQuick.Timeline \
qt6qmlimport-QtQuick.Timeline.1 \
qt6qmlimport-QtQuick.Window \
qt6qmlimport-QtQuick.Window.2 \
qt6qmlimport-QtQuick3D \
qt6qmlimport-QtQuick3D.Helpers \
qt6qmlimport-QtQuick3D.Particles3D"

inherit rpm
