SUMMARY = "Translations for package libKEduVocDocument5"
DESCRIPTION = "Provides translations for the 'libKEduVocDocument5' package."
LICENSE = "GPL-2.0-or-later"

PV = "26.08.1"

RPM_NAME = "libKEduVocDocument5-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "0c5d78485be72545875b1212e98e10a247564c95a03f7ea1a9780d3233a03b86371fe0832160177cbc42cc67d30e1185f20834a191787dd79aed6b777e157fc1"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKEduVocDocument5-lang \
libKEduVocDocument5-lang-all \
locale-libKEduVocDocument5-ar \
locale-libKEduVocDocument5-ast \
locale-libKEduVocDocument5-az \
locale-libKEduVocDocument5-be \
locale-libKEduVocDocument5-bg \
locale-libKEduVocDocument5-br \
locale-libKEduVocDocument5-bs \
locale-libKEduVocDocument5-ca \
locale-libKEduVocDocument5-ca@valencia \
locale-libKEduVocDocument5-cs \
locale-libKEduVocDocument5-cy \
locale-libKEduVocDocument5-da \
locale-libKEduVocDocument5-de \
locale-libKEduVocDocument5-el \
locale-libKEduVocDocument5-en-GB \
locale-libKEduVocDocument5-eo \
locale-libKEduVocDocument5-es \
locale-libKEduVocDocument5-et \
locale-libKEduVocDocument5-eu \
locale-libKEduVocDocument5-fa \
locale-libKEduVocDocument5-fi \
locale-libKEduVocDocument5-fr \
locale-libKEduVocDocument5-ga \
locale-libKEduVocDocument5-gl \
locale-libKEduVocDocument5-he \
locale-libKEduVocDocument5-hi \
locale-libKEduVocDocument5-hr \
locale-libKEduVocDocument5-hu \
locale-libKEduVocDocument5-ia \
locale-libKEduVocDocument5-is \
locale-libKEduVocDocument5-it \
locale-libKEduVocDocument5-ja \
locale-libKEduVocDocument5-ka \
locale-libKEduVocDocument5-kk \
locale-libKEduVocDocument5-km \
locale-libKEduVocDocument5-ko \
locale-libKEduVocDocument5-lt \
locale-libKEduVocDocument5-lv \
locale-libKEduVocDocument5-mai \
locale-libKEduVocDocument5-mk \
locale-libKEduVocDocument5-ml \
locale-libKEduVocDocument5-mr \
locale-libKEduVocDocument5-ms \
locale-libKEduVocDocument5-nb \
locale-libKEduVocDocument5-nds \
locale-libKEduVocDocument5-ne \
locale-libKEduVocDocument5-nl \
locale-libKEduVocDocument5-nn \
locale-libKEduVocDocument5-oc \
locale-libKEduVocDocument5-pa \
locale-libKEduVocDocument5-pl \
locale-libKEduVocDocument5-pt \
locale-libKEduVocDocument5-pt-BR \
locale-libKEduVocDocument5-ro \
locale-libKEduVocDocument5-ru \
locale-libKEduVocDocument5-si \
locale-libKEduVocDocument5-sk \
locale-libKEduVocDocument5-sl \
locale-libKEduVocDocument5-sq \
locale-libKEduVocDocument5-sv \
locale-libKEduVocDocument5-th \
locale-libKEduVocDocument5-tr \
locale-libKEduVocDocument5-ug \
locale-libKEduVocDocument5-uk \
locale-libKEduVocDocument5-vi \
locale-libKEduVocDocument5-zh-CN \
locale-libKEduVocDocument5-zh-TW"

RDEPENDS:${PN} += "libKEduVocDocument5"

inherit rpm
