SUMMARY = "Slightly modified computer modern fonts with Cyrillics"
DESCRIPTION = "The Cyrillic Modern fonts are based on the Computer Modern \
fonts designed in Metafont by D. E. Knuth and released in Type \
1 format by the American Mathematical Society under the SIL \
Open Font License (OFL). The Cyrillic Modern fonts are intended \
to make the Cyrillic letters with classical shapes typical to \
the modern fonts. Currently, the fonts add support for the \
Russian language, the numero sign and quotation marks required \
for Russian typesetting."
LICENSE = "OFL-1.1"

PV = "2026.226.0.0.4svn71183"

RPM_NAME = "texlive-cyrillic-modern-2026.226.0.0.4svn71183-61.2.noarch.rpm"
RPM_HASH = "4d3bdc25ccf1e4120013e4baf4b13ada9e40012e81cbc912da6f84f3450c335993e1168c2536c5bdc1d721c3dcd3174a955504e65efb4ede2f863fa88aa97d72"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-ls2-nmb10.tfm \
tex-ls2-nmbx10.tfm \
tex-ls2-nmbx12.tfm \
tex-ls2-nmbx5.tfm \
tex-ls2-nmbx6.tfm \
tex-ls2-nmbx7.tfm \
tex-ls2-nmbx8.tfm \
tex-ls2-nmbx9.tfm \
tex-ls2-nmbxsl10.tfm \
tex-ls2-nmbxti10.tfm \
tex-ls2-nmcsc10.tfm \
tex-ls2-nmr10.tfm \
tex-ls2-nmr12.tfm \
tex-ls2-nmr17.tfm \
tex-ls2-nmr5.tfm \
tex-ls2-nmr6.tfm \
tex-ls2-nmr7.tfm \
tex-ls2-nmr8.tfm \
tex-ls2-nmr9.tfm \
tex-ls2-nmsl10.tfm \
tex-ls2-nmsl12.tfm \
tex-ls2-nmsl8.tfm \
tex-ls2-nmsl9.tfm \
tex-ls2-nmss10.tfm \
tex-ls2-nmss12.tfm \
tex-ls2-nmss17.tfm \
tex-ls2-nmss8.tfm \
tex-ls2-nmss9.tfm \
tex-ls2-nmssbx10.tfm \
tex-ls2-nmssdc10.tfm \
tex-ls2-nmssi10.tfm \
tex-ls2-nmssi12.tfm \
tex-ls2-nmssi17.tfm \
tex-ls2-nmssi8.tfm \
tex-ls2-nmssi9.tfm \
tex-ls2-nmti10.tfm \
tex-ls2-nmti12.tfm \
tex-ls2-nmti7.tfm \
tex-ls2-nmti8.tfm \
tex-ls2-nmti9.tfm \
tex-ls2enc.def \
tex-ls2nmr.fd \
tex-ls2nmss.fd \
tex-nm-7t.enc \
tex-nm-7tsc.enc \
tex-nm-7tti.enc \
tex-nm-ls2.enc \
tex-nm-t2a.enc \
tex-nm-t2asc.enc \
tex-nm-t2ati.enc \
tex-nm.map \
tex-nm.sty \
tex-nmb10.tfm \
tex-nmbx10.tfm \
tex-nmbx12.tfm \
tex-nmbx5.tfm \
tex-nmbx6.tfm \
tex-nmbx7.tfm \
tex-nmbx8.tfm \
tex-nmbx9.tfm \
tex-nmbxsl10.tfm \
tex-nmbxti10.tfm \
tex-nmcsc10.tfm \
tex-nmmi.enc \
tex-nmmi10.tfm \
tex-nmmi12.tfm \
tex-nmmi5.tfm \
tex-nmmi6.tfm \
tex-nmmi7.tfm \
tex-nmmi8.tfm \
tex-nmmi9.tfm \
tex-nmmib10.tfm \
tex-nmmib5.tfm \
tex-nmmib6.tfm \
tex-nmmib7.tfm \
tex-nmmib8.tfm \
tex-nmmib9.tfm \
tex-nmr10.tfm \
tex-nmr12.tfm \
tex-nmr17.tfm \
tex-nmr5.tfm \
tex-nmr6.tfm \
tex-nmr7.tfm \
tex-nmr8.tfm \
tex-nmr9.tfm \
tex-nmsl10.tfm \
tex-nmsl12.tfm \
tex-nmsl8.tfm \
tex-nmsl9.tfm \
tex-nmss10.tfm \
tex-nmss12.tfm \
tex-nmss17.tfm \
tex-nmss8.tfm \
tex-nmss9.tfm \
tex-nmssbx10.tfm \
tex-nmssdc10.tfm \
tex-nmssi10.tfm \
tex-nmssi12.tfm \
tex-nmssi17.tfm \
tex-nmssi8.tfm \
tex-nmssi9.tfm \
tex-nmti10.tfm \
tex-nmti12.tfm \
tex-nmti7.tfm \
tex-nmti8.tfm \
tex-nmti9.tfm \
tex-omlnmm.fd \
tex-ot1-nmb10.tfm \
tex-ot1-nmbx10.tfm \
tex-ot1-nmbx12.tfm \
tex-ot1-nmbx5.tfm \
tex-ot1-nmbx6.tfm \
tex-ot1-nmbx7.tfm \
tex-ot1-nmbx8.tfm \
tex-ot1-nmbx9.tfm \
tex-ot1-nmbxsl10.tfm \
tex-ot1-nmbxti10.tfm \
tex-ot1-nmcsc10.tfm \
tex-ot1-nmr10.tfm \
tex-ot1-nmr12.tfm \
tex-ot1-nmr17.tfm \
tex-ot1-nmr5.tfm \
tex-ot1-nmr6.tfm \
tex-ot1-nmr7.tfm \
tex-ot1-nmr8.tfm \
tex-ot1-nmr9.tfm \
tex-ot1-nmsl10.tfm \
tex-ot1-nmsl12.tfm \
tex-ot1-nmsl8.tfm \
tex-ot1-nmsl9.tfm \
tex-ot1-nmss10.tfm \
tex-ot1-nmss12.tfm \
tex-ot1-nmss17.tfm \
tex-ot1-nmss8.tfm \
tex-ot1-nmss9.tfm \
tex-ot1-nmssbx10.tfm \
tex-ot1-nmssdc10.tfm \
tex-ot1-nmssi10.tfm \
tex-ot1-nmssi12.tfm \
tex-ot1-nmssi17.tfm \
tex-ot1-nmssi8.tfm \
tex-ot1-nmssi9.tfm \
tex-ot1-nmti10.tfm \
tex-ot1-nmti12.tfm \
tex-ot1-nmti7.tfm \
tex-ot1-nmti8.tfm \
tex-ot1-nmti9.tfm \
tex-ot1nmr.fd \
tex-ot1nmss.fd \
tex-t2anmr.fd \
tex-t2anmss.fd \
tex-unmr.fd \
tex-unmss.fd \
texlive-cyrillic-modern"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
texlive \
texlive-cyrillic-modern-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
