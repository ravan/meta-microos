SUMMARY = "Clear Sans fonts with LaTeX support"
DESCRIPTION = "Clear Sans was designed by Daniel Ratighan at Monotype under \
the direction of the User Experience team at Intel's Open \
Source Technology Center. Clear Sans is available in three \
weights (regular, medium, and bold) with corresponding italics, \
plus light and thin upright (without italics). Clear Sans has \
minimized, unambiguous characters and slightly narrow \
proportions, making it ideal for UI design. Its strong, \
recognizable forms avoid distracting ambiguity, making Clear \
Sans comfortable for reading short UI labels and long passages \
in both screen and print. The fonts are available in both \
TrueType and Type 1 formats."
LICENSE = "Apache-1.0"

PV = "2026.226.svn74767"

RPM_NAME = "texlive-clearsans-2026.226.svn74767-60.2.noarch.rpm"
RPM_HASH = "c914210f7e4fa7cc776595ba0f0555997b0064e16804a98add91918b515442fdf8b6c7d313df1fa21063510c84d9dc04bff167e2a22845ead643f0b739cd1c6c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-ClearSans-Bold-tlf-lgr--base.tfm \
tex-ClearSans-Bold-tlf-lgr.tfm \
tex-ClearSans-Bold-tlf-lgr.vf \
tex-ClearSans-Bold-tlf-ly1--base.tfm \
tex-ClearSans-Bold-tlf-ly1.tfm \
tex-ClearSans-Bold-tlf-ly1.vf \
tex-ClearSans-Bold-tlf-ot1.tfm \
tex-ClearSans-Bold-tlf-t1--base.tfm \
tex-ClearSans-Bold-tlf-t1.tfm \
tex-ClearSans-Bold-tlf-t1.vf \
tex-ClearSans-Bold-tlf-t2a.tfm \
tex-ClearSans-Bold-tlf-t2b.tfm \
tex-ClearSans-Bold-tlf-t2c.tfm \
tex-ClearSans-Bold-tlf-ts1--base.tfm \
tex-ClearSans-Bold-tlf-ts1.tfm \
tex-ClearSans-Bold-tlf-ts1.vf \
tex-ClearSans-BoldItalic-tlf-lgr--base.tfm \
tex-ClearSans-BoldItalic-tlf-lgr.tfm \
tex-ClearSans-BoldItalic-tlf-lgr.vf \
tex-ClearSans-BoldItalic-tlf-ly1--base.tfm \
tex-ClearSans-BoldItalic-tlf-ly1.tfm \
tex-ClearSans-BoldItalic-tlf-ly1.vf \
tex-ClearSans-BoldItalic-tlf-ot1.tfm \
tex-ClearSans-BoldItalic-tlf-t1--base.tfm \
tex-ClearSans-BoldItalic-tlf-t1.tfm \
tex-ClearSans-BoldItalic-tlf-t1.vf \
tex-ClearSans-BoldItalic-tlf-t2a.tfm \
tex-ClearSans-BoldItalic-tlf-t2b.tfm \
tex-ClearSans-BoldItalic-tlf-t2c.tfm \
tex-ClearSans-BoldItalic-tlf-ts1--base.tfm \
tex-ClearSans-BoldItalic-tlf-ts1.tfm \
tex-ClearSans-BoldItalic-tlf-ts1.vf \
tex-ClearSans-Italic-tlf-lgr--base.tfm \
tex-ClearSans-Italic-tlf-lgr.tfm \
tex-ClearSans-Italic-tlf-lgr.vf \
tex-ClearSans-Italic-tlf-ly1--base.tfm \
tex-ClearSans-Italic-tlf-ly1.tfm \
tex-ClearSans-Italic-tlf-ly1.vf \
tex-ClearSans-Italic-tlf-ot1.tfm \
tex-ClearSans-Italic-tlf-t1--base.tfm \
tex-ClearSans-Italic-tlf-t1.tfm \
tex-ClearSans-Italic-tlf-t1.vf \
tex-ClearSans-Italic-tlf-t2a.tfm \
tex-ClearSans-Italic-tlf-t2b.tfm \
tex-ClearSans-Italic-tlf-t2c.tfm \
tex-ClearSans-Italic-tlf-ts1--base.tfm \
tex-ClearSans-Italic-tlf-ts1.tfm \
tex-ClearSans-Italic-tlf-ts1.vf \
tex-ClearSans-Light-tlf-lgr--base.tfm \
tex-ClearSans-Light-tlf-lgr.tfm \
tex-ClearSans-Light-tlf-lgr.vf \
tex-ClearSans-Light-tlf-ly1--base.tfm \
tex-ClearSans-Light-tlf-ly1.tfm \
tex-ClearSans-Light-tlf-ly1.vf \
tex-ClearSans-Light-tlf-ot1.tfm \
tex-ClearSans-Light-tlf-t1--base.tfm \
tex-ClearSans-Light-tlf-t1.tfm \
tex-ClearSans-Light-tlf-t1.vf \
tex-ClearSans-Light-tlf-t2a.tfm \
tex-ClearSans-Light-tlf-t2b.tfm \
tex-ClearSans-Light-tlf-t2c.tfm \
tex-ClearSans-Light-tlf-ts1--base.tfm \
tex-ClearSans-Light-tlf-ts1.tfm \
tex-ClearSans-Light-tlf-ts1.vf \
tex-ClearSans-Medium-tlf-lgr--base.tfm \
tex-ClearSans-Medium-tlf-lgr.tfm \
tex-ClearSans-Medium-tlf-lgr.vf \
tex-ClearSans-Medium-tlf-ly1--base.tfm \
tex-ClearSans-Medium-tlf-ly1.tfm \
tex-ClearSans-Medium-tlf-ly1.vf \
tex-ClearSans-Medium-tlf-ot1.tfm \
tex-ClearSans-Medium-tlf-t1--base.tfm \
tex-ClearSans-Medium-tlf-t1.tfm \
tex-ClearSans-Medium-tlf-t1.vf \
tex-ClearSans-Medium-tlf-t2a.tfm \
tex-ClearSans-Medium-tlf-t2b.tfm \
tex-ClearSans-Medium-tlf-t2c.tfm \
tex-ClearSans-Medium-tlf-ts1--base.tfm \
tex-ClearSans-Medium-tlf-ts1.tfm \
tex-ClearSans-Medium-tlf-ts1.vf \
tex-ClearSans-MediumItalic-tlf-lgr--base.tfm \
tex-ClearSans-MediumItalic-tlf-lgr.tfm \
tex-ClearSans-MediumItalic-tlf-lgr.vf \
tex-ClearSans-MediumItalic-tlf-ly1--base.tfm \
tex-ClearSans-MediumItalic-tlf-ly1.tfm \
tex-ClearSans-MediumItalic-tlf-ly1.vf \
tex-ClearSans-MediumItalic-tlf-ot1.tfm \
tex-ClearSans-MediumItalic-tlf-t1--base.tfm \
tex-ClearSans-MediumItalic-tlf-t1.tfm \
tex-ClearSans-MediumItalic-tlf-t1.vf \
tex-ClearSans-MediumItalic-tlf-t2a.tfm \
tex-ClearSans-MediumItalic-tlf-t2b.tfm \
tex-ClearSans-MediumItalic-tlf-t2c.tfm \
tex-ClearSans-MediumItalic-tlf-ts1--base.tfm \
tex-ClearSans-MediumItalic-tlf-ts1.tfm \
tex-ClearSans-MediumItalic-tlf-ts1.vf \
tex-ClearSans-Thin-tlf-lgr--base.tfm \
tex-ClearSans-Thin-tlf-lgr.tfm \
tex-ClearSans-Thin-tlf-lgr.vf \
tex-ClearSans-Thin-tlf-ly1--base.tfm \
tex-ClearSans-Thin-tlf-ly1.tfm \
tex-ClearSans-Thin-tlf-ly1.vf \
tex-ClearSans-Thin-tlf-ot1.tfm \
tex-ClearSans-Thin-tlf-t1--base.tfm \
tex-ClearSans-Thin-tlf-t1.tfm \
tex-ClearSans-Thin-tlf-t1.vf \
tex-ClearSans-Thin-tlf-t2a.tfm \
tex-ClearSans-Thin-tlf-t2b.tfm \
tex-ClearSans-Thin-tlf-t2c.tfm \
tex-ClearSans-Thin-tlf-ts1--base.tfm \
tex-ClearSans-Thin-tlf-ts1.tfm \
tex-ClearSans-Thin-tlf-ts1.vf \
tex-ClearSans-tlf-lgr--base.tfm \
tex-ClearSans-tlf-lgr.tfm \
tex-ClearSans-tlf-lgr.vf \
tex-ClearSans-tlf-ly1--base.tfm \
tex-ClearSans-tlf-ly1.tfm \
tex-ClearSans-tlf-ly1.vf \
tex-ClearSans-tlf-ot1.tfm \
tex-ClearSans-tlf-t1--base.tfm \
tex-ClearSans-tlf-t1.tfm \
tex-ClearSans-tlf-t1.vf \
tex-ClearSans-tlf-t2a.tfm \
tex-ClearSans-tlf-t2b.tfm \
tex-ClearSans-tlf-t2c.tfm \
tex-ClearSans-tlf-ts1--base.tfm \
tex-ClearSans-tlf-ts1.tfm \
tex-ClearSans-tlf-ts1.vf \
tex-ClearSans.map \
tex-ClearSans.sty \
tex-LGRClearSans-TLF.fd \
tex-LY1ClearSans-TLF.fd \
tex-OT1ClearSans-TLF.fd \
tex-T1ClearSans-TLF.fd \
tex-T2AClearSans-TLF.fd \
tex-T2BClearSans-TLF.fd \
tex-T2CClearSans-TLF.fd \
tex-TS1ClearSans-TLF.fd \
tex-clr-bhvwzm.enc \
tex-clr-bjsdl7.enc \
tex-clr-c5eikb.enc \
tex-clr-efgn42.enc \
tex-clr-lz5qp4.enc \
tex-clr-qhdb7i.enc \
tex-clr-wefccw.enc \
tex-clr-zxbkm4.enc \
texlive-clearsans"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-clearsans-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
