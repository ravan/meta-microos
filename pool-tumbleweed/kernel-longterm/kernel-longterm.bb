ksym-longterm-rio-unregister-driver \
ksym-longterm-rio-unregister-mport \
ksym-longterm-rk8xx-probe \
ksym-longterm-rk8xx-resume \
ksym-longterm-rk8xx-shutdown \
ksym-longterm-rk8xx-suspend \
ksym-longterm-rl6231-calc-dmic-clk \
ksym-longterm-rl6231-get-clk-info \
ksym-longterm-rl6231-get-pre-div \
ksym-longterm-rl6231-pll-calc \
ksym-longterm-rm3100-common-probe \
ksym-longterm-rm3100-readable-table \
ksym-longterm-rm3100-volatile-table \
ksym-longterm-rm3100-writable-table \
ksym-longterm-rmi-2d-sensor-abs-process \
ksym-longterm-rmi-2d-sensor-abs-report \
ksym-longterm-rmi-2d-sensor-configure-input \
ksym-longterm-rmi-2d-sensor-of-probe \
ksym-longterm-rmi-2d-sensor-rel-report \
ksym-longterm-rmi-dbg \
ksym-longterm-rmi-driver-resume \
ksym-longterm-rmi-driver-suspend \
ksym-longterm-rmi-of-property-read-u32 \
ksym-longterm-rmi-register-transport-device \
ksym-longterm-rmi-set-attn-data \
ksym-longterm-rmi-unregister-function-handler \
ksym-longterm-rmi-unregister-transport-device \
ksym-longterm-rndis-add-hdr \
ksym-longterm-rndis-borrow-net \
ksym-longterm-rndis-command \
ksym-longterm-rndis-deregister \
ksym-longterm-rndis-free-response \
ksym-longterm-rndis-get-next-response \
ksym-longterm-rndis-msg-parser \
ksym-longterm-rndis-register \
ksym-longterm-rndis-rm-hdr \
ksym-longterm-rndis-rx-fixup \
ksym-longterm-rndis-set-host-mac \
ksym-longterm-rndis-set-param-dev \
ksym-longterm-rndis-set-param-medium \
ksym-longterm-rndis-set-param-vendor \
ksym-longterm-rndis-signal-connect \
ksym-longterm-rndis-signal-disconnect \
ksym-longterm-rndis-status \
ksym-longterm-rndis-tx-fixup \
ksym-longterm-rndis-unbind \
ksym-longterm-rndis-uninit \
ksym-longterm-rng-is-initialized \
ksym-longterm-roccat-common2-device-init-struct \
ksym-longterm-roccat-common2-receive \
ksym-longterm-roccat-common2-send \
ksym-longterm-roccat-common2-send-with-status \
ksym-longterm-roccat-common2-sysfs-read \
ksym-longterm-roccat-common2-sysfs-write \
ksym-longterm-roccat-connect \
ksym-longterm-roccat-disconnect \
ksym-longterm-roccat-report-event \
ksym-longterm-roce-del-all-netdev-gids \
ksym-longterm-roce-gid-type-mask-support \
ksym-longterm-rockchip-clk-finalize \
ksym-longterm-rockchip-clk-find-max-clk-id \
ksym-longterm-rockchip-clk-init \
ksym-longterm-rockchip-clk-init-early \
ksym-longterm-rockchip-clk-of-add-provider \
ksym-longterm-rockchip-clk-protect-critical \
ksym-longterm-rockchip-clk-register-armclk \
ksym-longterm-rockchip-clk-register-branches \
ksym-longterm-rockchip-clk-register-ddrclk \
ksym-longterm-rockchip-clk-register-late-branches \
ksym-longterm-rockchip-clk-register-plls \
ksym-longterm-rockchip-drm-wait-vact-end \
ksym-longterm-rockchip-pcie-cfg-configuration-accesses \
ksym-longterm-rockchip-pcie-deinit-phys \
ksym-longterm-rockchip-pcie-disable-clocks \
ksym-longterm-rockchip-pcie-enable-clocks \
ksym-longterm-rockchip-pcie-get-phys \
ksym-longterm-rockchip-pcie-init-port \
ksym-longterm-rockchip-pcie-parse-dt \
ksym-longterm-rockchip-pmu-block \
ksym-longterm-rockchip-pmu-unblock \
ksym-longterm-rockchip-register-restart-notifier \
ksym-longterm-rockchip-register-softrst-lut \
ksym-longterm-rockchip-rgb-fini \
ksym-longterm-rockchip-rgb-init \
ksym-longterm-rocket-pm-ops \
ksym-longterm-rohm-regulator-set-dvs-levels \
ksym-longterm-rohm-regulator-set-voltage-sel-restricted \
ksym-longterm-root-device-unregister \
ksym-longterm-round-jiffies \
ksym-longterm-round-jiffies-relative \
ksym-longterm-round-jiffies-up \
ksym-longterm-round-jiffies-up-relative \
ksym-longterm-rpc-add-pipe-dir-object \
ksym-longterm-rpc-alloc-iostats \
ksym-longterm-rpc-bind-new-program \
ksym-longterm-rpc-calc-rto \
ksym-longterm-rpc-call-async \
ksym-longterm-rpc-call-null \
ksym-longterm-rpc-call-start \
ksym-longterm-rpc-call-sync \
ksym-longterm-rpc-cancel-tasks \
ksym-longterm-rpc-clnt-add-xprt \
ksym-longterm-rpc-clnt-disconnect \
ksym-longterm-rpc-clnt-iterate-for-each-xprt \
ksym-longterm-rpc-clnt-manage-trunked-xprts \
ksym-longterm-rpc-clnt-probe-trunked-xprts \
ksym-longterm-rpc-clnt-setup-test-and-add-xprt \
ksym-longterm-rpc-clnt-show-stats \
ksym-longterm-rpc-clnt-swap-activate \
ksym-longterm-rpc-clnt-swap-deactivate \
ksym-longterm-rpc-clnt-test-and-add-xprt \
ksym-longterm-rpc-clnt-xprt-switch-add-xprt \
ksym-longterm-rpc-clnt-xprt-switch-has-addr \
ksym-longterm-rpc-clnt-xprt-switch-remove-xprt \
ksym-longterm-rpc-clone-client \
ksym-longterm-rpc-clone-client-set-auth \
ksym-longterm-rpc-count-iostats \
ksym-longterm-rpc-count-iostats-metrics \
ksym-longterm-rpc-create \
ksym-longterm-rpc-d-lookup-sb \
ksym-longterm-rpc-debug \
ksym-longterm-rpc-delay \
ksym-longterm-rpc-destroy-pipe-data \
ksym-longterm-rpc-destroy-wait-queue \
ksym-longterm-rpc-exit \
ksym-longterm-rpc-find-or-alloc-pipe-dir-object \
ksym-longterm-rpc-force-rebind \
ksym-longterm-rpc-free-iostats \
ksym-longterm-rpc-get-sb-net \
ksym-longterm-rpc-init-pipe-dir-head \
ksym-longterm-rpc-init-pipe-dir-object \
ksym-longterm-rpc-init-priority-wait-queue \
ksym-longterm-rpc-init-rtt \
ksym-longterm-rpc-init-wait-queue \
ksym-longterm-rpc-killall-tasks \
ksym-longterm-rpc-localaddr \
ksym-longterm-rpc-machine-cred \
ksym-longterm-rpc-max-bc-payload \
ksym-longterm-rpc-max-payload \
ksym-longterm-rpc-mkpipe-data \
ksym-longterm-rpc-mkpipe-dentry \
ksym-longterm-rpc-net-ns \
ksym-longterm-rpc-ntop \
ksym-longterm-rpc-num-bc-slots \
ksym-longterm-rpc-peeraddr \
ksym-longterm-rpc-peeraddr2str \
ksym-longterm-rpc-pipe-generic-upcall \
ksym-longterm-rpc-pipefs-notifier-register \
ksym-longterm-rpc-pipefs-notifier-unregister \
ksym-longterm-rpc-prepare-reply-pages \
ksym-longterm-rpc-proc-register \
ksym-longterm-rpc-proc-unregister \
ksym-longterm-rpc-pton \
ksym-longterm-rpc-put-sb-net \
ksym-longterm-rpc-put-task \
ksym-longterm-rpc-put-task-async \
ksym-longterm-rpc-queue-upcall \
ksym-longterm-rpc-release-client \
ksym-longterm-rpc-remove-pipe-dir-object \
ksym-longterm-rpc-restart-call \
ksym-longterm-rpc-restart-call-prepare \
ksym-longterm-rpc-run-task \
ksym-longterm-rpc-set-connect-timeout \
ksym-longterm-rpc-setbufsize \
ksym-longterm-rpc-shutdown-client \
ksym-longterm-rpc-sleep-on \
ksym-longterm-rpc-sleep-on-priority \
ksym-longterm-rpc-sleep-on-priority-timeout \
ksym-longterm-rpc-sleep-on-timeout \
ksym-longterm-rpc-switch-client-transport \
ksym-longterm-rpc-task-gfp-mask \
ksym-longterm-rpc-task-release-transport \
ksym-longterm-rpc-task-timeout \
ksym-longterm-rpc-uaddr2sockaddr \
ksym-longterm-rpc-unlink \
ksym-longterm-rpc-update-rtt \
ksym-longterm-rpc-wait-for-completion-task \
ksym-longterm-rpc-wake-up \
ksym-longterm-rpc-wake-up-first \
ksym-longterm-rpc-wake-up-next \
ksym-longterm-rpc-wake-up-queued-task \
ksym-longterm-rpc-wake-up-status \
ksym-longterm-rpcauth-create \
ksym-longterm-rpcauth-destroy-credcache \
ksym-longterm-rpcauth-get-gssinfo \
ksym-longterm-rpcauth-get-pseudoflavor \
ksym-longterm-rpcauth-init-cred \
ksym-longterm-rpcauth-init-credcache \
ksym-longterm-rpcauth-lookup-credcache \
ksym-longterm-rpcauth-lookupcred \
ksym-longterm-rpcauth-register \
ksym-longterm-rpcauth-stringify-acceptor \
ksym-longterm-rpcauth-unregister \
ksym-longterm-rpcauth-unwrap-resp-decode \
ksym-longterm-rpcauth-wrap-req-encode \
ksym-longterm-rpcb-getport-async \
ksym-longterm-rpcif-dirmap-read \
ksym-longterm-rpcif-hw-init \
ksym-longterm-rpcif-manual-xfer \
ksym-longterm-rpcif-prepare \
ksym-longterm-rpcif-sw-init \
ksym-longterm-rpi-firmware-clk-get-max-rate \
ksym-longterm-rpi-firmware-find-node \
ksym-longterm-rpi-firmware-get \
ksym-longterm-rpi-firmware-property \
ksym-longterm-rpi-firmware-property-list \
ksym-longterm-rpi-firmware-put \
ksym-longterm-rpmb-dev-find-device \
ksym-longterm-rpmb-dev-get \
ksym-longterm-rpmb-dev-put \
ksym-longterm-rpmb-dev-register \
ksym-longterm-rpmb-dev-unregister \
ksym-longterm-rpmb-interface-register \
ksym-longterm-rpmb-interface-unregister \
ksym-longterm-rpmb-route-frames \
ksym-longterm-rpmh-invalidate \
ksym-longterm-rpmh-write \
ksym-longterm-rpmh-write-async \
ksym-longterm-rpmh-write-batch \
ksym-longterm-rpmsg-chrdev-eptdev-create \
ksym-longterm-rpmsg-chrdev-eptdev-destroy \
ksym-longterm-rpmsg-class \
ksym-longterm-rpmsg-create-channel \
ksym-longterm-rpmsg-create-ept \
ksym-longterm-rpmsg-destroy-ept \
ksym-longterm-rpmsg-find-device \
ksym-longterm-rpmsg-get-mtu \
ksym-longterm-rpmsg-ns-register-device \
ksym-longterm-rpmsg-poll \
ksym-longterm-rpmsg-register-device \
ksym-longterm-rpmsg-register-device-override \
ksym-longterm-rpmsg-release-channel \
ksym-longterm-rpmsg-send \
ksym-longterm-rpmsg-sendto \
ksym-longterm-rpmsg-set-flow-control \
ksym-longterm-rpmsg-trysend \
ksym-longterm-rpmsg-trysendto \
ksym-longterm-rpmsg-unregister-device \
ksym-longterm-rproc-add \
ksym-longterm-rproc-add-carveout \
ksym-longterm-rproc-add-subdev \
ksym-longterm-rproc-alloc \
ksym-longterm-rproc-boot \
ksym-longterm-rproc-coredump \
ksym-longterm-rproc-coredump-add-custom-segment \
ksym-longterm-rproc-coredump-add-segment \
ksym-longterm-rproc-coredump-cleanup \
ksym-longterm-rproc-coredump-set-elf-info \
ksym-longterm-rproc-coredump-using-sections \
ksym-longterm-rproc-da-to-va \
ksym-longterm-rproc-del \
ksym-longterm-rproc-detach \
ksym-longterm-rproc-elf-find-loaded-rsc-table \
ksym-longterm-rproc-elf-get-boot-addr \
ksym-longterm-rproc-elf-load-rsc-table \
ksym-longterm-rproc-elf-load-segments \
ksym-longterm-rproc-elf-sanity-check \
ksym-longterm-rproc-free \
ksym-longterm-rproc-get-by-child \
ksym-longterm-rproc-get-by-phandle \
ksym-longterm-rproc-mem-entry-init \
ksym-longterm-rproc-of-parse-firmware \
ksym-longterm-rproc-of-resm-mem-entry-init \
ksym-longterm-rproc-put \
ksym-longterm-rproc-remove-subdev \
ksym-longterm-rproc-report-crash \
ksym-longterm-rproc-resource-cleanup \
ksym-longterm-rproc-set-firmware \
ksym-longterm-rproc-shutdown \
ksym-longterm-rproc-va-to-pa \
ksym-longterm-rproc-vq-interrupt \
ksym-longterm-rps-may-expire-flow \
ksym-longterm-rps-needed \
ksym-longterm-rqspinlock-held-locks \
ksym-longterm-rs-pretty-print-rate \
ksym-longterm-rsa-parse-priv-key \
ksym-longterm-rsa-parse-pub-key \
ksym-longterm-rsi-91x-deinit \
ksym-longterm-rsi-91x-init \
ksym-longterm-rsi-bt-ops \
ksym-longterm-rsi-config-wowlan \
ksym-longterm-rsi-dbg \
ksym-longterm-rsi-hal-device-init \
ksym-longterm-rsi-mac80211-detach \
ksym-longterm-rsi-present \
ksym-longterm-rsi-read-pkt \
ksym-longterm-rsi-zone-enabled \
ksym-longterm-rt-dst-alloc \
ksym-longterm-rt-dst-clone \
ksym-longterm-rt-mutex-base-init \
ksym-longterm-rt-mutex-lock \
ksym-longterm-rt-mutex-lock-interruptible \
ksym-longterm-rt-mutex-lock-killable \
ksym-longterm-rt-mutex-trylock \
ksym-longterm-rt-mutex-unlock \
ksym-longterm-rt2800-ampdu-action \
ksym-longterm-rt2800-check-firmware \
ksym-longterm-rt2800-clear-beacon \
ksym-longterm-rt2800-conf-tx \
ksym-longterm-rt2800-config \
ksym-longterm-rt2800-config-ant \
ksym-longterm-rt2800-config-erp \
ksym-longterm-rt2800-config-filter \
ksym-longterm-rt2800-config-intf \
ksym-longterm-rt2800-config-pairwise-key \
ksym-longterm-rt2800-config-shared-key \
ksym-longterm-rt2800-disable-radio \
ksym-longterm-rt2800-disable-wpdma \
ksym-longterm-rt2800-efuse-detect \
ksym-longterm-rt2800-enable-radio \
ksym-longterm-rt2800-gain-calibration \
ksym-longterm-rt2800-get-key-seq \
ksym-longterm-rt2800-get-survey \
ksym-longterm-rt2800-get-tsf \
ksym-longterm-rt2800-get-txwi-rxwi-size \
ksym-longterm-rt2800-link-stats \
ksym-longterm-rt2800-link-tuner \
ksym-longterm-rt2800-load-firmware \
ksym-longterm-rt2800-mcu-request \
ksym-longterm-rt2800-pre-reset-hw \
ksym-longterm-rt2800-probe-hw \
ksym-longterm-rt2800-process-rxwi \
ksym-longterm-rt2800-read-eeprom-efuse \
ksym-longterm-rt2800-reset-tuner \
ksym-longterm-rt2800-rfkill-poll \
ksym-longterm-rt2800-set-rts-threshold \
ksym-longterm-rt2800-sta-add \
ksym-longterm-rt2800-sta-remove \
ksym-longterm-rt2800-txdone \
ksym-longterm-rt2800-txdone-entry \
ksym-longterm-rt2800-txdone-nostatus \
ksym-longterm-rt2800-txstatus-pending \
ksym-longterm-rt2800-txstatus-timeout \
ksym-longterm-rt2800-vco-calibration \
ksym-longterm-rt2800-wait-csr-ready \
ksym-longterm-rt2800-wait-wpdma-ready \
ksym-longterm-rt2800-watchdog \
ksym-longterm-rt2800-write-beacon \
ksym-longterm-rt2800-write-tx-data \
ksym-longterm-rt2800mmio-autowake-tasklet \
ksym-longterm-rt2800mmio-clear-entry \
ksym-longterm-rt2800mmio-enable-radio \
ksym-longterm-rt2800mmio-fill-rxdone \
ksym-longterm-rt2800mmio-flush-queue \
ksym-longterm-rt2800mmio-get-dma-done \
ksym-longterm-rt2800mmio-get-entry-state \
ksym-longterm-rt2800mmio-get-txwi \
ksym-longterm-rt2800mmio-init-queues \
ksym-longterm-rt2800mmio-init-registers \
ksym-longterm-rt2800mmio-interrupt \
ksym-longterm-rt2800mmio-kick-queue \
ksym-longterm-rt2800mmio-pretbtt-tasklet \
ksym-longterm-rt2800mmio-probe-hw \
ksym-longterm-rt2800mmio-queue-init \
ksym-longterm-rt2800mmio-rxdone-tasklet \
ksym-longterm-rt2800mmio-start-queue \
ksym-longterm-rt2800mmio-stop-queue \
ksym-longterm-rt2800mmio-tbtt-tasklet \
ksym-longterm-rt2800mmio-toggle-irq \
ksym-longterm-rt2800mmio-txstatus-tasklet \
ksym-longterm-rt2800mmio-write-tx-desc \
ksym-longterm-rt2x00lib-beacondone \
ksym-longterm-rt2x00lib-dmadone \
ksym-longterm-rt2x00lib-dmastart \
ksym-longterm-rt2x00lib-get-bssidx \
ksym-longterm-rt2x00lib-pretbtt \
ksym-longterm-rt2x00lib-probe-dev \
ksym-longterm-rt2x00lib-remove-dev \
ksym-longterm-rt2x00lib-resume \
ksym-longterm-rt2x00lib-rxdone \
ksym-longterm-rt2x00lib-set-mac-address \
ksym-longterm-rt2x00lib-suspend \
ksym-longterm-rt2x00lib-txdone \
ksym-longterm-rt2x00lib-txdone-noinfo \
ksym-longterm-rt2x00lib-txdone-nomatch \
ksym-longterm-rt2x00mac-add-interface \
ksym-longterm-rt2x00mac-bss-info-changed \
ksym-longterm-rt2x00mac-conf-tx \
ksym-longterm-rt2x00mac-config \
ksym-longterm-rt2x00mac-configure-filter \
ksym-longterm-rt2x00mac-flush \
ksym-longterm-rt2x00mac-get-antenna \
ksym-longterm-rt2x00mac-get-ringparam \
ksym-longterm-rt2x00mac-get-stats \
ksym-longterm-rt2x00mac-reconfig-complete \
ksym-longterm-rt2x00mac-remove-interface \
ksym-longterm-rt2x00mac-rfkill-poll \
ksym-longterm-rt2x00mac-set-antenna \
ksym-longterm-rt2x00mac-set-key \
ksym-longterm-rt2x00mac-set-tim \
ksym-longterm-rt2x00mac-start \
ksym-longterm-rt2x00mac-stop \
ksym-longterm-rt2x00mac-sw-scan-complete \
ksym-longterm-rt2x00mac-sw-scan-start \
ksym-longterm-rt2x00mac-tx \
ksym-longterm-rt2x00mac-tx-frames-pending \
ksym-longterm-rt2x00mmio-flush-queue \
ksym-longterm-rt2x00mmio-initialize \
ksym-longterm-rt2x00mmio-regbusy-read \
ksym-longterm-rt2x00mmio-rxdone \
ksym-longterm-rt2x00mmio-uninitialize \
ksym-longterm-rt2x00pci-pm-ops \
ksym-longterm-rt2x00pci-probe \
ksym-longterm-rt2x00pci-remove \
ksym-longterm-rt2x00queue-flush-queue \
ksym-longterm-rt2x00queue-flush-queues \
ksym-longterm-rt2x00queue-for-each-entry \
ksym-longterm-rt2x00queue-get-entry \
ksym-longterm-rt2x00queue-map-txskb \
ksym-longterm-rt2x00queue-pause-queue \
ksym-longterm-rt2x00queue-start-queue \
ksym-longterm-rt2x00queue-start-queues \
ksym-longterm-rt2x00queue-stop-queue \
ksym-longterm-rt2x00queue-stop-queues \
ksym-longterm-rt2x00queue-unmap-skb \
ksym-longterm-rt2x00queue-unpause-queue \
ksym-longterm-rt2x00usb-clear-entry \
ksym-longterm-rt2x00usb-disable-radio \
ksym-longterm-rt2x00usb-disconnect \
ksym-longterm-rt2x00usb-flush-queue \
ksym-longterm-rt2x00usb-initialize \
ksym-longterm-rt2x00usb-kick-queue \
ksym-longterm-rt2x00usb-probe \
ksym-longterm-rt2x00usb-regbusy-read \
ksym-longterm-rt2x00usb-register-read-async \
ksym-longterm-rt2x00usb-resume \
ksym-longterm-rt2x00usb-suspend \
ksym-longterm-rt2x00usb-uninitialize \
ksym-longterm-rt2x00usb-vendor-req-buff-lock \
ksym-longterm-rt2x00usb-vendor-request \
ksym-longterm-rt2x00usb-vendor-request-buff \
ksym-longterm-rt2x00usb-watchdog \
ksym-longterm-rt5514-spi-burst-read \
ksym-longterm-rt5514-spi-burst-write \
ksym-longterm-rt5640-detect-headset \
ksym-longterm-rt5640-disable-micbias1-for-ovcd \
ksym-longterm-rt5640-dmic-enable \
ksym-longterm-rt5640-enable-micbias1-for-ovcd \
ksym-longterm-rt5640-sel-asrc-clk-src \
ksym-longterm-rt5640-set-ovcd-params \
ksym-longterm-rt5645-components \
ksym-longterm-rt5645-sel-asrc-clk-src \
ksym-longterm-rt5645-set-jack-detect \
ksym-longterm-rt5659-set-jack-detect \
ksym-longterm-rt5663-sel-asrc-clk-src \
ksym-longterm-rt5682-aif1-dai-ops \
ksym-longterm-rt5682-aif2-dai-ops \
ksym-longterm-rt5682-apply-patch-list \
ksym-longterm-rt5682-calibrate \
ksym-longterm-rt5682-get-ldo1 \
ksym-longterm-rt5682-jack-detect-handler \
ksym-longterm-rt5682-parse-dt \
ksym-longterm-rt5682-readable-register \
ksym-longterm-rt5682-reg \
ksym-longterm-rt5682-register-dai-clks \
ksym-longterm-rt5682-reset \
ksym-longterm-rt5682-sel-asrc-clk-src \
ksym-longterm-rt5682-soc-component-dev \
ksym-longterm-rt5682-supply-names \
ksym-longterm-rt5682-volatile-register \
ksym-longterm-rt5682s-sel-asrc-clk-src \
ksym-longterm-rt6-lookup \
ksym-longterm-rtc-add-group \
ksym-longterm-rtc-add-groups \
ksym-longterm-rtc-alarm-irq-enable \
ksym-longterm-rtc-class-close \
ksym-longterm-rtc-class-open \
ksym-longterm-rtc-initialize-alarm \
ksym-longterm-rtc-ktime-to-tm \
ksym-longterm-rtc-month-days \
ksym-longterm-rtc-read-alarm \
ksym-longterm-rtc-read-time \
ksym-longterm-rtc-set-alarm \
ksym-longterm-rtc-set-time \
ksym-longterm-rtc-time64-to-tm \
ksym-longterm-rtc-tm-to-ktime \
ksym-longterm-rtc-tm-to-time64 \
ksym-longterm-rtc-update-irq \
ksym-longterm-rtc-update-irq-enable \
ksym-longterm-rtc-valid-tm \
ksym-longterm-rtc-year-days \
ksym-longterm-rtd-pinctrl-probe \
ksym-longterm-rtl-action-proc \
ksym-longterm-rtl-addr-delay \
ksym-longterm-rtl-beacon-statistic \
ksym-longterm-rtl-btc-get-ops-pointer \
ksym-longterm-rtl-btc-status-false \
ksym-longterm-rtl-c2hcmd-enqueue \
ksym-longterm-rtl-cam-add-one-entry \
ksym-longterm-rtl-cam-del-entry \
ksym-longterm-rtl-cam-delete-one-entry \
ksym-longterm-rtl-cam-empty-entry \
ksym-longterm-rtl-cam-get-free-entry \
ksym-longterm-rtl-cam-mark-invalid \
ksym-longterm-rtl-cam-reset-all-entry \
ksym-longterm-rtl-cmd-send-packet \
ksym-longterm-rtl-collect-scan-list \
ksym-longterm-rtl-debug-add-one \
ksym-longterm-rtl-debug-remove-one \
ksym-longterm-rtl-deinit-core \
ksym-longterm-rtl-deinit-deferred-work \
ksym-longterm-rtl-deinit-rfkill \
ksym-longterm-rtl-dm-diginit \
ksym-longterm-rtl-efuse-ops-init \
ksym-longterm-rtl-efuse-shadow-map-update \
ksym-longterm-rtl-evm-db-to-percentage \
ksym-longterm-rtl-fill-dummy \
ksym-longterm-rtl-fw-block-write \
ksym-longterm-rtl-fw-cb \
ksym-longterm-rtl-fw-page-write \
ksym-longterm-rtl-get-hal-edca-param \
ksym-longterm-rtl-get-hwinfo \
ksym-longterm-rtl-get-tcb-desc \
ksym-longterm-rtl-hal-pwrseqcmdparsing \
ksym-longterm-rtl-init-core \
ksym-longterm-rtl-init-rfkill \
ksym-longterm-rtl-init-rx-config \
ksym-longterm-rtl-init-sw-leds \
ksym-longterm-rtl-ips-nic-on \
ksym-longterm-rtl-is-special-data \
ksym-longterm-rtl-lps-change-work-callback \
ksym-longterm-rtl-lps-enter \
ksym-longterm-rtl-lps-leave \
ksym-longterm-rtl-mrate-idx-to-arfr-id \
ksym-longterm-rtl-ops \
ksym-longterm-rtl-p2p-info \
ksym-longterm-rtl-pci-disconnect \
ksym-longterm-rtl-pci-probe \
ksym-longterm-rtl-pci-resume \
ksym-longterm-rtl-pci-suspend \
ksym-longterm-rtl-phy-scan-operation-backup \
ksym-longterm-rtl-process-phyinfo \
ksym-longterm-rtl-ps-disable-nic \
ksym-longterm-rtl-ps-enable-nic \
ksym-longterm-rtl-query-rxpwrpercentage \
ksym-longterm-rtl-recognize-peer \
ksym-longterm-rtl-rfreg-delay \
ksym-longterm-rtl-rx-ampdu-apply \
ksym-longterm-rtl-send-smps-action \
ksym-longterm-rtl-set-tx-report \
ksym-longterm-rtl-signal-scale-mapping \
ksym-longterm-rtl-swlps-beacon \
ksym-longterm-rtl-tid-to-ac \
ksym-longterm-rtl-tx-ackqueue \
ksym-longterm-rtl-tx-mgmt-proc \
ksym-longterm-rtl-tx-report-handler \
ksym-longterm-rtl-update-beacon-work-callback \
ksym-longterm-rtl-usb-disconnect \
ksym-longterm-rtl-usb-probe \
ksym-longterm-rtl-wowlan-fw-cb \
ksym-longterm-rtl8152-get-version \
ksym-longterm-rtl8192-phy-check-is-legal-rfpath \
ksym-longterm-rtl8366-enable-vlan \
ksym-longterm-rtl8366-enable-vlan4k \
ksym-longterm-rtl8366-get-ethtool-stats \
ksym-longterm-rtl8366-get-sset-count \
ksym-longterm-rtl8366-get-strings \
ksym-longterm-rtl8366-mc-is-used \
ksym-longterm-rtl8366-reset-vlan \
ksym-longterm-rtl8366-set-pvid \
ksym-longterm-rtl8366-set-vlan \
ksym-longterm-rtl8366-vlan-add \
ksym-longterm-rtl8366-vlan-del \
ksym-longterm-rtl83xx-lock \
ksym-longterm-rtl83xx-probe \
ksym-longterm-rtl83xx-register-switch \
ksym-longterm-rtl83xx-remove \
ksym-longterm-rtl83xx-setup-user-mdio \
ksym-longterm-rtl83xx-shutdown \
ksym-longterm-rtl83xx-unlock \
ksym-longterm-rtl83xx-unregister-switch \
ksym-longterm-rtl8723-dm-init-dynamic-bb-powersaving \
ksym-longterm-rtl8723-dm-init-dynamic-txpower \
ksym-longterm-rtl8723-dm-init-edca-turbo \
ksym-longterm-rtl8723-download-fw \
ksym-longterm-rtl8723-enable-fw-download \
ksym-longterm-rtl8723-fw-free-to-go \
ksym-longterm-rtl8723-phy-init-bb-rf-reg-def \
ksym-longterm-rtl8723-phy-mac-setting-calibration \
ksym-longterm-rtl8723-phy-path-a-fill-iqk-matrix \
ksym-longterm-rtl8723-phy-path-a-standby \
ksym-longterm-rtl8723-phy-path-adda-on \
ksym-longterm-rtl8723-phy-pi-mode-switch \
ksym-longterm-rtl8723-phy-query-bb-reg \
ksym-longterm-rtl8723-phy-reload-adda-registers \
ksym-longterm-rtl8723-phy-reload-mac-registers \
ksym-longterm-rtl8723-phy-rf-serial-read \
ksym-longterm-rtl8723-phy-rf-serial-write \
ksym-longterm-rtl8723-phy-save-mac-registers \
ksym-longterm-rtl8723-phy-set-bb-reg \
ksym-longterm-rtl8723-phy-set-sw-chnl-cmdarray \
ksym-longterm-rtl8723-phy-txpwr-idx-to-dbm \
ksym-longterm-rtl8723-save-adda-registers \
ksym-longterm-rtl8723-write-fw \
ksym-longterm-rtl8723ae-firmware-selfreset \
ksym-longterm-rtl8723be-firmware-selfreset \
ksym-longterm-rtl92c-bt-rssi-state-change \
ksym-longterm-rtl92c-dm-bt-coexist \
ksym-longterm-rtl92c-dm-check-txpower-tracking \
ksym-longterm-rtl92c-dm-init \
ksym-longterm-rtl92c-dm-init-edca-turbo \
ksym-longterm-rtl92c-dm-init-rate-adaptive-mask \
ksym-longterm-rtl92c-dm-rf-saving \
ksym-longterm-rtl92c-dm-watchdog \
ksym-longterm-rtl92c-dm-write-dig \
ksym-longterm-rtl92c-download-fw \
ksym-longterm-rtl92c-fill-h2c-cmd \
ksym-longterm-rtl92c-firmware-selfreset \
ksym-longterm-rtl92c-phy-ap-calibrate \
ksym-longterm-rtl92c-phy-iq-calibrate \
ksym-longterm-rtl92c-phy-lc-calibrate \
ksym-longterm-rtl92c-phy-query-bb-reg \
ksym-longterm-rtl92c-phy-rf-config \
ksym-longterm-rtl92c-phy-set-bb-reg \
ksym-longterm-rtl92c-phy-set-bw-mode \
ksym-longterm-rtl92c-phy-set-io \
ksym-longterm-rtl92c-phy-set-io-cmd \
ksym-longterm-rtl92c-phy-set-rfpath-switch \
ksym-longterm-rtl92c-phy-set-txpower-level \
ksym-longterm-rtl92c-phy-sw-chnl \
ksym-longterm-rtl92c-phy-sw-chnl-callback \
ksym-longterm-rtl92c-phy-update-txpower-dbm \
ksym-longterm-rtl92c-set-fw-joinbss-report-cmd \
ksym-longterm-rtl92c-set-fw-pwrmode-cmd \
ksym-longterm-rtl92c-set-fw-rsvdpagepkt \
ksym-longterm-rtl92c-set-p2p-ps-offload-cmd \
ksym-longterm-rtl92ce-phy-set-rf-on \
ksym-longterm-rtl92d-dm-check-edca-turbo \
ksym-longterm-rtl92d-dm-check-txpower-tracking-thermal-meter \
ksym-longterm-rtl92d-dm-dig \
ksym-longterm-rtl92d-dm-false-alarm-counter-statistics \
ksym-longterm-rtl92d-dm-find-minimum-rssi \
ksym-longterm-rtl92d-dm-init-edca-turbo \
ksym-longterm-rtl92d-dm-init-rate-adaptive-mask \
ksym-longterm-rtl92d-dm-initialize-txpower-tracking \
ksym-longterm-rtl92d-dm-write-dig \
ksym-longterm-rtl92d-enable-fw-download \
ksym-longterm-rtl92d-enable-hw-security-config \
ksym-longterm-rtl92d-fill-h2c-cmd \
ksym-longterm-rtl92d-firmware-selfreset \
ksym-longterm-rtl92d-fw-free-to-go \
ksym-longterm-rtl92d-fw-init \
ksym-longterm-rtl92d-get-chnlgroup-fromarray \
ksym-longterm-rtl92d-get-desc \
ksym-longterm-rtl92d-get-hw-reg \
ksym-longterm-rtl92d-get-rightchnlplace-for-iqk \
ksym-longterm-rtl92d-gpio-radio-on-off-checking \
ksym-longterm-rtl92d-is-fw-downloaded \
ksym-longterm-rtl92d-llt-write \
ksym-longterm-rtl92d-phy-calc-curvindex \
ksym-longterm-rtl92d-phy-config-maccoexist-rfpage \
ksym-longterm-rtl92d-phy-config-macphymode \
ksym-longterm-rtl92d-phy-config-macphymode-info \
ksym-longterm-rtl92d-phy-enable-rf-env \
ksym-longterm-rtl92d-phy-get-hw-reg-originalvalue \
ksym-longterm-rtl92d-phy-init-bb-rf-register-definition \
ksym-longterm-rtl92d-phy-mac-setting-calibration \
ksym-longterm-rtl92d-phy-path-adda-on \
ksym-longterm-rtl92d-phy-query-rf-reg \
ksym-longterm-rtl92d-phy-reset-iqk-result \
ksym-longterm-rtl92d-phy-restore-rf-env \
ksym-longterm-rtl92d-phy-rf6052-set-bandwidth \
ksym-longterm-rtl92d-phy-rf6052-set-cck-txpower \
ksym-longterm-rtl92d-phy-rf6052-set-ofdm-txpower \
ksym-longterm-rtl92d-phy-save-adda-registers \
ksym-longterm-rtl92d-phy-save-mac-registers \
ksym-longterm-rtl92d-phy-set-io-cmd \
ksym-longterm-rtl92d-phy-set-rf-reg \
ksym-longterm-rtl92d-phy-set-txpower-level \
ksym-longterm-rtl92d-read-eeprom-info \
ksym-longterm-rtl92d-resume-tx-beacon \
ksym-longterm-rtl92d-rx-query-desc \
ksym-longterm-rtl92d-set-desc \
ksym-longterm-rtl92d-set-fw-joinbss-report-cmd \
ksym-longterm-rtl92d-set-hw-reg \
ksym-longterm-rtl92d-set-key \
ksym-longterm-rtl92d-set-qos \
ksym-longterm-rtl92d-stop-tx-beacon \
ksym-longterm-rtl92d-store-pwrindex-diffrate-offset \
ksym-longterm-rtl92d-update-channel-access-setting \
ksym-longterm-rtl92d-update-hal-rate-tbl \
ksym-longterm-rtl92d-write-fw \
ksym-longterm-rtlwifi-rate-mapping \
ksym-longterm-rtm-getroute-parse-ip-proto \
ksym-longterm-rtnetlink-put-metrics \
ksym-longterm-rtnl-af-register \
ksym-longterm-rtnl-af-unregister \
ksym-longterm-rtnl-configure-link \
ksym-longterm-rtnl-create-link \
ksym-longterm-rtnl-delete-link \
ksym-longterm-rtnl-dev-link-net-capable \
ksym-longterm-rtnl-get-net-ns-capable \
ksym-longterm-rtnl-is-locked \
ksym-longterm-rtnl-kfree-skbs \
ksym-longterm-rtnl-link-get-net \
ksym-longterm-rtnl-link-register \
ksym-longterm-rtnl-link-unregister \
ksym-longterm-rtnl-lock \
ksym-longterm-rtnl-nla-parse-ifinfomsg \
ksym-longterm-rtnl-notify \
ksym-longterm-rtnl-offload-xstats-notify \
ksym-longterm-rtnl-put-cacheinfo \
ksym-longterm-rtnl-set-sk-err \
ksym-longterm-rtnl-trylock \
ksym-longterm-rtnl-unicast \
ksym-longterm-rtnl-unlock \
ksym-longterm-rtnl-unregister-all \
ksym-longterm-rtrs-addr-to-sockaddr \
ksym-longterm-rtrs-addr-to-str \
ksym-longterm-rtrs-clt-close \
ksym-longterm-rtrs-clt-get-permit \
ksym-longterm-rtrs-clt-open \
ksym-longterm-rtrs-clt-put-permit \
ksym-longterm-rtrs-clt-query \
ksym-longterm-rtrs-clt-rdma-cq-direct \
ksym-longterm-rtrs-clt-request \
ksym-longterm-rtrs-cq-qp-create \
ksym-longterm-rtrs-cq-qp-destroy \
ksym-longterm-rtrs-ib-dev-find-or-add \
ksym-longterm-rtrs-ib-dev-put \
ksym-longterm-rtrs-init-hb \
ksym-longterm-rtrs-iu-alloc \
ksym-longterm-rtrs-iu-free \
ksym-longterm-rtrs-iu-post-rdma-write-imm \
ksym-longterm-rtrs-iu-post-recv \
ksym-longterm-rtrs-iu-post-send \
ksym-longterm-rtrs-post-recv-empty \
ksym-longterm-rtrs-rdma-dev-pd-deinit \
ksym-longterm-rtrs-rdma-dev-pd-init \
ksym-longterm-rtrs-send-hb-ack \
ksym-longterm-rtrs-srv-close \
ksym-longterm-rtrs-srv-get-path-name \
ksym-longterm-rtrs-srv-get-queue-depth \
ksym-longterm-rtrs-srv-open \
ksym-longterm-rtrs-srv-resp-rdma \
ksym-longterm-rtrs-srv-set-sess-priv \
ksym-longterm-rtrs-start-hb \
ksym-longterm-rtrs-stop-hb \
ksym-longterm-rtsx-pci-add-cmd \
ksym-longterm-rtsx-pci-card-exclusive-check \
ksym-longterm-rtsx-pci-card-exist \
ksym-longterm-rtsx-pci-card-power-off \
ksym-longterm-rtsx-pci-card-power-on \
ksym-longterm-rtsx-pci-card-pull-ctl-disable \
ksym-longterm-rtsx-pci-card-pull-ctl-enable \
ksym-longterm-rtsx-pci-complete-unfinished-transfer \
ksym-longterm-rtsx-pci-dma-map-sg \
ksym-longterm-rtsx-pci-dma-transfer \
ksym-longterm-rtsx-pci-dma-unmap-sg \
ksym-longterm-rtsx-pci-read-phy-register \
ksym-longterm-rtsx-pci-read-ppbuf \
ksym-longterm-rtsx-pci-read-register \
ksym-longterm-rtsx-pci-send-cmd \
ksym-longterm-rtsx-pci-send-cmd-no-wait \
ksym-longterm-rtsx-pci-start-run \
ksym-longterm-rtsx-pci-stop-cmd \
ksym-longterm-rtsx-pci-switch-clock \
ksym-longterm-rtsx-pci-switch-output-voltage \
ksym-longterm-rtsx-pci-write-phy-register \
ksym-longterm-rtsx-pci-write-ppbuf \
ksym-longterm-rtsx-pci-write-register \
ksym-longterm-rtsx-usb-add-cmd \
ksym-longterm-rtsx-usb-card-exclusive-check \
ksym-longterm-rtsx-usb-ep0-read-register \
ksym-longterm-rtsx-usb-ep0-write-register \
ksym-longterm-rtsx-usb-get-card-status \
ksym-longterm-rtsx-usb-get-rsp \
ksym-longterm-rtsx-usb-read-ppbuf \
ksym-longterm-rtsx-usb-read-register \
ksym-longterm-rtsx-usb-send-cmd \
ksym-longterm-rtsx-usb-switch-clock \
ksym-longterm-rtsx-usb-transfer-data \
ksym-longterm-rtsx-usb-write-ppbuf \
ksym-longterm-rtsx-usb-write-register \
ksym-longterm-rtw-bf-cfg-csi-rate \
ksym-longterm-rtw-bf-enable-bfee-mu \
ksym-longterm-rtw-bf-enable-bfee-su \
ksym-longterm-rtw-bf-phy-init \
ksym-longterm-rtw-bf-remove-bfee-mu \
ksym-longterm-rtw-bf-remove-bfee-su \
ksym-longterm-rtw-bf-set-gid-table \
ksym-longterm-rtw-chip-info-setup \
ksym-longterm-rtw-coex-init-hw-config \
ksym-longterm-rtw-coex-power-off-setting \
ksym-longterm-rtw-coex-power-on-setting \
ksym-longterm-rtw-coex-read-indirect-reg \
ksym-longterm-rtw-coex-write-indirect-reg \
ksym-longterm-rtw-coex-write-scbd \
ksym-longterm-rtw-core-deinit \
ksym-longterm-rtw-core-init \
ksym-longterm-rtw-debug-mask \
ksym-longterm-rtw-disable-lps-deep-mode \
ksym-longterm-rtw-download-firmware \
ksym-longterm-rtw-dump-fw \
ksym-longterm-rtw-dump-reg \
ksym-longterm-rtw-fw-c2h-cmd-isr \
ksym-longterm-rtw-fw-c2h-cmd-rx-irqsafe \
ksym-longterm-rtw-fw-do-iqk \
ksym-longterm-rtw-fw-inform-rfk-status \
ksym-longterm-rtw-fw-recovery \
ksym-longterm-rtw-ops \
ksym-longterm-rtw-parse-tbl-bb-pg \
ksym-longterm-rtw-parse-tbl-phy-cond \
ksym-longterm-rtw-parse-tbl-txpwr-lmt \
ksym-longterm-rtw-pci-err-handler \
ksym-longterm-rtw-pci-probe \
ksym-longterm-rtw-pci-remove \
ksym-longterm-rtw-pci-shutdown \
ksym-longterm-rtw-phy-cfg-agc \
ksym-longterm-rtw-phy-cfg-bb \
ksym-longterm-rtw-phy-cfg-mac \
ksym-longterm-rtw-phy-cfg-rf \
ksym-longterm-rtw-phy-config-swing-table \
ksym-longterm-rtw-phy-get-tx-power-index \
ksym-longterm-rtw-phy-init \
ksym-longterm-rtw-phy-load-tables \
ksym-longterm-rtw-phy-parsing-cfo \
ksym-longterm-rtw-phy-pwrtrack-avg \
ksym-longterm-rtw-phy-pwrtrack-get-delta \
ksym-longterm-rtw-phy-pwrtrack-get-pwridx \
ksym-longterm-rtw-phy-pwrtrack-need-iqk \
ksym-longterm-rtw-phy-pwrtrack-need-lck \
ksym-longterm-rtw-phy-pwrtrack-thermal-changed \
ksym-longterm-rtw-phy-read-rf \
ksym-longterm-rtw-phy-read-rf-sipi \
ksym-longterm-rtw-phy-rf-power-2-rssi \
ksym-longterm-rtw-phy-set-edcca-th \
ksym-longterm-rtw-phy-set-tx-power-level \
ksym-longterm-rtw-phy-write-rf-reg-mix \
ksym-longterm-rtw-phy-write-rf-reg-sipi \
ksym-longterm-rtw-pm-ops \
ksym-longterm-rtw-power-mode-change \
ksym-longterm-rtw-power-off \
ksym-longterm-rtw-power-on \
ksym-longterm-rtw-pwr-seq-parser \
ksym-longterm-rtw-rate-section \
ksym-longterm-rtw-rate-size \
ksym-longterm-rtw-read8-physical-efuse \
ksym-longterm-rtw-regd-get \
ksym-longterm-rtw-regd-srrc \
ksym-longterm-rtw-register-hw \
ksym-longterm-rtw-restore-reg \
ksym-longterm-rtw-rx-query-rx-desc \
ksym-longterm-rtw-rx-stats \
ksym-longterm-rtw-sdio-pm-ops \
ksym-longterm-rtw-sdio-probe \
ksym-longterm-rtw-sdio-remove \
ksym-longterm-rtw-sdio-shutdown \
ksym-longterm-rtw-set-channel-mac \
ksym-longterm-rtw-set-rx-freq-band \
ksym-longterm-rtw-set-trx-fifo-info \
ksym-longterm-rtw-tx-ac-to-hwq \
ksym-longterm-rtw-tx-fill-tx-desc \
ksym-longterm-rtw-tx-queue-mapping \
ksym-longterm-rtw-tx-report-enqueue \
ksym-longterm-rtw-tx-write-data-h2c-get \
ksym-longterm-rtw-tx-write-data-rsvd-page-get \
ksym-longterm-rtw-unregister-hw \
ksym-longterm-rtw-update-rx-freq-from-ie \
ksym-longterm-rtw-usb-disconnect \
ksym-longterm-rtw-usb-probe \
ksym-longterm-rtw-wait-firmware-completion \
ksym-longterm-rtw-write-firmware-page \
ksym-longterm-rtw8703b-hw-spec \
ksym-longterm-rtw8723d-hw-spec \
ksym-longterm-rtw8723x-common \
ksym-longterm-rtw8812a-hw-spec \
ksym-longterm-rtw8814a-hw-spec \
ksym-longterm-rtw8821a-hw-spec \
ksym-longterm-rtw8821c-hw-spec \
ksym-longterm-rtw8822b-hw-spec \
ksym-longterm-rtw8822c-hw-spec \
ksym-longterm-rtw8851b-chip-info \
ksym-longterm-rtw8852a-chip-info \
ksym-longterm-rtw8852b-chip-info \
ksym-longterm-rtw8852bt-chip-info \
ksym-longterm-rtw8852bx-info \
ksym-longterm-rtw8852c-chip-info \
ksym-longterm-rtw88xxa-efuse-grant \
ksym-longterm-rtw88xxa-false-alarm-statistics \
ksym-longterm-rtw88xxa-iqk-backup-afe \
ksym-longterm-rtw88xxa-iqk-backup-mac-bb \
ksym-longterm-rtw88xxa-iqk-configure-mac \
ksym-longterm-rtw88xxa-iqk-finish \
ksym-longterm-rtw88xxa-iqk-restore-mac-bb \
ksym-longterm-rtw88xxa-phy-cck-pd-set \
ksym-longterm-rtw88xxa-phy-pwrtrack \
ksym-longterm-rtw88xxa-phy-read-rf \
ksym-longterm-rtw88xxa-power-off \
ksym-longterm-rtw88xxa-power-on \
ksym-longterm-rtw88xxa-query-phy-status \
ksym-longterm-rtw88xxa-read-efuse \
ksym-longterm-rtw88xxa-set-channel \
ksym-longterm-rtw88xxa-set-tx-power-index \
ksym-longterm-rtw89-alloc-ieee80211-hw \
ksym-longterm-rtw89-bd-ram-table-dual \
ksym-longterm-rtw89-bd-ram-table-single \
ksym-longterm-rtw89-btc-ntfy-conn-rfk \
ksym-longterm-rtw89-btc-ntfy-preserve-bt-time \
ksym-longterm-rtw89-btc-ntfy-wl-rfk \
ksym-longterm-rtw89-btc-set-policy \
ksym-longterm-rtw89-btc-set-policy-v1 \
ksym-longterm-rtw89-check-quirks \
ksym-longterm-rtw89-chip-info-setup \
ksym-longterm-rtw89-core-deinit \
ksym-longterm-rtw89-core-fill-txdesc \
ksym-longterm-rtw89-core-fill-txdesc-fwcmd-v1 \
ksym-longterm-rtw89-core-fill-txdesc-fwcmd-v2 \
ksym-longterm-rtw89-core-fill-txdesc-v1 \
ksym-longterm-rtw89-core-fill-txdesc-v2 \
ksym-longterm-rtw89-core-get-ch-dma \
ksym-longterm-rtw89-core-get-ch-dma-v1 \
ksym-longterm-rtw89-core-init \
ksym-longterm-rtw89-core-napi-deinit \
ksym-longterm-rtw89-core-napi-init \
ksym-longterm-rtw89-core-napi-start \
ksym-longterm-rtw89-core-napi-stop \
ksym-longterm-rtw89-core-query-rxdesc \
ksym-longterm-rtw89-core-query-rxdesc-v2 \
ksym-longterm-rtw89-core-register \
ksym-longterm-rtw89-core-rx \
ksym-longterm-rtw89-core-unregister \
ksym-longterm-rtw89-db-quarter-to-linear \
ksym-longterm-rtw89-db-to-linear \
ksym-longterm-rtw89-decode-chan-idx \
ksym-longterm-rtw89-encode-chan-idx \
ksym-longterm-rtw89-free-ieee80211-hw \
ksym-longterm-rtw89-fw-blacklist-default \
ksym-longterm-rtw89-fw-h2c-ampdu-cmac-tbl-g7 \
ksym-longterm-rtw89-fw-h2c-assoc-cmac-tbl \
ksym-longterm-rtw89-fw-h2c-assoc-cmac-tbl-g7 \
ksym-longterm-rtw89-fw-h2c-ba-cam \
ksym-longterm-rtw89-fw-h2c-ba-cam-v1 \
ksym-longterm-rtw89-fw-h2c-dctl-sec-cam-v1 \
ksym-longterm-rtw89-fw-h2c-dctl-sec-cam-v2 \
ksym-longterm-rtw89-fw-h2c-default-cmac-tbl \
ksym-longterm-rtw89-fw-h2c-default-cmac-tbl-g7 \
ksym-longterm-rtw89-fw-h2c-default-dmac-tbl-v2 \
ksym-longterm-rtw89-fw-h2c-punctured-cmac-tbl-g7 \
ksym-longterm-rtw89-fw-h2c-rf-ntfy-mcc \
ksym-longterm-rtw89-fw-h2c-rf-ps-info \
ksym-longterm-rtw89-fw-h2c-txtime-cmac-tbl \
ksym-longterm-rtw89-fw-h2c-txtime-cmac-tbl-g7 \
ksym-longterm-rtw89-fw-h2c-update-beacon \
ksym-longterm-rtw89-fw-h2c-update-beacon-be \
ksym-longterm-rtw89-linear-to-db \
ksym-longterm-rtw89-linear-to-db-quarter \
ksym-longterm-rtw89-mac-cfg-ctrl-path \
ksym-longterm-rtw89-mac-cfg-ctrl-path-v1 \
ksym-longterm-rtw89-mac-cfg-ctrl-path-v2 \
ksym-longterm-rtw89-mac-cfg-gnt \
ksym-longterm-rtw89-mac-cfg-gnt-v1 \
ksym-longterm-rtw89-mac-cfg-gnt-v2 \
ksym-longterm-rtw89-mac-cfg-phy-rpt-be \
ksym-longterm-rtw89-mac-coex-init \
ksym-longterm-rtw89-mac-coex-init-v1 \
ksym-longterm-rtw89-mac-disable-bb-rf \
ksym-longterm-rtw89-mac-enable-bb-rf \
ksym-longterm-rtw89-mac-gen-ax \
ksym-longterm-rtw89-mac-gen-be \
ksym-longterm-rtw89-mac-get-err-status \
ksym-longterm-rtw89-mac-resume-sch-tx \
ksym-longterm-rtw89-mac-resume-sch-tx-v1 \
ksym-longterm-rtw89-mac-resume-sch-tx-v2 \
ksym-longterm-rtw89-mac-set-err-status \
ksym-longterm-rtw89-mac-size \
ksym-longterm-rtw89-mac-stop-sch-tx \
ksym-longterm-rtw89-mac-stop-sch-tx-v1 \
ksym-longterm-rtw89-mac-stop-sch-tx-v2 \
ksym-longterm-rtw89-ops \
ksym-longterm-rtw89-pci-ch-dma-addr-set \
ksym-longterm-rtw89-pci-ch-dma-addr-set-be \
ksym-longterm-rtw89-pci-ch-dma-addr-set-be-v1 \
ksym-longterm-rtw89-pci-ch-dma-addr-set-v1 \
ksym-longterm-rtw89-pci-config-intr-mask \
ksym-longterm-rtw89-pci-config-intr-mask-v1 \
ksym-longterm-rtw89-pci-config-intr-mask-v2 \
ksym-longterm-rtw89-pci-config-intr-mask-v3 \
ksym-longterm-rtw89-pci-disable-intr \
ksym-longterm-rtw89-pci-disable-intr-v1 \
ksym-longterm-rtw89-pci-disable-intr-v2 \
ksym-longterm-rtw89-pci-disable-intr-v3 \
ksym-longterm-rtw89-pci-enable-intr \
ksym-longterm-rtw89-pci-enable-intr-v1 \
ksym-longterm-rtw89-pci-enable-intr-v2 \
ksym-longterm-rtw89-pci-enable-intr-v3 \
ksym-longterm-rtw89-pci-err-handler \
ksym-longterm-rtw89-pci-fill-txaddr-info \
ksym-longterm-rtw89-pci-fill-txaddr-info-v1 \
ksym-longterm-rtw89-pci-gen-ax \
ksym-longterm-rtw89-pci-gen-be \
ksym-longterm-rtw89-pci-isr-ax \
ksym-longterm-rtw89-pci-isr-be \
ksym-longterm-rtw89-pci-isr-be-v1 \
ksym-longterm-rtw89-pci-ltr-set \
ksym-longterm-rtw89-pci-ltr-set-v1 \
ksym-longterm-rtw89-pci-ltr-set-v2 \
ksym-longterm-rtw89-pci-parse-rpp \
ksym-longterm-rtw89-pci-parse-rpp-v1 \
ksym-longterm-rtw89-pci-probe \
ksym-longterm-rtw89-pci-recognize-intrs \
ksym-longterm-rtw89-pci-recognize-intrs-v1 \
ksym-longterm-rtw89-pci-recognize-intrs-v2 \
ksym-longterm-rtw89-pci-recognize-intrs-v3 \
ksym-longterm-rtw89-pci-remove \
ksym-longterm-rtw89-phy-ant-gain-pwr-offset \
ksym-longterm-rtw89-phy-config-rf-reg-v1 \
ksym-longterm-rtw89-phy-gen-ax \
ksym-longterm-rtw89-phy-gen-be \
ksym-longterm-rtw89-phy-get-kpath \
ksym-longterm-rtw89-phy-get-syn-sel \
ksym-longterm-rtw89-phy-get-txsb \
ksym-longterm-rtw89-phy-get-txsc \
ksym-longterm-rtw89-phy-load-txpwr-byrate \
ksym-longterm-rtw89-phy-read-rf \
ksym-longterm-rtw89-phy-read-rf-v1 \
ksym-longterm-rtw89-phy-read-rf-v2 \
ksym-longterm-rtw89-phy-read-txpwr-limit \
ksym-longterm-rtw89-phy-read32-idx \
ksym-longterm-rtw89-phy-rfk-dack-and-wait \
ksym-longterm-rtw89-phy-rfk-dpk-and-wait \
ksym-longterm-rtw89-phy-rfk-iqk-and-wait \
ksym-longterm-rtw89-phy-rfk-pre-ntfy-and-wait \
ksym-longterm-rtw89-phy-rfk-rxdck-and-wait \
ksym-longterm-rtw89-phy-rfk-tssi-and-wait \
ksym-longterm-rtw89-phy-rfk-txgapk-and-wait \
ksym-longterm-rtw89-phy-set-phy-regs \
ksym-longterm-rtw89-phy-tssi-ctrl-set-bandedge-cfg \
ksym-longterm-rtw89-phy-write-reg3-tbl \
ksym-longterm-rtw89-phy-write-rf \
ksym-longterm-rtw89-phy-write-rf-v1 \
ksym-longterm-rtw89-phy-write-rf-v2 \
ksym-longterm-rtw89-phy-write32-idx \
ksym-longterm-rtw89-phy-write32-idx-clr \
ksym-longterm-rtw89-phy-write32-idx-set \
ksym-longterm-rtw89-pm-ops \
ksym-longterm-rtw89-pm-ops-be \
ksym-longterm-rtw89-query-sar \
ksym-longterm-rtw89-read-efuse-ver \
ksym-longterm-rtw89-rfk-chan-lookup \
ksym-longterm-rtw89-rfk-parser \
ksym-longterm-rtw89-ser-notify \
ksym-longterm-rtw89-tas-chanctx-cb \
ksym-longterm-rtw89-usb-disconnect \
ksym-longterm-rtw89-usb-probe \
ksym-longterm-rtw8922a-chip-info \
ksym-longterm-rtw8922ae-vs-variant \
ksym-longterm-run-dax \
ksym-longterm-rw-verify-area \
ksym-longterm-rxgk-kernel-query-challenge \
ksym-longterm-rxgk-kernel-respond-to-challenge \
ksym-longterm-rxkad-kernel-respond-to-challenge \
ksym-longterm-rxrpc-debug-id \
ksym-longterm-rxrpc-get-null-key \
ksym-longterm-rxrpc-get-server-data-key \
ksym-longterm-rxrpc-kernel-abort-call \
ksym-longterm-rxrpc-kernel-begin-call \
ksym-longterm-rxrpc-kernel-charge-accept \
ksym-longterm-rxrpc-kernel-check-life \
ksym-longterm-rxrpc-kernel-dequeue-oob \
ksym-longterm-rxrpc-kernel-free-oob \
ksym-longterm-rxrpc-kernel-get-call-peer \
ksym-longterm-rxrpc-kernel-get-peer \
ksym-longterm-rxrpc-kernel-get-peer-data \
ksym-longterm-rxrpc-kernel-get-srtt \
ksym-longterm-rxrpc-kernel-lookup-peer \
ksym-longterm-rxrpc-kernel-put-call \
ksym-longterm-rxrpc-kernel-put-peer \
ksym-longterm-rxrpc-kernel-query-call-security \
ksym-longterm-rxrpc-kernel-query-challenge \
ksym-longterm-rxrpc-kernel-query-oob \
ksym-longterm-rxrpc-kernel-recv-data \
ksym-longterm-rxrpc-kernel-reject-challenge \
ksym-longterm-rxrpc-kernel-remote-addr \
ksym-longterm-rxrpc-kernel-remote-srx \
ksym-longterm-rxrpc-kernel-send-data \
ksym-longterm-rxrpc-kernel-set-notifications \
ksym-longterm-rxrpc-kernel-set-peer-data \
ksym-longterm-rxrpc-kernel-set-tx-length \
ksym-longterm-rxrpc-kernel-shutdown-call \
ksym-longterm-rxrpc-sock-set-manage-response \
ksym-longterm-rxrpc-sock-set-min-security-level \
ksym-longterm-rxrpc-sock-set-security-keyring \
ksym-longterm-rzv2h-icu-register-dma-req \
ksym-longterm-rzv2m-usb3drd-reset \
ksym-longterm-s2idle-wake \
ksym-longterm-s3fwrn5-phy-get-mode \
ksym-longterm-s3fwrn5-phy-power-ctrl \
ksym-longterm-s3fwrn5-phy-set-mode \
ksym-longterm-s3fwrn5-phy-set-wake \
ksym-longterm-s3fwrn5-probe \
ksym-longterm-s3fwrn5-recv-frame \
ksym-longterm-s3fwrn5-remove \
ksym-longterm-s5h1409-attach \
ksym-longterm-s5h1411-attach \
ksym-longterm-s5h1420-attach \
ksym-longterm-s5h1420-get-tuner-i2c-adapter \
ksym-longterm-s5h1432-attach \
ksym-longterm-s6e63m0-probe \
ksym-longterm-s6e63m0-remove \
ksym-longterm-s921-attach \
ksym-longterm-sa1100-rtc-init \
ksym-longterm-saa-dsp-writel \
ksym-longterm-saa7134-boards \
ksym-longterm-saa7134-devlist \
ksym-longterm-saa7134-devlist-lock \
ksym-longterm-saa7134-dmasound-exit \
ksym-longterm-saa7134-dmasound-init \
ksym-longterm-saa7134-enum-input \
ksym-longterm-saa7134-g-frequency \
ksym-longterm-saa7134-g-input \
ksym-longterm-saa7134-g-std \
ksym-longterm-saa7134-g-tuner \
ksym-longterm-saa7134-pgtable-alloc \
ksym-longterm-saa7134-pgtable-build \
ksym-longterm-saa7134-pgtable-free \
ksym-longterm-saa7134-querycap \
ksym-longterm-saa7134-querystd \
ksym-longterm-saa7134-s-frequency \
ksym-longterm-saa7134-s-input \
ksym-longterm-saa7134-s-std \
ksym-longterm-saa7134-s-tuner \
ksym-longterm-saa7134-set-dmabits \
ksym-longterm-saa7134-set-gpio \
ksym-longterm-saa7134-stop-streaming \
ksym-longterm-saa7134-ts-buffer-init \
ksym-longterm-saa7134-ts-buffer-prepare \
ksym-longterm-saa7134-ts-qops \
ksym-longterm-saa7134-ts-queue-setup \
ksym-longterm-saa7134-ts-register \
ksym-longterm-saa7134-ts-start-streaming \
ksym-longterm-saa7134-ts-stop-streaming \
ksym-longterm-saa7134-ts-unregister \
ksym-longterm-saa7134-tuner-callback \
ksym-longterm-saa7134-tvaudio-setmute \
ksym-longterm-saa7134-vb2-buffer-queue \
ksym-longterm-saa7146-debug \
ksym-longterm-saa7146-i2c-adapter-prepare \
ksym-longterm-saa7146-pgtable-alloc \
ksym-longterm-saa7146-pgtable-build-single \
ksym-longterm-saa7146-pgtable-free \
ksym-longterm-saa7146-register-device \
ksym-longterm-saa7146-register-extension \
ksym-longterm-saa7146-set-hps-source-and-sync \
ksym-longterm-saa7146-setgpio \
ksym-longterm-saa7146-unregister-device \
ksym-longterm-saa7146-unregister-extension \
ksym-longterm-saa7146-vfree-destroy-pgtable \
ksym-longterm-saa7146-vmalloc-build-pgtable \
ksym-longterm-saa7146-vv-init \
ksym-longterm-saa7146-vv-release \
ksym-longterm-saa7146-wait-for-debi-done \
ksym-longterm-safe-candev-priv \
ksym-longterm-sampling-rate-store \
ksym-longterm-samsung-asoc-dma-platform-register \
ksym-longterm-samsung-sdi-battery-get-info \
ksym-longterm-san-client-link \
ksym-longterm-san-dgpu-notifier-register \
ksym-longterm-san-dgpu-notifier-unregister \
ksym-longterm-sas-abort-task \
ksym-longterm-sas-abort-task-set \
ksym-longterm-sas-ata-device-link-abort \
ksym-longterm-sas-ata-ncq-prio-supported \
ksym-longterm-sas-ata-schedule-reset \
ksym-longterm-sas-ata-sdev-attr-group \
ksym-longterm-sas-attach-transport \
ksym-longterm-sas-bios-param \
ksym-longterm-sas-change-queue-depth \
ksym-longterm-sas-clear-task-set \
ksym-longterm-sas-disable-tlr \
ksym-longterm-sas-domain-attach-transport \
ksym-longterm-sas-drain-work \
ksym-longterm-sas-eh-abort-handler \
ksym-longterm-sas-eh-device-reset-handler \
ksym-longterm-sas-eh-target-reset-handler \
ksym-longterm-sas-enable-tlr \
ksym-longterm-sas-end-device-alloc \
ksym-longterm-sas-execute-ata-cmd \
ksym-longterm-sas-execute-internal-abort-dev \
ksym-longterm-sas-execute-internal-abort-single \
ksym-longterm-sas-expander-alloc \
ksym-longterm-sas-find-attached-phy-id \
ksym-longterm-sas-get-address \
ksym-longterm-sas-get-local-phy \
ksym-longterm-sas-ioctl \
ksym-longterm-sas-is-tlr-enabled \
ksym-longterm-sas-lu-reset \
ksym-longterm-sas-notify-phy-event \
ksym-longterm-sas-notify-port-event \
ksym-longterm-sas-phy-add \
ksym-longterm-sas-phy-alloc \
ksym-longterm-sas-phy-delete \
ksym-longterm-sas-phy-enable \
ksym-longterm-sas-phy-free \
ksym-longterm-sas-phy-reset \
ksym-longterm-sas-port-add \
ksym-longterm-sas-port-add-phy \
ksym-longterm-sas-port-alloc \
ksym-longterm-sas-port-alloc-num \
ksym-longterm-sas-port-delete \
ksym-longterm-sas-port-delete-phy \
ksym-longterm-sas-port-free \
ksym-longterm-sas-port-get-phy \
ksym-longterm-sas-port-mark-backlink \
ksym-longterm-sas-prep-resume-ha \
ksym-longterm-sas-query-task \
ksym-longterm-sas-queuecommand \
ksym-longterm-sas-read-port-mode-page \
ksym-longterm-sas-register-ha \
ksym-longterm-sas-release-transport \
ksym-longterm-sas-remove-children \
ksym-longterm-sas-remove-host \
ksym-longterm-sas-request-addr \
ksym-longterm-sas-resume-ha \
ksym-longterm-sas-rphy-add \
ksym-longterm-sas-rphy-delete \
ksym-longterm-sas-rphy-free \
ksym-longterm-sas-rphy-remove \
ksym-longterm-sas-rphy-unlink \
ksym-longterm-sas-sdev-configure \
ksym-longterm-sas-sdev-init \
ksym-longterm-sas-ssp-task-response \
ksym-longterm-sas-suspend-ha \
ksym-longterm-sas-target-alloc \
ksym-longterm-sas-target-destroy \
ksym-longterm-sas-task-abort \
ksym-longterm-sas-tlr-supported \
ksym-longterm-sas-unregister-ha \
ksym-longterm-sata-async-notification \
ksym-longterm-sata-deb-timing-hotplug \
ksym-longterm-sata-deb-timing-long \
ksym-longterm-sata-deb-timing-normal \
ksym-longterm-sata-link-debounce \
ksym-longterm-sata-link-hardreset \
ksym-longterm-sata-link-resume \
ksym-longterm-sata-link-scr-lpm \
ksym-longterm-sata-lpm-ignore-phy-events \
ksym-longterm-sata-pmp-error-handler \
ksym-longterm-sata-pmp-port-ops \
ksym-longterm-sata-pmp-qc-defer-cmd-switch \
ksym-longterm-sata-port-ops \
ksym-longterm-sata-scr-read \
ksym-longterm-sata-scr-valid \
ksym-longterm-sata-scr-write \
ksym-longterm-sata-scr-write-flush \
ksym-longterm-sata-set-spd \
ksym-longterm-sata-sff-hardreset \
ksym-longterm-sata-std-hardreset \
ksym-longterm-sb-init-dio-done-wq \
ksym-longterm-sb-min-blocksize \
ksym-longterm-sb-set-blocksize \
ksym-longterm-sb800-prefetch \
ksym-longterm-sbc-attrib-attrs \
ksym-longterm-sbc-dif-copy-prot \
ksym-longterm-sbc-dif-verify \
ksym-longterm-sbc-get-device-type \
ksym-longterm-sbc-get-write-same-sectors \
ksym-longterm-sbc-parse-cdb \
ksym-longterm-sbitmap-add-wait-queue \
ksym-longterm-sbitmap-any-bit-set \
ksym-longterm-sbitmap-bitmap-show \
ksym-longterm-sbitmap-del-wait-queue \
ksym-longterm-sbitmap-finish-wait \
ksym-longterm-sbitmap-get \
ksym-longterm-sbitmap-init-node \
ksym-longterm-sbitmap-prepare-to-wait \
ksym-longterm-sbitmap-queue-clear \
ksym-longterm-sbitmap-queue-get-shallow \
ksym-longterm-sbitmap-queue-init-node \
ksym-longterm-sbitmap-queue-min-shallow-depth \
ksym-longterm-sbitmap-queue-recalculate-wake-batch \
ksym-longterm-sbitmap-queue-resize \
ksym-longterm-sbitmap-queue-show \
ksym-longterm-sbitmap-queue-wake-all \
ksym-longterm-sbitmap-queue-wake-up \
ksym-longterm-sbitmap-resize \
ksym-longterm-sbitmap-show \
ksym-longterm-sbitmap-weight \
ksym-longterm-sc16is74x-devtype \
ksym-longterm-sc16is750-devtype \
ksym-longterm-sc16is752-devtype \
ksym-longterm-sc16is760-devtype \
ksym-longterm-sc16is762-devtype \
ksym-longterm-sc16is7xx-dt-ids \
ksym-longterm-sc16is7xx-probe \
ksym-longterm-sc16is7xx-regcfg \
ksym-longterm-sc16is7xx-regmap-name \
ksym-longterm-sc16is7xx-regmap-port-mask \
ksym-longterm-sc16is7xx-remove \
ksym-longterm-scatterwalk-ffwd \
ksym-longterm-scatterwalk-skip \
ksym-longterm-scd30-pm-ops \
ksym-longterm-scd30-probe \
ksym-longterm-sch-default-prio2band \
ksym-longterm-sch-frag-xmit-hook \
ksym-longterm-sch56xx-read-virtual-reg \
ksym-longterm-sch56xx-read-virtual-reg12 \
ksym-longterm-sch56xx-read-virtual-reg16 \
ksym-longterm-sch56xx-regmap-read16 \
ksym-longterm-sch56xx-regmap-write16 \
ksym-longterm-sch56xx-watchdog-register \
ksym-longterm-sch56xx-write-virtual-reg \
ksym-longterm-sched-clock \
ksym-longterm-sched-clock-register \
ksym-longterm-sched-numa-find-nth-cpu \
ksym-longterm-sched-numa-hop-mask \
ksym-longterm-sched-set-fifo \
ksym-longterm-sched-set-fifo-low \
ksym-longterm-sched-set-normal \
ksym-longterm-sched-setattr-nocheck \
ksym-longterm-sched-show-task \
ksym-longterm-sched-smt-present \
ksym-longterm-schedule \
ksym-longterm-schedule-cxl-memdev-detach \
ksym-longterm-schedule-hrtimeout \
ksym-longterm-schedule-hrtimeout-range \
ksym-longterm-schedule-hrtimeout-range-clock \
ksym-longterm-schedule-timeout \
ksym-longterm-schedule-timeout-idle \
ksym-longterm-schedule-timeout-interruptible \
ksym-longterm-schedule-timeout-killable \
ksym-longterm-schedule-timeout-uninterruptible \
ksym-longterm-sci-config-port \
ksym-longterm-sci-pm \
ksym-longterm-sci-port-disable \
ksym-longterm-sci-port-enable \
ksym-longterm-sci-release-port \
ksym-longterm-sci-request-port \
ksym-longterm-sci-shutdown \
ksym-longterm-sci-startup \
ksym-longterm-sci-verify-port \
ksym-longterm-scm-detach-fds \
ksym-longterm-scm-fp-dup \
ksym-longterm-scm-recv \
ksym-longterm-scmd-printk \
ksym-longterm-scmi-bus-type \
ksym-longterm-scmi-device-create \
ksym-longterm-scmi-device-destroy \
ksym-longterm-scmi-driver-register \
ksym-longterm-scmi-driver-unregister \
ksym-longterm-scmi-imx-cpu-reset-vector-set \
ksym-longterm-scmi-imx-cpu-start \
ksym-longterm-scmi-imx-cpu-started \
ksym-longterm-scmi-imx-lmm-info \
ksym-longterm-scmi-imx-lmm-operation \
ksym-longterm-scmi-imx-lmm-reset-vector-set \
ksym-longterm-scmi-imx-misc-ctrl-get \
ksym-longterm-scmi-imx-misc-ctrl-set \
ksym-longterm-scmi-protocol-register \
ksym-longterm-scmi-protocol-unregister \
ksym-longterm-scmi-requested-devices-nh \
ksym-longterm-scnprintf \
ksym-longterm-scp-get \
ksym-longterm-scp-get-device \
ksym-longterm-scp-get-rproc \
ksym-longterm-scp-get-vdec-hw-capa \
ksym-longterm-scp-get-venc-hw-capa \
ksym-longterm-scp-ipi-lock \
ksym-longterm-scp-ipi-register \
ksym-longterm-scp-ipi-send \
ksym-longterm-scp-ipi-unlock \
ksym-longterm-scp-ipi-unregister \
ksym-longterm-scp-mapping-dm-addr \
ksym-longterm-scp-memcpy-aligned \
ksym-longterm-scp-put \
ksym-longterm-screen-glyph \
ksym-longterm-screen-glyph-unicode \
ksym-longterm-screen-info \
ksym-longterm-screen-info-pci-dev \
ksym-longterm-screen-info-pixel-format \
ksym-longterm-screen-info-resources \
ksym-longterm-screen-pos \
ksym-longterm-scsi-add-device \
ksym-longterm-scsi-add-host-with-dma \
ksym-longterm-scsi-alloc-request \
ksym-longterm-scsi-alloc-sgtables \
ksym-longterm-scsi-autopm-get-device \
ksym-longterm-scsi-autopm-put-device \
ksym-longterm-scsi-bios-ptable \
ksym-longterm-scsi-block-requests \
ksym-longterm-scsi-block-targets \
ksym-longterm-scsi-block-when-processing-errors \
ksym-longterm-scsi-build-sense \
ksym-longterm-scsi-build-sense-buffer \
ksym-longterm-scsi-change-queue-depth \
ksym-longterm-scsi-check-sense \
ksym-longterm-scsi-cmd-allowed \
ksym-longterm-scsi-command-normalize-sense \
ksym-longterm-scsi-command-size-tbl \
ksym-longterm-scsi-dev-info-add-list \
ksym-longterm-scsi-dev-info-list-add-keyed \
ksym-longterm-scsi-dev-info-remove-list \
ksym-longterm-scsi-device-get \
ksym-longterm-scsi-device-lookup \
ksym-longterm-scsi-device-lookup-by-target \
ksym-longterm-scsi-device-put \
ksym-longterm-scsi-device-quiesce \
ksym-longterm-scsi-device-resume \
ksym-longterm-scsi-device-set-state \
ksym-longterm-scsi-device-type \
ksym-longterm-scsi-dh-activate \
ksym-longterm-scsi-dh-attach \
ksym-longterm-scsi-dh-attached-handler-name \
ksym-longterm-scsi-dh-set-params \
ksym-longterm-scsi-dma-map \
ksym-longterm-scsi-dma-unmap \
ksym-longterm-scsi-done \
ksym-longterm-scsi-done-direct \
ksym-longterm-scsi-eh-finish-cmd \
ksym-longterm-scsi-eh-flush-done-q \
ksym-longterm-scsi-eh-get-sense \
ksym-longterm-scsi-eh-prep-cmnd \
ksym-longterm-scsi-eh-ready-devs \
ksym-longterm-scsi-eh-restore-cmnd \
ksym-longterm-scsi-esp-cmd \
ksym-longterm-scsi-esp-intr \
ksym-longterm-scsi-esp-register \
ksym-longterm-scsi-esp-template \
ksym-longterm-scsi-esp-unregister \
ksym-longterm-scsi-execute-cmd \
ksym-longterm-scsi-extd-sense-format \
ksym-longterm-scsi-failures-reset-retries \
ksym-longterm-scsi-flush-work \
ksym-longterm-scsi-free-sgtables \
ksym-longterm-scsi-get-device-flags-keyed \
ksym-longterm-scsi-get-sense-info-fld \
ksym-longterm-scsi-get-vpd-page \
ksym-longterm-scsi-host-alloc \
ksym-longterm-scsi-host-block \
ksym-longterm-scsi-host-busy \
ksym-longterm-scsi-host-busy-iter \
ksym-longterm-scsi-host-complete-all-commands \
ksym-longterm-scsi-host-get \
ksym-longterm-scsi-host-lookup \
ksym-longterm-scsi-host-put \
ksym-longterm-scsi-host-unblock \
ksym-longterm-scsi-hostbyte-string \
ksym-longterm-scsi-init-limits \
ksym-longterm-scsi-internal-device-block-nowait \
ksym-longterm-scsi-internal-device-unblock-nowait \
ksym-longterm-scsi-ioctl \
ksym-longterm-scsi-ioctl-block-when-processing-errors \
ksym-longterm-scsi-is-fc-rport \
ksym-longterm-scsi-is-host-device \
ksym-longterm-scsi-is-sas-phy \
ksym-longterm-scsi-is-sas-port \
ksym-longterm-scsi-is-sas-rphy \
ksym-longterm-scsi-is-sdev-device \
ksym-longterm-scsi-is-target-device \
ksym-longterm-scsi-kmap-atomic-sg \
ksym-longterm-scsi-kunmap-atomic-sg \
ksym-longterm-scsi-logging-level \
ksym-longterm-scsi-mlreturn-string \
ksym-longterm-scsi-mode-select \
ksym-longterm-scsi-mode-sense \
ksym-longterm-scsi-nl-sock \
ksym-longterm-scsi-normalize-sense \
ksym-longterm-scsi-partsize \
ksym-longterm-scsi-pr-type-to-block \
ksym-longterm-scsi-print-command \
ksym-longterm-scsi-print-result \
ksym-longterm-scsi-print-sense \
ksym-longterm-scsi-print-sense-hdr \
ksym-longterm-scsi-queue-work \
ksym-longterm-scsi-register-device-handler \
ksym-longterm-scsi-register-interface \
ksym-longterm-scsi-remove-device \
ksym-longterm-scsi-remove-host \
ksym-longterm-scsi-remove-target \
ksym-longterm-scsi-report-bus-reset \
ksym-longterm-scsi-report-device-reset \
ksym-longterm-scsi-report-opcode \
ksym-longterm-scsi-rescan-device \
ksym-longterm-scsi-resume-device \
ksym-longterm-scsi-sanitize-inquiry-string \
ksym-longterm-scsi-scan-host \
ksym-longterm-scsi-scan-target \
ksym-longterm-scsi-schedule-eh \
ksym-longterm-scsi-sense-desc-find \
ksym-longterm-scsi-sense-key-string \
ksym-longterm-scsi-set-medium-removal \
ksym-longterm-scsi-set-sense-field-pointer \
ksym-longterm-scsi-set-sense-information \
ksym-longterm-scsi-target-quiesce \
ksym-longterm-scsi-target-resume \
ksym-longterm-scsi-target-unblock \
ksym-longterm-scsi-template-proc-dir \
ksym-longterm-scsi-test-unit-ready \
ksym-longterm-scsi-track-queue-full \
ksym-longterm-scsi-unblock-requests \
ksym-longterm-scsi-unregister-device-handler \
ksym-longterm-scsi-vpd-lun-id \
ksym-longterm-scsi-vpd-tpg-id \
ksym-longterm-scsicam-bios-param \
ksym-longterm-scsilun-to-int \
ksym-longterm-sctp-for-each-endpoint \
ksym-longterm-sctp-get-sctp-info \
ksym-longterm-sctp-transport-lookup-process \
ksym-longterm-sctp-transport-traverse-process \
ksym-longterm-sdev-disable-disk-events \
ksym-longterm-sdev-enable-disk-events \
ksym-longterm-sdev-evt-alloc \
ksym-longterm-sdev-evt-send \
ksym-longterm-sdev-evt-send-simple \
ksym-longterm-sdev-prefix-printk \
ksym-longterm-sdhci-abort-tuning \
ksym-longterm-sdhci-add-host \
ksym-longterm-sdhci-adma-write-desc \
ksym-longterm-sdhci-alloc-host \
ksym-longterm-sdhci-calc-clk \
ksym-longterm-sdhci-cleanup-host \
ksym-longterm-sdhci-complete-work \
ksym-longterm-sdhci-cqe-disable \
ksym-longterm-sdhci-cqe-enable \
ksym-longterm-sdhci-cqe-irq \
ksym-longterm-sdhci-data-line-cmd \
ksym-longterm-sdhci-disable-irq-wakeups \
ksym-longterm-sdhci-do-reset \
ksym-longterm-sdhci-dumpregs \
ksym-longterm-sdhci-enable-clk \
ksym-longterm-sdhci-enable-irq-wakeups \
ksym-longterm-sdhci-enable-preset-value \
ksym-longterm-sdhci-enable-sdio-irq \
ksym-longterm-sdhci-enable-v4-mode \
ksym-longterm-sdhci-end-tuning \
ksym-longterm-sdhci-execute-tuning \
ksym-longterm-sdhci-finish-mrq \
ksym-longterm-sdhci-get-cd-nogpio \
ksym-longterm-sdhci-get-property \
ksym-longterm-sdhci-get-ro \
ksym-longterm-sdhci-get-vdd-value \
ksym-longterm-sdhci-initialize-data \
ksym-longterm-sdhci-mod-timer \
ksym-longterm-sdhci-needs-reset \
ksym-longterm-sdhci-pltfm-clk-get-max-clock \
ksym-longterm-sdhci-pltfm-init \
ksym-longterm-sdhci-pltfm-init-and-add-host \
ksym-longterm-sdhci-pltfm-pmops \
ksym-longterm-sdhci-pltfm-remove \
ksym-longterm-sdhci-pltfm-resume \
ksym-longterm-sdhci-pltfm-suspend \
ksym-longterm-sdhci-prepare-dma \
ksym-longterm-sdhci-present-error \
ksym-longterm-sdhci-remove-host \
ksym-longterm-sdhci-request \
ksym-longterm-sdhci-request-atomic \
ksym-longterm-sdhci-request-done-dma \
ksym-longterm-sdhci-reset \
ksym-longterm-sdhci-reset-tuning \
ksym-longterm-sdhci-resume-host \
ksym-longterm-sdhci-runtime-resume-host \
ksym-longterm-sdhci-runtime-suspend-host \
ksym-longterm-sdhci-send-tuning \
ksym-longterm-sdhci-set-bus-width \
ksym-longterm-sdhci-set-clock \
ksym-longterm-sdhci-set-data-timeout-irq \
ksym-longterm-sdhci-set-ios \
ksym-longterm-sdhci-set-ios-common \
ksym-longterm-sdhci-set-power \
ksym-longterm-sdhci-set-power-and-bus-voltage \
ksym-longterm-sdhci-set-power-noreg \
ksym-longterm-sdhci-set-uhs-signaling \
ksym-longterm-sdhci-setup-host \
ksym-longterm-sdhci-start-signal-voltage-switch \
ksym-longterm-sdhci-start-tuning \
ksym-longterm-sdhci-suspend-host \
ksym-longterm-sdhci-switch-external-dma \
ksym-longterm-sdhci-thread-irq \
ksym-longterm-sdhci-uhs2-add-host \
ksym-longterm-sdhci-uhs2-clear-set-irqs \
ksym-longterm-sdhci-uhs2-dump-regs \
ksym-longterm-sdhci-uhs2-irq \
ksym-longterm-sdhci-uhs2-remove-host \
ksym-longterm-sdhci-uhs2-reset \
ksym-longterm-sdhci-uhs2-set-power \
ksym-longterm-sdhci-uhs2-set-timeout \
ksym-longterm-sdio-align-size \
ksym-longterm-sdio-claim-host \
ksym-longterm-sdio-claim-irq \
ksym-longterm-sdio-disable-func \
ksym-longterm-sdio-enable-func \
ksym-longterm-sdio-f0-readb \
ksym-longterm-sdio-f0-writeb \
ksym-longterm-sdio-get-host-pm-caps \
ksym-longterm-sdio-memcpy-fromio \
ksym-longterm-sdio-memcpy-toio \
ksym-longterm-sdio-readb \
ksym-longterm-sdio-readl \
ksym-longterm-sdio-readsb \
ksym-longterm-sdio-readw \
ksym-longterm-sdio-release-host \
ksym-longterm-sdio-release-irq \
ksym-longterm-sdio-retune-crc-disable \
ksym-longterm-sdio-retune-crc-enable \
ksym-longterm-sdio-retune-hold-now \
ksym-longterm-sdio-retune-release \
ksym-longterm-sdio-set-block-size \
ksym-longterm-sdio-set-host-pm-flags \
ksym-longterm-sdio-signal-irq \
ksym-longterm-sdio-unregister-driver \
ksym-longterm-sdio-writeb \
ksym-longterm-sdio-writeb-readb \
ksym-longterm-sdio-writel \
ksym-longterm-sdio-writesb \
ksym-longterm-sdio-writew \
ksym-longterm-sdw-alloc-stream \
ksym-longterm-sdw-amd-exit \
ksym-longterm-sdw-amd-get-slave-info \
ksym-longterm-sdw-amd-probe \
ksym-longterm-sdw-bpt-send-async \
ksym-longterm-sdw-bpt-send-sync \
ksym-longterm-sdw-bpt-wait \
ksym-longterm-sdw-bread-no-pm-unlocked \
ksym-longterm-sdw-bus-clk-stop \
ksym-longterm-sdw-bus-exit-clk-stop \
ksym-longterm-sdw-bus-master-add \
ksym-longterm-sdw-bus-master-delete \
ksym-longterm-sdw-bus-prep-clk-stop \
ksym-longterm-sdw-bus-type \
ksym-longterm-sdw-bwrite-no-pm-unlocked \
ksym-longterm-sdw-clear-slave-status \
ksym-longterm-sdw-cols \
ksym-longterm-sdw-compare-devid \
ksym-longterm-sdw-compute-params \
ksym-longterm-sdw-compute-slave-ports \
ksym-longterm-sdw-deprepare-stream \
ksym-longterm-sdw-disable-stream \
ksym-longterm-sdw-enable-stream \
ksym-longterm-sdw-extract-slave-id \
ksym-longterm-sdw-find-col-index \
ksym-longterm-sdw-find-row-index \
ksym-longterm-sdw-handle-slave-status \
ksym-longterm-sdw-intel-acpi-scan \
ksym-longterm-sdw-master-read-prop \
ksym-longterm-sdw-nread \
ksym-longterm-sdw-nread-no-pm \
ksym-longterm-sdw-nwrite \
ksym-longterm-sdw-nwrite-no-pm \
ksym-longterm-sdw-prepare-stream \
ksym-longterm-sdw-read \
ksym-longterm-sdw-read-no-pm \
ksym-longterm-sdw-release-stream \
ksym-longterm-sdw-rows \
ksym-longterm-sdw-show-ping-status \
ksym-longterm-sdw-shutdown-stream \
ksym-longterm-sdw-slave-add \
ksym-longterm-sdw-slave-get-current-bank \
ksym-longterm-sdw-slave-get-scale-index \
ksym-longterm-sdw-slave-read-lane-mapping \
ksym-longterm-sdw-slave-read-prop \
ksym-longterm-sdw-startup-stream \
ksym-longterm-sdw-stream-add-master \
ksym-longterm-sdw-stream-add-slave \
ksym-longterm-sdw-stream-remove-master \
ksym-longterm-sdw-stream-remove-slave \
ksym-longterm-sdw-unregister-driver \
ksym-longterm-sdw-update \
ksym-longterm-sdw-update-no-pm \
ksym-longterm-sdw-write \
ksym-longterm-sdw-write-no-pm \
ksym-longterm-sec-pmic-pm-ops \
ksym-longterm-sec-pmic-probe \
ksym-longterm-sec-pmic-shutdown \
ksym-longterm-secpath-set \
ksym-longterm-sections-per-block \
ksym-longterm-secure-ipv4-port-ephemeral \
ksym-longterm-secure-ipv6-port-ephemeral \
ksym-longterm-secure-tcp-seq-and-ts-off \
ksym-longterm-secure-tcpv6-seq-and-ts-off \
ksym-longterm-security-bdev-alloc \
ksym-longterm-security-bdev-free \
ksym-longterm-security-bdev-setintegrity \
ksym-longterm-security-cred-getlsmprop \
ksym-longterm-security-cred-getsecid \
ksym-longterm-security-current-getlsmprop-subj \
ksym-longterm-security-d-instantiate \
ksym-longterm-security-dentry-create-files-as \
ksym-longterm-security-dentry-init-security \
ksym-longterm-security-file-ioctl \
ksym-longterm-security-file-ioctl-compat \
ksym-longterm-security-file-post-open \
ksym-longterm-security-free-mnt-opts \
ksym-longterm-security-ib-alloc-security \
ksym-longterm-security-ib-endport-manage-subnet \
ksym-longterm-security-ib-free-security \
ksym-longterm-security-ib-pkey-access \
ksym-longterm-security-inet-conn-established \
ksym-longterm-security-inet-conn-request \
ksym-longterm-security-inode-copy-up \
ksym-longterm-security-inode-copy-up-xattr \
ksym-longterm-security-inode-create \
ksym-longterm-security-inode-getsecctx \
ksym-longterm-security-inode-init-security \
ksym-longterm-security-inode-invalidate-secctx \
ksym-longterm-security-inode-listsecurity \
ksym-longterm-security-inode-mkdir \
ksym-longterm-security-inode-notifysecctx \
ksym-longterm-security-inode-setattr \
ksym-longterm-security-inode-setintegrity \
ksym-longterm-security-inode-setsecctx \
ksym-longterm-security-ismaclabel \
ksym-longterm-security-kernel-load-data \
ksym-longterm-security-kernel-post-load-data \
ksym-longterm-security-kernel-post-read-file \
ksym-longterm-security-kernel-read-file \
ksym-longterm-security-lock-kernel-down \
ksym-longterm-security-locked-down \
ksym-longterm-security-lsmprop-to-secctx \
ksym-longterm-security-mmap-backing-file \
ksym-longterm-security-path-mkdir \
ksym-longterm-security-path-mknod \
ksym-longterm-security-path-rename \
ksym-longterm-security-path-unlink \
ksym-longterm-security-release-secctx \
ksym-longterm-security-req-classify-flow \
ksym-longterm-security-sb-clone-mnt-opts \
ksym-longterm-security-sb-eat-lsm-opts \
ksym-longterm-security-sb-mnt-opts-compat \
ksym-longterm-security-sb-remount \
ksym-longterm-security-sb-set-mnt-opts \
ksym-longterm-security-sctp-assoc-established \
ksym-longterm-security-sctp-assoc-request \
ksym-longterm-security-sctp-bind-connect \
ksym-longterm-security-sctp-sk-clone \
ksym-longterm-security-secctx-to-secid \
ksym-longterm-security-secid-to-secctx \
ksym-longterm-security-secmark-refcount-dec \
ksym-longterm-security-secmark-refcount-inc \
ksym-longterm-security-secmark-relabel-packet \
ksym-longterm-security-sk-classify-flow \
ksym-longterm-security-sk-clone \
ksym-longterm-security-skb-classify-flow \
ksym-longterm-security-sock-graft \
ksym-longterm-security-sock-rcv-skb \
ksym-longterm-security-socket-getpeersec-dgram \
ksym-longterm-security-socket-socketpair \
ksym-longterm-security-task-getlsmprop-obj \
ksym-longterm-security-tun-dev-alloc-security \
ksym-longterm-security-tun-dev-attach \
ksym-longterm-security-tun-dev-attach-queue \
ksym-longterm-security-tun-dev-create \
ksym-longterm-security-tun-dev-free-security \
ksym-longterm-security-tun-dev-open \
ksym-longterm-security-unix-may-send \
ksym-longterm-security-unix-stream-connect \
ksym-longterm-security-xfrm-policy-alloc \
ksym-longterm-security-xfrm-policy-free \
ksym-longterm-security-xfrm-state-alloc \
ksym-longterm-security-xfrm-state-delete \
ksym-longterm-securityfs-create-dir \
ksym-longterm-securityfs-create-file \
ksym-longterm-securityfs-create-symlink \
ksym-longterm-securityfs-remove \
ksym-longterm-sed-ioctl \
ksym-longterm-seg6-do-srh-encap \
ksym-longterm-seg6-do-srh-inline \
ksym-longterm-seg6-hmac-compute \
ksym-longterm-seg6-hmac-info-add \
ksym-longterm-seg6-hmac-info-del \
ksym-longterm-seg6-hmac-info-lookup \
ksym-longterm-seg6-hmac-net-exit \
ksym-longterm-seg6-hmac-validate-skb \
ksym-longterm-seg6-push-hmac \
ksym-longterm-send-implementation-id \
ksym-longterm-send-sig \
ksym-longterm-send-sig-info \
ksym-longterm-send-sig-mceerr \
ksym-longterm-sensor-hub-device-close \
ksym-longterm-sensor-hub-device-open \
ksym-longterm-sensor-hub-get-feature \
ksym-longterm-sensor-hub-input-attr-get-raw-value \
ksym-longterm-sensor-hub-input-attr-read-values \
ksym-longterm-sensor-hub-input-get-attribute-info \
ksym-longterm-sensor-hub-register-callback \
ksym-longterm-sensor-hub-remove-callback \
ksym-longterm-sensor-hub-set-feature \
ksym-longterm-seq-bprintf \
ksym-longterm-seq-buf-do-printk \
ksym-longterm-seq-buf-printf \
ksym-longterm-seq-buf-putc \
ksym-longterm-seq-buf-puts \
ksym-longterm-seq-dentry \
ksym-longterm-seq-escape-mem \
ksym-longterm-seq-file-path \
ksym-longterm-seq-hex-dump \
ksym-longterm-seq-hlist-next \
ksym-longterm-seq-hlist-next-percpu \
ksym-longterm-seq-hlist-next-rcu \
ksym-longterm-seq-hlist-start \
ksym-longterm-seq-hlist-start-head \
ksym-longterm-seq-hlist-start-head-rcu \
ksym-longterm-seq-hlist-start-percpu \
ksym-longterm-seq-hlist-start-rcu \
ksym-longterm-seq-list-next \
ksym-longterm-seq-list-next-rcu \
ksym-longterm-seq-list-start \
ksym-longterm-seq-list-start-head \
ksym-longterm-seq-list-start-head-rcu \
ksym-longterm-seq-list-start-rcu \
ksym-longterm-seq-lseek \
ksym-longterm-seq-open \
ksym-longterm-seq-open-private \
ksym-longterm-seq-pad \
ksym-longterm-seq-path \
ksym-longterm-seq-printf \
ksym-longterm-seq-put-decimal-ll \
ksym-longterm-seq-put-decimal-ull \
ksym-longterm-seq-putc \
ksym-longterm-seq-read \
ksym-longterm-seq-read-iter \
ksym-longterm-seq-release \
ksym-longterm-seq-release-private \
ksym-longterm-seq-vprintf \
ksym-longterm-seq-write \
ksym-longterm-serdev-acpi-get-uart-resource \
ksym-longterm-serdev-controller-add \
ksym-longterm-serdev-controller-alloc \
ksym-longterm-serdev-controller-remove \
ksym-longterm-serdev-device-add \
ksym-longterm-serdev-device-alloc \
ksym-longterm-serdev-device-break-ctl \
ksym-longterm-serdev-device-close \
ksym-longterm-serdev-device-get-tiocm \
ksym-longterm-serdev-device-open \
ksym-longterm-serdev-device-remove \
ksym-longterm-serdev-device-set-baudrate \
ksym-longterm-serdev-device-set-flow-control \
ksym-longterm-serdev-device-set-parity \
ksym-longterm-serdev-device-set-tiocm \
ksym-longterm-serdev-device-wait-until-sent \
ksym-longterm-serdev-device-write \
ksym-longterm-serdev-device-write-buf \
ksym-longterm-serdev-device-write-flush \
ksym-longterm-serdev-device-write-wakeup \
ksym-longterm-serial-8250-warn-need-ioport \
ksym-longterm-serial8250-clear-and-reinit-fifos \
ksym-longterm-serial8250-clear-fifos \
ksym-longterm-serial8250-do-get-mctrl \
ksym-longterm-serial8250-do-pm \
ksym-longterm-serial8250-do-set-divisor \
ksym-longterm-serial8250-do-set-ldisc \
ksym-longterm-serial8250-do-set-mctrl \
ksym-longterm-serial8250-do-set-termios \
ksym-longterm-serial8250-do-shutdown \
ksym-longterm-serial8250-do-startup \
ksym-longterm-serial8250-em485-config \
ksym-longterm-serial8250-em485-destroy \
ksym-longterm-serial8250-em485-start-tx \
ksym-longterm-serial8250-em485-stop-tx \
ksym-longterm-serial8250-em485-supported \
ksym-longterm-serial8250-fifo-wait-for-lsr-thre \
ksym-longterm-serial8250-get-port \
ksym-longterm-serial8250-handle-irq \
ksym-longterm-serial8250-handle-irq-locked \
ksym-longterm-serial8250-init-port \
ksym-longterm-serial8250-modem-status \
ksym-longterm-serial8250-pci-setup-port \
ksym-longterm-serial8250-read-char \
ksym-longterm-serial8250-register-8250-port \
ksym-longterm-serial8250-release-dma \
ksym-longterm-serial8250-request-dma \
ksym-longterm-serial8250-resume-port \
ksym-longterm-serial8250-rpm-get \
ksym-longterm-serial8250-rpm-put \
ksym-longterm-serial8250-rx-chars \
ksym-longterm-serial8250-rx-dma-flush \
ksym-longterm-serial8250-set-defaults \
ksym-longterm-serial8250-set-isa-configurator \
ksym-longterm-serial8250-suspend-port \
ksym-longterm-serial8250-tx-chars \
ksym-longterm-serial8250-unregister-port \
ksym-longterm-serial8250-update-uartclk \
ksym-longterm-serio-bus \
ksym-longterm-serio-close \
ksym-longterm-serio-interrupt \
ksym-longterm-serio-open \
ksym-longterm-serio-reconnect \
ksym-longterm-serio-rescan \
ksym-longterm-serio-unregister-child-port \
ksym-longterm-serio-unregister-driver \
ksym-longterm-serio-unregister-port \
ksym-longterm-serpent-setkey \
ksym-longterm-servreg-get-domain-list-req-ei \
ksym-longterm-servreg-get-domain-list-resp-ei \
ksym-longterm-servreg-loc-pfr-req-ei \
ksym-longterm-servreg-loc-pfr-resp-ei \
ksym-longterm-servreg-register-listener-req-ei \
ksym-longterm-servreg-register-listener-resp-ei \
ksym-longterm-servreg-restart-pd-req-ei \
ksym-longterm-servreg-restart-pd-resp-ei \
ksym-longterm-servreg-set-ack-req-ei \
ksym-longterm-servreg-set-ack-resp-ei \
ksym-longterm-servreg-state-updated-ind-ei \
ksym-longterm-set-and-calc-slave-port-state \
ksym-longterm-set-anon-super \
ksym-longterm-set-anon-super-fc \
ksym-longterm-set-binfmt \
ksym-longterm-set-blocksize \
ksym-longterm-set-cached-acl \
ksym-longterm-set-capacity \
ksym-longterm-set-capacity-and-notify \
ksym-longterm-set-cpus-allowed-ptr \
ksym-longterm-set-create-files-as \
ksym-longterm-set-current-groups \
ksym-longterm-set-dax-nocache \
ksym-longterm-set-dax-nomc \
ksym-longterm-set-dax-synchronous \
ksym-longterm-set-default-d-op \
ksym-longterm-set-disk-ro \
ksym-longterm-set-exclusive-cxl-commands \
ksym-longterm-set-freezable \
ksym-longterm-set-groups \
ksym-longterm-set-memory-decrypted \
ksym-longterm-set-memory-encrypted \
ksym-longterm-set-movable-ops \
ksym-longterm-set-nlink \
ksym-longterm-set-normalized-timespec64 \
ksym-longterm-set-online-page-callback \
ksym-longterm-set-page-dirty \
ksym-longterm-set-page-dirty-lock \
ksym-longterm-set-page-writeback \
ksym-longterm-set-phv-bit \
ksym-longterm-set-posix-acl \
ksym-longterm-set-primary-fwnode \
ksym-longterm-set-secondary-fwnode \
ksym-longterm-set-security-override \
ksym-longterm-set-security-override-from-ctx \
ksym-longterm-set-selection-kernel \
ksym-longterm-set-task-ioprio \
ksym-longterm-set-user-nice \
ksym-longterm-set-worker-desc \
ksym-longterm-setattr-copy \
ksym-longterm-setattr-prepare \
ksym-longterm-setattr-should-drop-sgid \
ksym-longterm-setattr-should-drop-suidgid \
ksym-longterm-setup-arg-pages \
ksym-longterm-setup-bdev-super \
ksym-longterm-setup-cn23xx-octeon-pf-device \
ksym-longterm-setup-fault-attr \
ksym-longterm-setup-max-cpus \
ksym-longterm-setup-new-exec \
ksym-longterm-setup-rx-oom-poll-fn \
ksym-longterm-setup-udp-tunnel-sock \
ksym-longterm-sfp-add-phy \
ksym-longterm-sfp-bus-add-upstream \
ksym-longterm-sfp-bus-del-upstream \
ksym-longterm-sfp-bus-find-fwnode \
ksym-longterm-sfp-bus-put \
ksym-longterm-sfp-get-module-caps \
ksym-longterm-sfp-get-module-eeprom \
ksym-longterm-sfp-get-module-eeprom-by-page \
ksym-longterm-sfp-get-module-info \
ksym-longterm-sfp-get-name \
ksym-longterm-sfp-link-down \
ksym-longterm-sfp-link-up \
ksym-longterm-sfp-module-insert \
ksym-longterm-sfp-module-remove \
ksym-longterm-sfp-module-start \
ksym-longterm-sfp-module-stop \
ksym-longterm-sfp-register-socket \
ksym-longterm-sfp-remove-phy \
ksym-longterm-sfp-select-interface \
ksym-longterm-sfp-unregister-socket \
ksym-longterm-sfp-upstream-set-signal-rate \
ksym-longterm-sfp-upstream-start \
ksym-longterm-sfp-upstream-stop \
ksym-longterm-sg-alloc-append-table-from-pages \
ksym-longterm-sg-alloc-table \
ksym-longterm-sg-alloc-table-chained \
ksym-longterm-sg-alloc-table-from-pages-segment \
ksym-longterm-sg-copy-buffer \
ksym-longterm-sg-copy-from-buffer \
ksym-longterm-sg-copy-to-buffer \
ksym-longterm-sg-free-append-table \
ksym-longterm-sg-free-table \
ksym-longterm-sg-free-table-chained \
ksym-longterm-sg-init-one \
ksym-longterm-sg-init-table \
ksym-longterm-sg-last \
ksym-longterm-sg-miter-next \
ksym-longterm-sg-miter-skip \
ksym-longterm-sg-miter-start \
ksym-longterm-sg-miter-stop \
ksym-longterm-sg-nents \
ksym-longterm-sg-nents-for-len \
ksym-longterm-sg-pcopy-from-buffer \
ksym-longterm-sg-pcopy-to-buffer \
ksym-longterm-sg-split \
ksym-longterm-sg-zero-buffer \
ksym-longterm-sg2042-cfg-ops \
ksym-longterm-sg2042-pconf-ops \
ksym-longterm-sg2042-pctrl-ops \
ksym-longterm-sg2042-pmx-ops \
ksym-longterm-sget \
ksym-longterm-sget-dev \
ksym-longterm-sget-fc \
ksym-longterm-sgl-alloc \
ksym-longterm-sgl-alloc-order \
ksym-longterm-sgl-free \
ksym-longterm-sgl-free-n-order \
ksym-longterm-sgl-free-order \
ksym-longterm-sha1 \
ksym-longterm-sha1-final \
ksym-longterm-sha1-init \
ksym-longterm-sha1-init-raw \
ksym-longterm-sha1-transform \
ksym-longterm-sha1-update \
ksym-longterm-sha1-zero-message-hash \
ksym-longterm-sha224 \
ksym-longterm-sha224-final \
ksym-longterm-sha224-init \
ksym-longterm-sha224-zero-message-hash \
ksym-longterm-sha256 \
ksym-longterm-sha256-final \
ksym-longterm-sha256-finup-2x \
ksym-longterm-sha256-finup-2x-is-optimized \
ksym-longterm-sha256-init \
ksym-longterm-sha256-zero-message-hash \
ksym-longterm-sha384 \
ksym-longterm-sha384-final \
ksym-longterm-sha384-init \
ksym-longterm-sha384-zero-message-hash \
ksym-longterm-sha512 \
ksym-longterm-sha512-final \
ksym-longterm-sha512-init \
ksym-longterm-sha512-zero-message-hash \
ksym-longterm-shake-folio \
ksym-longterm-shash-ahash-digest \
ksym-longterm-shash-ahash-finup \
ksym-longterm-shash-ahash-update \
ksym-longterm-shash-free-singlespawn-instance \
ksym-longterm-shash-no-setkey \
ksym-longterm-shash-register-instance \
ksym-longterm-shmem-file-setup \
ksym-longterm-shmem-file-setup-with-mnt \
ksym-longterm-shmem-get-folio \
ksym-longterm-shmem-kernel-file-setup \
ksym-longterm-shmem-mapping \
ksym-longterm-shmem-read-folio-gfp \
ksym-longterm-shmem-read-mapping-page-gfp \
ksym-longterm-shmem-truncate-range \
ksym-longterm-shmem-writeout \
ksym-longterm-should-fail \
ksym-longterm-show-class-attr-string \
ksym-longterm-show-rcu-gp-kthreads \
ksym-longterm-show-rcu-tasks-classic-gp-kthread \
ksym-longterm-show-rcu-tasks-rude-gp-kthread \
ksym-longterm-show-rcu-tasks-trace-gp-kthread \
ksym-longterm-shrink-dcache-parent \
ksym-longterm-shrink-dcache-sb \
ksym-longterm-shrinker-alloc \
ksym-longterm-shrinker-free \
ksym-longterm-shrinker-register \
ksym-longterm-si-mem-available \
ksym-longterm-si-meminfo \
ksym-longterm-si21xx-attach \
ksym-longterm-si470x-ctrl-ops \
ksym-longterm-si470x-set-freq \
ksym-longterm-si470x-start \
ksym-longterm-si470x-stop \
ksym-longterm-si470x-viddev-template \
ksym-longterm-sig-register-instance \
ksym-longterm-sigmadsp-attach \
ksym-longterm-sigmadsp-reset \
ksym-longterm-sigmadsp-restrict-params \
ksym-longterm-sigmadsp-setup \
ksym-longterm-sigprocmask \
ksym-longterm-simple-attr-open \
ksym-longterm-simple-attr-read \
ksym-longterm-simple-attr-release \
ksym-longterm-simple-attr-write \
ksym-longterm-simple-attr-write-signed \
ksym-longterm-simple-dir-inode-operations \
ksym-longterm-simple-dir-operations \
ksym-longterm-simple-empty \
ksym-longterm-simple-fill-super \
ksym-longterm-simple-get-link \
ksym-longterm-simple-getattr \
ksym-longterm-simple-inode-init-ts \
ksym-longterm-simple-link \
ksym-longterm-simple-lookup \
ksym-longterm-simple-map-init \
ksym-longterm-simple-nosetlease \
ksym-longterm-simple-open \
ksym-longterm-simple-pin-fs \
ksym-longterm-simple-read-from-buffer \
ksym-longterm-simple-recursive-removal \
ksym-longterm-simple-release-fs \
ksym-longterm-simple-remove-by-name \
ksym-longterm-simple-rename \
ksym-longterm-simple-rename-exchange \
ksym-longterm-simple-rename-timestamp \
ksym-longterm-simple-rmdir \
ksym-longterm-simple-setattr \
ksym-longterm-simple-start-creating \
ksym-longterm-simple-statfs \
ksym-longterm-simple-strntoul \
ksym-longterm-simple-strtol \
ksym-longterm-simple-strtoll \
ksym-longterm-simple-strtoul \
ksym-longterm-simple-strtoull \
ksym-longterm-simple-symlink-inode-operations \
ksym-longterm-simple-transaction-get \
ksym-longterm-simple-transaction-read \
ksym-longterm-simple-transaction-release \
ksym-longterm-simple-transaction-set \
ksym-longterm-simple-tuner-attach \
ksym-longterm-simple-unlink \
ksym-longterm-simple-util-be-hw-params-fixup \
ksym-longterm-simple-util-canonicalize-cpu \
ksym-longterm-simple-util-canonicalize-platform \
ksym-longterm-simple-util-clean-reference \
ksym-longterm-simple-util-dai-init \
ksym-longterm-simple-util-get-sample-fmt \
ksym-longterm-simple-util-hw-params \
ksym-longterm-simple-util-init-aux-jacks \
ksym-longterm-simple-util-init-jack \
ksym-longterm-simple-util-init-priv \
ksym-longterm-simple-util-is-convert-required \
ksym-longterm-simple-util-parse-card-name \
ksym-longterm-simple-util-parse-clk \
ksym-longterm-simple-util-parse-convert \
ksym-longterm-simple-util-parse-daifmt \
ksym-longterm-simple-util-parse-pin-switches \
ksym-longterm-simple-util-parse-routing \
ksym-longterm-simple-util-parse-tdm-width-map \
ksym-longterm-simple-util-parse-widgets \
ksym-longterm-simple-util-remove \
ksym-longterm-simple-util-set-dailink-name \
ksym-longterm-simple-util-shutdown \
ksym-longterm-simple-util-startup \
ksym-longterm-simple-write-begin \
ksym-longterm-simple-write-to-buffer \
ksym-longterm-single-open \
ksym-longterm-single-open-size \
ksym-longterm-single-release \
ksym-longterm-single-task-running \
ksym-longterm-siphash-1u32 \
ksym-longterm-siphash-1u64 \
ksym-longterm-siphash-2u64 \
ksym-longterm-siphash-3u32 \
ksym-longterm-siphash-3u64 \
ksym-longterm-siphash-4u64 \
ksym-longterm-sis-info133-for-sata \
ksym-longterm-sized-strscpy \
ksym-longterm-sja1000-interrupt \
ksym-longterm-sk-alloc \
ksym-longterm-sk-attach-filter \
ksym-longterm-sk-busy-loop-end \
ksym-longterm-sk-capable \
ksym-longterm-sk-clear-memalloc \
ksym-longterm-sk-clone-lock \
ksym-longterm-sk-common-release \
ksym-longterm-sk-detach-filter \
ksym-longterm-sk-dst-check \
ksym-longterm-sk-error-report \
ksym-longterm-sk-filter-trim-cap \
ksym-longterm-sk-free \
ksym-longterm-sk-ioctl \
ksym-longterm-sk-mc-loop \
ksym-longterm-sk-msg-alloc \
ksym-longterm-sk-msg-clone \
ksym-longterm-sk-msg-free \
ksym-longterm-sk-msg-free-nocharge \
ksym-longterm-sk-msg-free-partial \
ksym-longterm-sk-msg-is-readable \
ksym-longterm-sk-msg-memcopy-from-iter \
ksym-longterm-sk-msg-recvmsg \
ksym-longterm-sk-msg-return \
ksym-longterm-sk-msg-return-zero \
ksym-longterm-sk-msg-trim \
ksym-longterm-sk-msg-zerocopy-from-iter \
ksym-longterm-sk-net-capable \
ksym-longterm-sk-net-refcnt-upgrade \
ksym-longterm-sk-ns-capable \
ksym-longterm-sk-page-frag-refill \
ksym-longterm-sk-psock-drop \
ksym-longterm-sk-psock-init \
ksym-longterm-sk-psock-msg-verdict \
ksym-longterm-sk-psock-tls-strp-read \
ksym-longterm-sk-reset-timer \
ksym-longterm-sk-send-sigurg \
ksym-longterm-sk-set-memalloc \
ksym-longterm-sk-set-peek-off \
ksym-longterm-sk-setup-caps \
ksym-longterm-sk-skb-reason-drop \
ksym-longterm-sk-stop-timer \
ksym-longterm-sk-stop-timer-sync \
ksym-longterm-sk-stream-error \
ksym-longterm-sk-stream-kill-queues \
ksym-longterm-sk-stream-wait-close \
ksym-longterm-sk-stream-wait-connect \
ksym-longterm-sk-stream-wait-memory \
ksym-longterm-sk-wait-data \
ksym-longterm-skb-abort-seq-read \
ksym-longterm-skb-add-rx-frag-netmem \
ksym-longterm-skb-append \
ksym-longterm-skb-append-pagefrags \
ksym-longterm-skb-checksum \
ksym-longterm-skb-checksum-help \
ksym-longterm-skb-checksum-setup \
ksym-longterm-skb-checksum-trimmed \
ksym-longterm-skb-clone \
ksym-longterm-skb-clone-sk \
ksym-longterm-skb-coalesce-rx-frag \
ksym-longterm-skb-complete-tx-timestamp \
ksym-longterm-skb-complete-wifi-ack \
ksym-longterm-skb-condense \
ksym-longterm-skb-copy \
ksym-longterm-skb-copy-and-crc32c-datagram-iter \
ksym-longterm-skb-copy-and-csum-bits \
ksym-longterm-skb-copy-and-csum-datagram-msg \
ksym-longterm-skb-copy-and-csum-dev \
ksym-longterm-skb-copy-bits \
ksym-longterm-skb-copy-datagram-from-iter \
ksym-longterm-skb-copy-datagram-from-iter-full \
ksym-longterm-skb-copy-datagram-iter \
ksym-longterm-skb-copy-expand \
ksym-longterm-skb-copy-header \
ksym-longterm-skb-copy-seq-read \
ksym-longterm-skb-copy-ubufs \
ksym-longterm-skb-cow-data \
ksym-longterm-skb-cow-data-for-xdp \
ksym-longterm-skb-crc32c \
ksym-longterm-skb-crc32c-csum-help \
ksym-longterm-skb-csum-hwoffload-help \
ksym-longterm-skb-dequeue \
ksym-longterm-skb-dequeue-tail \
ksym-longterm-skb-dump \
ksym-longterm-skb-ensure-writable \
ksym-longterm-skb-ensure-writable-head-tail \
ksym-longterm-skb-errqueue-purge \
ksym-longterm-skb-eth-gso-segment \
ksym-longterm-skb-eth-pop \
ksym-longterm-skb-eth-push \
ksym-longterm-skb-expand-head \
ksym-longterm-skb-ext-add \
ksym-longterm-skb-find-text \
ksym-longterm-skb-flow-dissect-ct \
ksym-longterm-skb-flow-dissect-hash \
ksym-longterm-skb-flow-dissect-meta \
ksym-longterm-skb-flow-dissect-tunnel-info \
ksym-longterm-skb-flow-dissector-init \
ksym-longterm-skb-flow-get-icmp-tci \
ksym-longterm-skb-flow-get-ports \
ksym-longterm-skb-free-datagram \
ksym-longterm-skb-get-hash-perturb \
ksym-longterm-skb-gso-validate-mac-len \
ksym-longterm-skb-gso-validate-network-len \
ksym-longterm-skb-headers-offset-update \
ksym-longterm-skb-kill-datagram \
ksym-longterm-skb-mac-gso-segment \
ksym-longterm-skb-morph \
ksym-longterm-skb-mpls-dec-ttl \
ksym-longterm-skb-mpls-pop \
ksym-longterm-skb-mpls-push \
ksym-longterm-skb-mpls-update-lse \
ksym-longterm-skb-orphan-partial \
ksym-longterm-skb-page-frag-refill \
ksym-longterm-skb-partial-csum-set \
ksym-longterm-skb-pp-cow-data \
ksym-longterm-skb-prepare-seq-read \
ksym-longterm-skb-pull \
ksym-longterm-skb-pull-data \
ksym-longterm-skb-pull-rcsum \
ksym-longterm-skb-push \
ksym-longterm-skb-put \
ksym-longterm-skb-queue-head \
ksym-longterm-skb-queue-purge-reason \
ksym-longterm-skb-queue-tail \
ksym-longterm-skb-realloc-headroom \
ksym-longterm-skb-recv-datagram \
ksym-longterm-skb-scrub-packet \
ksym-longterm-skb-segment \
ksym-longterm-skb-segment-list \
ksym-longterm-skb-send-sock-locked \
ksym-longterm-skb-send-sock-locked-with-flags \
ksym-longterm-skb-seq-read \
ksym-longterm-skb-set-owner-w \
ksym-longterm-skb-splice-bits \
ksym-longterm-skb-splice-from-iter \
ksym-longterm-skb-split \
ksym-longterm-skb-store-bits \
ksym-longterm-skb-to-sgvec \
ksym-longterm-skb-to-sgvec-nomark \
ksym-longterm-skb-trim \
ksym-longterm-skb-try-coalesce \
ksym-longterm-skb-tstamp-tx \
ksym-longterm-skb-tunnel-check-pmtu \
ksym-longterm-skb-tx-error \
ksym-longterm-skb-udp-tunnel-segment \
ksym-longterm-skb-unlink \
ksym-longterm-skb-vlan-pop \
ksym-longterm-skb-vlan-push \
ksym-longterm-skb-vlan-untag \
ksym-longterm-skb-zerocopy \
ksym-longterm-skb-zerocopy-headlen \
ksym-longterm-skb-zerocopy-iter-stream \
ksym-longterm-skcipher-alloc-instance-simple \
ksym-longterm-skcipher-register-instance \
ksym-longterm-skcipher-walk-aead-decrypt \
ksym-longterm-skcipher-walk-aead-encrypt \
ksym-longterm-skcipher-walk-done \
ksym-longterm-skcipher-walk-first \
ksym-longterm-skcipher-walk-virt \
ksym-longterm-skip-spaces \
ksym-longterm-sl811h-driver \
ksym-longterm-slab-build-skb \
ksym-longterm-slash-name \
ksym-longterm-slhc-compress \
ksym-longterm-slhc-free \
ksym-longterm-slhc-init \
ksym-longterm-slhc-remember \
ksym-longterm-slhc-toss \
ksym-longterm-slhc-uncompress \
ksym-longterm-slim-alloc-txn-tid \
ksym-longterm-slim-ctrl-clk-pause \
ksym-longterm-slim-device-report-present \
ksym-longterm-slim-do-transfer \
ksym-longterm-slim-driver-unregister \
ksym-longterm-slim-free-txn-tid \
ksym-longterm-slim-get-device \
ksym-longterm-slim-get-logical-addr \
ksym-longterm-slim-msg-response \
ksym-longterm-slim-read \
ksym-longterm-slim-readb \
ksym-longterm-slim-register-controller \
ksym-longterm-slim-report-absent \
ksym-longterm-slim-stream-allocate \
ksym-longterm-slim-stream-disable \
ksym-longterm-slim-stream-enable \
ksym-longterm-slim-stream-free \
ksym-longterm-slim-stream-prepare \
ksym-longterm-slim-stream-unprepare \
ksym-longterm-slim-unregister-controller \
ksym-longterm-slim-write \
ksym-longterm-slim-writeb \
ksym-longterm-slim-xfer-msg \
ksym-longterm-slimbus-bus \
ksym-longterm-sm-register-device \
ksym-longterm-sm3-block-generic \
ksym-longterm-sm3-zero-message-hash \
ksym-longterm-sm4-ce-cbc-enc \
ksym-longterm-sm4-ce-crypt-block \
ksym-longterm-sm4-ce-expand-key \
ksym-longterm-sm4-crypt-block \
ksym-longterm-sm4-expandkey \
ksym-longterm-smc-proto \
ksym-longterm-smc-proto6 \
ksym-longterm-smp-ata-check-ready-type \
ksym-longterm-smp-call-function \
ksym-longterm-smp-call-function-any \
ksym-longterm-smp-call-function-many \
ksym-longterm-smp-call-function-single \
ksym-longterm-smp-call-function-single-async \
ksym-longterm-smp-call-on-cpu \
ksym-longterm-smpboot-register-percpu-thread \
ksym-longterm-smpboot-unregister-percpu-thread \
ksym-longterm-sms-board-event \
ksym-longterm-sms-board-led-feedback \
ksym-longterm-sms-board-lna-control \
ksym-longterm-sms-board-load-modules \
ksym-longterm-sms-board-power \
ksym-longterm-sms-board-setup \
ksym-longterm-sms-get-board \
ksym-longterm-smsc-phy-config-init \
ksym-longterm-smsc-phy-config-intr \
ksym-longterm-smsc-phy-get-tunable \
ksym-longterm-smsc-phy-handle-interrupt \
ksym-longterm-smsc-phy-probe \
ksym-longterm-smsc-phy-set-tunable \
ksym-longterm-smsclient-sendrequest \
ksym-longterm-smscore-get-board-id \
ksym-longterm-smscore-get-device-mode \
ksym-longterm-smscore-getbuffer \
ksym-longterm-smscore-onresponse \
ksym-longterm-smscore-putbuffer \
ksym-longterm-smscore-register-client \
ksym-longterm-smscore-register-device \
ksym-longterm-smscore-register-hotplug \
ksym-longterm-smscore-registry-getmode \
ksym-longterm-smscore-set-board-id \
ksym-longterm-smscore-start-device \
ksym-longterm-smscore-translate-msg \
ksym-longterm-smscore-unregister-client \
ksym-longterm-smscore-unregister-device \
ksym-longterm-smscore-unregister-hotplug \
ksym-longterm-smsendian-handle-message-header \
ksym-longterm-smsendian-handle-rx-message \
ksym-longterm-smsendian-handle-tx-message \
ksym-longterm-snd-ac97-bus \
ksym-longterm-snd-ac97-get-short-name \
ksym-longterm-snd-ac97-mixer \
ksym-longterm-snd-ac97-pcm-assign \
ksym-longterm-snd-ac97-pcm-close \
ksym-longterm-snd-ac97-pcm-double-rate-rules \
ksym-longterm-snd-ac97-pcm-open \
ksym-longterm-snd-ac97-read \
ksym-longterm-snd-ac97-reset \
ksym-longterm-snd-ac97-resume \
ksym-longterm-snd-ac97-set-rate \
ksym-longterm-snd-ac97-suspend \
ksym-longterm-snd-ac97-tune-hardware \
ksym-longterm-snd-ac97-update \
ksym-longterm-snd-ac97-update-bits \
ksym-longterm-snd-ac97-update-power \
ksym-longterm-snd-ac97-write \
ksym-longterm-snd-ac97-write-cache \
ksym-longterm-snd-ak4113-build \
ksym-longterm-snd-ak4113-check-rate-and-errors \
ksym-longterm-snd-ak4113-create \
ksym-longterm-snd-ak4113-external-rate \
ksym-longterm-snd-ak4113-reg-write \
ksym-longterm-snd-ak4113-reinit \
ksym-longterm-snd-ak4113-resume \
ksym-longterm-snd-ak4113-suspend \
ksym-longterm-snd-ak4114-build \
ksym-longterm-snd-ak4114-check-rate-and-errors \
ksym-longterm-snd-ak4114-create \
ksym-longterm-snd-ak4114-external-rate \
ksym-longterm-snd-ak4114-reg-write \
ksym-longterm-snd-ak4114-reinit \
ksym-longterm-snd-ak4114-resume \
ksym-longterm-snd-ak4114-suspend \
ksym-longterm-snd-akm4xxx-build-controls \
ksym-longterm-snd-akm4xxx-init \
ksym-longterm-snd-akm4xxx-reset \
ksym-longterm-snd-akm4xxx-write \
ksym-longterm-snd-amd-acp-find-config \
ksym-longterm-snd-array-free \
ksym-longterm-snd-array-new \
ksym-longterm-snd-card-add-dev-attr \
ksym-longterm-snd-card-disconnect \
ksym-longterm-snd-card-disconnect-sync \
ksym-longterm-snd-card-file-add \
ksym-longterm-snd-card-file-remove \
ksym-longterm-snd-card-free \
ksym-longterm-snd-card-free-on-error \
ksym-longterm-snd-card-free-when-closed \
ksym-longterm-snd-card-new \
ksym-longterm-snd-card-ref \
ksym-longterm-snd-card-register \
ksym-longterm-snd-card-rw-proc-new \
ksym-longterm-snd-card-set-id \
ksym-longterm-snd-component-add \
ksym-longterm-snd-compr-free-pages \
ksym-longterm-snd-compr-malloc-pages \
ksym-longterm-snd-compr-stop-error \
ksym-longterm-snd-compr-task-finished \
ksym-longterm-snd-compress-new \
ksym-longterm-snd-ctl-activate-id \
ksym-longterm-snd-ctl-add \
ksym-longterm-snd-ctl-add-followers \
ksym-longterm-snd-ctl-add-vmaster-hook \
ksym-longterm-snd-ctl-apply-vmaster-followers \
ksym-longterm-snd-ctl-boolean-mono-info \
ksym-longterm-snd-ctl-boolean-stereo-info \
ksym-longterm-snd-ctl-disconnect-layer \
ksym-longterm-snd-ctl-enum-info \
ksym-longterm-snd-ctl-find-id \
ksym-longterm-snd-ctl-find-numid \
ksym-longterm-snd-ctl-free-one \
ksym-longterm-snd-ctl-get-preferred-subdevice \
ksym-longterm-snd-ctl-make-virtual-master \
ksym-longterm-snd-ctl-new1 \
ksym-longterm-snd-ctl-notify \
ksym-longterm-snd-ctl-notify-one \
ksym-longterm-snd-ctl-register-ioctl \
ksym-longterm-snd-ctl-register-ioctl-compat \
ksym-longterm-snd-ctl-register-layer \
ksym-longterm-snd-ctl-remove \
ksym-longterm-snd-ctl-remove-id \
ksym-longterm-snd-ctl-rename \
ksym-longterm-snd-ctl-rename-id \
ksym-longterm-snd-ctl-replace \
ksym-longterm-snd-ctl-request-layer \
ksym-longterm-snd-ctl-sync-vmaster \
ksym-longterm-snd-ctl-unregister-ioctl \
ksym-longterm-snd-ctl-unregister-ioctl-compat \
ksym-longterm-snd-device-alloc \
ksym-longterm-snd-device-disconnect \
ksym-longterm-snd-device-free \
ksym-longterm-snd-device-new \
ksym-longterm-snd-device-register \
ksym-longterm-snd-devm-alloc-dir-pages \
ksym-longterm-snd-devm-card-new \
ksym-longterm-snd-dma-alloc-dir-pages \
ksym-longterm-snd-dma-alloc-pages-fallback \
ksym-longterm-snd-dma-buffer-mmap \
ksym-longterm-snd-dma-buffer-sync \
ksym-longterm-snd-dma-free-pages \
ksym-longterm-snd-dmaengine-pcm-close \
ksym-longterm-snd-dmaengine-pcm-close-release-chan \
ksym-longterm-snd-dmaengine-pcm-get-chan \
ksym-longterm-snd-dmaengine-pcm-open \
ksym-longterm-snd-dmaengine-pcm-pointer \
ksym-longterm-snd-dmaengine-pcm-pointer-no-residue \
ksym-longterm-snd-dmaengine-pcm-prepare-slave-config \
ksym-longterm-snd-dmaengine-pcm-refine-runtime-hwparams \
ksym-longterm-snd-dmaengine-pcm-register \
ksym-longterm-snd-dmaengine-pcm-request-channel \
ksym-longterm-snd-dmaengine-pcm-set-config-from-dai-data \
ksym-longterm-snd-dmaengine-pcm-sync-stop \
ksym-longterm-snd-dmaengine-pcm-trigger \
ksym-longterm-snd-dmaengine-pcm-unregister \
ksym-longterm-snd-ecards-limit \
ksym-longterm-snd-fasync-free \
ksym-longterm-snd-fasync-helper \
ksym-longterm-snd-fw-transaction \
ksym-longterm-snd-hda-activate-path \
ksym-longterm-snd-hda-add-imux-item \
ksym-longterm-snd-hda-add-new-ctls \
ksym-longterm-snd-hda-add-new-path \
ksym-longterm-snd-hda-add-verbs \
ksym-longterm-snd-hda-add-vmaster-hook \
ksym-longterm-snd-hda-apply-fixup \
ksym-longterm-snd-hda-apply-pincfgs \
ksym-longterm-snd-hda-apply-verbs \
ksym-longterm-snd-hda-attach-beep-device \
ksym-longterm-snd-hda-bus-type \
ksym-longterm-snd-hda-check-amp-caps \
ksym-longterm-snd-hda-check-amp-list-power \
ksym-longterm-snd-hda-codec-amp-init \
ksym-longterm-snd-hda-codec-amp-init-stereo \
ksym-longterm-snd-hda-codec-amp-stereo \
ksym-longterm-snd-hda-codec-amp-update \
ksym-longterm-snd-hda-codec-build-controls \
ksym-longterm-snd-hda-codec-cleanup \
ksym-longterm-snd-hda-codec-cleanup-for-unbind \
ksym-longterm-snd-hda-codec-configure \
ksym-longterm-snd-hda-codec-device-init \
ksym-longterm-snd-hda-codec-device-new \
ksym-longterm-snd-hda-codec-eapd-power-filter \
ksym-longterm-snd-hda-codec-get-pin-target \
ksym-longterm-snd-hda-codec-get-pincfg \
ksym-longterm-snd-hda-codec-load-dsp-cleanup \
ksym-longterm-snd-hda-codec-load-dsp-prepare \
ksym-longterm-snd-hda-codec-load-dsp-trigger \
ksym-longterm-snd-hda-codec-new \
ksym-longterm-snd-hda-codec-parse-pcms \
ksym-longterm-snd-hda-codec-pcm-new \
ksym-longterm-snd-hda-codec-pcm-put \
ksym-longterm-snd-hda-codec-prepare \
ksym-longterm-snd-hda-codec-register \
ksym-longterm-snd-hda-codec-set-name \
ksym-longterm-snd-hda-codec-set-pin-target \
ksym-longterm-snd-hda-codec-set-pincfg \
ksym-longterm-snd-hda-codec-set-power-save \
ksym-longterm-snd-hda-codec-set-power-to-all \
ksym-longterm-snd-hda-codec-setup-stream \
ksym-longterm-snd-hda-codec-unregister \
ksym-longterm-snd-hda-codec-update-widgets \
ksym-longterm-snd-hda-correct-pin-ctl \
ksym-longterm-snd-hda-create-dig-out-ctls \
ksym-longterm-snd-hda-create-spdif-in-ctls \
ksym-longterm-snd-hda-create-spdif-share-sw \
ksym-longterm-snd-hda-ctl-add \
ksym-longterm-snd-hda-detach-beep-device \
ksym-longterm-snd-hda-enable-beep-device \
ksym-longterm-snd-hda-enum-helper-info \
ksym-longterm-snd-hda-ext-driver-register \
ksym-longterm-snd-hda-ext-driver-unregister \
ksym-longterm-snd-hda-find-mixer-ctl \
ksym-longterm-snd-hda-gen-add-kctl \
ksym-longterm-snd-hda-gen-add-micmute-led-cdev \
ksym-longterm-snd-hda-gen-add-mute-led-cdev \
ksym-longterm-snd-hda-gen-build-controls \
ksym-longterm-snd-hda-gen-build-pcms \
ksym-longterm-snd-hda-gen-check-power-status \
ksym-longterm-snd-hda-gen-fix-pin-power \
ksym-longterm-snd-hda-gen-hp-automute \
ksym-longterm-snd-hda-gen-init \
ksym-longterm-snd-hda-gen-line-automute \
ksym-longterm-snd-hda-gen-mic-autoswitch \
ksym-longterm-snd-hda-gen-parse-auto-config \
ksym-longterm-snd-hda-gen-path-power-filter \
ksym-longterm-snd-hda-gen-remove \
ksym-longterm-snd-hda-gen-shutup-speakers \
ksym-longterm-snd-hda-gen-spec-init \
ksym-longterm-snd-hda-gen-stream-pm \
ksym-longterm-snd-hda-gen-update-outputs \
ksym-longterm-snd-hda-get-bool-hint \
ksym-longterm-snd-hda-get-conn-index \
ksym-longterm-snd-hda-get-conn-list \
ksym-longterm-snd-hda-get-connections \
ksym-longterm-snd-hda-get-default-vref \
ksym-longterm-snd-hda-get-dev-select \
ksym-longterm-snd-hda-get-hint \
ksym-longterm-snd-hda-get-input-pin-attr \
ksym-longterm-snd-hda-get-int-hint \
ksym-longterm-snd-hda-get-num-devices \
ksym-longterm-snd-hda-get-path-from-idx \
ksym-longterm-snd-hda-get-path-idx \
ksym-longterm-snd-hda-get-pin-label \
ksym-longterm-snd-hda-hdmi-acomp-init \
ksym-longterm-snd-hda-hdmi-acomp-master-bind \
ksym-longterm-snd-hda-hdmi-acomp-master-unbind \
ksym-longterm-snd-hda-hdmi-acomp-pin-eld-notify \
ksym-longterm-snd-hda-hdmi-check-presence-and-report \
ksym-longterm-snd-hda-hdmi-generic-alloc \
ksym-longterm-snd-hda-hdmi-generic-build-controls \
ksym-longterm-snd-hda-hdmi-generic-build-pcms \
ksym-longterm-snd-hda-hdmi-generic-init \
ksym-longterm-snd-hda-hdmi-generic-init-per-pins \
ksym-longterm-snd-hda-hdmi-generic-pcm-cleanup \
ksym-longterm-snd-hda-hdmi-generic-pcm-prepare \
ksym-longterm-snd-hda-hdmi-generic-probe \
ksym-longterm-snd-hda-hdmi-generic-remove \
ksym-longterm-snd-hda-hdmi-generic-resume \
ksym-longterm-snd-hda-hdmi-generic-spec-free \
ksym-longterm-snd-hda-hdmi-generic-suspend \
ksym-longterm-snd-hda-hdmi-generic-unsol-event \
ksym-longterm-snd-hda-hdmi-parse-codec \
ksym-longterm-snd-hda-hdmi-pin-id-to-pin-index \
ksym-longterm-snd-hda-hdmi-setup-audio-infoframe \
ksym-longterm-snd-hda-hdmi-setup-drm-audio-ops \
ksym-longterm-snd-hda-hdmi-setup-stream \
ksym-longterm-snd-hda-hdmi-simple-build-controls \
ksym-longterm-snd-hda-hdmi-simple-build-pcms \
ksym-longterm-snd-hda-hdmi-simple-init \
ksym-longterm-snd-hda-hdmi-simple-pcm-open \
ksym-longterm-snd-hda-hdmi-simple-probe \
ksym-longterm-snd-hda-hdmi-simple-remove \
ksym-longterm-snd-hda-hdmi-simple-unsol-event \
ksym-longterm-snd-hda-input-mux-info \
ksym-longterm-snd-hda-input-mux-put \
ksym-longterm-snd-hda-jack-add-kctl-mst \
ksym-longterm-snd-hda-jack-add-kctls \
ksym-longterm-snd-hda-jack-bind-keymap \
ksym-longterm-snd-hda-jack-detect-enable \
ksym-longterm-snd-hda-jack-detect-enable-callback-mst \
ksym-longterm-snd-hda-jack-detect-state-mst \
ksym-longterm-snd-hda-jack-pin-sense \
ksym-longterm-snd-hda-jack-poll-all \
ksym-longterm-snd-hda-jack-report-sync \
ksym-longterm-snd-hda-jack-set-button-state \
ksym-longterm-snd-hda-jack-set-dirty-all \
ksym-longterm-snd-hda-jack-set-gating-jack \
ksym-longterm-snd-hda-jack-tbl-get-from-tag \
ksym-longterm-snd-hda-jack-tbl-get-mst \
ksym-longterm-snd-hda-jack-unsol-event \
ksym-longterm-snd-hda-load-patch \
ksym-longterm-snd-hda-lock-devices \
ksym-longterm-snd-hda-mixer-amp-switch-get \
ksym-longterm-snd-hda-mixer-amp-switch-get-beep \
ksym-longterm-snd-hda-mixer-amp-switch-info \
ksym-longterm-snd-hda-mixer-amp-switch-put \
ksym-longterm-snd-hda-mixer-amp-switch-put-beep \
ksym-longterm-snd-hda-mixer-amp-tlv \
ksym-longterm-snd-hda-mixer-amp-volume-get \
ksym-longterm-snd-hda-mixer-amp-volume-info \
ksym-longterm-snd-hda-mixer-amp-volume-put \
ksym-longterm-snd-hda-multi-out-analog-cleanup \
ksym-longterm-snd-hda-multi-out-analog-open \
ksym-longterm-snd-hda-multi-out-analog-prepare \
ksym-longterm-snd-hda-multi-out-dig-cleanup \
ksym-longterm-snd-hda-multi-out-dig-close \
ksym-longterm-snd-hda-multi-out-dig-open \
ksym-longterm-snd-hda-multi-out-dig-prepare \
ksym-longterm-snd-hda-override-amp-caps \
ksym-longterm-snd-hda-override-conn-list \
ksym-longterm-snd-hda-parse-pin-defcfg \
ksym-longterm-snd-hda-pick-fixup \
ksym-longterm-snd-hda-pick-pin-fixup \
ksym-longterm-snd-hda-sequence-write \
ksym-longterm-snd-hda-set-dev-select \
ksym-longterm-snd-hda-set-power-save \
ksym-longterm-snd-hda-set-vmaster-tlv \
ksym-longterm-snd-hda-shutup-pins \
ksym-longterm-snd-hda-spdif-ctls-assign \
ksym-longterm-snd-hda-spdif-ctls-unassign \
ksym-longterm-snd-hda-spdif-out-of-nid \
ksym-longterm-snd-hda-sync-vmaster-hook \
ksym-longterm-snd-hda-unlock-devices \
ksym-longterm-snd-hdac-acomp-exit \
ksym-longterm-snd-hdac-acomp-get-eld \
ksym-longterm-snd-hdac-acomp-init \
ksym-longterm-snd-hdac-acomp-register-notifier \
ksym-longterm-snd-hdac-add-chmap-ctls \
ksym-longterm-snd-hdac-aligned-read \
ksym-longterm-snd-hdac-aligned-write \
ksym-longterm-snd-hdac-bus-alloc-stream-pages \
ksym-longterm-snd-hdac-bus-enter-link-reset \
ksym-longterm-snd-hdac-bus-exec-verb-unlocked \
ksym-longterm-snd-hdac-bus-exit \
ksym-longterm-snd-hdac-bus-exit-link-reset \
ksym-longterm-snd-hdac-bus-free-stream-pages \
ksym-longterm-snd-hdac-bus-get-response \
ksym-longterm-snd-hdac-bus-handle-stream-irq \
ksym-longterm-snd-hdac-bus-init \
ksym-longterm-snd-hdac-bus-init-chip \
ksym-longterm-snd-hdac-bus-init-cmd-io \
ksym-longterm-snd-hdac-bus-link-power \
ksym-longterm-snd-hdac-bus-parse-capabilities \
ksym-longterm-snd-hdac-bus-reset-link \
ksym-longterm-snd-hdac-bus-send-cmd \
ksym-longterm-snd-hdac-bus-stop-chip \
ksym-longterm-snd-hdac-bus-stop-cmd-io \
ksym-longterm-snd-hdac-bus-update-rirb \
ksym-longterm-snd-hdac-channel-allocation \
ksym-longterm-snd-hdac-check-power-state \
ksym-longterm-snd-hdac-chmap-to-spk-mask \
ksym-longterm-snd-hdac-codec-link-down \
ksym-longterm-snd-hdac-codec-link-up \
ksym-longterm-snd-hdac-codec-modalias \
ksym-longterm-snd-hdac-codec-read \
ksym-longterm-snd-hdac-codec-write \
ksym-longterm-snd-hdac-device-exit \
ksym-longterm-snd-hdac-device-init \
ksym-longterm-snd-hdac-device-register \
ksym-longterm-snd-hdac-device-set-chip-name \
ksym-longterm-snd-hdac-device-unregister \
ksym-longterm-snd-hdac-display-power \
ksym-longterm-snd-hdac-dsp-cleanup \
ksym-longterm-snd-hdac-dsp-prepare \
ksym-longterm-snd-hdac-dsp-trigger \
ksym-longterm-snd-hdac-ext-bus-device-remove \
ksym-longterm-snd-hdac-ext-bus-exit \
ksym-longterm-snd-hdac-ext-bus-get-hlink-by-addr \
ksym-longterm-snd-hdac-ext-bus-get-hlink-by-id \
ksym-longterm-snd-hdac-ext-bus-get-hlink-by-name \
ksym-longterm-snd-hdac-ext-bus-get-ml-capabilities \
ksym-longterm-snd-hdac-ext-bus-init \
ksym-longterm-snd-hdac-ext-bus-link-clear-stream-id \
ksym-longterm-snd-hdac-ext-bus-link-get \
ksym-longterm-snd-hdac-ext-bus-link-power \
ksym-longterm-snd-hdac-ext-bus-link-power-down \
ksym-longterm-snd-hdac-ext-bus-link-power-down-all \
ksym-longterm-snd-hdac-ext-bus-link-power-up \
ksym-longterm-snd-hdac-ext-bus-link-power-up-all \
ksym-longterm-snd-hdac-ext-bus-link-put \
ksym-longterm-snd-hdac-ext-bus-link-set-stream-id \
ksym-longterm-snd-hdac-ext-bus-ppcap-enable \
ksym-longterm-snd-hdac-ext-bus-ppcap-int-enable \
ksym-longterm-snd-hdac-ext-cstream-assign \
ksym-longterm-snd-hdac-ext-host-stream-setup \
ksym-longterm-snd-hdac-ext-link-free-all \
ksym-longterm-snd-hdac-ext-stream-assign \
ksym-longterm-snd-hdac-ext-stream-clear \
ksym-longterm-snd-hdac-ext-stream-decouple \
ksym-longterm-snd-hdac-ext-stream-decouple-locked \
ksym-longterm-snd-hdac-ext-stream-free-all \
ksym-longterm-snd-hdac-ext-stream-init-all \
ksym-longterm-snd-hdac-ext-stream-release \
ksym-longterm-snd-hdac-ext-stream-reset \
ksym-longterm-snd-hdac-ext-stream-setup \
ksym-longterm-snd-hdac-ext-stream-start \
ksym-longterm-snd-hdac-get-active-channels \
ksym-longterm-snd-hdac-get-ch-alloc-from-ca \
ksym-longterm-snd-hdac-get-connections \
ksym-longterm-snd-hdac-get-stream \
ksym-longterm-snd-hdac-get-stream-stripe-ctl \
ksym-longterm-snd-hdac-get-sub-nodes \
ksym-longterm-snd-hdac-i915-init \
ksym-longterm-snd-hdac-i915-set-bclk \
ksym-longterm-snd-hdac-is-supported-format \
ksym-longterm-snd-hdac-override-parm \
ksym-longterm-snd-hdac-power-down \
ksym-longterm-snd-hdac-power-down-pm \
ksym-longterm-snd-hdac-power-up \
ksym-longterm-snd-hdac-power-up-pm \
ksym-longterm-snd-hdac-print-channel-allocation \
ksym-longterm-snd-hdac-query-supported-pcm \
ksym-longterm-snd-hdac-read \
ksym-longterm-snd-hdac-read-parm-uncached \
ksym-longterm-snd-hdac-refresh-widgets \
ksym-longterm-snd-hdac-register-chmap-ops \
ksym-longterm-snd-hdac-regmap-add-vendor-verb \
ksym-longterm-snd-hdac-regmap-exit \
ksym-longterm-snd-hdac-regmap-init \
ksym-longterm-snd-hdac-regmap-read-raw \
ksym-longterm-snd-hdac-regmap-sync \
ksym-longterm-snd-hdac-regmap-update-raw \
ksym-longterm-snd-hdac-regmap-update-raw-once \
ksym-longterm-snd-hdac-regmap-write-raw \
ksym-longterm-snd-hdac-set-codec-wakeup \
ksym-longterm-snd-hdac-setup-channel-mapping \
ksym-longterm-snd-hdac-spdif-stream-format \
ksym-longterm-snd-hdac-spk-to-chmap \
ksym-longterm-snd-hdac-stop-streams \
ksym-longterm-snd-hdac-stop-streams-and-chip \
ksym-longterm-snd-hdac-stream-assign \
ksym-longterm-snd-hdac-stream-cleanup \
ksym-longterm-snd-hdac-stream-drsm-enable \
ksym-longterm-snd-hdac-stream-format \
ksym-longterm-snd-hdac-stream-format-bits \
ksym-longterm-snd-hdac-stream-init \
ksym-longterm-snd-hdac-stream-release \
ksym-longterm-snd-hdac-stream-release-locked \
ksym-longterm-snd-hdac-stream-reset \
ksym-longterm-snd-hdac-stream-set-dpibr \
ksym-longterm-snd-hdac-stream-set-lpib \
ksym-longterm-snd-hdac-stream-set-params \
ksym-longterm-snd-hdac-stream-set-spib \
ksym-longterm-snd-hdac-stream-setup \
ksym-longterm-snd-hdac-stream-setup-periods \
ksym-longterm-snd-hdac-stream-spbcap-enable \
ksym-longterm-snd-hdac-stream-start \
ksym-longterm-snd-hdac-stream-stop \
ksym-longterm-snd-hdac-stream-sync \
ksym-longterm-snd-hdac-stream-sync-trigger \
ksym-longterm-snd-hdac-stream-timecounter-init \
ksym-longterm-snd-hdac-stream-wait-drsm \
ksym-longterm-snd-hdac-sync-audio-rate \
ksym-longterm-snd-hdac-sync-power-state \
ksym-longterm-snd-hwdep-new \
ksym-longterm-snd-hwparams-to-dma-slave-config \
ksym-longterm-snd-i2c-bus-create \
ksym-longterm-snd-i2c-device-create \
ksym-longterm-snd-i2c-device-free \
ksym-longterm-snd-i2c-probeaddr \
ksym-longterm-snd-i2c-readbytes \
ksym-longterm-snd-i2c-sendbytes \
ksym-longterm-snd-ice1712-akm4xxx-build-controls \
ksym-longterm-snd-ice1712-akm4xxx-free \
ksym-longterm-snd-ice1712-akm4xxx-init \
ksym-longterm-snd-info-create-card-entry \
ksym-longterm-snd-info-create-module-entry \
ksym-longterm-snd-info-free-entry \
ksym-longterm-snd-info-get-line \
ksym-longterm-snd-info-get-str \
ksym-longterm-snd-info-register \
ksym-longterm-snd-intel-acpi-dsp-driver-probe \
ksym-longterm-snd-intel-dsp-driver-probe \
ksym-longterm-snd-interval-list \
ksym-longterm-snd-interval-ranges \
ksym-longterm-snd-interval-ratnum \
ksym-longterm-snd-interval-refine \
ksym-longterm-snd-jack-add-new-kctl \
ksym-longterm-snd-jack-new \
ksym-longterm-snd-jack-report \
ksym-longterm-snd-jack-set-key \
ksym-longterm-snd-kill-fasync \
ksym-longterm-snd-lookup-minor-data \
ksym-longterm-snd-lookup-oss-minor-data \
ksym-longterm-snd-major \
ksym-longterm-snd-midi-channel-alloc-set \
ksym-longterm-snd-midi-channel-free-set \
ksym-longterm-snd-midi-channel-set-clear \
ksym-longterm-snd-midi-event-decode \
ksym-longterm-snd-midi-event-encode-byte \
ksym-longterm-snd-midi-event-free \
ksym-longterm-snd-midi-event-new \
ksym-longterm-snd-midi-event-no-status \
ksym-longterm-snd-midi-event-reset-decode \
ksym-longterm-snd-midi-event-reset-encode \
ksym-longterm-snd-midi-process-event \
ksym-longterm-snd-mixer-oss-ioctl-card \
ksym-longterm-snd-mixer-oss-notify-callback \
ksym-longterm-snd-mpu401-uart-interrupt \
ksym-longterm-snd-mpu401-uart-interrupt-tx \
ksym-longterm-snd-mpu401-uart-new \
ksym-longterm-snd-opl3-create \
ksym-longterm-snd-opl3-find-patch \
ksym-longterm-snd-opl3-hwdep-new \
ksym-longterm-snd-opl3-init \
ksym-longterm-snd-opl3-interrupt \
ksym-longterm-snd-opl3-load-patch \
ksym-longterm-snd-opl3-new \
ksym-longterm-snd-opl3-regmap \
ksym-longterm-snd-opl3-reset \
ksym-longterm-snd-opl3-timer-new \
ksym-longterm-snd-oss-info-register \
ksym-longterm-snd-parse-eld \
ksym-longterm-snd-pci-quirk-lookup \
ksym-longterm-snd-pci-quirk-lookup-id \
ksym-longterm-snd-pcm-2-1-chmaps \
ksym-longterm-snd-pcm-add-chmap-ctls \
ksym-longterm-snd-pcm-alt-chmaps \
ksym-longterm-snd-pcm-create-iec958-consumer \
ksym-longterm-snd-pcm-create-iec958-consumer-default \
ksym-longterm-snd-pcm-create-iec958-consumer-hw-params \
ksym-longterm-snd-pcm-debug-name \
ksym-longterm-snd-pcm-fill-iec958-consumer \
ksym-longterm-snd-pcm-fill-iec958-consumer-hw-params \
ksym-longterm-snd-pcm-format-big-endian \
ksym-longterm-snd-pcm-format-linear \
ksym-longterm-snd-pcm-format-little-endian \
ksym-longterm-snd-pcm-format-name \
ksym-longterm-snd-pcm-format-physical-width \
ksym-longterm-snd-pcm-format-set-silence \
ksym-longterm-snd-pcm-format-signed \
ksym-longterm-snd-pcm-format-silence-64 \
ksym-longterm-snd-pcm-format-size \
ksym-longterm-snd-pcm-format-unsigned \
ksym-longterm-snd-pcm-format-width \
ksym-longterm-snd-pcm-hw-constraint-eld \
ksym-longterm-snd-pcm-hw-constraint-integer \
ksym-longterm-snd-pcm-hw-constraint-list \
ksym-longterm-snd-pcm-hw-constraint-mask64 \
ksym-longterm-snd-pcm-hw-constraint-minmax \
ksym-longterm-snd-pcm-hw-constraint-msbits \
ksym-longterm-snd-pcm-hw-constraint-pow2 \
ksym-longterm-snd-pcm-hw-constraint-ranges \
ksym-longterm-snd-pcm-hw-constraint-ratdens \
ksym-longterm-snd-pcm-hw-constraint-ratnums \
ksym-longterm-snd-pcm-hw-constraint-step \
ksym-longterm-snd-pcm-hw-limit-rates \
ksym-longterm-snd-pcm-hw-param-first \
ksym-longterm-snd-pcm-hw-param-last \
ksym-longterm-snd-pcm-hw-param-value \
ksym-longterm-snd-pcm-hw-params-bits \
ksym-longterm-snd-pcm-hw-refine \
ksym-longterm-snd-pcm-hw-rule-add \
ksym-longterm-snd-pcm-hw-rule-noresample \
ksym-longterm-snd-pcm-kernel-ioctl \
ksym-longterm-snd-pcm-lib-default-mmap \
ksym-longterm-snd-pcm-lib-free-pages \
ksym-longterm-snd-pcm-lib-ioctl \
ksym-longterm-snd-pcm-lib-malloc-pages \
ksym-longterm-snd-pcm-lib-preallocate-free-for-all \
ksym-longterm-snd-pcm-lib-preallocate-pages \
ksym-longterm-snd-pcm-lib-preallocate-pages-for-all \
ksym-longterm-snd-pcm-mmap-data \
ksym-longterm-snd-pcm-new \
ksym-longterm-snd-pcm-new-internal \
ksym-longterm-snd-pcm-new-stream \
ksym-longterm-snd-pcm-notify \
ksym-longterm-snd-pcm-open-substream \
ksym-longterm-snd-pcm-period-elapsed \
ksym-longterm-snd-pcm-period-elapsed-under-stream-lock \
ksym-longterm-snd-pcm-rate-bit-to-rate \
ksym-longterm-snd-pcm-rate-mask-intersect \
ksym-longterm-snd-pcm-rate-to-rate-bit \
ksym-longterm-snd-pcm-release-substream \
ksym-longterm-snd-pcm-runtime-buffer-set-silence \
ksym-longterm-snd-pcm-set-managed-buffer \
ksym-longterm-snd-pcm-set-managed-buffer-all \
ksym-longterm-snd-pcm-set-ops \
ksym-longterm-snd-pcm-set-sync-per-card \
ksym-longterm-snd-pcm-std-chmaps \
ksym-longterm-snd-pcm-stop \
ksym-longterm-snd-pcm-stop-xrun \
ksym-longterm-snd-pcm-stream-lock \
ksym-longterm-snd-pcm-stream-lock-irq \
ksym-longterm-snd-pcm-stream-unlock \
ksym-longterm-snd-pcm-stream-unlock-irq \
ksym-longterm-snd-pcm-stream-unlock-irqrestore \
ksym-longterm-snd-pcm-suspend-all \
ksym-longterm-snd-power-ref-and-wait \
ksym-longterm-snd-power-wait \
ksym-longterm-snd-print-eld-info \
ksym-longterm-snd-print-pcm-bits \
ksym-longterm-snd-pt2258-build-controls \
ksym-longterm-snd-pt2258-reset \
ksym-longterm-snd-rawmidi-drain-input \
ksym-longterm-snd-rawmidi-drain-output \
ksym-longterm-snd-rawmidi-drop-output \
ksym-longterm-snd-rawmidi-free \
ksym-longterm-snd-rawmidi-info-select \
ksym-longterm-snd-rawmidi-init \
ksym-longterm-snd-rawmidi-input-params \
ksym-longterm-snd-rawmidi-kernel-open \
ksym-longterm-snd-rawmidi-kernel-read \
ksym-longterm-snd-rawmidi-kernel-release \
ksym-longterm-snd-rawmidi-kernel-write \
ksym-longterm-snd-rawmidi-new \
ksym-longterm-snd-rawmidi-output-params \
ksym-longterm-snd-rawmidi-proceed \
ksym-longterm-snd-rawmidi-receive \
ksym-longterm-snd-rawmidi-set-ops \
ksym-longterm-snd-rawmidi-transmit \
ksym-longterm-snd-rawmidi-transmit-ack \
ksym-longterm-snd-rawmidi-transmit-empty \
ksym-longterm-snd-rawmidi-transmit-peek \
ksym-longterm-snd-register-device \
ksym-longterm-snd-register-oss-device \
ksym-longterm-snd-request-card \
ksym-longterm-snd-seq-autoload-exit \
ksym-longterm-snd-seq-autoload-init \
ksym-longterm-snd-seq-create-kernel-client \
ksym-longterm-snd-seq-delete-kernel-client \
ksym-longterm-snd-seq-device-load-drivers \
ksym-longterm-snd-seq-device-new \
ksym-longterm-snd-seq-driver-unregister \
ksym-longterm-snd-seq-dump-var-event \
ksym-longterm-snd-seq-event-port-attach \
ksym-longterm-snd-seq-event-port-detach \
ksym-longterm-snd-seq-expand-var-event \
ksym-longterm-snd-seq-expand-var-event-at \
ksym-longterm-snd-seq-kernel-client-ctl \
ksym-longterm-snd-seq-kernel-client-dispatch \
ksym-longterm-snd-seq-kernel-client-enqueue \
ksym-longterm-snd-seq-kernel-client-get \
ksym-longterm-snd-seq-kernel-client-ioctl \
ksym-longterm-snd-seq-kernel-client-put \
ksym-longterm-snd-seq-kernel-client-write-poll \
ksym-longterm-snd-seq-root \
ksym-longterm-snd-seq-set-queue-tempo \
ksym-longterm-snd-seq-system-broadcast \
ksym-longterm-snd-sgbuf-get-addr \
ksym-longterm-snd-sgbuf-get-chunk-size \
ksym-longterm-snd-sgbuf-get-page \
ksym-longterm-snd-show-eld \
ksym-longterm-snd-soc-acpi-amd-acp63-sof-machines \
ksym-longterm-snd-soc-acpi-amd-acp70-sof-machines \
ksym-longterm-snd-soc-acpi-amd-rmb-sof-machines \
ksym-longterm-snd-soc-acpi-amd-sof-machines \
ksym-longterm-snd-soc-acpi-amd-vangogh-sof-machines \
ksym-longterm-snd-soc-acpi-codec-list \
ksym-longterm-snd-soc-acpi-find-machine \
ksym-longterm-snd-soc-acpi-find-package-from-hid \
ksym-longterm-snd-soc-acpi-sdw-link-slaves-found \
ksym-longterm-snd-soc-add-card-controls \
ksym-longterm-snd-soc-add-component \
ksym-longterm-snd-soc-add-component-controls \
ksym-longterm-snd-soc-add-dai-controls \
ksym-longterm-snd-soc-add-pcm-runtimes \
ksym-longterm-snd-soc-alloc-ac97-component \
ksym-longterm-snd-soc-bytes-get \
ksym-longterm-snd-soc-bytes-info \
ksym-longterm-snd-soc-bytes-info-ext \
ksym-longterm-snd-soc-bytes-put \
ksym-longterm-snd-soc-bytes-tlv-callback \
ksym-longterm-snd-soc-calc-bclk \
ksym-longterm-snd-soc-calc-frame-size \
ksym-longterm-snd-soc-card-add-dai-link \
ksym-longterm-snd-soc-card-get-kcontrol \
ksym-longterm-snd-soc-card-jack-new \
ksym-longterm-snd-soc-card-jack-new-pins \
ksym-longterm-snd-soc-card-remove-dai-link \
ksym-longterm-snd-soc-close-delayed-work \
ksym-longterm-snd-soc-cnew \
ksym-longterm-snd-soc-component-async-complete \
ksym-longterm-snd-soc-component-compr-ack \
ksym-longterm-snd-soc-component-compr-copy \
ksym-longterm-snd-soc-component-compr-free \
ksym-longterm-snd-soc-component-compr-get-caps \
ksym-longterm-snd-soc-component-compr-get-codec-caps \
ksym-longterm-snd-soc-component-compr-get-metadata \
ksym-longterm-snd-soc-component-compr-get-params \
ksym-longterm-snd-soc-component-compr-open \
ksym-longterm-snd-soc-component-compr-pointer \
ksym-longterm-snd-soc-component-compr-set-metadata \
ksym-longterm-snd-soc-component-compr-set-params \
ksym-longterm-snd-soc-component-compr-trigger \
ksym-longterm-snd-soc-component-disable-pin \
ksym-longterm-snd-soc-component-disable-pin-unlocked \
ksym-longterm-snd-soc-component-enable-pin \
ksym-longterm-snd-soc-component-enable-pin-unlocked \
ksym-longterm-snd-soc-component-exit-regmap \
ksym-longterm-snd-soc-component-force-enable-pin \
ksym-longterm-snd-soc-component-force-enable-pin-unlocked \
ksym-longterm-snd-soc-component-get-jack-type \
ksym-longterm-snd-soc-component-get-kcontrol \
ksym-longterm-snd-soc-component-get-pin-status \
ksym-longterm-snd-soc-component-init-regmap \
ksym-longterm-snd-soc-component-initialize \
ksym-longterm-snd-soc-component-nc-pin \
ksym-longterm-snd-soc-component-nc-pin-unlocked \
ksym-longterm-snd-soc-component-notify-control \
ksym-longterm-snd-soc-component-read \
ksym-longterm-snd-soc-component-read-field \
ksym-longterm-snd-soc-component-set-jack \
ksym-longterm-snd-soc-component-set-pll \
ksym-longterm-snd-soc-component-set-sysclk \
ksym-longterm-snd-soc-component-test-bits \
ksym-longterm-snd-soc-component-update-bits \
ksym-longterm-snd-soc-component-update-bits-async \
ksym-longterm-snd-soc-component-write \
ksym-longterm-snd-soc-component-write-field \
ksym-longterm-snd-soc-copy-dai-args \
ksym-longterm-snd-soc-dai-action \
ksym-longterm-snd-soc-dai-active \
ksym-longterm-snd-soc-dai-compr-ack \
ksym-longterm-snd-soc-dai-compr-get-metadata \
ksym-longterm-snd-soc-dai-compr-get-params \
ksym-longterm-snd-soc-dai-compr-pointer \
ksym-longterm-snd-soc-dai-compr-set-metadata \
ksym-longterm-snd-soc-dai-compr-set-params \
ksym-longterm-snd-soc-dai-compr-shutdown \
ksym-longterm-snd-soc-dai-compr-startup \
ksym-longterm-snd-soc-dai-compr-trigger \
ksym-longterm-snd-soc-dai-digital-mute \
ksym-longterm-snd-soc-dai-get-channel-map \
ksym-longterm-snd-soc-dai-is-dummy \
ksym-longterm-snd-soc-dai-name-get \
ksym-longterm-snd-soc-dai-prepare \
ksym-longterm-snd-soc-dai-set-bclk-ratio \
ksym-longterm-snd-soc-dai-set-channel-map \
ksym-longterm-snd-soc-dai-set-clkdiv \
ksym-longterm-snd-soc-dai-set-fmt \
ksym-longterm-snd-soc-dai-set-pll \
ksym-longterm-snd-soc-dai-set-sysclk \
ksym-longterm-snd-soc-dai-set-tdm-slot \
ksym-longterm-snd-soc-dai-set-tristate \
ksym-longterm-snd-soc-daifmt-clock-provider-flipped \
ksym-longterm-snd-soc-daifmt-clock-provider-from-bitmap \
ksym-longterm-snd-soc-daifmt-parse-clock-provider-raw \
ksym-longterm-snd-soc-daifmt-parse-format \
ksym-longterm-snd-soc-dapm-add-routes \
ksym-longterm-snd-soc-dapm-clock-event \
ksym-longterm-snd-soc-dapm-dai-free-widgets \
ksym-longterm-snd-soc-dapm-dai-get-connected-widgets \
ksym-longterm-snd-soc-dapm-del-routes \
ksym-longterm-snd-soc-dapm-disable-pin \
ksym-longterm-snd-soc-dapm-disable-pin-unlocked \
ksym-longterm-snd-soc-dapm-enable-pin \
ksym-longterm-snd-soc-dapm-enable-pin-unlocked \
ksym-longterm-snd-soc-dapm-force-bias-level \
ksym-longterm-snd-soc-dapm-force-enable-pin \
ksym-longterm-snd-soc-dapm-force-enable-pin-unlocked \
ksym-longterm-snd-soc-dapm-free-widget \
ksym-longterm-snd-soc-dapm-get-bias-level \
ksym-longterm-snd-soc-dapm-get-component-pin-switch \
ksym-longterm-snd-soc-dapm-get-enum-double \
ksym-longterm-snd-soc-dapm-get-idle-bias \
ksym-longterm-snd-soc-dapm-get-pin-status \
ksym-longterm-snd-soc-dapm-get-pin-switch \
ksym-longterm-snd-soc-dapm-get-volsw \
ksym-longterm-snd-soc-dapm-ignore-suspend \
ksym-longterm-snd-soc-dapm-info-pin-switch \
ksym-longterm-snd-soc-dapm-init-bias-level \
ksym-longterm-snd-soc-dapm-kcontrol-get-value \
ksym-longterm-snd-soc-dapm-kcontrol-to-component \
ksym-longterm-snd-soc-dapm-kcontrol-to-dapm \
ksym-longterm-snd-soc-dapm-kcontrol-to-widget \
ksym-longterm-snd-soc-dapm-mixer-update-power \
ksym-longterm-snd-soc-dapm-mux-update-power \
ksym-longterm-snd-soc-dapm-new-control \
ksym-longterm-snd-soc-dapm-new-controls \
ksym-longterm-snd-soc-dapm-new-dai-widgets \
ksym-longterm-snd-soc-dapm-new-widgets \
ksym-longterm-snd-soc-dapm-pinctrl-event \
ksym-longterm-snd-soc-dapm-put-component-pin-switch \
ksym-longterm-snd-soc-dapm-put-enum-double \
ksym-longterm-snd-soc-dapm-put-pin-switch \
ksym-longterm-snd-soc-dapm-put-volsw \
ksym-longterm-snd-soc-dapm-regulator-event \
ksym-longterm-snd-soc-dapm-set-idle-bias \
ksym-longterm-snd-soc-dapm-stream-stop \
ksym-longterm-snd-soc-dapm-sync \
ksym-longterm-snd-soc-dapm-sync-unlocked \
ksym-longterm-snd-soc-dapm-to-card \
ksym-longterm-snd-soc-dapm-to-component \
ksym-longterm-snd-soc-dapm-to-dev \
ksym-longterm-snd-soc-dapm-widget-name-cmp \
ksym-longterm-snd-soc-debugfs-root \
ksym-longterm-snd-soc-dlc-is-dummy \
ksym-longterm-snd-soc-dlc-use-cpu-as-platform \
ksym-longterm-snd-soc-dpcm-get-substream \
ksym-longterm-snd-soc-dpcm-runtime-update \
ksym-longterm-snd-soc-dummy-dlc \
ksym-longterm-snd-soc-find-dai \
ksym-longterm-snd-soc-find-dai-with-mutex \
ksym-longterm-snd-soc-free-ac97-component \
ksym-longterm-snd-soc-get-dai-id \
ksym-longterm-snd-soc-get-dai-name \
ksym-longterm-snd-soc-get-dai-via-args \
ksym-longterm-snd-soc-get-dlc \
ksym-longterm-snd-soc-get-enum-double \
ksym-longterm-snd-soc-get-pcm-runtime \
ksym-longterm-snd-soc-get-stream-cpu \
ksym-longterm-snd-soc-get-strobe \
ksym-longterm-snd-soc-get-volsw \
ksym-longterm-snd-soc-get-volsw-sx \
ksym-longterm-snd-soc-get-xr-sx \
ksym-longterm-snd-soc-hda-codec-dai-ops \
ksym-longterm-snd-soc-info-enum-double \
ksym-longterm-snd-soc-info-volsw \
ksym-longterm-snd-soc-info-volsw-sx \
ksym-longterm-snd-soc-info-xr-sx \
ksym-longterm-snd-soc-jack-add-gpiods \
ksym-longterm-snd-soc-jack-add-gpios \
ksym-longterm-snd-soc-jack-add-pins \
ksym-longterm-snd-soc-jack-add-zones \
ksym-longterm-snd-soc-jack-free-gpios \
ksym-longterm-snd-soc-jack-get-type \
ksym-longterm-snd-soc-jack-notifier-register \
ksym-longterm-snd-soc-jack-notifier-unregister \
ksym-longterm-snd-soc-jack-report \
ksym-longterm-snd-soc-limit-volume \
ksym-longterm-snd-soc-link-compr-set-params \
ksym-longterm-snd-soc-link-compr-shutdown \
ksym-longterm-snd-soc-link-compr-startup \
ksym-longterm-snd-soc-lookup-component \
ksym-longterm-snd-soc-lookup-component-nolocked \
ksym-longterm-snd-soc-new-ac97-component \
ksym-longterm-snd-soc-new-compress \
ksym-longterm-snd-soc-of-get-dai-link-codecs \
ksym-longterm-snd-soc-of-get-dai-link-cpus \
ksym-longterm-snd-soc-of-get-dai-name \
ksym-longterm-snd-soc-of-get-dlc \
ksym-longterm-snd-soc-of-get-slot-mask \
ksym-longterm-snd-soc-of-parse-audio-routing \
ksym-longterm-snd-soc-of-parse-audio-simple-widgets \
ksym-longterm-snd-soc-of-parse-aux-devs \
ksym-longterm-snd-soc-of-parse-card-name \
ksym-longterm-snd-soc-of-parse-node-prefix \
ksym-longterm-snd-soc-of-parse-pin-switches \
ksym-longterm-snd-soc-of-parse-tdm-slot \
ksym-longterm-snd-soc-of-put-dai-link-codecs \
ksym-longterm-snd-soc-of-put-dai-link-cpus \
ksym-longterm-snd-soc-params-to-bclk \
ksym-longterm-snd-soc-params-to-frame-size \
ksym-longterm-snd-soc-pm-ops \
ksym-longterm-snd-soc-poweroff \
ksym-longterm-snd-soc-put-enum-double \
ksym-longterm-snd-soc-put-strobe \
ksym-longterm-snd-soc-put-volsw \
ksym-longterm-snd-soc-put-volsw-sx \
ksym-longterm-snd-soc-put-xr-sx \
ksym-longterm-snd-soc-register-card \
ksym-longterm-snd-soc-register-component \
ksym-longterm-snd-soc-register-dai \
ksym-longterm-snd-soc-remove-pcm-runtime \
ksym-longterm-snd-soc-resume \
ksym-longterm-snd-soc-ret \
ksym-longterm-snd-soc-rtdcom-lookup \
ksym-longterm-snd-soc-runtime-action \
ksym-longterm-snd-soc-runtime-calc-hw \
ksym-longterm-snd-soc-runtime-set-dai-fmt \
ksym-longterm-snd-soc-set-ac97-ops \
ksym-longterm-snd-soc-set-ac97-ops-of-reset \
ksym-longterm-snd-soc-suspend \
ksym-longterm-snd-soc-tdm-params-to-bclk \
ksym-longterm-snd-soc-tplg-component-load \
ksym-longterm-snd-soc-tplg-component-remove \
ksym-longterm-snd-soc-tplg-widget-bind-event \
ksym-longterm-snd-soc-unregister-card \
ksym-longterm-snd-soc-unregister-component-by-driver \
ksym-longterm-snd-soc-unregister-dai \
ksym-longterm-snd-soc-usb-add-port \
ksym-longterm-snd-soc-usb-allocate-port \
ksym-longterm-snd-soc-usb-connect \
ksym-longterm-snd-soc-usb-disconnect \
ksym-longterm-snd-soc-usb-find-priv-data \
ksym-longterm-snd-soc-usb-find-supported-format \
ksym-longterm-snd-soc-usb-free-port \
ksym-longterm-snd-soc-usb-remove-port \
ksym-longterm-snd-soc-usb-setup-offload-jack \
ksym-longterm-snd-soc-usb-update-offload-route \
ksym-longterm-snd-sof-complete \
ksym-longterm-snd-sof-create-page-table \
ksym-longterm-snd-sof-dbg-init \
ksym-longterm-snd-sof-dbg-memory-info-init \
ksym-longterm-snd-sof-debugfs-add-region-item-iomem \
ksym-longterm-snd-sof-debugfs-buf-item \
ksym-longterm-snd-sof-device-probe \
ksym-longterm-snd-sof-device-probe-completed \
ksym-longterm-snd-sof-device-remove \
ksym-longterm-snd-sof-device-shutdown \
ksym-longterm-snd-sof-dsp-dbg-dump \
ksym-longterm-snd-sof-dsp-only-d0i3-compatible-stream-active \
ksym-longterm-snd-sof-dsp-panic \
ksym-longterm-snd-sof-dsp-update-bits \
ksym-longterm-snd-sof-dsp-update-bits-forced \
ksym-longterm-snd-sof-dsp-update-bits-unlocked \
ksym-longterm-snd-sof-dsp-update-bits64 \
ksym-longterm-snd-sof-dsp-update-bits64-unlocked \
ksym-longterm-snd-sof-free-debug \
ksym-longterm-snd-sof-fw-unload \
ksym-longterm-snd-sof-handle-fw-exception \
ksym-longterm-snd-sof-ipc-free \
ksym-longterm-snd-sof-ipc-get-reply \
ksym-longterm-snd-sof-ipc-init \
ksym-longterm-snd-sof-ipc-reply \
ksym-longterm-snd-sof-load-firmware-memcpy \
ksym-longterm-snd-sof-load-firmware-raw \
ksym-longterm-snd-sof-load-topology \
ksym-longterm-snd-sof-pci-update-bits \
ksym-longterm-snd-sof-pcm-period-elapsed \
ksym-longterm-snd-sof-prepare \
ksym-longterm-snd-sof-resume \
ksym-longterm-snd-sof-run-firmware \
ksym-longterm-snd-sof-runtime-idle \
ksym-longterm-snd-sof-runtime-resume \
ksym-longterm-snd-sof-runtime-suspend \
ksym-longterm-snd-sof-suspend \
ksym-longterm-snd-tea575x-enum-freq-bands \
ksym-longterm-snd-tea575x-exit \
ksym-longterm-snd-tea575x-g-tuner \
ksym-longterm-snd-tea575x-hw-init \
ksym-longterm-snd-tea575x-init \
ksym-longterm-snd-tea575x-s-hw-freq-seek \
ksym-longterm-snd-tea575x-set-freq \
ksym-longterm-snd-timer-close \
ksym-longterm-snd-timer-continue \
ksym-longterm-snd-timer-global-free \
ksym-longterm-snd-timer-global-new \
ksym-longterm-snd-timer-global-register \
ksym-longterm-snd-timer-instance-free \
ksym-longterm-snd-timer-instance-new \
ksym-longterm-snd-timer-interrupt \
ksym-longterm-snd-timer-new \
ksym-longterm-snd-timer-notify \
ksym-longterm-snd-timer-open \
ksym-longterm-snd-timer-pause \
ksym-longterm-snd-timer-resolution \
ksym-longterm-snd-timer-start \
ksym-longterm-snd-timer-stop \
ksym-longterm-snd-ump-attach-legacy-rawmidi \
ksym-longterm-snd-ump-block-new \
ksym-longterm-snd-ump-convert-from-ump \
ksym-longterm-snd-ump-convert-to-ump \
ksym-longterm-snd-ump-endpoint-new \
ksym-longterm-snd-ump-parse-endpoint \
ksym-longterm-snd-ump-receive \
ksym-longterm-snd-ump-receive-ump-val \
ksym-longterm-snd-ump-switch-protocol \
ksym-longterm-snd-ump-transmit \
ksym-longterm-snd-ump-update-group-attrs \
ksym-longterm-snd-unregister-device \
ksym-longterm-snd-unregister-oss-device \
ksym-longterm-snd-usb-autoresume \
ksym-longterm-snd-usb-autosuspend \
ksym-longterm-snd-usb-endpoint-prepare \
ksym-longterm-snd-usb-find-csint-desc \
ksym-longterm-snd-usb-find-format \
ksym-longterm-snd-usb-find-substream-format \
ksym-longterm-snd-usb-find-suppported-substream \
ksym-longterm-snd-usb-hw-free \
ksym-longterm-snd-usb-hw-params \
ksym-longterm-snd-usb-lock-shutdown \
ksym-longterm-snd-usb-rediscover-devices \
ksym-longterm-snd-usb-register-platform-ops \
ksym-longterm-snd-usb-unlock-shutdown \
ksym-longterm-snd-usb-unregister-platform-ops \
ksym-longterm-snd-usbmidi-disconnect \
ksym-longterm-snd-usbmidi-input-start \
ksym-longterm-snd-usbmidi-input-stop \
ksym-longterm-snd-usbmidi-resume \
ksym-longterm-snd-usbmidi-suspend \
ksym-longterm-snd-use-lock-sync-helper \
ksym-longterm-snd-virmidi-new \
ksym-longterm-snd-vx-check-reg-bit \
ksym-longterm-snd-vx-create \
ksym-longterm-snd-vx-dsp-boot \
ksym-longterm-snd-vx-dsp-load \
ksym-longterm-snd-vx-free-firmware \
ksym-longterm-snd-vx-irq-handler \
ksym-longterm-snd-vx-load-boot-image \
ksym-longterm-snd-vx-resume \
ksym-longterm-snd-vx-setup-firmware \
ksym-longterm-snd-vx-suspend \
ksym-longterm-snd-vx-threaded-irq-handler \
ksym-longterm-snmp-fold-field \
ksym-longterm-snprintf \
ksym-longterm-soc-ac97-ops \
ksym-longterm-soc-codec-dev-max98373 \
ksym-longterm-soc-codec-dev-max98373-sdw \
ksym-longterm-soc-device-match \
ksym-longterm-soc-device-register \
ksym-longterm-soc-device-unregister \
ksym-longterm-soc-hda-ext-bus-ops \
ksym-longterm-sock-alloc \
ksym-longterm-sock-alloc-file \
ksym-longterm-sock-alloc-send-pskb \
ksym-longterm-sock-bind-add \
ksym-longterm-sock-bindtoindex \
ksym-longterm-sock-cmsg-send \
ksym-longterm-sock-common-getsockopt \
ksym-longterm-sock-common-recvmsg \
ksym-longterm-sock-common-setsockopt \
ksym-longterm-sock-copy-user-timeval \
ksym-longterm-sock-create \
ksym-longterm-sock-create-kern \
ksym-longterm-sock-create-lite \
ksym-longterm-sock-dequeue-err-skb \
ksym-longterm-sock-diag-check-cookie \
ksym-longterm-sock-diag-destroy \
ksym-longterm-sock-diag-put-filterinfo \
ksym-longterm-sock-diag-put-meminfo \
ksym-longterm-sock-diag-register \
ksym-longterm-sock-diag-register-inet-compat \
ksym-longterm-sock-diag-save-cookie \
ksym-longterm-sock-diag-unregister \
ksym-longterm-sock-diag-unregister-inet-compat \
ksym-longterm-sock-edemux \
ksym-longterm-sock-efree \
ksym-longterm-sock-from-file \
ksym-longterm-sock-gen-put \
ksym-longterm-sock-get-timeout \
ksym-longterm-sock-gettstamp \
ksym-longterm-sock-init-data \
ksym-longterm-sock-init-data-uid \
ksym-longterm-sock-inuse-get \
ksym-longterm-sock-ioctl-inout \
ksym-longterm-sock-kfree-s \
ksym-longterm-sock-kmalloc \
ksym-longterm-sock-kmemdup \
ksym-longterm-sock-kzfree-s \
ksym-longterm-sock-load-diag-module \
ksym-longterm-sock-map-close \
ksym-longterm-sock-map-destroy \
ksym-longterm-sock-map-unhash \
ksym-longterm-sock-no-accept \
ksym-longterm-sock-no-bind \
ksym-longterm-sock-no-connect \
ksym-longterm-sock-no-getname \
ksym-longterm-sock-no-ioctl \
ksym-longterm-sock-no-linger \
ksym-longterm-sock-no-listen \
ksym-longterm-sock-no-mmap \
ksym-longterm-sock-no-recvmsg \
ksym-longterm-sock-no-sendmsg \
ksym-longterm-sock-no-sendmsg-locked \
ksym-longterm-sock-no-shutdown \
ksym-longterm-sock-no-socketpair \
ksym-longterm-sock-pfree \
ksym-longterm-sock-prot-inuse-get \
ksym-longterm-sock-queue-err-skb \
ksym-longterm-sock-queue-rcv-skb-reason \
ksym-longterm-sock-recv-errqueue \
ksym-longterm-sock-recvmsg \
ksym-longterm-sock-register \
ksym-longterm-sock-release \
ksym-longterm-sock-rfree \
ksym-longterm-sock-sendmsg \
ksym-longterm-sock-set-keepalive \
ksym-longterm-sock-set-mark \
ksym-longterm-sock-set-priority \
ksym-longterm-sock-set-rcvbuf \
ksym-longterm-sock-set-reuseaddr \
ksym-longterm-sock-set-reuseport \
ksym-longterm-sock-set-sndtimeo \
ksym-longterm-sock-setsockopt \
ksym-longterm-sock-unregister \
ksym-longterm-sock-wake-async \
ksym-longterm-sock-wfree \
ksym-longterm-sock-wmalloc \
ksym-longterm-sockaddr-to-str \
ksym-longterm-sockfd-lookup \
ksym-longterm-sockopt-capable \
ksym-longterm-sockopt-lock-sock \
ksym-longterm-sockopt-ns-capable \
ksym-longterm-sockopt-release-sock \
ksym-longterm-sof-block-read \
ksym-longterm-sof-block-write \
ksym-longterm-sof-compressed-ops \
ksym-longterm-sof-create-ipc-file-profile \
ksym-longterm-sof-dai-get-bclk \
ksym-longterm-sof-dai-get-mclk \
ksym-longterm-sof-dai-get-tdm-slots \
ksym-longterm-sof-debug-check-flag \
ksym-longterm-sof-imx-ops \
ksym-longterm-sof-io-read \
ksym-longterm-sof-io-read64 \
ksym-longterm-sof-io-write \
ksym-longterm-sof-io-write64 \
ksym-longterm-sof-ipc-msg-data \
ksym-longterm-sof-ipc-set-get-data \
ksym-longterm-sof-ipc-tx-message \
ksym-longterm-sof-ipc-tx-message-no-pm \
ksym-longterm-sof-ipc3-do-rx-work \
ksym-longterm-sof-machine-register \
ksym-longterm-sof-machine-unregister \
ksym-longterm-sof-mailbox-read \
ksym-longterm-sof-mailbox-write \
ksym-longterm-sof-of-pm \
ksym-longterm-sof-of-probe \
ksym-longterm-sof-of-remove \
ksym-longterm-sof-of-shutdown \
ksym-longterm-sof-pcm-dai-link-fixup \
ksym-longterm-sof-print-oops-and-stack \
ksym-longterm-sof-set-fw-state \
ksym-longterm-sof-set-stream-data-offset \
ksym-longterm-sof-stream-pcm-close \
ksym-longterm-sof-stream-pcm-open \
ksym-longterm-sof-widget-free \
ksym-longterm-sof-widget-setup \
ksym-longterm-sof-xtensa-arch-ops \
ksym-longterm-softnet-data \
ksym-longterm-software-node-find-by-name \
ksym-longterm-software-node-fwnode \
ksym-longterm-software-node-register \
ksym-longterm-software-node-register-node-group \
ksym-longterm-software-node-unregister \
ksym-longterm-software-node-unregister-node-group \
ksym-longterm-sonet-copy-stats \
ksym-longterm-sonet-subtract-stats \
ksym-longterm-sophgo-pinctrl-probe \
ksym-longterm-sort \
ksym-longterm-sort-nonatomic \
ksym-longterm-sort-r \
ksym-longterm-sort-r-nonatomic \
ksym-longterm-sound-class \
ksym-longterm-sound-debugfs-root \
ksym-longterm-sp8870-attach \
ksym-longterm-sp887x-attach \
ksym-longterm-sparse-keymap-entry-from-keycode \
ksym-longterm-sparse-keymap-entry-from-scancode \
ksym-longterm-sparse-keymap-report-entry \
ksym-longterm-sparse-keymap-report-event \
ksym-longterm-sparse-keymap-setup \
ksym-longterm-spc-emulate-evpd-83 \
ksym-longterm-spc-emulate-inquiry-std \
ksym-longterm-spc-emulate-report-luns \
ksym-longterm-spc-parse-cdb \
ksym-longterm-spi-add-device \
ksym-longterm-spi-alloc-device \
ksym-longterm-spi-async \
ksym-longterm-spi-attach-transport \
ksym-longterm-spi-bitbang-cleanup \
ksym-longterm-spi-bitbang-init \
ksym-longterm-spi-bitbang-setup \
ksym-longterm-spi-bitbang-setup-transfer \
ksym-longterm-spi-bitbang-start \
ksym-longterm-spi-bitbang-stop \
ksym-longterm-spi-bus-lock \
ksym-longterm-spi-bus-type \
ksym-longterm-spi-bus-unlock \
ksym-longterm-spi-controller-dma-map-mem-op-data \
ksym-longterm-spi-controller-dma-unmap-mem-op-data \
ksym-longterm-spi-controller-resume \
ksym-longterm-spi-controller-suspend \
ksym-longterm-spi-delay-exec \
ksym-longterm-spi-delay-to-ns \
ksym-longterm-spi-display-xfer-agreement \
ksym-longterm-spi-dv-device \
ksym-longterm-spi-finalize-current-message \
ksym-longterm-spi-finalize-current-transfer \
ksym-longterm-spi-get-device-id \
ksym-longterm-spi-get-device-match-data \
ksym-longterm-spi-get-next-queued-message \
ksym-longterm-spi-mem-adjust-op-freq \
ksym-longterm-spi-mem-adjust-op-size \
ksym-longterm-spi-mem-calc-op-duration \
ksym-longterm-spi-mem-default-supports-op \
ksym-longterm-spi-mem-dirmap-create \
ksym-longterm-spi-mem-dirmap-destroy \
ksym-longterm-spi-mem-dirmap-read \
ksym-longterm-spi-mem-dirmap-write \
ksym-longterm-spi-mem-driver-register-with-owner \
ksym-longterm-spi-mem-driver-unregister \
ksym-longterm-spi-mem-exec-op \
ksym-longterm-spi-mem-get-name \
ksym-longterm-spi-mem-poll-status \
ksym-longterm-spi-mem-supports-op \
ksym-longterm-spi-new-ancillary-device \
ksym-longterm-spi-new-device \
ksym-longterm-spi-nor-scan \
ksym-longterm-spi-offload-trigger-disable \
ksym-longterm-spi-offload-trigger-enable \
ksym-longterm-spi-offload-trigger-get-priv \
ksym-longterm-spi-offload-trigger-validate \
ksym-longterm-spi-optimize-message \
ksym-longterm-spi-populate-ppr-msg \
ksym-longterm-spi-populate-sync-msg \
ksym-longterm-spi-populate-tag-msg \
ksym-longterm-spi-populate-width-msg \
ksym-longterm-spi-print-msg \
ksym-longterm-spi-register-controller \
ksym-longterm-spi-release-transport \
ksym-longterm-spi-schedule-dv-device \
ksym-longterm-spi-setup \
ksym-longterm-spi-split-transfers-maxsize \
ksym-longterm-spi-split-transfers-maxwords \
ksym-longterm-spi-sync \
ksym-longterm-spi-sync-locked \
ksym-longterm-spi-take-timestamp-post \
ksym-longterm-spi-take-timestamp-pre \
ksym-longterm-spi-target-abort \
ksym-longterm-spi-test-execute-msg \
ksym-longterm-spi-test-run-test \
ksym-longterm-spi-test-run-tests \
ksym-longterm-spi-transfer-cs-change-delay-exec \
ksym-longterm-spi-unoptimize-message \
ksym-longterm-spi-unregister-controller \
ksym-longterm-spi-unregister-device \
ksym-longterm-spi-write-then-read \
ksym-longterm-splice-direct-to-actor \
ksym-longterm-splice-file-range \
ksym-longterm-splice-to-pipe \
ksym-longterm-split-key-done \
ksym-longterm-split-page \
ksym-longterm-spmi-command-reset \
ksym-longterm-spmi-command-shutdown \
ksym-longterm-spmi-command-sleep \
ksym-longterm-spmi-command-wakeup \
ksym-longterm-spmi-controller-add \
ksym-longterm-spmi-controller-alloc \
ksym-longterm-spmi-controller-remove \
ksym-longterm-spmi-device-add \
ksym-longterm-spmi-device-alloc \
ksym-longterm-spmi-device-remove \
ksym-longterm-spmi-ext-register-read \
ksym-longterm-spmi-ext-register-readl \
ksym-longterm-spmi-ext-register-write \
ksym-longterm-spmi-ext-register-writel \
ksym-longterm-spmi-find-device-by-of-node \
ksym-longterm-spmi-register-read \
ksym-longterm-spmi-register-write \
ksym-longterm-spmi-register-zero-write \
ksym-longterm-sprd-clk-probe \
ksym-longterm-sprd-clk-regmap-init \
ksym-longterm-sprd-comp-ops \
ksym-longterm-sprd-div-helper-recalc-rate \
ksym-longterm-sprd-div-helper-set-rate \
ksym-longterm-sprd-div-ops \
ksym-longterm-sprd-gate-ops \
ksym-longterm-sprd-mcdt-chan-dma-disable \
ksym-longterm-sprd-mcdt-chan-dma-enable \
ksym-longterm-sprd-mcdt-chan-int-disable \
ksym-longterm-sprd-mcdt-chan-int-enable \
ksym-longterm-sprd-mcdt-chan-read \
ksym-longterm-sprd-mcdt-chan-write \
ksym-longterm-sprd-mcdt-free-chan \
ksym-longterm-sprd-mcdt-request-chan \
ksym-longterm-sprd-mux-helper-get-parent \
ksym-longterm-sprd-mux-helper-set-parent \
ksym-longterm-sprd-mux-ops \
ksym-longterm-sprd-pinctrl-core-probe \
ksym-longterm-sprd-pinctrl-remove \
ksym-longterm-sprd-pinctrl-shutdown \
ksym-longterm-sprd-pll-ops \
ksym-longterm-sprd-pll-sc-gate-ops \
ksym-longterm-sprd-pmic-detect-charger-type \
ksym-longterm-sprd-sc-gate-ops \
ksym-longterm-sprint-oid \
ksym-longterm-sprint-symbol \
ksym-longterm-sprint-symbol-build-id \
ksym-longterm-sprint-symbol-no-offset \
ksym-longterm-sprintf \
ksym-longterm-sps30-probe \
ksym-longterm-srcu-barrier \
ksym-longterm-srcu-batches-completed \
ksym-longterm-srcu-init-notifier-head \
ksym-longterm-srcu-notifier-call-chain \
ksym-longterm-srcu-notifier-chain-register \
ksym-longterm-srcu-notifier-chain-unregister \
ksym-longterm-srcu-torture-stats-print \
ksym-longterm-srcutorture-get-gp-data \
ksym-longterm-srp-attach-transport \
ksym-longterm-srp-parse-tmo \
ksym-longterm-srp-reconnect-rport \
ksym-longterm-srp-release-transport \
ksym-longterm-srp-remove-host \
ksym-longterm-srp-rport-add \
ksym-longterm-srp-rport-del \
ksym-longterm-srp-rport-get \
ksym-longterm-srp-rport-put \
ksym-longterm-srp-start-tl-fail-timers \
ksym-longterm-srp-stop-rport-timers \
ksym-longterm-srp-timed-out \
ksym-longterm-srp-tmo-valid \
ksym-longterm-ssam-client-bind \
ksym-longterm-ssam-client-link \
ksym-longterm-ssam-controller-device \
ksym-longterm-ssam-controller-event-disable \
ksym-longterm-ssam-controller-event-enable \
ksym-longterm-ssam-controller-get \
ksym-longterm-ssam-controller-put \
ksym-longterm-ssam-controller-statelock \
ksym-longterm-ssam-controller-stateunlock \
ksym-longterm-ssam-device-add \
ksym-longterm-ssam-device-alloc \
ksym-longterm-ssam-device-driver-unregister \
ksym-longterm-ssam-device-get-match \
ksym-longterm-ssam-device-get-match-data \
ksym-longterm-ssam-device-id-match \
ksym-longterm-ssam-device-remove \
ksym-longterm-ssam-device-type \
ksym-longterm-ssam-get-controller \
ksym-longterm-ssam-notifier-register \
ksym-longterm-ssam-remove-clients \
ksym-longterm-ssam-request-do-sync \
ksym-longterm-ssam-request-do-sync-with-buffer \
ksym-longterm-ssam-request-sync-alloc \
ksym-longterm-ssam-request-sync-free \
ksym-longterm-ssam-request-sync-init \
ksym-longterm-ssam-request-sync-submit \
ksym-longterm-ssam-request-write-data \
ksym-longterm-ssb-admatch-base \
ksym-longterm-ssb-admatch-size \
ksym-longterm-ssb-bus-may-powerdown \
ksym-longterm-ssb-bus-powerup \
ksym-longterm-ssb-bus-resume \
ksym-longterm-ssb-bus-sdiobus-register \
ksym-longterm-ssb-bus-suspend \
ksym-longterm-ssb-bus-unregister \
ksym-longterm-ssb-chipco-gpio-control \
ksym-longterm-ssb-clockspeed \
ksym-longterm-ssb-commit-settings \
ksym-longterm-ssb-device-disable \
ksym-longterm-ssb-device-enable \
ksym-longterm-ssb-device-is-enabled \
ksym-longterm-ssb-dma-translation \
ksym-longterm-ssb-driver-unregister \
ksym-longterm-ssb-pcicore-dev-irqvecs-enable \
ksym-longterm-ssb-pcihost-register \
ksym-longterm-ssb-pmu-set-ldo-paref \
ksym-longterm-ssb-pmu-set-ldo-voltage \
ksym-longterm-ssb-pmu-spuravoid-pllupdate \
ksym-longterm-ssb-set-devtypedata \
ksym-longterm-sscanf \
ksym-longterm-ssd130x-probe \
ksym-longterm-ssd130x-remove \
ksym-longterm-ssd130x-shutdown \
ksym-longterm-ssd130x-variants \
ksym-longterm-ssh-packet-get \
ksym-longterm-ssh-packet-put \
ksym-longterm-ssm2602-probe \
ksym-longterm-ssm2602-regmap-config \
ksym-longterm-st-accel-common-probe \
ksym-longterm-st-accel-get-settings \
ksym-longterm-st-lsm6dsx-pm-ops \
ksym-longterm-st-lsm6dsx-probe \
ksym-longterm-st-lsm9ds0-probe \
ksym-longterm-st-magn-common-probe \
ksym-longterm-st-magn-get-settings \
ksym-longterm-st-nci-disable-se \
ksym-longterm-st-nci-discover-se \
ksym-longterm-st-nci-enable-se \
ksym-longterm-st-nci-hci-cmd-received \
ksym-longterm-st-nci-hci-event-received \
ksym-longterm-st-nci-hci-load-session \
ksym-longterm-st-nci-probe \
ksym-longterm-st-nci-remove \
ksym-longterm-st-nci-se-deinit \
ksym-longterm-st-nci-se-init \
ksym-longterm-st-nci-se-io \
ksym-longterm-st-nci-vendor-cmds-init \
ksym-longterm-st-press-common-probe \
ksym-longterm-st-press-get-settings \
ksym-longterm-st-sensors-allocate-trigger \
ksym-longterm-st-sensors-debugfs-reg-access \
ksym-longterm-st-sensors-dev-name-probe \
ksym-longterm-st-sensors-get-settings-index \
ksym-longterm-st-sensors-i2c-configure \
ksym-longterm-st-sensors-init-sensor \
ksym-longterm-st-sensors-power-enable \
ksym-longterm-st-sensors-read-info-raw \
ksym-longterm-st-sensors-set-axis-enable \
ksym-longterm-st-sensors-set-dataready-irq \
ksym-longterm-st-sensors-set-enable \
ksym-longterm-st-sensors-set-fullscale-by-gain \
ksym-longterm-st-sensors-set-odr \
ksym-longterm-st-sensors-spi-configure \
ksym-longterm-st-sensors-sysfs-sampling-frequency-avail \
ksym-longterm-st-sensors-sysfs-scale-avail \
ksym-longterm-st-sensors-trigger-handler \
ksym-longterm-st-sensors-validate-device \
ksym-longterm-st-sensors-verify-id \
ksym-longterm-st-thermal-pm-ops \
ksym-longterm-st-thermal-register \
ksym-longterm-st-thermal-unregister \
ksym-longterm-st-uvis25-pm-ops \
ksym-longterm-st-uvis25-probe \
ksym-longterm-st21nfca-apdu-reader-event-received \
ksym-longterm-st21nfca-connectivity-event-received \
ksym-longterm-st21nfca-dep-deinit \
ksym-longterm-st21nfca-dep-event-received \
ksym-longterm-st21nfca-dep-init \
ksym-longterm-st21nfca-hci-disable-se \
ksym-longterm-st21nfca-hci-discover-se \
ksym-longterm-st21nfca-hci-enable-se \
ksym-longterm-st21nfca-hci-loopback-event-received \
ksym-longterm-st21nfca-hci-probe \
ksym-longterm-st21nfca-hci-remove \
ksym-longterm-st21nfca-hci-se-io \
ksym-longterm-st21nfca-im-send-atr-req \
ksym-longterm-st21nfca-im-send-dep-req \
ksym-longterm-st21nfca-se-deinit \
ksym-longterm-st21nfca-se-init \
ksym-longterm-st21nfca-tm-send-dep-res \
ksym-longterm-st21nfca-vendor-cmds-init \
ksym-longterm-st33zp24-pm-resume \
ksym-longterm-st33zp24-pm-suspend \
ksym-longterm-st33zp24-probe \
ksym-longterm-st33zp24-remove \
ksym-longterm-st95hf-spi-recv-echo-res \
ksym-longterm-st95hf-spi-recv-response \
ksym-longterm-st95hf-spi-send \
ksym-longterm-stable-page-flags \
ksym-longterm-stack-depot-fetch \
ksym-longterm-stack-depot-get-extra-bits \
ksym-longterm-stack-depot-init \
ksym-longterm-stack-depot-print \
ksym-longterm-stack-depot-put \
ksym-longterm-stack-depot-save \
ksym-longterm-stack-depot-save-flags \
ksym-longterm-stack-depot-set-extra-bits \
ksym-longterm-stack-depot-snprint \
ksym-longterm-stack-trace-print \
ksym-longterm-stack-trace-save \
ksym-longterm-stack-trace-save-tsk \
ksym-longterm-stack-trace-snprint \
ksym-longterm-starget-for-each-device \
ksym-longterm-start-creating-path \
ksym-longterm-start-creating-user-path \
ksym-longterm-start-poll-synchronize-rcu \
ksym-longterm-start-poll-synchronize-rcu-expedited \
ksym-longterm-start-poll-synchronize-rcu-expedited-full \
ksym-longterm-start-poll-synchronize-rcu-full \
ksym-longterm-start-poll-synchronize-srcu \
ksym-longterm-start-removing-user-path-at \
ksym-longterm-start-tty \
ksym-longterm-static-dev-dax \
ksym-longterm-static-key-count \
ksym-longterm-static-key-disable \
ksym-longterm-static-key-disable-cpuslocked \
ksym-longterm-static-key-enable \
ksym-longterm-static-key-enable-cpuslocked \
ksym-longterm-static-key-fast-inc-not-disabled \
ksym-longterm-static-key-initialized \
ksym-longterm-static-key-slow-dec \
ksym-longterm-static-key-slow-inc \
ksym-longterm-stb0899-attach \
ksym-longterm-stb6000-attach \
ksym-longterm-stb6100-attach \
ksym-longterm-stm-data-write \
ksym-longterm-stm-register-device \
ksym-longterm-stm-register-protocol \
ksym-longterm-stm-source-register-device \
ksym-longterm-stm-source-unregister-device \
ksym-longterm-stm-source-write \
ksym-longterm-stm-unregister-device \
ksym-longterm-stm-unregister-protocol \
ksym-longterm-stm32-dfsdm-get-buff-cb \
ksym-longterm-stm32-dfsdm-release-buff-cb \
ksym-longterm-stm32-dfsdm-start-dfsdm \
ksym-longterm-stm32-dfsdm-stop-dfsdm \
ksym-longterm-stm32-firewall-controller-register \
ksym-longterm-stm32-firewall-controller-unregister \
ksym-longterm-stm32-firewall-get-firewall \
ksym-longterm-stm32-firewall-grant-access \
ksym-longterm-stm32-firewall-grant-access-by-id \
ksym-longterm-stm32-firewall-populate-bus \
ksym-longterm-stm32-firewall-release-access \
ksym-longterm-stm32-firewall-release-access-by-id \
ksym-longterm-stm32-pctl-probe \
ksym-longterm-stm32-pinctrl-resume \
ksym-longterm-stm32-pinctrl-suspend \
ksym-longterm-stm32-timers-dma-burst-read \
ksym-longterm-stmfx-function-disable \
ksym-longterm-stmfx-function-enable \
ksym-longterm-stmmac-dvr-probe \
ksym-longterm-stmmac-dvr-remove \
ksym-longterm-stmmac-get-mac-addr \
ksym-longterm-stmmac-get-platform-resources \
ksym-longterm-stmmac-pltfr-find-clk \
ksym-longterm-stmmac-pltfr-pm-ops \
ksym-longterm-stmmac-pltfr-probe \
ksym-longterm-stmmac-pltfr-remove \
ksym-longterm-stmmac-resume \
ksym-longterm-stmmac-set-clk-tx-rate \
ksym-longterm-stmmac-set-mac-addr \
ksym-longterm-stmmac-simple-pm-ops \
ksym-longterm-stmmac-suspend \
ksym-longterm-stmp-reset-block \
ksym-longterm-stop-core-cpuslocked \
ksym-longterm-stop-machine \
ksym-longterm-stop-tty \
ksym-longterm-store-cdrom-address \
ksym-longterm-stp-proto-register \
ksym-longterm-stp-proto-unregister \
ksym-longterm-stpcpy \
ksym-longterm-stratix10-svc-allocate-memory \
ksym-longterm-stratix10-svc-done \
ksym-longterm-stratix10-svc-free-channel \
ksym-longterm-stratix10-svc-free-memory \
ksym-longterm-stratix10-svc-request-channel-byname \
ksym-longterm-stratix10-svc-send \
ksym-longterm-strcasecmp \
ksym-longterm-strcat \
ksym-longterm-strchr \
ksym-longterm-strchrnul \
ksym-longterm-strcmp \
ksym-longterm-strcpy \
ksym-longterm-strcspn \
ksym-longterm-stream-open \
ksym-longterm-strim \
ksym-longterm-string-escape-mem \
ksym-longterm-string-get-size \
ksym-longterm-string-unescape \
ksym-longterm-strlcat \
ksym-longterm-strlen \
ksym-longterm-strncasecmp \
ksym-longterm-strncat \
ksym-longterm-strnchr \
ksym-longterm-strncmp \
ksym-longterm-strncpy \
ksym-longterm-strncpy-from-user \
ksym-longterm-strndup-user \
ksym-longterm-strnlen \
ksym-longterm-strnlen-user \
ksym-longterm-strnstr \
ksym-longterm-strp-check-rcv \
ksym-longterm-strp-data-ready \
ksym-longterm-strp-done \
ksym-longterm-strp-init \
ksym-longterm-strp-process \
ksym-longterm-strp-stop \
ksym-longterm-strp-unpause \
ksym-longterm-strpbrk \
ksym-longterm-strrchr \
ksym-longterm-strreplace \
ksym-longterm-strsep \
ksym-longterm-strspn \
ksym-longterm-strstr \
ksym-longterm-stutter-wait \
ksym-longterm-stv0288-attach \
ksym-longterm-stv0297-attach \
ksym-longterm-stv0299-attach \
ksym-longterm-stv0367cab-attach \
ksym-longterm-stv0367ddb-attach \
ksym-longterm-stv0367ter-attach \
ksym-longterm-stv0900-attach \
ksym-longterm-stv090x-attach \
ksym-longterm-stv0910-attach \
ksym-longterm-stv6110-attach \
ksym-longterm-stv6110x-attach \
ksym-longterm-stv6111-attach \
ksym-longterm-subdev-8255-cb-init \
ksym-longterm-subdev-8255-io-init \
ksym-longterm-subdev-8255-mm-init \
ksym-longterm-subdev-8255-regbase \
ksym-longterm-submit-bh \
ksym-longterm-submit-bio \
ksym-longterm-submit-bio-noacct \
ksym-longterm-submit-bio-wait \
ksym-longterm-subsys-interface-register \
ksym-longterm-subsys-interface-unregister \
ksym-longterm-subsys-system-register \
ksym-longterm-subsys-virtual-register \
ksym-longterm-sun4i-dclk-create \
ksym-longterm-sun4i-dclk-free \
ksym-longterm-sun4i-lvds-init \
ksym-longterm-sun4i-rgb-init \
ksym-longterm-sun4i-tcon-enable-vblank \
ksym-longterm-sun4i-tcon-mode-set \
ksym-longterm-sun4i-tcon-of-table \
ksym-longterm-sun4i-usb-phy-set-squelch-detect \
ksym-longterm-sun8i-adda-pr-regmap-init \
ksym-longterm-sun8i-tcon-top-de-config \
ksym-longterm-sun8i-tcon-top-of-table \
ksym-longterm-sun8i-tcon-top-set-hdmi-src \
ksym-longterm-sungem-phy-probe \
ksym-longterm-suni-init \
ksym-longterm-sunrpc-cache-lookup-rcu \
ksym-longterm-sunrpc-cache-pipe-upcall \
ksym-longterm-sunrpc-cache-pipe-upcall-timeout \
ksym-longterm-sunrpc-cache-register-pipefs \
ksym-longterm-sunrpc-cache-unhash \
ksym-longterm-sunrpc-cache-unregister-pipefs \
ksym-longterm-sunrpc-cache-update \
ksym-longterm-sunrpc-destroy-cache-detail \
ksym-longterm-sunrpc-get-pool-mode \
ksym-longterm-sunrpc-init-cache-detail \
ksym-longterm-sunrpc-net-id \
ksym-longterm-sunrpc-set-pool-mode \
ksym-longterm-sunxi-ccu-get-mmc-timing-mode \
ksym-longterm-sunxi-ccu-set-mmc-timing-mode \
ksym-longterm-sunxi-rsb-driver-register \
ksym-longterm-sunxi-sram-claim \
ksym-longterm-sunxi-sram-release \
ksym-longterm-super-setup-bdi \
ksym-longterm-super-setup-bdi-name \
ksym-longterm-surface-hid-device-add \
ksym-longterm-surface-hid-device-destroy \
ksym-longterm-surface-hid-pm-ops \
ksym-longterm-suspend-set-ops \
ksym-longterm-suspend-valid-only-mem \
ksym-longterm-svc-addsock \
ksym-longterm-svc-age-temp-xprts-now \
ksym-longterm-svc-auth-flavor \
ksym-longterm-svc-auth-register \
ksym-longterm-svc-auth-unregister \
ksym-longterm-svc-bind \
ksym-longterm-svc-create \
ksym-longterm-svc-create-pooled \
ksym-longterm-svc-destroy \
ksym-longterm-svc-encode-result-payload \
ksym-longterm-svc-exit-thread \
ksym-longterm-svc-fill-symlink-pathname \
ksym-longterm-svc-find-listener \
ksym-longterm-svc-find-xprt \
ksym-longterm-svc-generic-init-request \
ksym-longterm-svc-generic-rpcbind-set \
ksym-longterm-svc-max-payload \
ksym-longterm-svc-pool-stats-open \
ksym-longterm-svc-pool-wake-idle-thread \
ksym-longterm-svc-print-addr \
ksym-longterm-svc-proc-register \
ksym-longterm-svc-proc-unregister \
ksym-longterm-svc-recv \
ksym-longterm-svc-reg-xprt-class \
ksym-longterm-svc-reserve \
ksym-longterm-svc-rqst-replace-page \
ksym-longterm-svc-seq-show \
ksym-longterm-svc-set-client \
ksym-longterm-svc-set-num-threads \
ksym-longterm-svc-unreg-xprt-class \
ksym-longterm-svc-wake-up \
ksym-longterm-svc-xprt-close \
ksym-longterm-svc-xprt-copy-addrs \
ksym-longterm-svc-xprt-create \
ksym-longterm-svc-xprt-create-from-sa \
ksym-longterm-svc-xprt-deferred-close \
ksym-longterm-svc-xprt-destroy-all \
ksym-longterm-svc-xprt-enqueue \
ksym-longterm-svc-xprt-init \
ksym-longterm-svc-xprt-names \
ksym-longterm-svc-xprt-put \
ksym-longterm-svc-xprt-received \
ksym-longterm-svcauth-gss-flavor \
ksym-longterm-svcauth-gss-register-pseudoflavor \
ksym-longterm-svcauth-map-clnt-to-svc-cred-local \
ksym-longterm-svcauth-unix-purge \
ksym-longterm-svcauth-unix-set-client \
ksym-longterm-sw842-compress \
ksym-longterm-sw842-decompress \
ksym-longterm-swake-up-all \
ksym-longterm-swake-up-locked \
ksym-longterm-swake-up-one \
ksym-longterm-switchdev-bridge-port-offload \
ksym-longterm-switchdev-bridge-port-replay \
ksym-longterm-switchdev-bridge-port-unoffload \
ksym-longterm-switchdev-deferred-process \
ksym-longterm-switchdev-handle-fdb-event-to-device \
ksym-longterm-switchdev-handle-port-attr-set \
ksym-longterm-switchdev-handle-port-obj-add \
ksym-longterm-switchdev-handle-port-obj-add-foreign \
ksym-longterm-switchdev-handle-port-obj-del \
ksym-longterm-switchdev-handle-port-obj-del-foreign \
ksym-longterm-switchdev-port-attr-set \
ksym-longterm-switchdev-port-obj-act-is-deferred \
ksym-longterm-switchdev-port-obj-add \
ksym-longterm-switchdev-port-obj-del \
ksym-longterm-switchtec-class \
ksym-longterm-swnode-gpio-undefined \
ksym-longterm-swphy-read-reg \
ksym-longterm-swphy-validate-state \
ksym-longterm-sx-common-events \
ksym-longterm-sx-common-probe \
ksym-longterm-sx-common-read-event-config \
ksym-longterm-sx-common-read-proximity \
ksym-longterm-sx-common-write-event-config \
ksym-longterm-symbol-put-addr \
ksym-longterm-sync-blockdev \
ksym-longterm-sync-blockdev-nowait \
ksym-longterm-sync-blockdev-range \
ksym-longterm-sync-dirty-buffer \
ksym-longterm-sync-file-create \
ksym-longterm-sync-file-get-fence \
ksym-longterm-sync-filesystem \
ksym-longterm-sync-inode-metadata \
ksym-longterm-sync-inodes-sb \
ksym-longterm-sync-mapping-buffers \
ksym-longterm-sync-page-io \
ksym-longterm-synchronize-hardirq \
ksym-longterm-synchronize-irq \
ksym-longterm-synchronize-net \
ksym-longterm-synchronize-rcu \
ksym-longterm-synchronize-rcu-expedited \
ksym-longterm-synchronize-rcu-tasks \
ksym-longterm-synchronize-rcu-tasks-rude \
ksym-longterm-synchronize-rcu-tasks-trace \
ksym-longterm-synchronize-srcu \
ksym-longterm-synchronize-srcu-expedited \
ksym-longterm-synproxy-init-timestamp-cookie \
ksym-longterm-synproxy-net-id \
ksym-longterm-synproxy-parse-options \
ksym-longterm-synproxy-recv-client-ack \
ksym-longterm-synproxy-recv-client-ack-ipv6 \
ksym-longterm-synproxy-send-client-synack \
ksym-longterm-synproxy-send-client-synack-ipv6 \
ksym-longterm-synth-event-add-field \
ksym-longterm-synth-event-add-field-str \
ksym-longterm-synth-event-add-fields \
ksym-longterm-synth-event-add-next-val \
ksym-longterm-synth-event-add-val \
ksym-longterm-synth-event-cmd-init \
ksym-longterm-synth-event-create \
ksym-longterm-synth-event-delete \
ksym-longterm-synth-event-gen-cmd-array-start \
ksym-longterm-synth-event-trace \
ksym-longterm-synth-event-trace-array \
ksym-longterm-synth-event-trace-end \
ksym-longterm-synth-event-trace-start \
ksym-longterm-sys-copyarea \
ksym-longterm-sys-fillrect \
ksym-longterm-sys-imageblit \
ksym-longterm-sys-tz \
ksym-longterm-syscon-node-to-regmap \
ksym-longterm-syscon-regmap-lookup-by-compatible \
ksym-longterm-syscon-regmap-lookup-by-phandle \
ksym-longterm-syscon-regmap-lookup-by-phandle-args \
ksym-longterm-syscon-regmap-lookup-by-phandle-optional \
ksym-longterm-sysconfig-probe \
ksym-longterm-syscore-resume \
ksym-longterm-syscore-suspend \
ksym-longterm-sysctl-devconf-inherit-init-net \
ksym-longterm-sysctl-fb-tunnels-only-for-init-net \
ksym-longterm-sysctl-hung-task-timeout-secs \
ksym-longterm-sysctl-long-vals \
ksym-longterm-sysctl-nf-log-all-netns \
ksym-longterm-sysctl-rmem-max \
ksym-longterm-sysctl-vals \
ksym-longterm-sysctl-wmem-max \
ksym-longterm-sysfb-disable \
ksym-longterm-sysfb-handles-screen-info \
ksym-longterm-sysfs-add-file-to-group \
ksym-longterm-sysfs-add-link-to-group \
ksym-longterm-sysfs-bin-attr-simple-read \
ksym-longterm-sysfs-break-active-protection \
ksym-longterm-sysfs-change-owner \
ksym-longterm-sysfs-chmod-file \
ksym-longterm-sysfs-create-bin-file \
ksym-longterm-sysfs-create-file-ns \
ksym-longterm-sysfs-create-files \
ksym-longterm-sysfs-create-group \
ksym-longterm-sysfs-create-groups \
ksym-longterm-sysfs-create-link \
ksym-longterm-sysfs-create-link-nowarn \
ksym-longterm-sysfs-create-mount-point \
ksym-longterm-sysfs-emit \
ksym-longterm-sysfs-emit-at \
ksym-longterm-sysfs-file-change-owner \
ksym-longterm-sysfs-format-mac \
ksym-longterm-sysfs-group-change-owner \
ksym-longterm-sysfs-groups-change-owner \
ksym-longterm-sysfs-merge-group \
ksym-longterm-sysfs-notify \
ksym-longterm-sysfs-remove-bin-file \
ksym-longterm-sysfs-remove-file-from-group \
ksym-longterm-sysfs-remove-file-ns \
ksym-longterm-sysfs-remove-file-self \
ksym-longterm-sysfs-remove-files \
ksym-longterm-sysfs-remove-group \
ksym-longterm-sysfs-remove-groups \
ksym-longterm-sysfs-remove-link \
ksym-longterm-sysfs-remove-link-from-group \
ksym-longterm-sysfs-remove-mount-point \
ksym-longterm-sysfs-rename-link-ns \
ksym-longterm-sysfs-streq \
ksym-longterm-sysfs-unbreak-active-protection \
ksym-longterm-sysfs-unmerge-group \
ksym-longterm-sysfs-update-group \
ksym-longterm-sysfs-update-groups \
ksym-longterm-sysrq-mask \
ksym-longterm-sysrq-toggle-support \
ksym-longterm-system-bh-highpri-wq \
ksym-longterm-system-bh-wq \
ksym-longterm-system-cpucaps \
ksym-longterm-system-dfl-wq \
ksym-longterm-system-entering-hibernation \
ksym-longterm-system-freezable-power-efficient-wq \
ksym-longterm-system-freezable-wq \
ksym-longterm-system-highpri-wq \
ksym-longterm-system-long-wq \
ksym-longterm-system-percpu-wq \
ksym-longterm-system-power-efficient-wq \
ksym-longterm-system-state \
ksym-longterm-system-unbound-wq \
ksym-longterm-system-wq \
ksym-longterm-t3-l2e-free \
ksym-longterm-t3-l2t-get \
ksym-longterm-t3-l2t-send-slow \
ksym-longterm-t3-register-cpl-handler \
ksym-longterm-t4-cleanup-clip-tbl \
ksym-longterm-tag-pages-for-writeback \
ksym-longterm-take-dentry-name-snapshot \
ksym-longterm-tap-create-cdev \
ksym-longterm-tap-del-queues \
ksym-longterm-tap-destroy-cdev \
ksym-longterm-tap-free-minor \
ksym-longterm-tap-get-minor \
ksym-longterm-tap-get-ptr-ring \
ksym-longterm-tap-get-socket \
ksym-longterm-tap-handle-frame \
ksym-longterm-tap-queue-resize \
ksym-longterm-taprio-offload-free \
ksym-longterm-taprio-offload-get \
ksym-longterm-target-alloc-cmd-counter \
ksym-longterm-target-alloc-sgl \
ksym-longterm-target-backend-unregister \
ksym-longterm-target-cmd-init-cdb \
ksym-longterm-target-cmd-parse-cdb \
ksym-longterm-target-complete-cmd \
ksym-longterm-target-complete-cmd-with-length \
ksym-longterm-target-complete-cmd-with-sense \
ksym-longterm-target-configure-unmap-from-queue \
ksym-longterm-target-depend-item \
ksym-longterm-target-execute-cmd \
ksym-longterm-target-free-cmd-counter \
ksym-longterm-target-free-sgl \
ksym-longterm-target-get-sess-cmd \
ksym-longterm-target-init-cmd \
ksym-longterm-target-lun-is-rdonly \
ksym-longterm-target-nacl-find-deve \
ksym-longterm-target-put-nacl \
ksym-longterm-target-put-sess-cmd \
ksym-longterm-target-register-template \
ksym-longterm-target-remove-session \
ksym-longterm-target-send-busy \
ksym-longterm-target-set-cmd-data-length \
ksym-longterm-target-setup-session \
ksym-longterm-target-show-cmd \
ksym-longterm-target-show-dynamic-sessions \
ksym-longterm-target-stop-cmd-counter \
ksym-longterm-target-stop-session \
ksym-longterm-target-submit \
ksym-longterm-target-submit-cmd \
ksym-longterm-target-submit-prep \
ksym-longterm-target-submit-tmr \
ksym-longterm-target-to-linux-sector \
ksym-longterm-target-tpg-has-node-acl \
ksym-longterm-target-undepend-item \
ksym-longterm-target-unregister-template \
ksym-longterm-target-wait-for-cmds \
ksym-longterm-target-wait-for-sess-cmds \
ksym-longterm-tas2781-hda-remove \
ksym-longterm-tas2781-load-calibration \
ksym-longterm-tas2781-save-calibration \
ksym-longterm-tascodec-init \
ksym-longterm-tasdev-chn-switch \
ksym-longterm-tasdev-fct-efi-guid \
ksym-longterm-tasdevice-amp-getvol \
ksym-longterm-tasdevice-amp-putvol \
ksym-longterm-tasdevice-calbin-remove \
ksym-longterm-tasdevice-config-get \
ksym-longterm-tasdevice-config-info-remove \
ksym-longterm-tasdevice-config-put \
ksym-longterm-tasdevice-dev-bulk-read \
ksym-longterm-tasdevice-dev-bulk-write \
ksym-longterm-tasdevice-dev-read \
ksym-longterm-tasdevice-dev-update-bits \
ksym-longterm-tasdevice-dev-write \
ksym-longterm-tasdevice-digital-getvol \
ksym-longterm-tasdevice-digital-putvol \
ksym-longterm-tasdevice-dsp-parser \
ksym-longterm-tasdevice-dsp-remove \
ksym-longterm-tasdevice-get-profile-id \
ksym-longterm-tasdevice-info-config \
ksym-longterm-tasdevice-info-profile \
ksym-longterm-tasdevice-info-programs \
ksym-longterm-tasdevice-init \
ksym-longterm-tasdevice-kzalloc \
ksym-longterm-tasdevice-prmg-load \
ksym-longterm-tasdevice-program-get \
ksym-longterm-tasdevice-program-put \
ksym-longterm-tasdevice-rca-parser \
ksym-longterm-tasdevice-remove \
ksym-longterm-tasdevice-reset \
ksym-longterm-tasdevice-select-cfg-blk \
ksym-longterm-tasdevice-select-tuningprm-cfg \
ksym-longterm-tasdevice-set-profile-id \
ksym-longterm-tasdevice-tuning-switch \
ksym-longterm-task-active-pid-ns \
ksym-longterm-task-cls-state \
ksym-longterm-task-cputime-adjusted \
ksym-longterm-task-user-regset-view \
ksym-longterm-tasklet-init \
ksym-longterm-tasklet-kill \
ksym-longterm-tasklet-setup \
ksym-longterm-tasklet-unlock \
ksym-longterm-tasklet-unlock-spin-wait \
ksym-longterm-tasklet-unlock-wait \
ksym-longterm-tb-property-add-data \
ksym-longterm-tb-property-add-dir \
ksym-longterm-tb-property-add-immediate \
ksym-longterm-tb-property-add-text \
ksym-longterm-tb-property-create-dir \
ksym-longterm-tb-property-find \
ksym-longterm-tb-property-free-dir \
ksym-longterm-tb-property-get-next \
ksym-longterm-tb-property-remove \
ksym-longterm-tb-register-property-dir \
ksym-longterm-tb-register-protocol-handler \
ksym-longterm-tb-register-service-driver \
ksym-longterm-tb-ring-alloc-rx \
ksym-longterm-tb-ring-alloc-tx \
ksym-longterm-tb-ring-free \
ksym-longterm-tb-ring-poll \
ksym-longterm-tb-ring-poll-complete \
ksym-longterm-tb-ring-start \
ksym-longterm-tb-ring-stop \
ksym-longterm-tb-service-type \
ksym-longterm-tb-unregister-property-dir \
ksym-longterm-tb-unregister-protocol-handler \
ksym-longterm-tb-unregister-service-driver \
ksym-longterm-tb-xdomain-alloc-in-hopid \
ksym-longterm-tb-xdomain-alloc-out-hopid \
ksym-longterm-tb-xdomain-disable-paths \
ksym-longterm-tb-xdomain-enable-paths \
ksym-longterm-tb-xdomain-find-by-route \
ksym-longterm-tb-xdomain-find-by-uuid \
ksym-longterm-tb-xdomain-lane-bonding-disable \
ksym-longterm-tb-xdomain-lane-bonding-enable \
ksym-longterm-tb-xdomain-release-in-hopid \
ksym-longterm-tb-xdomain-release-out-hopid \
ksym-longterm-tb-xdomain-request \
ksym-longterm-tb-xdomain-response \
ksym-longterm-tb-xdomain-type \
ksym-longterm-tc-cleanup-offload-action \
ksym-longterm-tc-setup-cb-add \
ksym-longterm-tc-setup-cb-call \
ksym-longterm-tc-setup-cb-destroy \
ksym-longterm-tc-setup-cb-reoffload \
ksym-longterm-tc-setup-cb-replace \
ksym-longterm-tc-setup-offload-action \
ksym-longterm-tc-skb-ext-tc \
ksym-longterm-tc-skb-ext-tc-disable \
ksym-longterm-tc-skb-ext-tc-enable \
ksym-longterm-tcf-action-check-ctrlact \
ksym-longterm-tcf-action-exec \
ksym-longterm-tcf-action-set-ctrlact \
ksym-longterm-tcf-action-update-hw-stats \
ksym-longterm-tcf-action-update-stats \
ksym-longterm-tcf-block-get \
ksym-longterm-tcf-block-get-ext \
ksym-longterm-tcf-block-lookup \
ksym-longterm-tcf-block-netif-keep-dst \
ksym-longterm-tcf-block-put \
ksym-longterm-tcf-block-put-ext \
ksym-longterm-tcf-chain-get-by-act \
ksym-longterm-tcf-chain-put-by-act \
ksym-longterm-tcf-classify \
ksym-longterm-tcf-dev-queue-xmit \
ksym-longterm-tcf-em-register \
ksym-longterm-tcf-em-tree-destroy \
ksym-longterm-tcf-em-tree-dump \
ksym-longterm-tcf-em-tree-validate \
ksym-longterm-tcf-em-unregister \
ksym-longterm-tcf-exts-change \
ksym-longterm-tcf-exts-destroy \
ksym-longterm-tcf-exts-dump \
ksym-longterm-tcf-exts-dump-stats \
ksym-longterm-tcf-exts-init-ex \
ksym-longterm-tcf-exts-num-actions \
ksym-longterm-tcf-exts-terse-dump \
ksym-longterm-tcf-exts-validate \
ksym-longterm-tcf-exts-validate-ex \
ksym-longterm-tcf-frag-xmit-count \
ksym-longterm-tcf-generic-walker \
ksym-longterm-tcf-get-next-chain \
ksym-longterm-tcf-get-next-proto \
ksym-longterm-tcf-idr-check-alloc \
ksym-longterm-tcf-idr-cleanup \
ksym-longterm-tcf-idr-create \
ksym-longterm-tcf-idr-create-from-flags \
ksym-longterm-tcf-idr-release \
ksym-longterm-tcf-idr-search \
ksym-longterm-tcf-idrinfo-destroy \
ksym-longterm-tcf-qevent-destroy \
ksym-longterm-tcf-qevent-dump \
ksym-longterm-tcf-qevent-handle \
ksym-longterm-tcf-qevent-init \
ksym-longterm-tcf-qevent-validate-change \
ksym-longterm-tcf-queue-work \
ksym-longterm-tcf-register-action \
ksym-longterm-tcf-sw-enabled-key \
ksym-longterm-tcf-unregister-action \
ksym-longterm-tcp-abort \
ksym-longterm-tcp-bpf-sendmsg-redir \
ksym-longterm-tcp-bpf-update-proto \
ksym-longterm-tcp-close \
ksym-longterm-tcp-cong-avoid-ai \
ksym-longterm-tcp-connect \
ksym-longterm-tcp-create-openreq-child \
ksym-longterm-tcp-disconnect \
ksym-longterm-tcp-do-parse-auth-options \
ksym-longterm-tcp-done \
ksym-longterm-tcp-enter-cwr \
ksym-longterm-tcp-get-info \
ksym-longterm-tcp-gro-complete \
ksym-longterm-tcp-have-smc \
ksym-longterm-tcp-is-ulp-esp \
ksym-longterm-tcp-memory-per-cpu-fw-alloc \
ksym-longterm-tcp-memory-pressure \
ksym-longterm-tcp-mss-to-mtu \
ksym-longterm-tcp-orphan-count \
ksym-longterm-tcp-parse-options \
ksym-longterm-tcp-plb-check-rehash \
ksym-longterm-tcp-plb-update-state \
ksym-longterm-tcp-plb-update-state-upon-rto \
ksym-longterm-tcp-poll \
ksym-longterm-tcp-prot \
ksym-longterm-tcp-rate-check-app-limited \
ksym-longterm-tcp-read-done \
ksym-longterm-tcp-read-sock \
ksym-longterm-tcp-recv-skb \
ksym-longterm-tcp-register-congestion-control \
ksym-longterm-tcp-register-ulp \
ksym-longterm-tcp-reno-cong-avoid \
ksym-longterm-tcp-reno-ssthresh \
ksym-longterm-tcp-reno-undo-cwnd \
ksym-longterm-tcp-sendmsg \
ksym-longterm-tcp-sendmsg-locked \
ksym-longterm-tcp-set-state \
ksym-longterm-tcp-sigpool-algo \
ksym-longterm-tcp-sigpool-alloc-ahash \
ksym-longterm-tcp-sigpool-end \
ksym-longterm-tcp-sigpool-get \
ksym-longterm-tcp-sigpool-hash-skb-data \
ksym-longterm-tcp-sigpool-release \
ksym-longterm-tcp-sigpool-start \
ksym-longterm-tcp-slow-start \
ksym-longterm-tcp-sock-set-cork \
ksym-longterm-tcp-sock-set-keepcnt \
ksym-longterm-tcp-sock-set-keepidle \
ksym-longterm-tcp-sock-set-keepintvl \
ksym-longterm-tcp-sock-set-nodelay \
ksym-longterm-tcp-sock-set-quickack \
ksym-longterm-tcp-sock-set-syncnt \
ksym-longterm-tcp-sock-set-user-timeout \
ksym-longterm-tcp-stream-memory-free \
ksym-longterm-tcp-time-wait \
ksym-longterm-tcp-unregister-congestion-control \
ksym-longterm-tcp-unregister-ulp \
ksym-longterm-tcp-v4-do-rcv \
ksym-longterm-tcp-vegas-cwnd-event \
ksym-longterm-tcp-vegas-get-info \
ksym-longterm-tcp-vegas-init \
ksym-longterm-tcp-vegas-pkts-acked \
ksym-longterm-tcp-vegas-state \
ksym-longterm-tcpci-get-tcpm-port \
ksym-longterm-tcpci-irq \
ksym-longterm-tcpci-register-port \
ksym-longterm-tcpci-unregister-port \
ksym-longterm-tcpm-cc-change \
ksym-longterm-tcpm-pd-hard-reset \
ksym-longterm-tcpm-pd-receive \
ksym-longterm-tcpm-pd-transmit-complete \
ksym-longterm-tcpm-port-clean \
ksym-longterm-tcpm-port-error-recovery \
ksym-longterm-tcpm-port-is-toggling \
ksym-longterm-tcpm-register-port \
ksym-longterm-tcpm-sink-frs \
ksym-longterm-tcpm-sourcing-vbus \
ksym-longterm-tcpm-tcpc-reset \
ksym-longterm-tcpm-unregister-port \
ksym-longterm-tcpm-vbus-change \
ksym-longterm-tcpv6-prot \
ksym-longterm-tda10021-attach \
ksym-longterm-tda10023-attach \
ksym-longterm-tda10045-attach \
ksym-longterm-tda10046-attach \
ksym-longterm-tda10048-attach \
ksym-longterm-tda10086-attach \
ksym-longterm-tda18218-attach \
ksym-longterm-tda18271-attach \
ksym-longterm-tda18271c2dd-attach \
ksym-longterm-tda665x-attach \
ksym-longterm-tda8083-attach \
ksym-longterm-tda8261-attach \
ksym-longterm-tda826x-attach \
ksym-longterm-tda827x-attach \
ksym-longterm-tda829x-attach \
ksym-longterm-tda829x-probe \
ksym-longterm-tda9887-attach \
ksym-longterm-tea5761-attach \
ksym-longterm-tea5761-autodetection \
ksym-longterm-tea5767-attach \
ksym-longterm-tea5767-autodetection \
ksym-longterm-team-mode-register \
ksym-longterm-team-mode-unregister \
ksym-longterm-team-modeop-port-change-dev-addr \
ksym-longterm-team-modeop-port-enter \
ksym-longterm-team-option-inst-set-change \
ksym-longterm-team-options-change-check \
ksym-longterm-team-options-register \
ksym-longterm-team-options-unregister \
ksym-longterm-tee-bnxt-copy-coredump \
ksym-longterm-tee-bnxt-fw-load \
ksym-longterm-tee-bus-type \
ksym-longterm-tee-client-close-context \
ksym-longterm-tee-client-close-session \
ksym-longterm-tee-client-get-version \
ksym-longterm-tee-client-invoke-func \
ksym-longterm-tee-client-open-context \
ksym-longterm-tee-client-open-session \
ksym-longterm-tee-client-system-session \
ksym-longterm-tee-device-alloc \
ksym-longterm-tee-device-get \
ksym-longterm-tee-device-put \
ksym-longterm-tee-device-put-all-dma-heaps \
ksym-longterm-tee-device-register \
ksym-longterm-tee-device-register-dma-heap \
ksym-longterm-tee-device-set-dev-groups \
ksym-longterm-tee-device-unregister \
ksym-longterm-tee-dyn-shm-alloc-helper \
ksym-longterm-tee-dyn-shm-free-helper \
ksym-longterm-tee-get-drvdata \
ksym-longterm-tee-protmem-static-pool-alloc \
ksym-longterm-tee-session-calc-client-uuid \
ksym-longterm-tee-shm-alloc-dma-mem \
ksym-longterm-tee-shm-alloc-kernel-buf \
ksym-longterm-tee-shm-alloc-priv-buf \
ksym-longterm-tee-shm-free \
ksym-longterm-tee-shm-get-from-id \
ksym-longterm-tee-shm-get-pa \
ksym-longterm-tee-shm-get-va \
ksym-longterm-tee-shm-pool-alloc-res-mem \
ksym-longterm-tee-shm-put \
ksym-longterm-tee-shm-register-fd \
ksym-longterm-tee-shm-register-kernel-buf \
ksym-longterm-teedev-close-context \
ksym-longterm-teedev-ctx-get \
ksym-longterm-teedev-ctx-put \
ksym-longterm-teedev-open \
ksym-longterm-tegra-ahb-enable-smmu \
ksym-longterm-tegra-asoc-machine-init \
ksym-longterm-tegra-asoc-machine-probe \
ksym-longterm-tegra-bpmp-free-mrq \
ksym-longterm-tegra-bpmp-get \
ksym-longterm-tegra-bpmp-mrq-is-supported \
ksym-longterm-tegra-bpmp-mrq-return \
ksym-longterm-tegra-bpmp-put \
ksym-longterm-tegra-bpmp-request-mrq \
ksym-longterm-tegra-bpmp-transfer \
ksym-longterm-tegra-bpmp-transfer-atomic \
ksym-longterm-tegra-dfll-register \
ksym-longterm-tegra-dfll-resume \
ksym-longterm-tegra-dfll-runtime-resume \
ksym-longterm-tegra-dfll-runtime-suspend \
ksym-longterm-tegra-dfll-suspend \
ksym-longterm-tegra-dfll-unregister \
ksym-longterm-tegra-fuse-readl \
ksym-longterm-tegra-io-pad-power-disable \
ksym-longterm-tegra-io-pad-power-enable \
ksym-longterm-tegra-ivc-align \
ksym-longterm-tegra-ivc-cleanup \
ksym-longterm-tegra-ivc-init \
ksym-longterm-tegra-ivc-notified \
ksym-longterm-tegra-ivc-read-advance \
ksym-longterm-tegra-ivc-read-get-next-frame \
ksym-longterm-tegra-ivc-reset \
ksym-longterm-tegra-ivc-total-queue-size \
ksym-longterm-tegra-ivc-write-advance \
ksym-longterm-tegra-ivc-write-get-next-frame \
ksym-longterm-tegra-mc-get-carveout-info \
ksym-longterm-tegra-mc-get-emem-device-count \
ksym-longterm-tegra-mc-probe-device \
ksym-longterm-tegra-mc-write-emem-configuration \
ksym-longterm-tegra-mipi-disable \
ksym-longterm-tegra-mipi-enable \
ksym-longterm-tegra-mipi-finish-calibration \
ksym-longterm-tegra-mipi-free \
ksym-longterm-tegra-mipi-request \
ksym-longterm-tegra-mipi-start-calibration \
ksym-longterm-tegra-pcm-close \
ksym-longterm-tegra-pcm-construct \
ksym-longterm-tegra-pcm-hw-params \
ksym-longterm-tegra-pcm-open \
ksym-longterm-tegra-pcm-platform-register \
ksym-longterm-tegra-pcm-platform-register-with-chan-names \
ksym-longterm-tegra-pcm-platform-unregister \
ksym-longterm-tegra-pcm-pointer \
ksym-longterm-tegra-phy-xusb-utmi-pad-power-down \
ksym-longterm-tegra-phy-xusb-utmi-pad-power-on \
ksym-longterm-tegra-phy-xusb-utmi-port-reset \
ksym-longterm-tegra-powergate-power-off \
ksym-longterm-tegra-powergate-power-on \
ksym-longterm-tegra-powergate-remove-clamping \
ksym-longterm-tegra-powergate-sequence-power-up \
ksym-longterm-tegra-read-ram-code \
ksym-longterm-tegra-sku-info \
ksym-longterm-tegra-xusb-padctl-disable-phy-sleepwalk \
ksym-longterm-tegra-xusb-padctl-disable-phy-wake \
ksym-longterm-tegra-xusb-padctl-enable-phy-sleepwalk \
ksym-longterm-tegra-xusb-padctl-enable-phy-wake \
ksym-longterm-tegra-xusb-padctl-get \
ksym-longterm-tegra-xusb-padctl-get-port-number \
ksym-longterm-tegra-xusb-padctl-get-usb3-companion \
ksym-longterm-tegra-xusb-padctl-hsic-set-idle \
ksym-longterm-tegra-xusb-padctl-legacy-probe \
ksym-longterm-tegra-xusb-padctl-legacy-remove \
ksym-longterm-tegra-xusb-padctl-put \
ksym-longterm-tegra-xusb-padctl-remote-wake-detected \
ksym-longterm-tegra-xusb-padctl-set-vbus-override \
ksym-longterm-tegra-xusb-padctl-usb3-save-context \
ksym-longterm-tegra-xusb-padctl-usb3-set-lfps-detect \
ksym-longterm-tegra124-xusb-padctl-soc \
ksym-longterm-tegra186-xusb-padctl-soc \
ksym-longterm-tegra194-miscreg-mask-serror \
ksym-longterm-tegra194-xusb-padctl-soc \
ksym-longterm-tegra210-clk-emc-attach \
ksym-longterm-tegra210-clk-emc-detach \
ksym-longterm-tegra210-clk-emc-dll-enable \
ksym-longterm-tegra210-clk-emc-dll-update-setting \
ksym-longterm-tegra210-clk-emc-update-setting \
ksym-longterm-tegra210-plle-hw-sequence-is-enabled \
ksym-longterm-tegra210-plle-hw-sequence-start \
ksym-longterm-tegra210-put-utmipll-in-iddq \
ksym-longterm-tegra210-put-utmipll-out-iddq \
ksym-longterm-tegra210-sata-pll-hw-control-enable \
ksym-longterm-tegra210-sata-pll-hw-sequence-start \
ksym-longterm-tegra210-set-sata-pll-seq-sw \
ksym-longterm-tegra210-xusb-padctl-soc \
ksym-longterm-tegra210-xusb-pll-hw-control-enable \
ksym-longterm-tegra210-xusb-pll-hw-sequence-start \
ksym-longterm-tegra234-xusb-padctl-soc \
ksym-longterm-test-taint \
ksym-longterm-textsearch-destroy \
ksym-longterm-textsearch-find-continuous \
ksym-longterm-textsearch-prepare \
ksym-longterm-textsearch-register \
ksym-longterm-textsearch-unregister \
ksym-longterm-thaw-super \
ksym-longterm-thermal-acpi-active-trip-temp \
ksym-longterm-thermal-acpi-critical-trip-temp \
ksym-longterm-thermal-acpi-hot-trip-temp \
ksym-longterm-thermal-acpi-passive-trip-temp \
ksym-longterm-thermal-add-hwmon-sysfs \
ksym-longterm-thermal-cooling-device-register \
ksym-longterm-thermal-cooling-device-unregister \
ksym-longterm-thermal-cooling-device-update \
ksym-longterm-thermal-genl-cpu-capability-event \
ksym-longterm-thermal-of-cooling-device-register \
ksym-longterm-thermal-remove-hwmon-sysfs \
ksym-longterm-thermal-trip-is-bound-to-cdev \
ksym-longterm-thermal-tripless-zone-device-register \
ksym-longterm-thermal-zone-device \
ksym-longterm-thermal-zone-device-critical \
ksym-longterm-thermal-zone-device-disable \
ksym-longterm-thermal-zone-device-enable \
ksym-longterm-thermal-zone-device-id \
ksym-longterm-thermal-zone-device-priv \
ksym-longterm-thermal-zone-device-register-with-trips \
ksym-longterm-thermal-zone-device-type \
ksym-longterm-thermal-zone-device-unregister \
ksym-longterm-thermal-zone-device-update \
ksym-longterm-thermal-zone-for-each-trip \
ksym-longterm-thermal-zone-get-crit-temp \
ksym-longterm-thermal-zone-get-offset \
ksym-longterm-thermal-zone-get-slope \
ksym-longterm-thermal-zone-get-temp \
ksym-longterm-thermal-zone-get-zone-by-name \
ksym-longterm-thermal-zone-set-trip-temp \
ksym-longterm-this-cpu-has-cap \
ksym-longterm-thp-get-unmapped-area \
ksym-longterm-ti-lmu-common-get-brt-res \
ksym-longterm-ti-lmu-common-get-ramp-params \
ksym-longterm-ti-lmu-common-set-brightness \
ksym-longterm-ti-lmu-common-set-ramp \
ksym-longterm-tick-broadcast-control \
ksym-longterm-tick-broadcast-oneshot-control \
ksym-longterm-tick-nohz-dep-clear-cpu \
ksym-longterm-tick-nohz-dep-clear-task \
ksym-longterm-tick-nohz-dep-set-cpu \
ksym-longterm-tick-nohz-dep-set-task \
ksym-longterm-tick-nohz-full-mask \
ksym-longterm-tick-nohz-full-running \
ksym-longterm-tifm-add-adapter \
ksym-longterm-tifm-alloc-adapter \
ksym-longterm-tifm-alloc-device \
ksym-longterm-tifm-eject \
ksym-longterm-tifm-free-adapter \
ksym-longterm-tifm-free-device \
ksym-longterm-tifm-has-ms-pif \
ksym-longterm-tifm-map-sg \
ksym-longterm-tifm-queue-work \
ksym-longterm-tifm-register-driver \
ksym-longterm-tifm-remove-adapter \
ksym-longterm-tifm-unmap-sg \
ksym-longterm-tifm-unregister-driver \
ksym-longterm-time64-to-tm \
ksym-longterm-timecounter-cyc2time \
ksym-longterm-timecounter-init \
ksym-longterm-timecounter-read \
ksym-longterm-timekeeping-clocksource-has-base \
ksym-longterm-timer-delete \
ksym-longterm-timer-delete-sync \
ksym-longterm-timer-delete-sync-try \
ksym-longterm-timer-init-key \
ksym-longterm-timer-reduce \
ksym-longterm-timer-shutdown \
ksym-longterm-timer-shutdown-sync \
ksym-longterm-timer-unstable-counter-workaround \
ksym-longterm-timerqueue-add \
ksym-longterm-timerqueue-del \
ksym-longterm-timerqueue-iterate-next \
ksym-longterm-timespec64-add-safe \
ksym-longterm-timespec64-to-jiffies \
ksym-longterm-timestamp-truncate \
ksym-longterm-tipc-dump-done \
ksym-longterm-tipc-dump-start \
ksym-longterm-tipc-nl-sk-walk \
ksym-longterm-tipc-sk-fill-sock-diag \
ksym-longterm-tls-alert-recv \
ksym-longterm-tls-client-hello-anon \
ksym-longterm-tls-client-hello-psk \
ksym-longterm-tls-client-hello-x509 \
ksym-longterm-tls-device-sk-destruct \
ksym-longterm-tls-encrypt-skb \
ksym-longterm-tls-get-record \
ksym-longterm-tls-get-record-type \
ksym-longterm-tls-handshake-cancel \
ksym-longterm-tls-handshake-close \
ksym-longterm-tls-offload-tx-resync-request \
ksym-longterm-tls-server-hello-psk \
ksym-longterm-tls-server-hello-x509 \
ksym-longterm-tls-validate-xmit-skb \
ksym-longterm-tlv320aic23-probe \
ksym-longterm-tlv320aic23-regmap \
ksym-longterm-tmc-alloc-sg-table \
ksym-longterm-tmc-etr-get-buffer \
ksym-longterm-tmc-etr-get-catu-device \
ksym-longterm-tmc-etr-remove-catu-ops \
ksym-longterm-tmc-etr-set-catu-ops \
ksym-longterm-tmc-free-sg-table \
ksym-longterm-tmc-sg-table-get-data \
ksym-longterm-tmc-sg-table-sync-data-range \
ksym-longterm-tmc-sg-table-sync-table \
ksym-longterm-tmio-mmc-disable-mmc-irqs \
ksym-longterm-tmio-mmc-do-data-irq \
ksym-longterm-tmio-mmc-enable-mmc-irqs \
ksym-longterm-tmio-mmc-host-alloc \
ksym-longterm-tmio-mmc-host-probe \
ksym-longterm-tmio-mmc-host-remove \
ksym-longterm-tmio-mmc-host-runtime-resume \
ksym-longterm-tmio-mmc-host-runtime-suspend \
ksym-longterm-tmio-mmc-irq \
ksym-longterm-tnum-strn \
ksym-longterm-to-cxl-dax-region \
ksym-longterm-to-cxl-decoder \
ksym-longterm-to-cxl-endpoint-decoder \
ksym-longterm-to-cxl-nvdimm \
ksym-longterm-to-cxl-nvdimm-bridge \
ksym-longterm-to-cxl-pmem-region \
ksym-longterm-to-cxl-port \
ksym-longterm-to-cxl-root-decoder \
ksym-longterm-to-cxl-switch-decoder \
ksym-longterm-to-cxlfs \
ksym-longterm-to-drm-sched-fence \
ksym-longterm-to-hisi-sas-port \
ksym-longterm-to-nd-btt \
ksym-longterm-to-nd-dax \
ksym-longterm-to-nd-desc \
ksym-longterm-to-nd-pfn \
ksym-longterm-to-nd-region \
ksym-longterm-to-ndd \
ksym-longterm-to-nfit-uuid \
ksym-longterm-to-nvdimm \
ksym-longterm-to-nvdimm-bus \
ksym-longterm-to-nvdimm-bus-dev \
ksym-longterm-to-of-pinfo \
ksym-longterm-to-pdrv-policy-node \
ksym-longterm-to-software-node \
ksym-longterm-topology-clear-scale-freq-source \
ksym-longterm-topology-set-scale-freq-source \
ksym-longterm-topology-update-hw-pressure \
ksym-longterm-torture-cleanup-begin \
ksym-longterm-torture-cleanup-end \
ksym-longterm-torture-hrtimeout-jiffies \
ksym-longterm-torture-hrtimeout-ms \
ksym-longterm-torture-hrtimeout-ns \
ksym-longterm-torture-hrtimeout-s \
ksym-longterm-torture-hrtimeout-us \
ksym-longterm-torture-init-begin \
ksym-longterm-torture-init-end \
ksym-longterm-torture-kthread-stopping \
ksym-longterm-torture-must-stop \
ksym-longterm-torture-must-stop-irq \
ksym-longterm-torture-num-online-cpus \
ksym-longterm-torture-offline \
ksym-longterm-torture-online \
ksym-longterm-torture-onoff-failures \
ksym-longterm-torture-onoff-init \
ksym-longterm-torture-onoff-stats \
ksym-longterm-torture-random \
ksym-longterm-torture-sched-setaffinity \
ksym-longterm-torture-shuffle-init \
ksym-longterm-torture-shuffle-task-register \
ksym-longterm-torture-shutdown-absorb \
ksym-longterm-torture-shutdown-init \
ksym-longterm-torture-stutter-init \
ksym-longterm-touch-atime \
ksym-longterm-touch-buffer \
ksym-longterm-touch-overlay-get-touchscreen-abs \
ksym-longterm-touch-overlay-map \
ksym-longterm-touch-overlay-mapped-touchscreen \
ksym-longterm-touch-overlay-process-contact \
ksym-longterm-touch-overlay-sync-frame \
ksym-longterm-touch-softlockup-watchdog \
ksym-longterm-touchscreen-parse-properties \
ksym-longterm-touchscreen-report-pos \
ksym-longterm-touchscreen-set-mt-pos \
ksym-longterm-tpm-buf-append \
ksym-longterm-tpm-buf-append-hmac-session \
ksym-longterm-tpm-buf-append-name \
ksym-longterm-tpm-buf-append-u16 \
ksym-longterm-tpm-buf-append-u32 \
ksym-longterm-tpm-buf-append-u8 \
ksym-longterm-tpm-buf-destroy \
ksym-longterm-tpm-buf-init \
ksym-longterm-tpm-buf-init-sized \
ksym-longterm-tpm-buf-length \
ksym-longterm-tpm-buf-read-u16 \
ksym-longterm-tpm-buf-read-u32 \
ksym-longterm-tpm-buf-read-u8 \
ksym-longterm-tpm-buf-reset \
ksym-longterm-tpm-buf-reset-sized \
ksym-longterm-tpm-calc-ordinal-duration \
ksym-longterm-tpm-chip-alloc \
ksym-longterm-tpm-chip-bootstrap \
ksym-longterm-tpm-chip-register \
ksym-longterm-tpm-chip-start \
ksym-longterm-tpm-chip-stop \
ksym-longterm-tpm-chip-unregister \
ksym-longterm-tpm-crb-ffa-init \
ksym-longterm-tpm-crb-ffa-start \
ksym-longterm-tpm-default-chip \
ksym-longterm-tpm-get-random \
ksym-longterm-tpm-get-timeouts \
ksym-longterm-tpm-is-tpm2 \
ksym-longterm-tpm-pcr-extend \
ksym-longterm-tpm-pcr-read \
ksym-longterm-tpm-pm-resume \
ksym-longterm-tpm-pm-suspend \
ksym-longterm-tpm-put-ops \
ksym-longterm-tpm-tis-core-init \
ksym-longterm-tpm-tis-remove \
ksym-longterm-tpm-tis-resume \
ksym-longterm-tpm-transmit-cmd \
ksym-longterm-tpm-try-get-ops \
ksym-longterm-tpm1-do-selftest \
ksym-longterm-tpm1-getcap \
ksym-longterm-tpm2-flush-context \
ksym-longterm-tpm2-get-cc-attrs-tbl \
ksym-longterm-tpm2-get-tpm-pt \
ksym-longterm-tpm2-probe \
ksym-longterm-tpmm-chip-alloc \
ksym-longterm-tps65010-config-vdcdc2 \
ksym-longterm-tps65010-config-vregs1 \
ksym-longterm-tps65010-set-gpio-out-value \
ksym-longterm-tps65010-set-led \
ksym-longterm-tps65010-set-low-pwr \
ksym-longterm-tps65010-set-vbus-draw \
ksym-longterm-tps65010-set-vib \
ksym-longterm-tps65013-set-low-pwr \
ksym-longterm-tps65224-volatile-table \
ksym-longterm-tps6594-device-init \
ksym-longterm-tps6594-volatile-table \
ksym-longterm-trace-add-event-call \
ksym-longterm-trace-array-destroy \
ksym-longterm-trace-array-get-by-name \
ksym-longterm-trace-array-init-printk \
ksym-longterm-trace-array-printk \
ksym-longterm-trace-array-put \
ksym-longterm-trace-array-set-clr-event \
ksym-longterm-trace-clock \
ksym-longterm-trace-clock-global \
ksym-longterm-trace-clock-jiffies \
ksym-longterm-trace-clock-local \
ksym-longterm-trace-define-field \
ksym-longterm-trace-dump-stack \
ksym-longterm-trace-event-buffer-commit \
ksym-longterm-trace-event-buffer-lock-reserve \
ksym-longterm-trace-event-buffer-reserve \
ksym-longterm-trace-event-ignore-this-pid \
ksym-longterm-trace-event-printf \
ksym-longterm-trace-event-raw-init \
ksym-longterm-trace-event-reg \
ksym-longterm-trace-get-event-file \
ksym-longterm-trace-handle-return \
ksym-longterm-trace-output-call \
ksym-longterm-trace-print-array-seq \
ksym-longterm-trace-print-bitmask-seq \
ksym-longterm-trace-print-flags-seq \
ksym-longterm-trace-print-hex-dump-seq \
ksym-longterm-trace-print-hex-seq \
ksym-longterm-trace-print-symbols-seq \
ksym-longterm-trace-printk-init-buffers \
ksym-longterm-trace-put-event-file \
ksym-longterm-trace-raw-output-prep \
ksym-longterm-trace-remove-event-call \
ksym-longterm-trace-seq-acquire \
ksym-longterm-trace-seq-bitmask \
ksym-longterm-trace-seq-bprintf \
ksym-longterm-trace-seq-hex-dump \
ksym-longterm-trace-seq-path \
ksym-longterm-trace-seq-printf \
ksym-longterm-trace-seq-putc \
ksym-longterm-trace-seq-putmem \
ksym-longterm-trace-seq-putmem-hex \
ksym-longterm-trace-seq-puts \
ksym-longterm-trace-seq-to-user \
ksym-longterm-trace-seq-vprintf \
ksym-longterm-trace-set-clr-event \
ksym-longterm-trace-vbprintk \
ksym-longterm-trace-vprintk \
ksym-longterm-tracepoint-probe-register \
ksym-longterm-tracepoint-probe-register-prio \
ksym-longterm-tracepoint-probe-register-prio-may-exist \
ksym-longterm-tracepoint-probe-unregister \
ksym-longterm-tracing-alloc-snapshot \
ksym-longterm-tracing-cond-snapshot-data \
ksym-longterm-tracing-is-on \
ksym-longterm-tracing-off \
ksym-longterm-tracing-on \
ksym-longterm-tracing-snapshot \
ksym-longterm-tracing-snapshot-alloc \
ksym-longterm-tracing-snapshot-cond \
ksym-longterm-tracing-snapshot-cond-disable \
ksym-longterm-tracing-snapshot-cond-enable \
ksym-longterm-transport-add-device \
ksym-longterm-transport-alloc-session \
ksym-longterm-transport-alloc-session-tags \
ksym-longterm-transport-backend-register \
ksym-longterm-transport-class-register \
ksym-longterm-transport-class-unregister \
ksym-longterm-transport-configure-device \
ksym-longterm-transport-copy-sense-to-cmd \
ksym-longterm-transport-deregister-session \
ksym-longterm-transport-deregister-session-configfs \
ksym-longterm-transport-destroy-device \
ksym-longterm-transport-free-session \
ksym-longterm-transport-generic-free-cmd \
ksym-longterm-transport-generic-handle-tmr \
ksym-longterm-transport-generic-new-cmd \
ksym-longterm-transport-generic-request-failure \
ksym-longterm-transport-init-session \
ksym-longterm-transport-kmap-data-sg \
ksym-longterm-transport-kunmap-data-sg \
ksym-longterm-transport-lookup-cmd-lun \
ksym-longterm-transport-lookup-tmr-lun \
ksym-longterm-transport-register-session \
ksym-longterm-transport-remove-device \
ksym-longterm-transport-send-check-condition-and-sense \
ksym-longterm-transport-set-vpd-assoc \
ksym-longterm-transport-set-vpd-ident \
ksym-longterm-transport-set-vpd-ident-type \
ksym-longterm-transport-set-vpd-proto-id \
ksym-longterm-transport-setup-device \
ksym-longterm-transport-wait-for-tasks \
ksym-longterm-truncate-inode-pages \
ksym-longterm-truncate-inode-pages-final \
ksym-longterm-truncate-inode-pages-range \
ksym-longterm-truncate-pagecache \
ksym-longterm-truncate-pagecache-range \
ksym-longterm-truncate-setsize \
ksym-longterm-try-lookup-noperm \
ksym-longterm-try-module-get \
ksym-longterm-try-offline-node \
ksym-longterm-try-test-sas-gpio-gp-bit \
ksym-longterm-try-to-free-buffers \
ksym-longterm-try-to-writeback-inodes-sb \
ksym-longterm-try-wait-for-completion \
ksym-longterm-ts2020-attach \
ksym-longterm-ts3a227e-enable-jack-detect \
ksym-longterm-tsa-serial-connect \
ksym-longterm-tsa-serial-disconnect \
ksym-longterm-tsa-serial-get-byphandle \
ksym-longterm-tsa-serial-get-info \
ksym-longterm-tsa-serial-get-num \
ksym-longterm-tsa-serial-put \
ksym-longterm-tsc200x-groups \
ksym-longterm-tsc200x-pm-ops \
ksym-longterm-tsc200x-probe \
ksym-longterm-tsc200x-regmap-config \
ksym-longterm-tsm-report-register \
ksym-longterm-tsm-report-unregister \
ksym-longterm-tso-build-data \
ksym-longterm-tso-build-hdr \
ksym-longterm-tso-start \
ksym-longterm-ttm-backup-bytes-avail \
ksym-longterm-ttm-bo-access \
ksym-longterm-ttm-bo-eviction-valuable \
ksym-longterm-ttm-bo-init-reserved \
ksym-longterm-ttm-bo-init-validate \
ksym-longterm-ttm-bo-kmap \
ksym-longterm-ttm-bo-kmap-try-from-panic \
ksym-longterm-ttm-bo-kunmap \
ksym-longterm-ttm-bo-lru-cursor-fini \
ksym-longterm-ttm-bo-lru-cursor-first \
ksym-longterm-ttm-bo-lru-cursor-init \
ksym-longterm-ttm-bo-lru-cursor-next \
ksym-longterm-ttm-bo-mem-space \
ksym-longterm-ttm-bo-mmap-obj \
ksym-longterm-ttm-bo-move-accel-cleanup \
ksym-longterm-ttm-bo-move-memcpy \
ksym-longterm-ttm-bo-move-sync-cleanup \
ksym-longterm-ttm-bo-move-to-lru-tail \
ksym-longterm-ttm-bo-pin \
ksym-longterm-ttm-bo-populate \
ksym-longterm-ttm-bo-put \
ksym-longterm-ttm-bo-set-bulk-move \
ksym-longterm-ttm-bo-setup-export \
ksym-longterm-ttm-bo-shrink \
ksym-longterm-ttm-bo-shrink-avoid-wait \
ksym-longterm-ttm-bo-shrink-suitable \
ksym-longterm-ttm-bo-unmap-virtual \
ksym-longterm-ttm-bo-unpin \
ksym-longterm-ttm-bo-validate \
ksym-longterm-ttm-bo-vm-access \
ksym-longterm-ttm-bo-vm-close \
ksym-longterm-ttm-bo-vm-dummy-page \
ksym-longterm-ttm-bo-vm-fault \
ksym-longterm-ttm-bo-vm-fault-reserved \
ksym-longterm-ttm-bo-vm-open \
ksym-longterm-ttm-bo-vm-reserve \
ksym-longterm-ttm-bo-vmap \
ksym-longterm-ttm-bo-vunmap \
ksym-longterm-ttm-bo-wait-ctx \
ksym-longterm-ttm-device-clear-dma-mappings \
ksym-longterm-ttm-device-fini \
ksym-longterm-ttm-device-init \
ksym-longterm-ttm-device-prepare-hibernation \
ksym-longterm-ttm-device-swapout \
ksym-longterm-ttm-eu-backoff-reservation \
ksym-longterm-ttm-eu-fence-buffer-objects \
ksym-longterm-ttm-eu-reserve-buffers \
ksym-longterm-ttm-glob \
ksym-longterm-ttm-io-prot \
ksym-longterm-ttm-kmap-iter-iomap-init \
ksym-longterm-ttm-kmap-iter-tt-init \
ksym-longterm-ttm-lru-bulk-move-fini \
ksym-longterm-ttm-lru-bulk-move-init \
ksym-longterm-ttm-lru-bulk-move-tail \
ksym-longterm-ttm-lru-walk-for-evict \
ksym-longterm-ttm-move-memcpy \
ksym-longterm-ttm-pool-alloc \
ksym-longterm-ttm-pool-debugfs \
ksym-longterm-ttm-pool-fini \
ksym-longterm-ttm-pool-free \
ksym-longterm-ttm-pool-init \
ksym-longterm-ttm-range-man-fini-nocheck \
ksym-longterm-ttm-range-man-init-nocheck \
ksym-longterm-ttm-resource-fini \
ksym-longterm-ttm-resource-free \
ksym-longterm-ttm-resource-init \
ksym-longterm-ttm-resource-manager-create-debugfs \
ksym-longterm-ttm-resource-manager-debug \
ksym-longterm-ttm-resource-manager-evict-all \
ksym-longterm-ttm-resource-manager-init \
ksym-longterm-ttm-resource-manager-usage \
ksym-longterm-ttm-sg-tt-init \
ksym-longterm-ttm-tt-fini \
ksym-longterm-ttm-tt-init \
ksym-longterm-ttm-tt-pages-limit \
ksym-longterm-ttm-tt-restore \
ksym-longterm-ttm-tt-setup-backup \
ksym-longterm-ttpci-budget-debiread \
ksym-longterm-ttpci-budget-debiwrite \
ksym-longterm-ttpci-budget-deinit \
ksym-longterm-ttpci-budget-init \
ksym-longterm-ttpci-budget-init-hooks \
ksym-longterm-ttpci-budget-irq10-handler \
ksym-longterm-ttpci-budget-set-video-port \
ksym-longterm-ttpci-eeprom-decode-mac \
ksym-longterm-ttpci-eeprom-parse-mac \
ksym-longterm-ttusbdecfe-dvbs-attach \
ksym-longterm-ttusbdecfe-dvbt-attach \
ksym-longterm-tty-buffer-lock-exclusive \
ksym-longterm-tty-buffer-request-room \
ksym-longterm-tty-buffer-set-limit \
ksym-longterm-tty-buffer-space-avail \
ksym-longterm-tty-buffer-unlock-exclusive \
ksym-longterm-tty-chars-in-buffer \
ksym-longterm-tty-check-change \
ksym-longterm-tty-dev-name-to-number \
ksym-longterm-tty-devnum \
ksym-longterm-tty-do-resize \
ksym-longterm-tty-driver-flush-buffer \
ksym-longterm-tty-driver-kref-put \
ksym-longterm-tty-encode-baud-rate \
ksym-longterm-tty-find-polling-driver \
ksym-longterm-tty-flip-buffer-push \
ksym-longterm-tty-get-char-size \
ksym-longterm-tty-get-frame-size \
ksym-longterm-tty-get-icount \
ksym-longterm-tty-get-pgrp \
ksym-longterm-tty-get-tiocm \
ksym-longterm-tty-hangup \
ksym-longterm-tty-hung-up-p \
ksym-longterm-tty-init-termios \
ksym-longterm-tty-kclose \
ksym-longterm-tty-kopen-exclusive \
ksym-longterm-tty-kopen-shared \
ksym-longterm-tty-kref-put \
ksym-longterm-tty-ldisc-deref \
ksym-longterm-tty-ldisc-flush \
ksym-longterm-tty-ldisc-receive-buf \
ksym-longterm-tty-ldisc-ref \
ksym-longterm-tty-ldisc-ref-wait \
ksym-longterm-tty-lock \
ksym-longterm-tty-mode-ioctl \
ksym-longterm-tty-name \
ksym-longterm-tty-perform-flush \
ksym-longterm-tty-port-alloc-xmit-buf \
ksym-longterm-tty-port-block-til-ready \
ksym-longterm-tty-port-carrier-raised \
ksym-longterm-tty-port-close \
ksym-longterm-tty-port-close-end \
ksym-longterm-tty-port-close-start \
ksym-longterm-tty-port-default-client-ops \
ksym-longterm-tty-port-destroy \
ksym-longterm-tty-port-free-xmit-buf \
ksym-longterm-tty-port-hangup \
ksym-longterm-tty-port-init \
ksym-longterm-tty-port-install \
ksym-longterm-tty-port-link-device \
ksym-longterm-tty-port-lower-dtr-rts \
ksym-longterm-tty-port-open \
ksym-longterm-tty-port-put \
ksym-longterm-tty-port-raise-dtr-rts \
ksym-longterm-tty-port-register-device \
ksym-longterm-tty-port-register-device-attr \
ksym-longterm-tty-port-register-device-attr-serdev \
ksym-longterm-tty-port-tty-get \
ksym-longterm-tty-port-tty-set \
ksym-longterm-tty-port-tty-wakeup \
ksym-longterm-tty-port-unregister-device \
ksym-longterm-tty-prepare-flip-string \
ksym-longterm-tty-put-char \
ksym-longterm-tty-register-device \
ksym-longterm-tty-register-device-attr \
ksym-longterm-tty-register-driver \
ksym-longterm-tty-register-ldisc \
ksym-longterm-tty-release-struct \
ksym-longterm-tty-save-termios \
ksym-longterm-tty-set-ldisc \
ksym-longterm-tty-set-termios \
ksym-longterm-tty-standard-install \
ksym-longterm-tty-std-termios \
ksym-longterm-tty-termios-baud-rate \
ksym-longterm-tty-termios-copy-hw \
ksym-longterm-tty-termios-encode-baud-rate \
ksym-longterm-tty-termios-hw-change \
ksym-longterm-tty-termios-input-baud-rate \
ksym-longterm-tty-unlock \
ksym-longterm-tty-unregister-device \
ksym-longterm-tty-unregister-driver \
ksym-longterm-tty-unregister-ldisc \
ksym-longterm-tty-unthrottle \
ksym-longterm-tty-vhangup \
ksym-longterm-tty-wait-until-sent \
ksym-longterm-tty-wakeup \
ksym-longterm-tty-write-room \
ksym-longterm-tua6100-attach \
ksym-longterm-tun-get-socket \
ksym-longterm-tun-get-tx-ring \
ksym-longterm-tun-ptr-free \
ksym-longterm-tuner-count \
ksym-longterm-tuners \
ksym-longterm-tveeprom-hauppauge-analog \
ksym-longterm-tveeprom-read \
ksym-longterm-twofish-setkey \
ksym-longterm-typec-altmode-attention \
ksym-longterm-typec-altmode-enter \
ksym-longterm-typec-altmode-exit \
ksym-longterm-typec-altmode-get-partner \
ksym-longterm-typec-altmode-get-plug \
ksym-longterm-typec-altmode-notify \
ksym-longterm-typec-altmode-put-plug \
ksym-longterm-typec-altmode-set-ops \
ksym-longterm-typec-altmode-unregister-driver \
ksym-longterm-typec-altmode-update-active \
ksym-longterm-typec-altmode-vdm \
ksym-longterm-typec-altmode2port \
ksym-longterm-typec-cable-altmode-enter \
ksym-longterm-typec-cable-altmode-exit \
ksym-longterm-typec-cable-altmode-vdm \
ksym-longterm-typec-cable-get \
ksym-longterm-typec-cable-is-active \
ksym-longterm-typec-cable-put \
ksym-longterm-typec-cable-set-identity \
ksym-longterm-typec-cable-set-svdm-version \
ksym-longterm-typec-find-orientation \
ksym-longterm-typec-find-port-data-role \
ksym-longterm-typec-find-port-power-role \
ksym-longterm-typec-find-power-role \
ksym-longterm-typec-find-pwr-opmode \
ksym-longterm-typec-get-cable-svdm-version \
ksym-longterm-typec-get-drvdata \
ksym-longterm-typec-get-fw-cap \
ksym-longterm-typec-get-negotiated-svdm-version \
ksym-longterm-typec-get-orientation \
ksym-longterm-typec-match-altmode \
ksym-longterm-typec-mux-get-drvdata \
ksym-longterm-typec-mux-put \
ksym-longterm-typec-mux-register \
ksym-longterm-typec-mux-set \
ksym-longterm-typec-mux-set-drvdata \
ksym-longterm-typec-mux-unregister \
ksym-longterm-typec-partner-register-altmode \
ksym-longterm-typec-partner-set-identity \
ksym-longterm-typec-partner-set-num-altmodes \
ksym-longterm-typec-partner-set-pd-revision \
ksym-longterm-typec-partner-set-svdm-version \
ksym-longterm-typec-partner-set-usb-mode \
ksym-longterm-typec-partner-set-usb-power-delivery \
ksym-longterm-typec-partner-usb-power-delivery-register \
ksym-longterm-typec-plug-register-altmode \
ksym-longterm-typec-plug-set-num-altmodes \
ksym-longterm-typec-port-register-altmode \
ksym-longterm-typec-port-register-altmodes \
ksym-longterm-typec-port-register-cable-ops \
ksym-longterm-typec-port-set-usb-mode \
ksym-longterm-typec-port-set-usb-power-delivery \
ksym-longterm-typec-register-cable \
ksym-longterm-typec-register-partner \
ksym-longterm-typec-register-plug \
ksym-longterm-typec-register-port \
ksym-longterm-typec-retimer-get-drvdata \
ksym-longterm-typec-retimer-put \
ksym-longterm-typec-retimer-register \
ksym-longterm-typec-retimer-set \
ksym-longterm-typec-retimer-unregister \
ksym-longterm-typec-set-data-role \
ksym-longterm-typec-set-mode \
ksym-longterm-typec-set-orientation \
ksym-longterm-typec-set-pwr-opmode \
ksym-longterm-typec-set-pwr-role \
ksym-longterm-typec-set-vconn-role \
ksym-longterm-typec-switch-get-drvdata \
ksym-longterm-typec-switch-put \
ksym-longterm-typec-switch-register \
ksym-longterm-typec-switch-set \
ksym-longterm-typec-switch-set-drvdata \
ksym-longterm-typec-switch-unregister \
ksym-longterm-typec-unregister-altmode \
ksym-longterm-typec-unregister-cable \
ksym-longterm-typec-unregister-partner \
ksym-longterm-typec-unregister-plug \
ksym-longterm-typec-unregister-port \
ksym-longterm-u-audio-get-capture-srate \
ksym-longterm-u-audio-get-mute \
ksym-longterm-u-audio-get-playback-srate \
ksym-longterm-u-audio-get-volume \
ksym-longterm-u-audio-set-capture-srate \
ksym-longterm-u-audio-set-mute \
ksym-longterm-u-audio-set-playback-srate \
ksym-longterm-u-audio-set-volume \
ksym-longterm-u-audio-start-capture \
ksym-longterm-u-audio-start-playback \
ksym-longterm-u-audio-stop-capture \
ksym-longterm-u-audio-stop-playback \
ksym-longterm-u-audio-suspend \
ksym-longterm-u-boot-env-parse \
ksym-longterm-uacce-alloc \
ksym-longterm-uacce-register \
ksym-longterm-uacce-remove \
ksym-longterm-uart-add-one-port \
ksym-longterm-uart-console-device \
ksym-longterm-uart-console-write \
ksym-longterm-uart-get-baud-rate \
ksym-longterm-uart-get-divisor \
ksym-longterm-uart-get-rs485-mode \
ksym-longterm-uart-handle-cts-change \
ksym-longterm-uart-handle-dcd-change \
ksym-longterm-uart-insert-char \
ksym-longterm-uart-match-port \
ksym-longterm-uart-parse-earlycon \
ksym-longterm-uart-parse-options \
ksym-longterm-uart-read-and-validate-port-properties \
ksym-longterm-uart-read-port-properties \
ksym-longterm-uart-register-driver \
ksym-longterm-uart-remove-one-port \
ksym-longterm-uart-resume-port \
ksym-longterm-uart-set-options \
ksym-longterm-uart-suspend-port \
ksym-longterm-uart-try-toggle-sysrq \
ksym-longterm-uart-unregister-driver \
ksym-longterm-uart-update-timeout \
ksym-longterm-uart-write-wakeup \
ksym-longterm-uart-xchar-out \
ksym-longterm-ubi-close-volume \
ksym-longterm-ubi-do-get-device-info \
ksym-longterm-ubi-get-device-info \
ksym-longterm-ubi-get-volume-info \
ksym-longterm-ubi-is-mapped \
ksym-longterm-ubi-leb-change \
ksym-longterm-ubi-leb-erase \
ksym-longterm-ubi-leb-map \
ksym-longterm-ubi-leb-read \
ksym-longterm-ubi-leb-read-sg \
ksym-longterm-ubi-leb-unmap \
ksym-longterm-ubi-leb-write \
ksym-longterm-ubi-open-volume \
ksym-longterm-ubi-open-volume-nm \
ksym-longterm-ubi-open-volume-path \
ksym-longterm-ubi-register-volume-notifier \
ksym-longterm-ubi-sync \
ksym-longterm-ubi-unregister-volume-notifier \
ksym-longterm-ucc-fast-disable \
ksym-longterm-ucc-fast-dump-regs \
ksym-longterm-ucc-fast-enable \
ksym-longterm-ucc-fast-free \
ksym-longterm-ucc-fast-get-qe-cr-subblock \
ksym-longterm-ucc-fast-init \
ksym-longterm-ucc-fast-transmit-on-demand \
ksym-longterm-ucc-mux-set-grant-tsa-bkpt \
ksym-longterm-ucc-of-parse-tdm \
ksym-longterm-ucc-set-qe-mux-mii-mng \
ksym-longterm-ucc-tdm-init \
ksym-longterm-ucs2-as-utf8 \
ksym-longterm-ucs2-strlen \
ksym-longterm-ucs2-strncmp \
ksym-longterm-ucs2-strnlen \
ksym-longterm-ucs2-strscpy \
ksym-longterm-ucs2-strsize \
ksym-longterm-ucs2-utf8size \
ksym-longterm-ucsi-connector-change \
ksym-longterm-ucsi-create \
ksym-longterm-ucsi-destroy \
ksym-longterm-ucsi-get-drvdata \
ksym-longterm-ucsi-notify-common \
ksym-longterm-ucsi-register \
ksym-longterm-ucsi-resume \
ksym-longterm-ucsi-send-command \
ksym-longterm-ucsi-set-drvdata \
ksym-longterm-ucsi-suspend \
ksym-longterm-ucsi-sync-control-common \
ksym-longterm-ucsi-unregister \
ksym-longterm-udc-basic-init \
ksym-longterm-udc-enable-dev-setup-interrupts \
ksym-longterm-udc-irq \
ksym-longterm-udc-mask-unused-interrupts \
ksym-longterm-udc-probe \
ksym-longterm-udc-remove \
ksym-longterm-udp-bpf-update-proto \
ksym-longterm-udp-encap-disable \
ksym-longterm-udp-encap-enable \
ksym-longterm-udp-flow-hashrnd \
ksym-longterm-udp-gro-complete \
ksym-longterm-udp-gro-receive \
ksym-longterm-udp-memory-per-cpu-fw-alloc \
ksym-longterm-udp-prot \
ksym-longterm-udp-sendmsg \
ksym-longterm-udp-set-csum \
ksym-longterm-udp-sock-create4 \
ksym-longterm-udp-sock-create6 \
ksym-longterm-udp-tun-rx-dst \
ksym-longterm-udp-tunnel-drop-rx-port \
ksym-longterm-udp-tunnel-dst-lookup \
ksym-longterm-udp-tunnel-nic-ops \
ksym-longterm-udp-tunnel-notify-add-rx-port \
ksym-longterm-udp-tunnel-notify-del-rx-port \
ksym-longterm-udp-tunnel-push-rx-port \
ksym-longterm-udp-tunnel-sock-release \
ksym-longterm-udp-tunnel-update-gro-lookup \
ksym-longterm-udp-tunnel-update-gro-rcv \
ksym-longterm-udp-tunnel-xmit-skb \
ksym-longterm-udp-tunnel6-dst-lookup \
ksym-longterm-udp-tunnel6-xmit-skb \
ksym-longterm-udp4-hwcsum \
ksym-longterm-udp4-lib-lookup \
ksym-longterm-udp6-csum-init \
ksym-longterm-udp6-lib-lookup \
ksym-longterm-udp6-seq-ops \
ksym-longterm-udp6-set-csum \
ksym-longterm-udplite-prot \
ksym-longterm-udplite-table \
ksym-longterm-udpv6-encap-enable \
ksym-longterm-udpv6-sendmsg \
ksym-longterm-ufshcd-alloc-host \
ksym-longterm-ufshcd-auto-hibern8-update \
ksym-longterm-ufshcd-clkgate-delay-set \
ksym-longterm-ufshcd-config-pwr-mode \
ksym-longterm-ufshcd-delay-us \
ksym-longterm-ufshcd-disable-irq \
ksym-longterm-ufshcd-dme-configure-adapt \
ksym-longterm-ufshcd-dme-enable \
ksym-longterm-ufshcd-dme-get-attr \
ksym-longterm-ufshcd-dme-reset \
ksym-longterm-ufshcd-dme-rmw \
ksym-longterm-ufshcd-dme-set-attr \
ksym-longterm-ufshcd-dump-regs \
ksym-longterm-ufshcd-enable-irq \
ksym-longterm-ufshcd-fixup-dev-quirks \
ksym-longterm-ufshcd-force-error-recovery \
ksym-longterm-ufshcd-get-vreg \
ksym-longterm-ufshcd-hba-enable \
ksym-longterm-ufshcd-hba-stop \
ksym-longterm-ufshcd-hold \
ksym-longterm-ufshcd-init \
ksym-longterm-ufshcd-init-host-params \
ksym-longterm-ufshcd-is-hba-active \
ksym-longterm-ufshcd-link-recovery \
ksym-longterm-ufshcd-make-hba-operational \
ksym-longterm-ufshcd-mcq-config-esi \
ksym-longterm-ufshcd-mcq-config-mac \
ksym-longterm-ufshcd-mcq-enable \
ksym-longterm-ufshcd-mcq-enable-esi \
ksym-longterm-ufshcd-mcq-make-queues-operational \
ksym-longterm-ufshcd-mcq-poll-cqe-lock \
ksym-longterm-ufshcd-mcq-queue-cfg-addr \
ksym-longterm-ufshcd-mcq-read-cqis \
ksym-longterm-ufshcd-mcq-write-cqis \
ksym-longterm-ufshcd-negotiate-pwr-params \
ksym-longterm-ufshcd-opp-config-clks \
ksym-longterm-ufshcd-parse-gear-limits \
ksym-longterm-ufshcd-pltfrm-init \
ksym-longterm-ufshcd-pltfrm-remove \
ksym-longterm-ufshcd-populate-vreg \
ksym-longterm-ufshcd-release \
ksym-longterm-ufshcd-remove \
ksym-longterm-ufshcd-resume-complete \
ksym-longterm-ufshcd-runtime-resume \
ksym-longterm-ufshcd-runtime-suspend \
ksym-longterm-ufshcd-suspend-prepare \
ksym-longterm-ufshcd-system-freeze \
ksym-longterm-ufshcd-system-restore \
ksym-longterm-ufshcd-system-resume \
ksym-longterm-ufshcd-system-suspend \
ksym-longterm-ufshcd-system-thaw \
ksym-longterm-ufshcd-uic-change-pwr-mode \
ksym-longterm-ufshcd-uic-hibern8-enter \
ksym-longterm-ufshcd-uic-hibern8-exit \
ksym-longterm-ufshcd-update-evt-hist \
ksym-longterm-uhci-check-and-reset-hc \
ksym-longterm-uhci-reset-hc \
ksym-longterm-uio-event-notify \
ksym-longterm-uio-unregister-device \
ksym-longterm-ulpi-read \
ksym-longterm-ulpi-register-interface \
ksym-longterm-ulpi-unregister-driver \
ksym-longterm-ulpi-unregister-interface \
ksym-longterm-ulpi-viewport-access-ops \
ksym-longterm-ulpi-write \
ksym-longterm-unix-domain-find \
ksym-longterm-unix-inq-len \
ksym-longterm-unix-outq-len \
ksym-longterm-unix-peer-get \
ksym-longterm-unload-nls \
ksym-longterm-unlock-buffer \
ksym-longterm-unlock-new-inode \
ksym-longterm-unlock-page \
ksym-longterm-unlock-rename \
ksym-longterm-unlock-system-sleep \
ksym-longterm-unlock-two-nondirectories \
ksym-longterm-unmap-mapping-pages \
ksym-longterm-unmap-mapping-range \
ksym-longterm-unpack \
ksym-longterm-unpack-fields-u16 \
ksym-longterm-unpack-fields-u8 \
ksym-longterm-unpin-folio \
ksym-longterm-unpin-folios \
ksym-longterm-unpin-user-folio \
ksym-longterm-unpin-user-page \
ksym-longterm-unpin-user-page-range-dirty-lock \
ksym-longterm-unpin-user-pages \
ksym-longterm-unpin-user-pages-dirty-lock \
ksym-longterm-unpoison-memory \
ksym-longterm-unregister-acpi-bus-type \
ksym-longterm-unregister-acpi-hed-notifier \
ksym-longterm-unregister-acpi-notifier \
ksym-longterm-unregister-asymmetric-key-parser \
ksym-longterm-unregister-atmdevice-notifier \
ksym-longterm-unregister-binfmt \
ksym-longterm-unregister-blkdev \
ksym-longterm-unregister-blocking-lsm-notifier \
ksym-longterm-unregister-c-can-dev \
ksym-longterm-unregister-candev \
ksym-longterm-unregister-cdrom \
ksym-longterm-unregister-chrdev-region \
ksym-longterm-unregister-console \
ksym-longterm-unregister-dcbevent-notifier \
ksym-longterm-unregister-die-notifier \
ksym-longterm-unregister-dpll-notifier \
ksym-longterm-unregister-fib-notifier \
ksym-longterm-unregister-filesystem \
ksym-longterm-unregister-firmware-config-sysctl \
ksym-longterm-unregister-framebuffer \
ksym-longterm-unregister-ftrace-direct \
ksym-longterm-unregister-ftrace-export \
ksym-longterm-unregister-ftrace-function \
ksym-longterm-unregister-gadget-item \
ksym-longterm-unregister-hdlc-device \
ksym-longterm-unregister-hdlc-protocol \
ksym-longterm-unregister-hw-breakpoint \
ksym-longterm-unregister-ife-op \
ksym-longterm-unregister-inet6addr-notifier \
ksym-longterm-unregister-inet6addr-validator-notifier \
ksym-longterm-unregister-inetaddr-notifier \
ksym-longterm-unregister-inetaddr-validator-notifier \
ksym-longterm-unregister-ip-vs-app \
ksym-longterm-unregister-ip-vs-pe \
ksym-longterm-unregister-ip-vs-scheduler \
ksym-longterm-unregister-key-type \
ksym-longterm-unregister-keyboard-notifier \
ksym-longterm-unregister-kprobe \
ksym-longterm-unregister-kprobes \
ksym-longterm-unregister-kretprobe \
ksym-longterm-unregister-kretprobes \
ksym-longterm-unregister-md-submodule \
ksym-longterm-unregister-memory-notifier \
ksym-longterm-unregister-module-notifier \
ksym-longterm-unregister-mt-adistance-algorithm \
ksym-longterm-unregister-mtd-chip-driver \
ksym-longterm-unregister-mtd-user \
ksym-longterm-unregister-net-sysctl-table \
ksym-longterm-unregister-netdev \
ksym-longterm-unregister-netdevice-many \
ksym-longterm-unregister-netdevice-notifier \
ksym-longterm-unregister-netdevice-notifier-dev-net \
ksym-longterm-unregister-netdevice-notifier-net \
ksym-longterm-unregister-netdevice-queue \
ksym-longterm-unregister-netevent-notifier \
ksym-longterm-unregister-nexthop-notifier \
ksym-longterm-unregister-nfs-version \
ksym-longterm-unregister-nls \
ksym-longterm-unregister-node-notifier \
ksym-longterm-unregister-nvdimm-pmu \
ksym-longterm-unregister-oom-notifier \
ksym-longterm-unregister-pernet-device \
ksym-longterm-unregister-pernet-subsys \
ksym-longterm-unregister-platform-power-off \
ksym-longterm-unregister-pm-notifier \
ksym-longterm-unregister-pppox-proto \
ksym-longterm-unregister-pstore-device \
ksym-longterm-unregister-pstore-zone \
ksym-longterm-unregister-qdisc \
ksym-longterm-unregister-quota-format \
ksym-longterm-unregister-random-vmfork-notifier \
ksym-longterm-unregister-reboot-notifier \
ksym-longterm-unregister-restart-handler \
ksym-longterm-unregister-rpmsg-driver \
ksym-longterm-unregister-sja1000dev \
ksym-longterm-unregister-snap-client \
ksym-longterm-unregister-sound-dsp \
ksym-longterm-unregister-sound-mixer \
ksym-longterm-unregister-sound-special \
ksym-longterm-unregister-switchdev-blocking-notifier \
ksym-longterm-unregister-switchdev-notifier \
ksym-longterm-unregister-sys-off-handler \
ksym-longterm-unregister-syscore-ops \
ksym-longterm-unregister-sysctl-table \
ksym-longterm-unregister-sysrq-key \
ksym-longterm-unregister-tcf-proto-ops \
ksym-longterm-unregister-trace-event \
ksym-longterm-unregister-tracepoint-module-notifier \
ksym-longterm-unregister-virtio-device \
ksym-longterm-unregister-virtio-driver \
ksym-longterm-unregister-vmap-purge-notifier \
ksym-longterm-unregister-vmcore-cb \
ksym-longterm-unregister-vt-notifier \
ksym-longterm-unregister-wide-hw-breakpoint \
ksym-longterm-unshare-fs-struct \
ksym-longterm-up \
ksym-longterm-up-read \
ksym-longterm-up-write \
ksym-longterm-update-devfreq \
ksym-longterm-update-region \
ksym-longterm-uprobe-register \
ksym-longterm-uprobe-unregister-nosync \
ksym-longterm-uprobe-unregister-sync \
ksym-longterm-usb-acpi-port-lpm-incapable \
ksym-longterm-usb-acpi-power-manageable \
ksym-longterm-usb-acpi-set-power-state \
ksym-longterm-usb-add-config \
ksym-longterm-usb-add-config-only \
ksym-longterm-usb-add-function \
ksym-longterm-usb-add-gadget \
ksym-longterm-usb-add-gadget-udc \
ksym-longterm-usb-add-gadget-udc-release \
ksym-longterm-usb-add-hcd \
ksym-longterm-usb-add-phy \
ksym-longterm-usb-add-phy-dev \
ksym-longterm-usb-alloc-coherent \
ksym-longterm-usb-alloc-dev \
ksym-longterm-usb-alloc-noncoherent \
ksym-longterm-usb-alloc-streams \
ksym-longterm-usb-alloc-urb \
ksym-longterm-usb-altnum-to-altsetting \
ksym-longterm-usb-amd-dev-put \
ksym-longterm-usb-amd-hang-symptom-quirk \
ksym-longterm-usb-amd-prefetch-quirk \
ksym-longterm-usb-amd-pt-check-port \
ksym-longterm-usb-amd-quirk-pll-check \
ksym-longterm-usb-amd-quirk-pll-disable \
ksym-longterm-usb-amd-quirk-pll-enable \
ksym-longterm-usb-anchor-empty \
ksym-longterm-usb-anchor-resume-wakeups \
ksym-longterm-usb-anchor-suspend-wakeups \
ksym-longterm-usb-anchor-urb \
ksym-longterm-usb-asmedia-modifyflowcontrol \
ksym-longterm-usb-assign-descriptors \
ksym-longterm-usb-autopm-get-interface \
ksym-longterm-usb-autopm-get-interface-async \
ksym-longterm-usb-autopm-get-interface-no-resume \
ksym-longterm-usb-autopm-put-interface \
ksym-longterm-usb-autopm-put-interface-async \
ksym-longterm-usb-autopm-put-interface-no-suspend \
ksym-longterm-usb-block-urb \
ksym-longterm-usb-bulk-msg \
ksym-longterm-usb-bulk-msg-killable \
ksym-longterm-usb-bus-idr \
ksym-longterm-usb-bus-idr-lock \
ksym-longterm-usb-bus-start-enum \
ksym-longterm-usb-cache-string \
ksym-longterm-usb-calc-bus-time \
ksym-longterm-usb-cdc-wdm-register \
ksym-longterm-usb-check-bulk-endpoints \
ksym-longterm-usb-check-int-endpoints \
ksym-longterm-usb-choose-configuration \
ksym-longterm-usb-clear-halt \
ksym-longterm-usb-composite-overwrite-options \
ksym-longterm-usb-composite-probe \
ksym-longterm-usb-composite-setup-continue \
ksym-longterm-usb-composite-unregister \
ksym-longterm-usb-control-msg \
ksym-longterm-usb-control-msg-recv \
ksym-longterm-usb-control-msg-send \
ksym-longterm-usb-copy-descriptors \
ksym-longterm-usb-create-hcd \
ksym-longterm-usb-create-shared-hcd \
ksym-longterm-usb-cypress-load-firmware \
ksym-longterm-usb-debug-root \
ksym-longterm-usb-decode-ctrl \
ksym-longterm-usb-decode-interval \
ksym-longterm-usb-del-gadget \
ksym-longterm-usb-del-gadget-udc \
ksym-longterm-usb-deregister \
ksym-longterm-usb-deregister-dev \
ksym-longterm-usb-deregister-device-driver \
ksym-longterm-usb-descriptor-fillbuf \
ksym-longterm-usb-device-match-id \
ksym-longterm-usb-disable-autosuspend \
ksym-longterm-usb-disable-lpm \
ksym-longterm-usb-disable-ltm \
ksym-longterm-usb-disable-xhci-ports \
ksym-longterm-usb-disabled \
ksym-longterm-usb-driver-claim-interface \
ksym-longterm-usb-driver-release-interface \
ksym-longterm-usb-driver-set-configuration \
ksym-longterm-usb-dynids-lock \
ksym-longterm-usb-enable-autosuspend \
ksym-longterm-usb-enable-intel-xhci-ports \
ksym-longterm-usb-enable-lpm \
ksym-longterm-usb-enable-ltm \
ksym-longterm-usb-endpoint-is-hs-isoc-double \
ksym-longterm-usb-endpoint-max-periodic-payload \
ksym-longterm-usb-ep-alloc-request \
ksym-longterm-usb-ep-autoconfig \
ksym-longterm-usb-ep-autoconfig-release \
ksym-longterm-usb-ep-autoconfig-reset \
ksym-longterm-usb-ep-autoconfig-ss \
ksym-longterm-usb-ep-clear-halt \
ksym-longterm-usb-ep-dequeue \
ksym-longterm-usb-ep-disable \
ksym-longterm-usb-ep-enable \
ksym-longterm-usb-ep-fifo-flush \
ksym-longterm-usb-ep-fifo-status \
ksym-longterm-usb-ep-free-request \
ksym-longterm-usb-ep-queue \
ksym-longterm-usb-ep-set-halt \
ksym-longterm-usb-ep-set-maxpacket-limit \
ksym-longterm-usb-ep-set-wedge \
ksym-longterm-usb-ep-type-string \
ksym-longterm-usb-ep0-reinit \
ksym-longterm-usb-find-alt-setting \
ksym-longterm-usb-find-common-endpoints \
ksym-longterm-usb-find-common-endpoints-reverse \
ksym-longterm-usb-find-interface \
ksym-longterm-usb-for-each-dev \
ksym-longterm-usb-free-all-descriptors \
ksym-longterm-usb-free-coherent \
ksym-longterm-usb-free-noncoherent \
ksym-longterm-usb-free-streams \
ksym-longterm-usb-free-urb \
ksym-longterm-usb-func-wakeup \
ksym-longterm-usb-function-activate \
ksym-longterm-usb-function-deactivate \
ksym-longterm-usb-function-register \
ksym-longterm-usb-function-unregister \
ksym-longterm-usb-gadget-activate \
ksym-longterm-usb-gadget-check-config \
ksym-longterm-usb-gadget-clear-selfpowered \
ksym-longterm-usb-gadget-connect \
ksym-longterm-usb-gadget-deactivate \
ksym-longterm-usb-gadget-disconnect \
ksym-longterm-usb-gadget-ep-match-desc \
ksym-longterm-usb-gadget-frame-number \
ksym-longterm-usb-gadget-get-string \
ksym-longterm-usb-gadget-giveback-request \
ksym-longterm-usb-gadget-map-request \
ksym-longterm-usb-gadget-map-request-by-dev \
ksym-longterm-usb-gadget-register-driver-owner \
ksym-longterm-usb-gadget-set-remote-wakeup \
ksym-longterm-usb-gadget-set-selfpowered \
ksym-longterm-usb-gadget-set-state \
ksym-longterm-usb-gadget-udc-reset \
ksym-longterm-usb-gadget-unmap-request \
ksym-longterm-usb-gadget-unmap-request-by-dev \
ksym-longterm-usb-gadget-unregister-driver \
ksym-longterm-usb-gadget-vbus-connect \
ksym-longterm-usb-gadget-vbus-disconnect \
ksym-longterm-usb-gadget-vbus-draw \
ksym-longterm-usb-gadget-wakeup \
ksym-longterm-usb-gen-phy-init \
ksym-longterm-usb-gen-phy-shutdown \
ksym-longterm-usb-get-current-frame-number \
ksym-longterm-usb-get-descriptor \
ksym-longterm-usb-get-dev \
ksym-longterm-usb-get-dr-mode \
ksym-longterm-usb-get-from-anchor \
ksym-longterm-usb-get-function \
ksym-longterm-usb-get-function-instance \
ksym-longterm-usb-get-gadget-udc-name \
ksym-longterm-usb-get-hcd \
ksym-longterm-usb-get-intf \
ksym-longterm-usb-get-maximum-speed \
ksym-longterm-usb-get-maximum-ssp-rate \
ksym-longterm-usb-get-phy \
ksym-longterm-usb-get-role-switch-default-mode \
ksym-longterm-usb-get-status \
ksym-longterm-usb-get-urb \
ksym-longterm-usb-gstrings-attach \
ksym-longterm-usb-hc-died \
ksym-longterm-usb-hcd-amd-remote-wakeup-quirk \
ksym-longterm-usb-hcd-check-unlink-urb \
ksym-longterm-usb-hcd-end-port-resume \
ksym-longterm-usb-hcd-giveback-urb \
ksym-longterm-usb-hcd-irq \
ksym-longterm-usb-hcd-is-primary-hcd \
ksym-longterm-usb-hcd-link-urb-to-ep \
ksym-longterm-usb-hcd-map-urb-for-dma \
ksym-longterm-usb-hcd-pci-pm-ops \
ksym-longterm-usb-hcd-pci-probe \
ksym-longterm-usb-hcd-pci-remove \
ksym-longterm-usb-hcd-pci-shutdown \
ksym-longterm-usb-hcd-platform-shutdown \
ksym-longterm-usb-hcd-poll-rh-status \
ksym-longterm-usb-hcd-resume-root-hub \
ksym-longterm-usb-hcd-setup-local-mem \
ksym-longterm-usb-hcd-start-port-resume \
ksym-longterm-usb-hcd-unlink-urb-from-ep \
ksym-longterm-usb-hcd-unmap-urb-for-dma \
ksym-longterm-usb-hcd-unmap-urb-setup-for-dma \
ksym-longterm-usb-hcds-loaded \
ksym-longterm-usb-hub-claim-port \
ksym-longterm-usb-hub-clear-tt-buffer \
ksym-longterm-usb-hub-find-child \
ksym-longterm-usb-hub-release-port \
ksym-longterm-usb-ifnum-to-if \
ksym-longterm-usb-init-urb \
ksym-longterm-usb-initialize-gadget \
ksym-longterm-usb-interface-id \
ksym-longterm-usb-interrupt-msg \
ksym-longterm-usb-intf-get-dma-device \
ksym-longterm-usb-kill-anchored-urbs \
ksym-longterm-usb-kill-urb \
ksym-longterm-usb-led-activity \
ksym-longterm-usb-lock-device-for-reset \
ksym-longterm-usb-match-id \
ksym-longterm-usb-match-one-id \
ksym-longterm-usb-mon-deregister \
ksym-longterm-usb-mon-register \
ksym-longterm-usb-of-get-companion-dev \
ksym-longterm-usb-of-get-connect-type \
ksym-longterm-usb-of-get-device-node \
ksym-longterm-usb-of-get-interface-node \
ksym-longterm-usb-of-has-combined-node \
ksym-longterm-usb-offload-check \
ksym-longterm-usb-offload-get \
ksym-longterm-usb-offload-put \
ksym-longterm-usb-offload-set-pm-locked \
ksym-longterm-usb-os-desc-prepare-interf-dir \
ksym-longterm-usb-otg-descriptor-alloc \
ksym-longterm-usb-otg-descriptor-init \
ksym-longterm-usb-otg-state-string \
ksym-longterm-usb-phy-gen-create-phy \
ksym-longterm-usb-phy-generic-register \
ksym-longterm-usb-phy-generic-unregister \
ksym-longterm-usb-phy-get-charger-current \
ksym-longterm-usb-phy-roothub-alloc \
ksym-longterm-usb-phy-roothub-alloc-usb3-phy \
ksym-longterm-usb-phy-roothub-calibrate \
ksym-longterm-usb-phy-roothub-exit \
ksym-longterm-usb-phy-roothub-init \
ksym-longterm-usb-phy-roothub-notify-connect \
ksym-longterm-usb-phy-roothub-notify-disconnect \
ksym-longterm-usb-phy-roothub-power-off \
ksym-longterm-usb-phy-roothub-power-on \
ksym-longterm-usb-phy-roothub-resume \
ksym-longterm-usb-phy-roothub-set-mode \
ksym-longterm-usb-phy-roothub-suspend \
ksym-longterm-usb-phy-set-charger-current \
ksym-longterm-usb-phy-set-charger-state \
ksym-longterm-usb-phy-set-event \
ksym-longterm-usb-pipe-type-check \
ksym-longterm-usb-poison-anchored-urbs \
ksym-longterm-usb-poison-urb \
ksym-longterm-usb-power-delivery-link-device \
ksym-longterm-usb-power-delivery-register \
ksym-longterm-usb-power-delivery-register-capabilities \
ksym-longterm-usb-power-delivery-unlink-device \
ksym-longterm-usb-power-delivery-unregister \
ksym-longterm-usb-power-delivery-unregister-capabilities \
ksym-longterm-usb-put-dev \
ksym-longterm-usb-put-function \
ksym-longterm-usb-put-function-instance \
ksym-longterm-usb-put-hcd \
ksym-longterm-usb-put-intf \
ksym-longterm-usb-put-phy \
ksym-longterm-usb-queue-reset-device \
ksym-longterm-usb-register-dev \
ksym-longterm-usb-register-device-driver \
ksym-longterm-usb-register-driver \
ksym-longterm-usb-register-notify \
ksym-longterm-usb-remove-function \
ksym-longterm-usb-remove-hcd \
ksym-longterm-usb-remove-phy \
ksym-longterm-usb-reset-configuration \
ksym-longterm-usb-reset-device \
ksym-longterm-usb-reset-endpoint \
ksym-longterm-usb-role-string \
ksym-longterm-usb-role-switch-find-by-fwnode \
ksym-longterm-usb-role-switch-get \
ksym-longterm-usb-role-switch-get-drvdata \
ksym-longterm-usb-role-switch-get-role \
ksym-longterm-usb-role-switch-put \
ksym-longterm-usb-role-switch-register \
ksym-longterm-usb-role-switch-set-drvdata \
ksym-longterm-usb-role-switch-set-role \
ksym-longterm-usb-role-switch-unregister \
ksym-longterm-usb-root-hub-lost-power \
ksym-longterm-usb-scuttle-anchored-urbs \
ksym-longterm-usb-serial-claim-interface \
ksym-longterm-usb-serial-deregister-drivers \
ksym-longterm-usb-serial-generic-chars-in-buffer \
ksym-longterm-usb-serial-generic-close \
ksym-longterm-usb-serial-generic-get-icount \
ksym-longterm-usb-serial-generic-open \
ksym-longterm-usb-serial-generic-process-read-urb \
ksym-longterm-usb-serial-generic-read-bulk-callback \
ksym-longterm-usb-serial-generic-resume \
ksym-longterm-usb-serial-generic-submit-read-urbs \
ksym-longterm-usb-serial-generic-throttle \
ksym-longterm-usb-serial-generic-tiocmiwait \
ksym-longterm-usb-serial-generic-unthrottle \
ksym-longterm-usb-serial-generic-wait-until-sent \
ksym-longterm-usb-serial-generic-write \
ksym-longterm-usb-serial-generic-write-bulk-callback \
ksym-longterm-usb-serial-generic-write-start \
ksym-longterm-usb-serial-handle-dcd-change \
ksym-longterm-usb-serial-port-softint \
ksym-longterm-usb-serial-resume \
ksym-longterm-usb-serial-suspend \
ksym-longterm-usb-set-configuration \
ksym-longterm-usb-set-device-state \
ksym-longterm-usb-set-interface \
ksym-longterm-usb-set-wireless-status \
ksym-longterm-usb-sg-cancel \
ksym-longterm-usb-sg-init \
ksym-longterm-usb-sg-wait \
ksym-longterm-usb-show-dynids \
ksym-longterm-usb-speed-string \
ksym-longterm-usb-state-string \
ksym-longterm-usb-stor-Bulk-reset \
ksym-longterm-usb-stor-Bulk-transport \
ksym-longterm-usb-stor-CB-reset \
ksym-longterm-usb-stor-CB-transport \
ksym-longterm-usb-stor-access-xfer-buf \
ksym-longterm-usb-stor-adjust-quirks \
ksym-longterm-usb-stor-bulk-srb \
ksym-longterm-usb-stor-bulk-transfer-buf \
ksym-longterm-usb-stor-bulk-transfer-sg \
ksym-longterm-usb-stor-clear-halt \
ksym-longterm-usb-stor-control-msg \
ksym-longterm-usb-stor-ctrl-transfer \
ksym-longterm-usb-stor-disconnect \
ksym-longterm-usb-stor-host-template-init \
ksym-longterm-usb-stor-post-reset \
ksym-longterm-usb-stor-pre-reset \
ksym-longterm-usb-stor-probe1 \
ksym-longterm-usb-stor-probe2 \
ksym-longterm-usb-stor-reset-resume \
ksym-longterm-usb-stor-resume \
ksym-longterm-usb-stor-sense-invalidCDB \
ksym-longterm-usb-stor-set-xfer-buf \
ksym-longterm-usb-stor-suspend \
ksym-longterm-usb-stor-transparent-scsi-command \
ksym-longterm-usb-store-new-id \
ksym-longterm-usb-string \
ksym-longterm-usb-string-id \
ksym-longterm-usb-string-ids-n \
ksym-longterm-usb-string-ids-tab \
ksym-longterm-usb-submit-urb \
ksym-longterm-usb-udc-vbus-handler \
ksym-longterm-usb-unanchor-urb \
ksym-longterm-usb-unlink-urb \
ksym-longterm-usb-unlocked-disable-lpm \
ksym-longterm-usb-unlocked-enable-lpm \
ksym-longterm-usb-unpoison-anchored-urbs \
ksym-longterm-usb-unpoison-urb \
ksym-longterm-usb-unregister-notify \
ksym-longterm-usb-urb-ep-type-check \
ksym-longterm-usb-validate-langid \
ksym-longterm-usb-wait-anchor-empty-timeout \
ksym-longterm-usb-wakeup-enabled-descendants \
ksym-longterm-usb-wakeup-notification \
ksym-longterm-usb-wwan-chars-in-buffer \
ksym-longterm-usb-wwan-close \
ksym-longterm-usb-wwan-dtr-rts \
ksym-longterm-usb-wwan-open \
ksym-longterm-usb-wwan-port-probe \
ksym-longterm-usb-wwan-port-remove \
ksym-longterm-usb-wwan-resume \
ksym-longterm-usb-wwan-suspend \
ksym-longterm-usb-wwan-tiocmget \
ksym-longterm-usb-wwan-tiocmset \
ksym-longterm-usb-wwan-write \
ksym-longterm-usb-wwan-write-room \
ksym-longterm-usb4-usb3-port-match \
ksym-longterm-usbatm-usb-disconnect \
ksym-longterm-usbatm-usb-probe \
ksym-longterm-usbip-alloc-iso-desc-pdu \
ksym-longterm-usbip-debug-flag \
ksym-longterm-usbip-dump-header \
ksym-longterm-usbip-dump-urb \
ksym-longterm-usbip-event-add \
ksym-longterm-usbip-event-happened \
ksym-longterm-usbip-header-correct-endian \
ksym-longterm-usbip-in-eh \
ksym-longterm-usbip-pack-pdu \
ksym-longterm-usbip-pad-iso \
ksym-longterm-usbip-recv \
ksym-longterm-usbip-recv-iso \
ksym-longterm-usbip-recv-xbuff \
ksym-longterm-usbip-start-eh \
ksym-longterm-usbip-stop-eh \
ksym-longterm-usbnet-cdc-bind \
ksym-longterm-usbnet-cdc-status \
ksym-longterm-usbnet-cdc-unbind \
ksym-longterm-usbnet-cdc-update-filter \
ksym-longterm-usbnet-cdc-zte-rx-fixup \
ksym-longterm-usbnet-change-mtu \
ksym-longterm-usbnet-defer-kevent \
ksym-longterm-usbnet-device-suggests-idle \
ksym-longterm-usbnet-disconnect \
ksym-longterm-usbnet-ether-cdc-bind \
ksym-longterm-usbnet-generic-cdc-bind \
ksym-longterm-usbnet-get-drvinfo \
ksym-longterm-usbnet-get-endpoints \
ksym-longterm-usbnet-get-ethernet-addr \
ksym-longterm-usbnet-get-link \
ksym-longterm-usbnet-get-link-ksettings-internal \
ksym-longterm-usbnet-get-link-ksettings-mii \
ksym-longterm-usbnet-get-msglevel \
ksym-longterm-usbnet-link-change \
ksym-longterm-usbnet-manage-power \
ksym-longterm-usbnet-nway-reset \
ksym-longterm-usbnet-open \
ksym-longterm-usbnet-pause-rx \
ksym-longterm-usbnet-probe \
ksym-longterm-usbnet-purge-paused-rxq \
ksym-longterm-usbnet-read-cmd \
ksym-longterm-usbnet-read-cmd-nopm \
ksym-longterm-usbnet-resume \
ksym-longterm-usbnet-resume-rx \
ksym-longterm-usbnet-set-link-ksettings-mii \
ksym-longterm-usbnet-set-msglevel \
ksym-longterm-usbnet-set-rx-mode \
ksym-longterm-usbnet-skb-return \
ksym-longterm-usbnet-start-xmit \
ksym-longterm-usbnet-status-start \
ksym-longterm-usbnet-status-stop \
ksym-longterm-usbnet-stop \
ksym-longterm-usbnet-suspend \
ksym-longterm-usbnet-tx-timeout \
ksym-longterm-usbnet-unlink-rx-urbs \
ksym-longterm-usbnet-update-max-qlen \
ksym-longterm-usbnet-write-cmd \
ksym-longterm-usbnet-write-cmd-async \
ksym-longterm-usbnet-write-cmd-nopm \
ksym-longterm-user-describe \
ksym-longterm-user-destroy \
ksym-longterm-user-free-preparse \
ksym-longterm-user-path-at \
ksym-longterm-user-preparse \
ksym-longterm-user-read \
ksym-longterm-user-revoke \
ksym-longterm-user-update \
ksym-longterm-usermodehelper-read-lock-wait \
ksym-longterm-usermodehelper-read-trylock \
ksym-longterm-usermodehelper-read-unlock \
ksym-longterm-usleep-range-state \
ksym-longterm-utf16s-to-utf8s \
ksym-longterm-utf32-to-utf8 \
ksym-longterm-utf8-casefold \
ksym-longterm-utf8-casefold-hash \
ksym-longterm-utf8-data-table \
ksym-longterm-utf8-load \
ksym-longterm-utf8-normalize \
ksym-longterm-utf8-parse-version \
ksym-longterm-utf8-strncasecmp \
ksym-longterm-utf8-strncasecmp-folded \
ksym-longterm-utf8-strncmp \
ksym-longterm-utf8-to-utf32 \
ksym-longterm-utf8-unload \
ksym-longterm-utf8-validate \
ksym-longterm-utf8s-to-utf16s \
ksym-longterm-uuid-gen \
ksym-longterm-uuid-is-valid \
ksym-longterm-uuid-null \
ksym-longterm-uuid-parse \
ksym-longterm-uvc-format-by-guid \
ksym-longterm-uverbs-copy-to \
ksym-longterm-uverbs-copy-to-struct-or-zero \
ksym-longterm-uverbs-destroy-def-handler \
ksym-longterm-uverbs-fd-class \
ksym-longterm-uverbs-finalize-uobj-create \
ksym-longterm-uverbs-get-flags32 \
ksym-longterm-uverbs-get-flags64 \
ksym-longterm-uverbs-idr-class \
ksym-longterm-uverbs-try-lock-object \
ksym-longterm-uverbs-uobject-fd-release \
ksym-longterm-uverbs-uobject-put \
ksym-longterm-v4l-bound-align-image \
ksym-longterm-v4l-disable-media-source \
ksym-longterm-v4l-enable-media-source \
ksym-longterm-v4l-printk-ioctl \
ksym-longterm-v4l-vb2q-enable-media-source \
ksym-longterm-v4l2-apply-frmsize-constraints \
ksym-longterm-v4l2-async-connection-unique \
ksym-longterm-v4l2-async-nf-cleanup \
ksym-longterm-v4l2-async-nf-init \
ksym-longterm-v4l2-async-nf-register \
ksym-longterm-v4l2-async-nf-unregister \
ksym-longterm-v4l2-async-subdev-endpoint-add \
ksym-longterm-v4l2-async-subdev-nf-init \
ksym-longterm-v4l2-async-unregister-subdev \
ksym-longterm-v4l2-calc-aspect-ratio \
ksym-longterm-v4l2-calc-timeperframe \
ksym-longterm-v4l2-compat-ioctl32 \
ksym-longterm-v4l2-create-fwnode-links \
ksym-longterm-v4l2-create-fwnode-links-to-pad \
ksym-longterm-v4l2-ctrl-activate \
ksym-longterm-v4l2-ctrl-add-handler \
ksym-longterm-v4l2-ctrl-auto-cluster \
ksym-longterm-v4l2-ctrl-cluster \
ksym-longterm-v4l2-ctrl-fill \
ksym-longterm-v4l2-ctrl-find \
ksym-longterm-v4l2-ctrl-g-ctrl \
ksym-longterm-v4l2-ctrl-g-ctrl-int64 \
ksym-longterm-v4l2-ctrl-get-int-menu \
ksym-longterm-v4l2-ctrl-get-menu \
ksym-longterm-v4l2-ctrl-get-name \
ksym-longterm-v4l2-ctrl-handler-free \
ksym-longterm-v4l2-ctrl-handler-init-class \
ksym-longterm-v4l2-ctrl-handler-log-status \
ksym-longterm-v4l2-ctrl-handler-setup \
ksym-longterm-v4l2-ctrl-log-status \
ksym-longterm-v4l2-ctrl-merge \
ksym-longterm-v4l2-ctrl-new-custom \
ksym-longterm-v4l2-ctrl-new-fwnode-properties \
ksym-longterm-v4l2-ctrl-new-int-menu \
ksym-longterm-v4l2-ctrl-new-std \
ksym-longterm-v4l2-ctrl-new-std-compound \
ksym-longterm-v4l2-ctrl-new-std-menu \
ksym-longterm-v4l2-ctrl-new-std-menu-items \
ksym-longterm-v4l2-ctrl-notify \
ksym-longterm-v4l2-ctrl-poll \
ksym-longterm-v4l2-ctrl-query-fill \
ksym-longterm-v4l2-ctrl-radio-filter \
ksym-longterm-v4l2-ctrl-replace \
ksym-longterm-v4l2-ctrl-request-complete \
ksym-longterm-v4l2-ctrl-request-hdl-ctrl-find \
ksym-longterm-v4l2-ctrl-request-hdl-find \
ksym-longterm-v4l2-ctrl-request-setup \
ksym-longterm-v4l2-ctrl-sub-ev-ops \
ksym-longterm-v4l2-ctrl-subdev-log-status \
ksym-longterm-v4l2-ctrl-subdev-subscribe-event \
ksym-longterm-v4l2-ctrl-subscribe-event \
ksym-longterm-v4l2-ctrl-type-op-equal \
ksym-longterm-v4l2-ctrl-type-op-init \
ksym-longterm-v4l2-ctrl-type-op-log \
ksym-longterm-v4l2-ctrl-type-op-validate \
ksym-longterm-v4l2-debugfs-if-alloc \
ksym-longterm-v4l2-debugfs-if-free \
ksym-longterm-v4l2-debugfs-root \
ksym-longterm-v4l2-detect-cvt \
ksym-longterm-v4l2-detect-gtf \
ksym-longterm-v4l2-device-disconnect \
ksym-longterm-v4l2-device-put \
ksym-longterm-v4l2-device-register \
ksym-longterm-v4l2-device-set-name \
ksym-longterm-v4l2-device-unregister \
ksym-longterm-v4l2-device-unregister-subdev \
ksym-longterm-v4l2-dv-timings-aspect-ratio \
ksym-longterm-v4l2-dv-timings-presets \
ksym-longterm-v4l2-enum-dv-timings-cap \
ksym-longterm-v4l2-event-dequeue \
ksym-longterm-v4l2-event-pending \
ksym-longterm-v4l2-event-queue \
ksym-longterm-v4l2-event-queue-fh \
ksym-longterm-v4l2-event-subdev-unsubscribe \
ksym-longterm-v4l2-event-subscribe \
ksym-longterm-v4l2-event-unsubscribe \
ksym-longterm-v4l2-event-unsubscribe-all \
ksym-longterm-v4l2-event-wake-all \
ksym-longterm-v4l2-fh-add \
ksym-longterm-v4l2-fh-del \
ksym-longterm-v4l2-fh-exit \
ksym-longterm-v4l2-fh-init \
ksym-longterm-v4l2-fh-is-singular \
ksym-longterm-v4l2-fh-open \
ksym-longterm-v4l2-fh-release \
ksym-longterm-v4l2-field-names \
ksym-longterm-v4l2-fill-pixfmt \
ksym-longterm-v4l2-fill-pixfmt-mp \
ksym-longterm-v4l2-find-dv-timings-cap \
ksym-longterm-v4l2-find-dv-timings-cea861-vic \
ksym-longterm-v4l2-format-info \
ksym-longterm-v4l2-fraction-to-interval \
ksym-longterm-v4l2-fwnode-connector-add-link \
ksym-longterm-v4l2-fwnode-connector-free \
ksym-longterm-v4l2-fwnode-connector-parse \
ksym-longterm-v4l2-fwnode-device-parse \
ksym-longterm-v4l2-fwnode-endpoint-alloc-parse \
ksym-longterm-v4l2-fwnode-endpoint-free \
ksym-longterm-v4l2-fwnode-endpoint-parse \
ksym-longterm-v4l2-fwnode-parse-link \
ksym-longterm-v4l2-fwnode-put-link \
ksym-longterm-v4l2-g-ctrl \
ksym-longterm-v4l2-g-ext-ctrls \
ksym-longterm-v4l2-g-parm-cap \
ksym-longterm-v4l2-get-edid-phys-addr \
ksym-longterm-v4l2-get-link-freq \
ksym-longterm-v4l2-h264-build-b-ref-lists \
ksym-longterm-v4l2-h264-build-p-ref-list \
ksym-longterm-v4l2-h264-init-reflist-builder \
ksym-longterm-v4l2-hdmi-rx-colorimetry \
ksym-longterm-v4l2-i2c-new-subdev \
ksym-longterm-v4l2-i2c-new-subdev-board \
ksym-longterm-v4l2-i2c-subdev-addr \
ksym-longterm-v4l2-i2c-subdev-init \
ksym-longterm-v4l2-i2c-subdev-set-name \
ksym-longterm-v4l2-i2c-tuner-addrs \
ksym-longterm-v4l2-jpeg-parse-header \
ksym-longterm-v4l2-jpeg-ref-table-chroma-ac-ht \
ksym-longterm-v4l2-jpeg-ref-table-chroma-dc-ht \
ksym-longterm-v4l2-jpeg-ref-table-chroma-qt \
ksym-longterm-v4l2-jpeg-ref-table-luma-ac-ht \
ksym-longterm-v4l2-jpeg-ref-table-luma-dc-ht \
ksym-longterm-v4l2-jpeg-ref-table-luma-qt \
ksym-longterm-v4l2-jpeg-zigzag-scan-index \
ksym-longterm-v4l2-link-freq-to-bitmap \
ksym-longterm-v4l2-m2m-buf-copy-metadata \
ksym-longterm-v4l2-m2m-buf-done-and-job-finish \
ksym-longterm-v4l2-m2m-buf-queue \
ksym-longterm-v4l2-m2m-buf-remove \
ksym-longterm-v4l2-m2m-buf-remove-by-buf \
ksym-longterm-v4l2-m2m-buf-remove-by-idx \
ksym-longterm-v4l2-m2m-create-bufs \
ksym-longterm-v4l2-m2m-ctx-init \
ksym-longterm-v4l2-m2m-ctx-release \
ksym-longterm-v4l2-m2m-decoder-cmd \
ksym-longterm-v4l2-m2m-dqbuf \
ksym-longterm-v4l2-m2m-encoder-cmd \
ksym-longterm-v4l2-m2m-expbuf \
ksym-longterm-v4l2-m2m-fop-mmap \
ksym-longterm-v4l2-m2m-fop-poll \
ksym-longterm-v4l2-m2m-get-curr-priv \
ksym-longterm-v4l2-m2m-get-vq \
ksym-longterm-v4l2-m2m-init \
ksym-longterm-v4l2-m2m-ioctl-create-bufs \
ksym-longterm-v4l2-m2m-ioctl-decoder-cmd \
ksym-longterm-v4l2-m2m-ioctl-dqbuf \
ksym-longterm-v4l2-m2m-ioctl-encoder-cmd \
ksym-longterm-v4l2-m2m-ioctl-expbuf \
ksym-longterm-v4l2-m2m-ioctl-prepare-buf \
ksym-longterm-v4l2-m2m-ioctl-qbuf \
ksym-longterm-v4l2-m2m-ioctl-querybuf \
ksym-longterm-v4l2-m2m-ioctl-remove-bufs \
ksym-longterm-v4l2-m2m-ioctl-reqbufs \
ksym-longterm-v4l2-m2m-ioctl-stateless-decoder-cmd \
ksym-longterm-v4l2-m2m-ioctl-stateless-try-decoder-cmd \
ksym-longterm-v4l2-m2m-ioctl-streamoff \
ksym-longterm-v4l2-m2m-ioctl-streamon \
ksym-longterm-v4l2-m2m-ioctl-try-decoder-cmd \
ksym-longterm-v4l2-m2m-ioctl-try-encoder-cmd \
ksym-longterm-v4l2-m2m-job-finish \
ksym-longterm-v4l2-m2m-last-buf \
ksym-longterm-v4l2-m2m-last-buffer-done \
ksym-longterm-v4l2-m2m-mmap \
ksym-longterm-v4l2-m2m-next-buf \
ksym-longterm-v4l2-m2m-poll \
ksym-longterm-v4l2-m2m-prepare-buf \
ksym-longterm-v4l2-m2m-qbuf \
ksym-longterm-v4l2-m2m-querybuf \
ksym-longterm-v4l2-m2m-register-media-controller \
ksym-longterm-v4l2-m2m-release \
ksym-longterm-v4l2-m2m-reqbufs \
ksym-longterm-v4l2-m2m-request-queue \
ksym-longterm-v4l2-m2m-resume \
ksym-longterm-v4l2-m2m-streamoff \
ksym-longterm-v4l2-m2m-streamon \
ksym-longterm-v4l2-m2m-suspend \
ksym-longterm-v4l2-m2m-try-schedule \
ksym-longterm-v4l2-m2m-unregister-media-controller \
ksym-longterm-v4l2-m2m-update-start-streaming-state \
ksym-longterm-v4l2-m2m-update-stop-streaming-state \
ksym-longterm-v4l2-match-dv-timings \
ksym-longterm-v4l2-mc-create-media-graph \
ksym-longterm-v4l2-norm-to-name \
ksym-longterm-v4l2-num-edid-blocks \
ksym-longterm-v4l2-phys-addr-for-input \
ksym-longterm-v4l2-phys-addr-validate \
ksym-longterm-v4l2-pipeline-link-notify \
ksym-longterm-v4l2-pipeline-pm-get \
ksym-longterm-v4l2-pipeline-pm-put \
ksym-longterm-v4l2-print-dv-timings \
ksym-longterm-v4l2-prio-change \
ksym-longterm-v4l2-prio-check \
ksym-longterm-v4l2-prio-close \
ksym-longterm-v4l2-prio-init \
ksym-longterm-v4l2-prio-max \
ksym-longterm-v4l2-prio-open \
ksym-longterm-v4l2-query-ext-ctrl \
ksym-longterm-v4l2-query-ext-ctrl-to-v4l2-queryctrl \
ksym-longterm-v4l2-queryctrl \
ksym-longterm-v4l2-querymenu \
ksym-longterm-v4l2-s-ctrl \
ksym-longterm-v4l2-s-ext-ctrls \
ksym-longterm-v4l2-s-parm-cap \
ksym-longterm-v4l2-set-edid-phys-addr \
ksym-longterm-v4l2-simplify-fraction \
ksym-longterm-v4l2-spi-new-subdev \
ksym-longterm-v4l2-spi-subdev-init \
ksym-longterm-v4l2-src-change-event-subdev-subscribe \
ksym-longterm-v4l2-src-change-event-subscribe \
ksym-longterm-v4l2-subdev-call-wrappers \
ksym-longterm-v4l2-subdev-cleanup \
ksym-longterm-v4l2-subdev-disable-streams \
ksym-longterm-v4l2-subdev-enable-streams \
ksym-longterm-v4l2-subdev-get-fmt \
ksym-longterm-v4l2-subdev-get-frame-interval \
ksym-longterm-v4l2-subdev-get-fwnode-pad-1-to-1 \
ksym-longterm-v4l2-subdev-get-privacy-led \
ksym-longterm-v4l2-subdev-has-pad-interdep \
ksym-longterm-v4l2-subdev-init \
ksym-longterm-v4l2-subdev-is-streaming \
ksym-longterm-v4l2-subdev-link-validate \
ksym-longterm-v4l2-subdev-link-validate-default \
ksym-longterm-v4l2-subdev-notify-event \
ksym-longterm-v4l2-subdev-put-privacy-led \
ksym-longterm-v4l2-subdev-routing-find-opposite-end \
ksym-longterm-v4l2-subdev-routing-validate \
ksym-longterm-v4l2-subdev-s-stream-helper \
ksym-longterm-v4l2-subdev-set-routing \
ksym-longterm-v4l2-subdev-set-routing-with-fmt \
ksym-longterm-v4l2-subdev-state-get-opposite-stream-format \
ksym-longterm-v4l2-subdev-state-xlate-streams \
ksym-longterm-v4l2-translate-cmd \
ksym-longterm-v4l2-try-ext-ctrls \
ksym-longterm-v4l2-type-names \
ksym-longterm-v4l2-valid-dv-timings \
ksym-longterm-v4l2-video-std-construct \
ksym-longterm-v4l2-video-std-frame-period \
ksym-longterm-v4l2-vp9-adapt-coef-probs \
ksym-longterm-v4l2-vp9-adapt-noncoef-probs \
ksym-longterm-v4l2-vp9-default-probs \
ksym-longterm-v4l2-vp9-fw-update-probs \
ksym-longterm-v4l2-vp9-kf-partition-probs \
ksym-longterm-v4l2-vp9-kf-uv-mode-prob \
ksym-longterm-v4l2-vp9-kf-y-mode-prob \
ksym-longterm-v4l2-vp9-reset-frame-ctx \
ksym-longterm-v4l2-vp9-seg-feat-enabled \
ksym-longterm-v9fs-get-default-trans \
ksym-longterm-v9fs-get-trans-by-name \
ksym-longterm-v9fs-register-trans \
ksym-longterm-v9fs-unregister-trans \
ksym-longterm-validate-slab-cache \
ksym-longterm-validate-usercopy-range \
ksym-longterm-validate-xmit-skb-list \
ksym-longterm-validate-xmit-xfrm \
ksym-longterm-vb2-buffer-done \
ksym-longterm-vb2-buffer-in-use \
ksym-longterm-vb2-common-vm-ops \
ksym-longterm-vb2-core-create-bufs \
ksym-longterm-vb2-core-dqbuf \
ksym-longterm-vb2-core-expbuf \
ksym-longterm-vb2-core-poll \
ksym-longterm-vb2-core-prepare-buf \
ksym-longterm-vb2-core-qbuf \
ksym-longterm-vb2-core-querybuf \
ksym-longterm-vb2-core-queue-init \
ksym-longterm-vb2-core-queue-release \
ksym-longterm-vb2-core-remove-bufs \
ksym-longterm-vb2-core-reqbufs \
ksym-longterm-vb2-core-streamoff \
ksym-longterm-vb2-core-streamon \
ksym-longterm-vb2-create-bufs \
ksym-longterm-vb2-create-framevec \
ksym-longterm-vb2-destroy-framevec \
ksym-longterm-vb2-discard-done \
ksym-longterm-vb2-dma-contig-memops \
ksym-longterm-vb2-dma-contig-set-max-seg-size \
ksym-longterm-vb2-dma-sg-memops \
ksym-longterm-vb2-dqbuf \
ksym-longterm-vb2-dvb-alloc-frontend \
ksym-longterm-vb2-dvb-dealloc-frontends \
ksym-longterm-vb2-dvb-find-frontend \
ksym-longterm-vb2-dvb-get-frontend \
ksym-longterm-vb2-dvb-register-bus \
ksym-longterm-vb2-dvb-unregister-bus \
ksym-longterm-vb2-expbuf \
ksym-longterm-vb2-find-buffer \
ksym-longterm-vb2-fop-mmap \
ksym-longterm-vb2-fop-poll \
ksym-longterm-vb2-fop-read \
ksym-longterm-vb2-fop-release \
ksym-longterm-vb2-fop-write \
ksym-longterm-vb2-ioctl-create-bufs \
ksym-longterm-vb2-ioctl-dqbuf \
ksym-longterm-vb2-ioctl-expbuf \
ksym-longterm-vb2-ioctl-prepare-buf \
ksym-longterm-vb2-ioctl-qbuf \
ksym-longterm-vb2-ioctl-querybuf \
ksym-longterm-vb2-ioctl-remove-bufs \
ksym-longterm-vb2-ioctl-reqbufs \
ksym-longterm-vb2-ioctl-streamoff \
ksym-longterm-vb2-ioctl-streamon \
ksym-longterm-vb2-mmap \
ksym-longterm-vb2-ops-wait-finish \
ksym-longterm-vb2-ops-wait-prepare \
ksym-longterm-vb2-plane-cookie \
ksym-longterm-vb2-plane-vaddr \
ksym-longterm-vb2-poll \
ksym-longterm-vb2-prepare-buf \
ksym-longterm-vb2-qbuf \
ksym-longterm-vb2-querybuf \
ksym-longterm-vb2-queue-change-type \
ksym-longterm-vb2-queue-error \
ksym-longterm-vb2-queue-init \
ksym-longterm-vb2-queue-init-name \
ksym-longterm-vb2-queue-release \
ksym-longterm-vb2-read \
ksym-longterm-vb2-reqbufs \
ksym-longterm-vb2-request-buffer-cnt \
ksym-longterm-vb2-request-object-is-buffer \
ksym-longterm-vb2-request-queue \
ksym-longterm-vb2-request-validate \
ksym-longterm-vb2-streamoff \
ksym-longterm-vb2-streamon \
ksym-longterm-vb2-thread-start \
ksym-longterm-vb2-thread-stop \
ksym-longterm-vb2-verify-memory-type \
ksym-longterm-vb2-video-unregister-device \
ksym-longterm-vb2-vmalloc-memops \
ksym-longterm-vb2-wait-for-all-buffers \
ksym-longterm-vb2-write \
ksym-longterm-vbg-err \
ksym-longterm-vbg-err-ratelimited \
ksym-longterm-vbg-get-gdev \
ksym-longterm-vbg-hgcm-call \
ksym-longterm-vbg-hgcm-connect \
ksym-longterm-vbg-hgcm-disconnect \
ksym-longterm-vbg-info \
ksym-longterm-vbg-put-gdev \
ksym-longterm-vbg-status-code-to-errno \
ksym-longterm-vbg-warn \
ksym-longterm-vbin-printf \
ksym-longterm-vc-cons \
ksym-longterm-vcalloc-noprof \
ksym-longterm-vcap-add-rule \
ksym-longterm-vcap-addr-keysets \
ksym-longterm-vcap-admin-rule-count \
ksym-longterm-vcap-alloc-rule \
ksym-longterm-vcap-chain-id-to-lookup \
ksym-longterm-vcap-chain-offset \
ksym-longterm-vcap-copy-rule \
ksym-longterm-vcap-debugfs \
ksym-longterm-vcap-del-rule \
ksym-longterm-vcap-del-rules \
ksym-longterm-vcap-enable-lookups \
ksym-longterm-vcap-filter-rule-keys \
ksym-longterm-vcap-find-actionfield \
ksym-longterm-vcap-find-admin \
ksym-longterm-vcap-find-keystream-keysets \
ksym-longterm-vcap-free-rule \
ksym-longterm-vcap-get-rule \
ksym-longterm-vcap-get-rule-count-by-cookie \
ksym-longterm-vcap-is-last-chain \
ksym-longterm-vcap-is-next-lookup \
ksym-longterm-vcap-keyfield-name \
ksym-longterm-vcap-keyfieldset \
ksym-longterm-vcap-keyset-list-add \
ksym-longterm-vcap-keyset-name \
ksym-longterm-vcap-lookup-keyfield \
ksym-longterm-vcap-lookup-rule-by-cookie \
ksym-longterm-vcap-mod-rule \
ksym-longterm-vcap-netbytes-copy \
ksym-longterm-vcap-port-debugfs \
ksym-longterm-vcap-rule-add-action-bit \
ksym-longterm-vcap-rule-add-action-u32 \
ksym-longterm-vcap-rule-add-action-u72 \
ksym-longterm-vcap-rule-add-key-bit \
ksym-longterm-vcap-rule-add-key-u128 \
ksym-longterm-vcap-rule-add-key-u32 \
ksym-longterm-vcap-rule-add-key-u48 \
ksym-longterm-vcap-rule-add-key-u72 \
ksym-longterm-vcap-rule-find-keysets \
ksym-longterm-vcap-rule-get-counter \
ksym-longterm-vcap-rule-get-key-u32 \
ksym-longterm-vcap-rule-mod-action-u32 \
ksym-longterm-vcap-rule-mod-key-u32 \
ksym-longterm-vcap-rule-rem-key \
ksym-longterm-vcap-rule-set-counter \
ksym-longterm-vcap-rule-set-counter-id \
ksym-longterm-vcap-select-min-rule-keyset \
ksym-longterm-vcap-set-rule-set-actionset \
ksym-longterm-vcap-set-rule-set-keyset \
ksym-longterm-vcap-set-tc-exterr \
ksym-longterm-vcap-tc-flower-handler-arp-usage \
ksym-longterm-vcap-tc-flower-handler-cvlan-usage \
ksym-longterm-vcap-tc-flower-handler-ethaddr-usage \
ksym-longterm-vcap-tc-flower-handler-ip-usage \
ksym-longterm-vcap-tc-flower-handler-ipv4-usage \
ksym-longterm-vcap-tc-flower-handler-ipv6-usage \
ksym-longterm-vcap-tc-flower-handler-portnum-usage \
ksym-longterm-vcap-tc-flower-handler-tcp-usage \
ksym-longterm-vcap-tc-flower-handler-vlan-usage \
ksym-longterm-vcap-val-rule \
ksym-longterm-vcc-hash \
ksym-longterm-vcc-insert-socket \
ksym-longterm-vcc-process-recv-queue \
ksym-longterm-vcc-release-async \
ksym-longterm-vcc-sklist-lock \
ksym-longterm-vchan-dma-desc-free-list \
ksym-longterm-vchan-find-desc \
ksym-longterm-vchan-init \
ksym-longterm-vchan-tx-desc-free \
ksym-longterm-vchan-tx-submit \
ksym-longterm-vchiq-add-connected-callback \
ksym-longterm-vchiq-bulk-receive \
ksym-longterm-vchiq-bulk-transmit \
ksym-longterm-vchiq-close-service \
ksym-longterm-vchiq-connect \
ksym-longterm-vchiq-driver-register \
ksym-longterm-vchiq-driver-unregister \
ksym-longterm-vchiq-get-peer-version \
ksym-longterm-vchiq-get-service-userdata \
ksym-longterm-vchiq-initialise \
ksym-longterm-vchiq-mmal-component-disable \
ksym-longterm-vchiq-mmal-component-enable \
ksym-longterm-vchiq-mmal-component-finalise \
ksym-longterm-vchiq-mmal-component-init \
ksym-longterm-vchiq-mmal-finalise \
ksym-longterm-vchiq-mmal-init \
ksym-longterm-vchiq-mmal-port-connect-tunnel \
ksym-longterm-vchiq-mmal-port-disable \
ksym-longterm-vchiq-mmal-port-enable \
ksym-longterm-vchiq-mmal-port-parameter-get \
ksym-longterm-vchiq-mmal-port-parameter-set \
ksym-longterm-vchiq-mmal-port-set-format \
ksym-longterm-vchiq-mmal-submit-buffer \
ksym-longterm-vchiq-mmal-version \
ksym-longterm-vchiq-msg-hold \
ksym-longterm-vchiq-msg-queue-push \
ksym-longterm-vchiq-open-service \
ksym-longterm-vchiq-queue-kernel-message \
ksym-longterm-vchiq-release-message \
ksym-longterm-vchiq-release-service \
ksym-longterm-vchiq-shutdown \
ksym-longterm-vchiq-use-service \
ksym-longterm-vdpa-get-config \
ksym-longterm-vdpa-mgmtdev-register \
ksym-longterm-vdpa-mgmtdev-unregister \
ksym-longterm-vdpa-register-device \
ksym-longterm-vdpa-set-config \
ksym-longterm-vdpa-set-status \
ksym-longterm-vdpa-unregister-device \
ksym-longterm-vdpa-unregister-driver \
ksym-longterm-vdpasim-create \
ksym-longterm-vdpasim-schedule-work \
ksym-longterm-venus-close-common \
ksym-longterm-venus-helper-acquire-buf-ref \
ksym-longterm-venus-helper-alloc-dpb-bufs \
ksym-longterm-venus-helper-buffers-done \
ksym-longterm-venus-helper-change-dpb-owner \
ksym-longterm-venus-helper-check-codec \
ksym-longterm-venus-helper-check-format \
ksym-longterm-venus-helper-find-buf \
ksym-longterm-venus-helper-free-dpb-bufs \
ksym-longterm-venus-helper-get-bufreq \
ksym-longterm-venus-helper-get-framesz \
ksym-longterm-venus-helper-get-framesz-raw \
ksym-longterm-venus-helper-get-opb-size \
ksym-longterm-venus-helper-get-out-fmts \
ksym-longterm-venus-helper-get-profile-level \
ksym-longterm-venus-helper-get-ts-metadata \
ksym-longterm-venus-helper-init-instance \
ksym-longterm-venus-helper-intbufs-alloc \
ksym-longterm-venus-helper-intbufs-free \
ksym-longterm-venus-helper-intbufs-realloc \
ksym-longterm-venus-helper-m2m-device-run \
ksym-longterm-venus-helper-m2m-job-abort \
ksym-longterm-venus-helper-process-initial-cap-bufs \
ksym-longterm-venus-helper-process-initial-out-bufs \
ksym-longterm-venus-helper-queue-dpb-bufs \
ksym-longterm-venus-helper-release-buf-ref \
ksym-longterm-venus-helper-session-init \
ksym-longterm-venus-helper-set-bufsize \
ksym-longterm-venus-helper-set-color-format \
ksym-longterm-venus-helper-set-dyn-bufmode \
ksym-longterm-venus-helper-set-format-constraints \
ksym-longterm-venus-helper-set-input-resolution \
ksym-longterm-venus-helper-set-multistream \
ksym-longterm-venus-helper-set-num-bufs \
ksym-longterm-venus-helper-set-output-resolution \
ksym-longterm-venus-helper-set-profile-level \
ksym-longterm-venus-helper-set-raw-format \
ksym-longterm-venus-helper-set-stride \
ksym-longterm-venus-helper-set-work-mode \
ksym-longterm-venus-helper-unregister-bufs \
ksym-longterm-venus-helper-vb2-buf-init \
ksym-longterm-venus-helper-vb2-buf-prepare \
ksym-longterm-venus-helper-vb2-buf-queue \
ksym-longterm-venus-helper-vb2-queue-error \
ksym-longterm-venus-helper-vb2-start-streaming \
ksym-longterm-venus-helper-vb2-stop-streaming \
ksym-longterm-verbose-torout-sleep \
ksym-longterm-verify-pkcs7-signature \
ksym-longterm-verify-signature \
ksym-longterm-verify-spi-info \
ksym-longterm-ves1820-attach \
ksym-longterm-ves1x93-attach \
ksym-longterm-vesa-modes \
ksym-longterm-vfio-assign-device-set \
ksym-longterm-vfio-combine-iova-ranges \
ksym-longterm-vfio-device-set-open-count \
ksym-longterm-vfio-dma-rw \
ksym-longterm-vfio-file-enforced-coherent \
ksym-longterm-vfio-file-has-dev \
ksym-longterm-vfio-file-iommu-group \
ksym-longterm-vfio-file-is-group \
ksym-longterm-vfio-file-is-valid \
ksym-longterm-vfio-file-set-kvm \
ksym-longterm-vfio-find-device-in-devset \
ksym-longterm-vfio-info-add-capability \
ksym-longterm-vfio-info-cap-add \
ksym-longterm-vfio-info-cap-shift \
ksym-longterm-vfio-mig-get-next-state \
ksym-longterm-vfio-pci-core-aer-err-detected \
ksym-longterm-vfio-pci-core-close-device \
ksym-longterm-vfio-pci-core-disable \
ksym-longterm-vfio-pci-core-do-io-rw \
ksym-longterm-vfio-pci-core-enable \
ksym-longterm-vfio-pci-core-err-handlers \
ksym-longterm-vfio-pci-core-finish-enable \
ksym-longterm-vfio-pci-core-init-dev \
ksym-longterm-vfio-pci-core-ioctl \
ksym-longterm-vfio-pci-core-ioctl-feature \
ksym-longterm-vfio-pci-core-ioread16 \
ksym-longterm-vfio-pci-core-ioread32 \
ksym-longterm-vfio-pci-core-ioread64 \
ksym-longterm-vfio-pci-core-ioread8 \
ksym-longterm-vfio-pci-core-iowrite16 \
ksym-longterm-vfio-pci-core-iowrite32 \
ksym-longterm-vfio-pci-core-iowrite64 \
ksym-longterm-vfio-pci-core-iowrite8 \
ksym-longterm-vfio-pci-core-match \
ksym-longterm-vfio-pci-core-match-token-uuid \
ksym-longterm-vfio-pci-core-mmap \
ksym-longterm-vfio-pci-core-range-intersect-range \
ksym-longterm-vfio-pci-core-read \
ksym-longterm-vfio-pci-core-register-dev-region \
ksym-longterm-vfio-pci-core-register-device \
ksym-longterm-vfio-pci-core-release-dev \
ksym-longterm-vfio-pci-core-request \
ksym-longterm-vfio-pci-core-set-params \
ksym-longterm-vfio-pci-core-setup-barmap \
ksym-longterm-vfio-pci-core-sriov-configure \
ksym-longterm-vfio-pci-core-unregister-device \
ksym-longterm-vfio-pci-core-write \
ksym-longterm-vfio-pci-vmf-insert-pfn \
ksym-longterm-vfio-pin-pages \
ksym-longterm-vfio-platform-close-device \
ksym-longterm-vfio-platform-init-common \
ksym-longterm-vfio-platform-ioctl \
ksym-longterm-vfio-platform-mmap \
ksym-longterm-vfio-platform-open-device \
ksym-longterm-vfio-platform-read \
ksym-longterm-vfio-platform-release-common \
ksym-longterm-vfio-platform-unregister-reset \
ksym-longterm-vfio-platform-write \
ksym-longterm-vfio-register-emulated-iommu-dev \
ksym-longterm-vfio-register-group-dev \
ksym-longterm-vfio-register-iommu-driver \
ksym-longterm-vfio-set-irqs-validate-and-prepare \
ksym-longterm-vfio-unpin-pages \
ksym-longterm-vfio-unregister-group-dev \
ksym-longterm-vfio-unregister-iommu-driver \
ksym-longterm-vfio-virqfd-disable \
ksym-longterm-vfio-virqfd-enable \
ksym-longterm-vfio-virqfd-flush-thread \
ksym-longterm-vfree \
ksym-longterm-vfs-cancel-lock \
ksym-longterm-vfs-clone-file-range \
ksym-longterm-vfs-copy-file-range \
ksym-longterm-vfs-create \
ksym-longterm-vfs-create-mount \
ksym-longterm-vfs-dedupe-file-range \
ksym-longterm-vfs-dedupe-file-range-one \
ksym-longterm-vfs-dup-fs-context \
ksym-longterm-vfs-fadvise \
ksym-longterm-vfs-fallocate \
ksym-longterm-vfs-fileattr-get \
ksym-longterm-vfs-fileattr-set \
ksym-longterm-vfs-fsync \
ksym-longterm-vfs-fsync-range \
ksym-longterm-vfs-get-acl \
ksym-longterm-vfs-get-fsid \
ksym-longterm-vfs-get-link \
ksym-longterm-vfs-get-tree \
ksym-longterm-vfs-getattr \
ksym-longterm-vfs-getattr-nosec \
ksym-longterm-vfs-getxattr \
ksym-longterm-vfs-inode-has-locks \
ksym-longterm-vfs-iocb-iter-read \
ksym-longterm-vfs-iocb-iter-write \
ksym-longterm-vfs-iter-read \
ksym-longterm-vfs-iter-write \
ksym-longterm-vfs-kern-mount \
ksym-longterm-vfs-link \
ksym-longterm-vfs-listxattr \
ksym-longterm-vfs-llseek \
ksym-longterm-vfs-lock-file \
ksym-longterm-vfs-mkdir \
ksym-longterm-vfs-mknod \
ksym-longterm-vfs-mkobj \
ksym-longterm-vfs-parse-fs-param \
ksym-longterm-vfs-parse-fs-param-source \
ksym-longterm-vfs-parse-fs-qstr \
ksym-longterm-vfs-parse-monolithic-sep \
ksym-longterm-vfs-path-lookup \
ksym-longterm-vfs-path-parent-lookup \
ksym-longterm-vfs-pressure-ratio \
ksym-longterm-vfs-readlink \
ksym-longterm-vfs-remove-acl \
ksym-longterm-vfs-removexattr \
ksym-longterm-vfs-rename \
ksym-longterm-vfs-rmdir \
ksym-longterm-vfs-set-acl \
ksym-longterm-vfs-setlease \
ksym-longterm-vfs-setpos \
ksym-longterm-vfs-setxattr \
ksym-longterm-vfs-splice-read \
ksym-longterm-vfs-statfs \
ksym-longterm-vfs-symlink \
ksym-longterm-vfs-test-lock \
ksym-longterm-vfs-truncate \
ksym-longterm-vfs-unlink \
ksym-longterm-vfsgid-in-group-p \
ksym-longterm-vga-client-register \
ksym-longterm-vga-default-device \
ksym-longterm-vga-get \
ksym-longterm-vga-put \
ksym-longterm-vga-remove-vgacon \
ksym-longterm-vga-set-legacy-decoding \
ksym-longterm-vhost-add-used \
ksym-longterm-vhost-add-used-and-signal \
ksym-longterm-vhost-add-used-and-signal-n \
ksym-longterm-vhost-add-used-n \
ksym-longterm-vhost-chr-poll \
ksym-longterm-vhost-chr-read-iter \
ksym-longterm-vhost-chr-write-iter \
ksym-longterm-vhost-clear-msg \
ksym-longterm-vhost-dequeue-msg \
ksym-longterm-vhost-dev-check-owner \
ksym-longterm-vhost-dev-cleanup \
ksym-longterm-vhost-dev-flush \
ksym-longterm-vhost-dev-has-owner \
ksym-longterm-vhost-dev-init \
ksym-longterm-vhost-dev-ioctl \
ksym-longterm-vhost-dev-reset-owner \
ksym-longterm-vhost-dev-reset-owner-prepare \
ksym-longterm-vhost-dev-set-owner \
ksym-longterm-vhost-dev-stop \
ksym-longterm-vhost-disable-notify \
ksym-longterm-vhost-discard-vq-desc \
ksym-longterm-vhost-enable-notify \
ksym-longterm-vhost-enqueue-msg \
ksym-longterm-vhost-exceeds-weight \
ksym-longterm-vhost-get-vq-desc \
ksym-longterm-vhost-get-vq-desc-n \
ksym-longterm-vhost-init-device-iotlb \
ksym-longterm-vhost-iotlb-add-range \
ksym-longterm-vhost-iotlb-add-range-ctx \
ksym-longterm-vhost-iotlb-alloc \
ksym-longterm-vhost-iotlb-del-range \
ksym-longterm-vhost-iotlb-free \
ksym-longterm-vhost-iotlb-init \
ksym-longterm-vhost-iotlb-itree-first \
ksym-longterm-vhost-iotlb-itree-next \
ksym-longterm-vhost-iotlb-map-free \
ksym-longterm-vhost-iotlb-reset \
ksym-longterm-vhost-log-access-ok \
ksym-longterm-vhost-log-write \
ksym-longterm-vhost-new-msg \
ksym-longterm-vhost-poll-init \
ksym-longterm-vhost-poll-queue \
ksym-longterm-vhost-poll-start \
ksym-longterm-vhost-poll-stop \
ksym-longterm-vhost-set-backend-features \
ksym-longterm-vhost-signal \
ksym-longterm-vhost-task-create \
ksym-longterm-vhost-task-start \
ksym-longterm-vhost-task-stop \
ksym-longterm-vhost-task-wake \
ksym-longterm-vhost-vq-access-ok \
ksym-longterm-vhost-vq-avail-empty \
ksym-longterm-vhost-vq-has-work \
ksym-longterm-vhost-vq-init-access \
ksym-longterm-vhost-vq-is-setup \
ksym-longterm-vhost-vq-work-queue \
ksym-longterm-vhost-vring-ioctl \
ksym-longterm-vhost-work-init \
ksym-longterm-vhost-worker-ioctl \
ksym-longterm-viai2c-init \
ksym-longterm-viai2c-irq-xfer \
ksym-longterm-viai2c-wait-bus-not-busy \
ksym-longterm-viai2c-xfer \
ksym-longterm-vid-from-reg \
ksym-longterm-vid-is-dsa-8021q \
ksym-longterm-vid-which-vrm \
ksym-longterm-video-devdata \
ksym-longterm-video-device-alloc \
ksym-longterm-video-device-pipeline \
ksym-longterm-video-device-pipeline-alloc-start \
ksym-longterm-video-device-pipeline-start \
ksym-longterm-video-device-pipeline-stop \
ksym-longterm-video-device-release \
ksym-longterm-video-device-release-empty \
ksym-longterm-video-firmware-drivers-only \
ksym-longterm-video-get-options \
ksym-longterm-video-ioctl2 \
ksym-longterm-video-unregister-device \
ksym-longterm-videomode-from-timing \
ksym-longterm-videomode-from-timings \
ksym-longterm-vif-device-init \
ksym-longterm-virtio-add-status \
ksym-longterm-virtio-break-device \
ksym-longterm-virtio-check-driver-offered-feature \
ksym-longterm-virtio-check-mem-acc-cb \
ksym-longterm-virtio-config-changed \
ksym-longterm-virtio-config-driver-disable \
ksym-longterm-virtio-config-driver-enable \
ksym-longterm-virtio-device-freeze \
ksym-longterm-virtio-device-reset-done \
ksym-longterm-virtio-device-reset-prepare \
ksym-longterm-virtio-device-restore \
ksym-longterm-virtio-dma-buf-attach \
ksym-longterm-virtio-dma-buf-export \
ksym-longterm-virtio-dma-buf-get-uuid \
ksym-longterm-virtio-max-dma-size \
ksym-longterm-virtio-pci-admin-dev-parts-get \
ksym-longterm-virtio-pci-admin-dev-parts-metadata-get \
ksym-longterm-virtio-pci-admin-dev-parts-set \
ksym-longterm-virtio-pci-admin-has-dev-parts \
ksym-longterm-virtio-pci-admin-mode-set \
ksym-longterm-virtio-pci-admin-obj-create \
ksym-longterm-virtio-pci-admin-obj-destroy \
ksym-longterm-virtio-pmem-host-ack \
ksym-longterm-virtio-require-restricted-mem-acc \
ksym-longterm-virtio-reset-device \
ksym-longterm-virtio-transport-connect \
ksym-longterm-virtio-transport-consume-skb-sent \
ksym-longterm-virtio-transport-deliver-tap-pkt \
ksym-longterm-virtio-transport-destruct \
ksym-longterm-virtio-transport-dgram-allow \
ksym-longterm-virtio-transport-dgram-bind \
ksym-longterm-virtio-transport-dgram-dequeue \
ksym-longterm-virtio-transport-dgram-enqueue \
ksym-longterm-virtio-transport-do-socket-init \
ksym-longterm-virtio-transport-get-credit \
ksym-longterm-virtio-transport-inc-tx-pkt \
ksym-longterm-virtio-transport-notify-buffer-size \
ksym-longterm-virtio-transport-notify-poll-in \
ksym-longterm-virtio-transport-notify-poll-out \
ksym-longterm-virtio-transport-notify-recv-init \
ksym-longterm-virtio-transport-notify-recv-post-dequeue \
ksym-longterm-virtio-transport-notify-recv-pre-block \
ksym-longterm-virtio-transport-notify-recv-pre-dequeue \
ksym-longterm-virtio-transport-notify-send-init \
ksym-longterm-virtio-transport-notify-send-post-enqueue \
ksym-longterm-virtio-transport-notify-send-pre-block \
ksym-longterm-virtio-transport-notify-send-pre-enqueue \
ksym-longterm-virtio-transport-notify-set-rcvlowat \
ksym-longterm-virtio-transport-purge-skbs \
ksym-longterm-virtio-transport-put-credit \
ksym-longterm-virtio-transport-read-skb \
ksym-longterm-virtio-transport-recv-pkt \
ksym-longterm-virtio-transport-release \
ksym-longterm-virtio-transport-seqpacket-dequeue \
ksym-longterm-virtio-transport-seqpacket-enqueue \
ksym-longterm-virtio-transport-seqpacket-has-data \
ksym-longterm-virtio-transport-shutdown \
ksym-longterm-virtio-transport-stream-allow \
ksym-longterm-virtio-transport-stream-dequeue \
ksym-longterm-virtio-transport-stream-enqueue \
ksym-longterm-virtio-transport-stream-has-data \
ksym-longterm-virtio-transport-stream-has-space \
ksym-longterm-virtio-transport-stream-is-active \
ksym-longterm-virtio-transport-stream-rcvhiwat \
ksym-longterm-virtio-transport-unsent-bytes \
ksym-longterm-virtqueue-add-inbuf \
ksym-longterm-virtqueue-add-inbuf-ctx \
ksym-longterm-virtqueue-add-inbuf-premapped \
ksym-longterm-virtqueue-add-outbuf \
ksym-longterm-virtqueue-add-outbuf-premapped \
ksym-longterm-virtqueue-add-sgs \
ksym-longterm-virtqueue-detach-unused-buf \
ksym-longterm-virtqueue-disable-cb \
ksym-longterm-virtqueue-dma-dev \
ksym-longterm-virtqueue-enable-cb \
ksym-longterm-virtqueue-enable-cb-delayed \
ksym-longterm-virtqueue-enable-cb-prepare \
ksym-longterm-virtqueue-get-avail-addr \
ksym-longterm-virtqueue-get-buf \
ksym-longterm-virtqueue-get-buf-ctx \
ksym-longterm-virtqueue-get-desc-addr \
ksym-longterm-virtqueue-get-used-addr \
ksym-longterm-virtqueue-get-vring \
ksym-longterm-virtqueue-get-vring-size \
ksym-longterm-virtqueue-is-broken \
ksym-longterm-virtqueue-kick \
ksym-longterm-virtqueue-kick-prepare \
ksym-longterm-virtqueue-map-alloc-coherent \
ksym-longterm-virtqueue-map-free-coherent \
ksym-longterm-virtqueue-map-mapping-error \
ksym-longterm-virtqueue-map-need-sync \
ksym-longterm-virtqueue-map-page-attrs \
ksym-longterm-virtqueue-map-single-attrs \
ksym-longterm-virtqueue-map-sync-single-range-for-cpu \
ksym-longterm-virtqueue-map-sync-single-range-for-device \
ksym-longterm-virtqueue-notify \
ksym-longterm-virtqueue-poll \
ksym-longterm-virtqueue-reset \
ksym-longterm-virtqueue-resize \
ksym-longterm-virtqueue-unmap-page-attrs \
ksym-longterm-virtqueue-unmap-single-attrs \
ksym-longterm-visitor128 \
ksym-longterm-visitor32 \
ksym-longterm-visitor64 \
ksym-longterm-visitorl \
ksym-longterm-vivaldi-attribute-groups \
ksym-longterm-vivaldi-feature-mapping \
ksym-longterm-vivaldi-function-row-physmap-show \
ksym-longterm-vlan-dev-real-dev \
ksym-longterm-vlan-dev-vlan-id \
ksym-longterm-vlan-dev-vlan-proto \
ksym-longterm-vlan-filter-drop-vids \
ksym-longterm-vlan-filter-push-vids \
ksym-longterm-vlan-for-each \
ksym-longterm-vlan-ioctl-set \
ksym-longterm-vlan-uses-dev \
ksym-longterm-vlan-vid-add \
ksym-longterm-vlan-vid-del \
ksym-longterm-vlan-vids-add-by-dev \
ksym-longterm-vlan-vids-del-by-dev \
ksym-longterm-vli-cmp \
ksym-longterm-vli-from-be64 \
ksym-longterm-vli-from-le64 \
ksym-longterm-vli-is-zero \
ksym-longterm-vli-mod-inv \
ksym-longterm-vli-mod-mult-slow \
ksym-longterm-vli-num-bits \
ksym-longterm-vli-sub \
ksym-longterm-vm-brk-flags \
ksym-longterm-vm-event-states \
ksym-longterm-vm-get-page-prot \
ksym-longterm-vm-insert-page \
ksym-longterm-vm-insert-pages \
ksym-longterm-vm-iomap-memory \
ksym-longterm-vm-map-pages \
ksym-longterm-vm-map-pages-zero \
ksym-longterm-vm-map-ram \
ksym-longterm-vm-memory-committed \
ksym-longterm-vm-mmap \
ksym-longterm-vm-munmap \
ksym-longterm-vm-node-stat \
ksym-longterm-vm-unmap-aliases \
ksym-longterm-vm-unmap-ram \
ksym-longterm-vm-zone-stat \
ksym-longterm-vma-alloc-folio-noprof \
ksym-longterm-vma-kernel-pagesize \
ksym-longterm-vma-set-file \
ksym-longterm-vmalloc-32-noprof \
ksym-longterm-vmalloc-32-user-noprof \
ksym-longterm-vmalloc-array-noprof \
ksym-longterm-vmalloc-huge-node-noprof \
ksym-longterm-vmalloc-node-noprof \
ksym-longterm-vmalloc-noprof \
ksym-longterm-vmalloc-to-page \
ksym-longterm-vmalloc-to-pfn \
ksym-longterm-vmalloc-user-noprof \
ksym-longterm-vmap \
ksym-longterm-vmap-pfn \
ksym-longterm-vmbus-alloc-ring \
ksym-longterm-vmbus-allocate-mmio \
ksym-longterm-vmbus-close \
ksym-longterm-vmbus-connect-ring \
ksym-longterm-vmbus-connection \
ksym-longterm-vmbus-device-unregister \
ksym-longterm-vmbus-devs \
ksym-longterm-vmbus-disconnect-ring \
ksym-longterm-vmbus-driver-unregister \
ksym-longterm-vmbus-establish-gpadl \
ksym-longterm-vmbus-free-mmio \
ksym-longterm-vmbus-free-ring \
ksym-longterm-vmbus-hvsock-device-unregister \
ksym-longterm-vmbus-initiate-unload \
ksym-longterm-vmbus-is-confidential \
ksym-longterm-vmbus-next-request-id \
ksym-longterm-vmbus-open \
ksym-longterm-vmbus-prep-negotiate-resp \
ksym-longterm-vmbus-proto-version \
ksym-longterm-vmbus-recvpacket \
ksym-longterm-vmbus-recvpacket-raw \
ksym-longterm-vmbus-request-addr \
ksym-longterm-vmbus-request-addr-match \
ksym-longterm-vmbus-send-modifychannel \
ksym-longterm-vmbus-send-tl-connect-request \
ksym-longterm-vmbus-sendpacket \
ksym-longterm-vmbus-sendpacket-getid \
ksym-longterm-vmbus-sendpacket-mpb-desc \
ksym-longterm-vmbus-set-chn-rescind-callback \
ksym-longterm-vmbus-set-event \
ksym-longterm-vmbus-set-sc-create-callback \
ksym-longterm-vmbus-set-skip-unload \
ksym-longterm-vmbus-setevent \
ksym-longterm-vmbus-teardown-gpadl \
ksym-longterm-vmci-context-get-priv-flags \
ksym-longterm-vmci-datagram-create-handle \
ksym-longterm-vmci-datagram-create-handle-priv \
ksym-longterm-vmci-datagram-destroy-handle \
ksym-longterm-vmci-datagram-send \
ksym-longterm-vmci-doorbell-create \
ksym-longterm-vmci-doorbell-destroy \
ksym-longterm-vmci-event-subscribe \
ksym-longterm-vmci-event-unsubscribe \
ksym-longterm-vmci-get-context-id \
ksym-longterm-vmci-is-context-owner \
ksym-longterm-vmci-qpair-alloc \
ksym-longterm-vmci-qpair-consume-buf-ready \
ksym-longterm-vmci-qpair-consume-free-space \
ksym-longterm-vmci-qpair-dequev \
ksym-longterm-vmci-qpair-detach \
ksym-longterm-vmci-qpair-enquev \
ksym-longterm-vmci-qpair-get-consume-indexes \
ksym-longterm-vmci-qpair-get-produce-indexes \
ksym-longterm-vmci-qpair-peekv \
ksym-longterm-vmci-qpair-produce-buf-ready \
ksym-longterm-vmci-qpair-produce-free-space \
ksym-longterm-vmci-register-vsock-callback \
ksym-longterm-vmci-send-datagram \
ksym-longterm-vmcore-add-device-dump \
ksym-longterm-vmemdup-user \
ksym-longterm-vmf-insert-folio-pmd \
ksym-longterm-vmf-insert-mixed \
ksym-longterm-vmf-insert-page-mkwrite \
ksym-longterm-vmf-insert-pfn \
ksym-longterm-vmf-insert-pfn-pmd \
ksym-longterm-vmf-insert-pfn-prot \
ksym-longterm-vnic-dev-get-pdev \
ksym-longterm-vnic-dev-get-res \
ksym-longterm-vnic-dev-get-res-count \
ksym-longterm-vnic-dev-register \
ksym-longterm-vnic-dev-unregister \
ksym-longterm-vop-component-ops \
ksym-longterm-vop2-component-ops \
ksym-longterm-vp-legacy-config-vector \
ksym-longterm-vp-legacy-get-driver-features \
ksym-longterm-vp-legacy-get-features \
ksym-longterm-vp-legacy-get-queue-enable \
ksym-longterm-vp-legacy-get-queue-size \
ksym-longterm-vp-legacy-get-status \
ksym-longterm-vp-legacy-probe \
ksym-longterm-vp-legacy-queue-vector \
ksym-longterm-vp-legacy-remove \
ksym-longterm-vp-legacy-set-features \
ksym-longterm-vp-legacy-set-queue-address \
ksym-longterm-vp-legacy-set-status \
ksym-longterm-vp-modern-avq-index \
ksym-longterm-vp-modern-avq-num \
ksym-longterm-vp-modern-config-vector \
ksym-longterm-vp-modern-generation \
ksym-longterm-vp-modern-get-driver-extended-features \
ksym-longterm-vp-modern-get-extended-features \
ksym-longterm-vp-modern-get-num-queues \
ksym-longterm-vp-modern-get-queue-enable \
ksym-longterm-vp-modern-get-queue-reset \
ksym-longterm-vp-modern-get-queue-size \
ksym-longterm-vp-modern-get-status \
ksym-longterm-vp-modern-map-vq-notify \
ksym-longterm-vp-modern-probe \
ksym-longterm-vp-modern-queue-address \
ksym-longterm-vp-modern-queue-vector \
ksym-longterm-vp-modern-remove \
ksym-longterm-vp-modern-set-extended-features \
ksym-longterm-vp-modern-set-queue-enable \
ksym-longterm-vp-modern-set-queue-reset \
ksym-longterm-vp-modern-set-queue-size \
ksym-longterm-vp-modern-set-status \
ksym-longterm-vp3054-i2c-probe \
ksym-longterm-vp3054-i2c-remove \
ksym-longterm-vpanic \
ksym-longterm-vprintk \
ksym-longterm-vprintk-default \
ksym-longterm-vprintk-emit \
ksym-longterm-vpu-get-plat-device \
ksym-longterm-vpu-get-vdec-hw-capa \
ksym-longterm-vpu-get-venc-hw-capa \
ksym-longterm-vpu-ipi-register \
ksym-longterm-vpu-ipi-send \
ksym-longterm-vpu-load-firmware \
ksym-longterm-vpu-mapping-dm-addr \
ksym-longterm-vpu-wdt-reg-handler \
ksym-longterm-vq-meta-prefetch \
ksym-longterm-vring-create-virtqueue \
ksym-longterm-vring-create-virtqueue-map \
ksym-longterm-vring-del-virtqueue \
ksym-longterm-vring-interrupt \
ksym-longterm-vring-new-virtqueue \
ksym-longterm-vring-notification-data \
ksym-longterm-vring-transport-features \
ksym-longterm-vringh-complete-iotlb \
ksym-longterm-vringh-complete-kern \
ksym-longterm-vringh-complete-multi-user \
ksym-longterm-vringh-complete-user \
ksym-longterm-vringh-getdesc-iotlb \
ksym-longterm-vringh-getdesc-kern \
ksym-longterm-vringh-getdesc-user \
ksym-longterm-vringh-init-iotlb \
ksym-longterm-vringh-init-iotlb-va \
ksym-longterm-vringh-init-kern \
ksym-longterm-vringh-init-user \
ksym-longterm-vringh-iov-pull-iotlb \
ksym-longterm-vringh-iov-pull-user \
ksym-longterm-vringh-iov-push-iotlb \
ksym-longterm-vringh-iov-push-user \
ksym-longterm-vringh-kiov-advance \
ksym-longterm-vringh-need-notify-iotlb \
ksym-longterm-vringh-need-notify-kern \
ksym-longterm-vringh-need-notify-user \
ksym-longterm-vringh-notify-disable-kern \
ksym-longterm-vringh-notify-disable-user \
ksym-longterm-vringh-notify-enable-kern \
ksym-longterm-vringh-notify-enable-user \
ksym-longterm-vringh-set-iotlb \
ksym-longterm-vsc73xx-is-addr-valid \
ksym-longterm-vsc73xx-probe \
ksym-longterm-vsc73xx-remove \
ksym-longterm-vsc73xx-shutdown \
ksym-longterm-vsc7514-regfields \
ksym-longterm-vsc7514-regmap \
ksym-longterm-vsc7514-vcap-props \
ksym-longterm-vscnprintf \
ksym-longterm-vsnprintf \
ksym-longterm-vsock-add-pending \
ksym-longterm-vsock-add-tap \
ksym-longterm-vsock-addr-bound \
ksym-longterm-vsock-addr-cast \
ksym-longterm-vsock-addr-equals-addr \
ksym-longterm-vsock-addr-init \
ksym-longterm-vsock-addr-unbind \
ksym-longterm-vsock-addr-validate \
ksym-longterm-vsock-assign-transport \
ksym-longterm-vsock-bind-table \
ksym-longterm-vsock-connected-table \
ksym-longterm-vsock-connectible-has-data \
ksym-longterm-vsock-connectible-recvmsg \
ksym-longterm-vsock-core-get-transport \
ksym-longterm-vsock-core-register \
ksym-longterm-vsock-core-unregister \
ksym-longterm-vsock-create-connected \
ksym-longterm-vsock-data-ready \
ksym-longterm-vsock-deliver-tap \
ksym-longterm-vsock-dgram-recvmsg \
ksym-longterm-vsock-enqueue-accept \
ksym-longterm-vsock-find-bound-socket \
ksym-longterm-vsock-find-cid \
ksym-longterm-vsock-find-connected-socket \
ksym-longterm-vsock-for-each-connected-socket \
ksym-longterm-vsock-insert-connected \
ksym-longterm-vsock-linger \
ksym-longterm-vsock-remove-bound \
ksym-longterm-vsock-remove-connected \
ksym-longterm-vsock-remove-pending \
ksym-longterm-vsock-remove-sock \
ksym-longterm-vsock-remove-tap \
ksym-longterm-vsock-stream-has-data \
ksym-longterm-vsock-stream-has-space \
ksym-longterm-vsock-table-lock \
ksym-longterm-vsp1-du-atomic-begin \
ksym-longterm-vsp1-du-atomic-flush \
ksym-longterm-vsp1-du-atomic-update \
ksym-longterm-vsp1-du-init \
ksym-longterm-vsp1-du-map-sg \
ksym-longterm-vsp1-du-setup-lif \
ksym-longterm-vsp1-du-unmap-sg \
ksym-longterm-vsp1-isp-alloc-buffer \
ksym-longterm-vsp1-isp-free-buffer \
ksym-longterm-vsp1-isp-get-bus-master \
ksym-longterm-vsp1-isp-init \
ksym-longterm-vsp1-isp-job-prepare \
ksym-longterm-vsp1-isp-job-release \
ksym-longterm-vsp1-isp-job-run \
ksym-longterm-vsp1-isp-start-streaming \
ksym-longterm-vsp1-isp-stop-streaming \
ksym-longterm-vsprintf \
ksym-longterm-vsscanf \
ksym-longterm-vt-get-leds \
ksym-longterm-vtime-guest-enter \
ksym-longterm-vtime-guest-exit \
ksym-longterm-vunmap \
ksym-longterm-vxlan-dev-create \
ksym-longterm-vxlan-fdb-clear-offload \
ksym-longterm-vxlan-fdb-find-uc \
ksym-longterm-vxlan-fdb-replay \
ksym-longterm-vzalloc-node-noprof \
ksym-longterm-vzalloc-noprof \
ksym-longterm-w1-add-master-device \
ksym-longterm-w1-calc-crc8 \
ksym-longterm-w1-ds2780-eeprom-cmd \
ksym-longterm-w1-ds2780-io \
ksym-longterm-w1-ds2781-eeprom-cmd \
ksym-longterm-w1-ds2781-io \
ksym-longterm-w1-next-pullup \
ksym-longterm-w1-read-8 \
ksym-longterm-w1-read-block \
ksym-longterm-w1-register-family \
ksym-longterm-w1-remove-master-device \
ksym-longterm-w1-reset-bus \
ksym-longterm-w1-reset-resume-command \
ksym-longterm-w1-reset-select-slave \
ksym-longterm-w1-touch-bit \
ksym-longterm-w1-touch-block \
ksym-longterm-w1-triplet \
ksym-longterm-w1-unregister-family \
ksym-longterm-w1-write-8 \
ksym-longterm-w1-write-block \
ksym-longterm-w5100-ops-priv \
ksym-longterm-w5100-pm-ops \
ksym-longterm-w5100-probe \
ksym-longterm-w5100-remove \
ksym-longterm-wait-for-completion \
ksym-longterm-wait-for-completion-interruptible \
ksym-longterm-wait-for-completion-interruptible-timeout \
ksym-longterm-wait-for-completion-io \
ksym-longterm-wait-for-completion-io-timeout \
ksym-longterm-wait-for-completion-killable \
ksym-longterm-wait-for-completion-killable-timeout \
ksym-longterm-wait-for-completion-state \
ksym-longterm-wait-for-completion-timeout \
ksym-longterm-wait-for-device-probe \
ksym-longterm-wait-for-initramfs \
ksym-longterm-wait-for-key-construction \
ksym-longterm-wait-for-random-bytes \
ksym-longterm-wait-on-page-writeback \
ksym-longterm-wait-woken \
ksym-longterm-wake-bit-function \
ksym-longterm-wake-up-all-idle-cpus \
ksym-longterm-wake-up-bit \
ksym-longterm-wake-up-process \
ksym-longterm-wake-up-var \
ksym-longterm-wakeme-after-rcu \
ksym-longterm-wakeup-source-register \
ksym-longterm-wakeup-source-unregister \
ksym-longterm-wakeup-sources-read-lock \
ksym-longterm-wakeup-sources-read-unlock \
ksym-longterm-wakeup-sources-walk-next \
ksym-longterm-wakeup-sources-walk-start \
ksym-longterm-walk-hmem-resources \
ksym-longterm-walk-iomem-res-desc \
ksym-longterm-watchdog-init-timeout \
ksym-longterm-watchdog-notify-pretimeout \
ksym-longterm-watchdog-register-device \
ksym-longterm-watchdog-register-governor \
ksym-longterm-watchdog-set-last-hw-keepalive \
ksym-longterm-watchdog-set-restart-priority \
ksym-longterm-watchdog-unregister-device \
ksym-longterm-watchdog-unregister-governor \
ksym-longterm-wb-writeout-inc \
ksym-longterm-wbc-account-cgroup-owner \
ksym-longterm-wbc-attach-fdatawrite-inode \
ksym-longterm-wbc-detach-inode \
ksym-longterm-wbt-disable-default \
ksym-longterm-wbt-enable-default \
ksym-longterm-wcd-bus-config \
ksym-longterm-wcd-clsh-ctrl-alloc \
ksym-longterm-wcd-clsh-ctrl-free \
ksym-longterm-wcd-clsh-ctrl-get-state \
ksym-longterm-wcd-clsh-ctrl-set-state \
ksym-longterm-wcd-clsh-set-hph-mode \
ksym-longterm-wcd-dt-parse-mbhc-data \
ksym-longterm-wcd-dt-parse-micbias-info \
ksym-longterm-wcd-get-micb-vout-ctl-val \
ksym-longterm-wcd-interrupt-callback \
ksym-longterm-wcd-mbhc-deinit \
ksym-longterm-wcd-mbhc-event-notify \
ksym-longterm-wcd-mbhc-get-hph-type \
ksym-longterm-wcd-mbhc-get-impedance \
ksym-longterm-wcd-mbhc-init \
ksym-longterm-wcd-mbhc-set-hph-type \
ksym-longterm-wcd-mbhc-start \
ksym-longterm-wcd-mbhc-stop \
ksym-longterm-wcd-mbhc-typec-report-plug \
ksym-longterm-wcd-mbhc-typec-report-unplug \
ksym-longterm-wcd-sdw-component-ops \
ksym-longterm-wcd-update-status \
ksym-longterm-wcd938x-sdw-free \
ksym-longterm-wcd938x-sdw-hw-params \
ksym-longterm-wcd938x-sdw-set-sdw-stream \
ksym-longterm-wcd939x-sdw-free \
ksym-longterm-wcd939x-sdw-hw-params \
ksym-longterm-wcd939x-sdw-set-sdw-stream \
ksym-longterm-wdev-chandef \
ksym-longterm-wdev-to-ieee80211-vif \
ksym-longterm-widget-in-list \
ksym-longterm-wiphy-apply-custom-regulatory \
ksym-longterm-wiphy-delayed-work-cancel \
ksym-longterm-wiphy-delayed-work-flush \
ksym-longterm-wiphy-delayed-work-pending \
ksym-longterm-wiphy-delayed-work-queue \
ksym-longterm-wiphy-delayed-work-timer \
ksym-longterm-wiphy-free \
ksym-longterm-wiphy-hrtimer-work-cancel \
ksym-longterm-wiphy-hrtimer-work-flush \
ksym-longterm-wiphy-hrtimer-work-pending \
ksym-longterm-wiphy-hrtimer-work-queue \
ksym-longterm-wiphy-hrtimer-work-timer \
ksym-longterm-wiphy-new-nm \
ksym-longterm-wiphy-read-of-freq-limits \
ksym-longterm-wiphy-register \
ksym-longterm-wiphy-rfkill-set-hw-state-reason \
ksym-longterm-wiphy-rfkill-start-polling \
ksym-longterm-wiphy-to-ieee80211-hw \
ksym-longterm-wiphy-unregister \
ksym-longterm-wiphy-work-cancel \
ksym-longterm-wiphy-work-flush \
ksym-longterm-wiphy-work-queue \
ksym-longterm-wireless-nlevent-flush \
ksym-longterm-wireless-send-event \
ksym-longterm-wl1251-alloc-hw \
ksym-longterm-wl1251-free-hw \
ksym-longterm-wl1251-init-ieee80211 \
ksym-longterm-wl1271-acx-init-mem-config \
ksym-longterm-wl1271-acx-pm-config \
ksym-longterm-wl1271-acx-set-ht-capabilities \
ksym-longterm-wl1271-acx-sleep-auth \
ksym-longterm-wl1271-cmd-configure \
ksym-longterm-wl1271-cmd-data-path \
ksym-longterm-wl1271-cmd-send \
ksym-longterm-wl1271-cmd-test \
ksym-longterm-wl1271-debugfs-update-stats \
ksym-longterm-wl1271-format-buffer \
ksym-longterm-wl1271-free-tx-id \
ksym-longterm-wl1271-tx-flush \
ksym-longterm-wl1271-tx-min-rate-get \
ksym-longterm-wl12xx-acx-mem-cfg \
ksym-longterm-wl12xx-cmd-build-probe-req \
ksym-longterm-wl12xx-debug-level \
ksym-longterm-wl12xx-is-dummy-packet \
ksym-longterm-wlcore-alloc-hw \
ksym-longterm-wlcore-boot-run-firmware \
ksym-longterm-wlcore-boot-upload-firmware \
ksym-longterm-wlcore-boot-upload-nvs \
ksym-longterm-wlcore-calc-packet-alignment \
ksym-longterm-wlcore-cmd-generic-cfg \
ksym-longterm-wlcore-cmd-wait-for-event-or-timeout \
ksym-longterm-wlcore-disable-interrupts \
ksym-longterm-wlcore-disable-interrupts-nosync \
ksym-longterm-wlcore-enable-interrupts \
ksym-longterm-wlcore-event-ba-rx-constraint \
ksym-longterm-wlcore-event-beacon-loss \
ksym-longterm-wlcore-event-channel-switch \
ksym-longterm-wlcore-event-dummy-packet \
ksym-longterm-wlcore-event-fw-logger \
ksym-longterm-wlcore-event-inactive-sta \
ksym-longterm-wlcore-event-max-tx-failure \
ksym-longterm-wlcore-event-roc-complete \
ksym-longterm-wlcore-event-rssi-trigger \
ksym-longterm-wlcore-event-sched-scan-completed \
ksym-longterm-wlcore-event-soft-gemini-sense \
ksym-longterm-wlcore-free-hw \
ksym-longterm-wlcore-get-native-channel-type \
ksym-longterm-wlcore-probe \
ksym-longterm-wlcore-remove \
ksym-longterm-wlcore-scan-sched-scan-results \
ksym-longterm-wlcore-scan-sched-scan-ssid-list \
ksym-longterm-wlcore-set-key \
ksym-longterm-wlcore-set-partition \
ksym-longterm-wlcore-set-scan-chan-params \
ksym-longterm-wlcore-synchronize-interrupts \
ksym-longterm-wlcore-translate-addr \
ksym-longterm-wlcore-tx-complete \
ksym-longterm-wm-adsp-compr-copy \
ksym-longterm-wm-adsp-compr-free \
ksym-longterm-wm-adsp-compr-get-caps \
ksym-longterm-wm-adsp-compr-handle-irq \
ksym-longterm-wm-adsp-compr-open \
ksym-longterm-wm-adsp-compr-pointer \
ksym-longterm-wm-adsp-compr-set-params \
ksym-longterm-wm-adsp-compr-trigger \
ksym-longterm-wm-adsp-control-add \
ksym-longterm-wm-adsp-early-event \
ksym-longterm-wm-adsp-event \
ksym-longterm-wm-adsp-fw-enum \
ksym-longterm-wm-adsp-fw-get \
ksym-longterm-wm-adsp-fw-put \
ksym-longterm-wm-adsp-power-down \
ksym-longterm-wm-adsp-power-up \
ksym-longterm-wm-adsp-read-ctl \
ksym-longterm-wm-adsp-run \
ksym-longterm-wm-adsp-stop \
ksym-longterm-wm-adsp-write-ctl \
ksym-longterm-wm-adsp1-event \
ksym-longterm-wm-adsp1-init \
ksym-longterm-wm-adsp2-bus-error \
ksym-longterm-wm-adsp2-component-probe \
ksym-longterm-wm-adsp2-component-remove \
ksym-longterm-wm-adsp2-init \
ksym-longterm-wm-adsp2-preloader-get \
ksym-longterm-wm-adsp2-preloader-put \
ksym-longterm-wm-adsp2-remove \
ksym-longterm-wm-adsp2-set-dspclk \
ksym-longterm-wm-halo-bus-error \
ksym-longterm-wm-halo-init \
ksym-longterm-wm-halo-wdt-expire \
ksym-longterm-wm-hubs-add-analogue-controls \
ksym-longterm-wm-hubs-add-analogue-routes \
ksym-longterm-wm-hubs-dcs-done \
ksym-longterm-wm-hubs-handle-analogue-pdata \
ksym-longterm-wm-hubs-hpl-mux \
ksym-longterm-wm-hubs-hpr-mux \
ksym-longterm-wm-hubs-set-bias-level \
ksym-longterm-wm-hubs-spkmix-tlv \
ksym-longterm-wm-hubs-update-class-w \
ksym-longterm-wm-hubs-vmid-ena \
ksym-longterm-wm1811-regmap-config \
ksym-longterm-wm8804-pm \
ksym-longterm-wm8804-probe \
ksym-longterm-wm8804-regmap-config \
ksym-longterm-wm8804-remove \
ksym-longterm-wm8903-mic-detect \
ksym-longterm-wm8958-mic-detect \
ksym-longterm-wm8958-regmap-config \
ksym-longterm-wm8962-mic-detect \
ksym-longterm-wm8994-base-regmap-config \
ksym-longterm-wm8994-irq-exit \
ksym-longterm-wm8994-irq-init \
ksym-longterm-wm8994-mic-detect \
ksym-longterm-wm8994-regmap-config \
ksym-longterm-wm9705-codec \
ksym-longterm-wm9712-codec \
ksym-longterm-wm9713-codec \
ksym-longterm-wm97xx-config-gpio \
ksym-longterm-wm97xx-get-gpio \
ksym-longterm-wm97xx-read-aux-adc \
ksym-longterm-wm97xx-reg-read \
ksym-longterm-wm97xx-reg-write \
ksym-longterm-wm97xx-register-mach-ops \
ksym-longterm-wm97xx-set-gpio \
ksym-longterm-wm97xx-set-suspend-mode \
ksym-longterm-wm97xx-unregister-mach-ops \
ksym-longterm-woken-wake-bit-function \
ksym-longterm-woken-wake-function \
ksym-longterm-work-busy \
ksym-longterm-work-on-cpu-key \
ksym-longterm-workqueue-congested \
ksym-longterm-workqueue-set-max-active \
ksym-longterm-would-dump \
ksym-longterm-wp-shared-mapping-range \
ksym-longterm-wpan-phy-find \
ksym-longterm-wpan-phy-for-each \
ksym-longterm-wpan-phy-free \
ksym-longterm-wpan-phy-new \
ksym-longterm-wpan-phy-register \
ksym-longterm-wpan-phy-unregister \
ksym-longterm-wrap-directory-iterator \
ksym-longterm-write-bytes-to-xdr-buf \
ksym-longterm-write-dirty-buffer \
ksym-longterm-write-dst \
ksym-longterm-write-inode-now \
ksym-longterm-writeback-inodes-sb \
ksym-longterm-writeback-inodes-sb-nr \
ksym-longterm-writeback-iter \
ksym-longterm-wsa-macro-set-spkr-mode \
ksym-longterm-ww-mutex-lock \
ksym-longterm-ww-mutex-lock-interruptible \
ksym-longterm-ww-mutex-trylock \
ksym-longterm-ww-mutex-unlock \
ksym-longterm-wwan-create-port \
ksym-longterm-wwan-port-get-drvdata \
ksym-longterm-wwan-port-rx \
ksym-longterm-wwan-port-txoff \
ksym-longterm-wwan-port-txon \
ksym-longterm-wwan-register-ops \
ksym-longterm-wwan-remove-port \
ksym-longterm-wwan-unregister-ops \
ksym-longterm-wx-change-mtu \
ksym-longterm-wx-check-flash-load \
ksym-longterm-wx-clean-all-rx-rings \
ksym-longterm-wx-clean-all-tx-rings \
ksym-longterm-wx-clear-hw-cntrs \
ksym-longterm-wx-clear-interrupt-scheme \
ksym-longterm-wx-configure \
ksym-longterm-wx-configure-rx \
ksym-longterm-wx-configure-vectors \
ksym-longterm-wx-configure-vf \
ksym-longterm-wx-control-hw \
ksym-longterm-wx-decode-ptype \
ksym-longterm-wx-disable-pcie-master \
ksym-longterm-wx-disable-rx \
ksym-longterm-wx-disable-rx-queue \
ksym-longterm-wx-disable-sec-rx-path \
ksym-longterm-wx-disable-sriov \
ksym-longterm-wx-disable-vf-rx-tx \
ksym-longterm-wx-enable-rx-queue \
ksym-longterm-wx-enable-sec-rx-path \
ksym-longterm-wx-fc-enable \
ksym-longterm-wx-features-check \
ksym-longterm-wx-fix-features \
ksym-longterm-wx-flush-sw-mac-table \
ksym-longterm-wx-free-irq \
ksym-longterm-wx-free-isb-resources \
ksym-longterm-wx-free-resources \
ksym-longterm-wx-get-channels \
ksym-longterm-wx-get-coalesce \
ksym-longterm-wx-get-drvinfo \
ksym-longterm-wx-get-ethtool-stats \
ksym-longterm-wx-get-fw-version-vf \
ksym-longterm-wx-get-link-ksettings \
ksym-longterm-wx-get-link-state-vf \
ksym-longterm-wx-get-mac-addr \
ksym-longterm-wx-get-mac-addr-vf \
ksym-longterm-wx-get-mac-stats \
ksym-longterm-wx-get-msglevel \
ksym-longterm-wx-get-pause-stats \
ksym-longterm-wx-get-pauseparam \
ksym-longterm-wx-get-pcie-msix-counts \
ksym-longterm-wx-get-ptp-stats \
ksym-longterm-wx-get-queues-vf \
ksym-longterm-wx-get-ringparam \
ksym-longterm-wx-get-rxfh \
ksym-longterm-wx-get-rxfh-fields \
ksym-longterm-wx-get-rxfh-key-size \
ksym-longterm-wx-get-sset-count \
ksym-longterm-wx-get-stats64 \
ksym-longterm-wx-get-strings \
ksym-longterm-wx-get-ts-info \
ksym-longterm-wx-host-interface-command \
ksym-longterm-wx-hwtstamp-get \
ksym-longterm-wx-hwtstamp-set \
ksym-longterm-wx-init-eeprom-params \
ksym-longterm-wx-init-hw-vf \
ksym-longterm-wx-init-interrupt-scheme \
ksym-longterm-wx-init-mbx-params-vf \
ksym-longterm-wx-init-rx-addrs \
ksym-longterm-wx-intr-enable \
ksym-longterm-wx-irq-disable \
ksym-longterm-wx-mac-set-default-filter \
ksym-longterm-wx-misc-isb \
ksym-longterm-wx-mng-present \
ksym-longterm-wx-msg-task \
ksym-longterm-wx-msix-clean-rings \
ksym-longterm-wx-napi-disable-all \
ksym-longterm-wx-napi-enable-all \
ksym-longterm-wx-negotiate-api-version \
ksym-longterm-wx-negotiate-api-vf \
ksym-longterm-wx-nway-reset \
ksym-longterm-wx-pci-sriov-configure \
ksym-longterm-wx-phy-read-reg-mdi-c22 \
ksym-longterm-wx-phy-read-reg-mdi-c45 \
ksym-longterm-wx-phy-write-reg-mdi-c22 \
ksym-longterm-wx-phy-write-reg-mdi-c45 \
ksym-longterm-wx-ping-all-vfs-with-link-status \
ksym-longterm-wx-ptp-check-pps-event \
ksym-longterm-wx-ptp-init \
ksym-longterm-wx-ptp-reset \
ksym-longterm-wx-ptp-reset-cyclecounter \
ksym-longterm-wx-ptp-stop \
ksym-longterm-wx-ptp-suspend \
ksym-longterm-wx-read-ee-hostif \
ksym-longterm-wx-read-ee-hostif-buffer \
ksym-longterm-wx-request-msix-irqs-vf \
ksym-longterm-wx-reset-hw-vf \
ksym-longterm-wx-reset-interrupt-capability \
ksym-longterm-wx-reset-mac \
ksym-longterm-wx-reset-misc \
ksym-longterm-wx-reset-vf \
ksym-longterm-wx-rlpml-set-vf \
ksym-longterm-wx-rss-indir-size \
ksym-longterm-wx-service-event-complete \
ksym-longterm-wx-service-event-schedule \
ksym-longterm-wx-service-timer \
ksym-longterm-wx-set-all-vfs \
ksym-longterm-wx-set-channels \
ksym-longterm-wx-set-coalesce \
ksym-longterm-wx-set-ethtool-ops-vf \
ksym-longterm-wx-set-features \
ksym-longterm-wx-set-link-ksettings \
ksym-longterm-wx-set-mac \
ksym-longterm-wx-set-mac-vf \
ksym-longterm-wx-set-msglevel \
ksym-longterm-wx-set-pauseparam \
ksym-longterm-wx-set-rar-vf \
ksym-longterm-wx-set-ring \
ksym-longterm-wx-set-rx-mode \
ksym-longterm-wx-set-rx-mode-vf \
ksym-longterm-wx-set-rxfh \
ksym-longterm-wx-set-rxfh-fields \
ksym-longterm-wx-set-uc-addr-vf \
ksym-longterm-wx-set-vfta-vf \
ksym-longterm-wx-setup-isb-resources \
ksym-longterm-wx-setup-resources \
ksym-longterm-wx-start-hw \
ksym-longterm-wx-stop-adapter \
ksym-longterm-wx-stop-adapter-vf \
ksym-longterm-wx-sw-init \
ksym-longterm-wx-update-mc-addr-list-vf \
ksym-longterm-wx-update-stats \
ksym-longterm-wx-update-xcast-mode-vf \
ksym-longterm-wx-vlan-rx-add-vid \
ksym-longterm-wx-vlan-rx-kill-vid \
ksym-longterm-wx-xmit-frame \
ksym-longterm-wxvf-close \
ksym-longterm-wxvf-init-service \
ksym-longterm-wxvf-open \
ksym-longterm-wxvf-remove \
ksym-longterm-wxvf-resume \
ksym-longterm-wxvf-shutdown \
ksym-longterm-wxvf-suspend \
ksym-longterm-wxvf-watchdog-update-link \
ksym-longterm-x509-cert-parse \
ksym-longterm-x509-decode-time \
ksym-longterm-x509-free-certificate \
ksym-longterm-x509-load-certificate-list \
ksym-longterm-xa-clear-mark \
ksym-longterm-xa-delete-node \
ksym-longterm-xa-destroy \
ksym-longterm-xa-erase \
ksym-longterm-xa-extract \
ksym-longterm-xa-find \
ksym-longterm-xa-find-after \
ksym-longterm-xa-get-mark \
ksym-longterm-xa-get-order \
ksym-longterm-xa-load \
ksym-longterm-xa-set-mark \
ksym-longterm-xa-store \
ksym-longterm-xa-store-range \
ksym-longterm-xas-clear-mark \
ksym-longterm-xas-create-range \
ksym-longterm-xas-destroy \
ksym-longterm-xas-find \
ksym-longterm-xas-find-conflict \
ksym-longterm-xas-find-marked \
ksym-longterm-xas-get-mark \
ksym-longterm-xas-get-order \
ksym-longterm-xas-init-marks \
ksym-longterm-xas-load \
ksym-longterm-xas-nomem \
ksym-longterm-xas-pause \
ksym-longterm-xas-set-mark \
ksym-longterm-xas-split \
ksym-longterm-xas-split-alloc \
ksym-longterm-xas-store \
ksym-longterm-xas-try-split \
ksym-longterm-xas-try-split-min-order \
ksym-longterm-xattr-full-name \
ksym-longterm-xattr-supports-user-prefix \
ksym-longterm-xc2028-attach \
ksym-longterm-xc4000-attach \
ksym-longterm-xc5000-attach \
ksym-longterm-xchacha20poly1305-decrypt \
ksym-longterm-xchacha20poly1305-encrypt \
ksym-longterm-xcv-init-hw \
ksym-longterm-xcv-setup-link \
ksym-longterm-xdma-disable-user-irq \
ksym-longterm-xdma-enable-user-irq \
ksym-longterm-xdma-get-user-irq \
ksym-longterm-xdp-attachment-setup \
ksym-longterm-xdp-build-skb-from-buff \
ksym-longterm-xdp-build-skb-from-frame \
ksym-longterm-xdp-build-skb-from-zc \
ksym-longterm-xdp-convert-zc-to-xdp-frame \
ksym-longterm-xdp-do-flush \
ksym-longterm-xdp-do-redirect \
ksym-longterm-xdp-do-redirect-frame \
ksym-longterm-xdp-features-clear-redirect-target \
ksym-longterm-xdp-features-clear-redirect-target-locked \
ksym-longterm-xdp-features-set-redirect-target \
ksym-longterm-xdp-features-set-redirect-target-locked \
ksym-longterm-xdp-master-redirect \
ksym-longterm-xdp-reg-mem-model \
ksym-longterm-xdp-reg-page-pool \
ksym-longterm-xdp-return-buff \
ksym-longterm-xdp-return-frag \
ksym-longterm-xdp-return-frame \
ksym-longterm-xdp-return-frame-bulk \
ksym-longterm-xdp-return-frame-rx-napi \
ksym-longterm-xdp-rxq-info-attach-page-pool \
ksym-longterm-xdp-rxq-info-is-reg \
ksym-longterm-xdp-rxq-info-reg-mem-model \
ksym-longterm-xdp-rxq-info-unreg \
ksym-longterm-xdp-rxq-info-unreg-mem-model \
ksym-longterm-xdp-rxq-info-unused \
ksym-longterm-xdp-set-features-flag \
ksym-longterm-xdp-set-features-flag-locked \
ksym-longterm-xdp-unreg-mem-model \
ksym-longterm-xdp-unreg-page-pool \
ksym-longterm-xdp-warn \
ksym-longterm-xdr-buf-from-iov \
ksym-longterm-xdr-buf-subsegment \
ksym-longterm-xdr-buf-to-bvec \
ksym-longterm-xdr-buf-to-sg \
ksym-longterm-xdr-buf-to-sg-alloc \
ksym-longterm-xdr-buf-trim \
ksym-longterm-xdr-decode-array2 \
ksym-longterm-xdr-decode-word \
ksym-longterm-xdr-encode-array2 \
ksym-longterm-xdr-encode-netobj \
ksym-longterm-xdr-encode-opaque \
ksym-longterm-xdr-encode-opaque-fixed \
ksym-longterm-xdr-encode-string \
ksym-longterm-xdr-encode-word \
ksym-longterm-xdr-enter-page \
ksym-longterm-xdr-finish-decode \
ksym-longterm-xdr-init-decode \
ksym-longterm-xdr-init-decode-pages \
ksym-longterm-xdr-init-encode \
ksym-longterm-xdr-init-encode-pages \
ksym-longterm-xdr-inline-decode \
ksym-longterm-xdr-inline-pages \
ksym-longterm-xdr-page-pos \
ksym-longterm-xdr-process-buf \
ksym-longterm-xdr-read-pages \
ksym-longterm-xdr-reserve-space \
ksym-longterm-xdr-reserve-space-vec \
ksym-longterm-xdr-restrict-buflen \
ksym-longterm-xdr-set-pagelen \
ksym-longterm-xdr-stream-decode-opaque-auth \
ksym-longterm-xdr-stream-decode-string-dup \
ksym-longterm-xdr-stream-encode-opaque-auth \
ksym-longterm-xdr-stream-move-subsegment \
ksym-longterm-xdr-stream-pos \
ksym-longterm-xdr-stream-subsegment \
ksym-longterm-xdr-stream-zero \
ksym-longterm-xdr-terminate-string \
ksym-longterm-xdr-truncate-decode \
ksym-longterm-xdr-truncate-encode \
ksym-longterm-xdr-write-pages \
ksym-longterm-xfer-to-guest-mode-handle-work \
ksym-longterm-xfrm-aalg-get-byid \
ksym-longterm-xfrm-aalg-get-byidx \
ksym-longterm-xfrm-aalg-get-byname \
ksym-longterm-xfrm-aead-get-byname \
ksym-longterm-xfrm-alloc-spi \
ksym-longterm-xfrm-audit-policy-add \
ksym-longterm-xfrm-audit-policy-delete \
ksym-longterm-xfrm-audit-state-add \
ksym-longterm-xfrm-audit-state-delete \
ksym-longterm-xfrm-audit-state-icvfail \
ksym-longterm-xfrm-audit-state-notfound \
ksym-longterm-xfrm-audit-state-notfound-simple \
ksym-longterm-xfrm-audit-state-replay \
ksym-longterm-xfrm-audit-state-replay-overflow \
ksym-longterm-xfrm-bpf-md-dst \
ksym-longterm-xfrm-calg-get-byid \
ksym-longterm-xfrm-calg-get-byname \
ksym-longterm-xfrm-count-pfkey-auth-supported \
ksym-longterm-xfrm-count-pfkey-enc-supported \
ksym-longterm-xfrm-dev-offload-ok \
ksym-longterm-xfrm-dev-policy-add \
ksym-longterm-xfrm-dev-policy-flush \
ksym-longterm-xfrm-dev-resume \
ksym-longterm-xfrm-dev-state-add \
ksym-longterm-xfrm-dev-state-delete \
ksym-longterm-xfrm-dev-state-flush \
ksym-longterm-xfrm-dst-ifdown \
ksym-longterm-xfrm-ealg-get-byid \
ksym-longterm-xfrm-ealg-get-byidx \
ksym-longterm-xfrm-ealg-get-byname \
ksym-longterm-xfrm-find-acq \
ksym-longterm-xfrm-find-acq-byseq \
ksym-longterm-xfrm-flush-gc \
ksym-longterm-xfrm-get-acqseq \
ksym-longterm-xfrm-if-register-cb \
ksym-longterm-xfrm-if-unregister-cb \
ksym-longterm-xfrm-init-replay \
ksym-longterm-xfrm-init-state \
ksym-longterm-xfrm-input \
ksym-longterm-xfrm-input-register-afinfo \
ksym-longterm-xfrm-input-resume \
ksym-longterm-xfrm-input-state-lookup \
ksym-longterm-xfrm-input-unregister-afinfo \
ksym-longterm-xfrm-local-error \
ksym-longterm-xfrm-lookup \
ksym-longterm-xfrm-lookup-route \
ksym-longterm-xfrm-lookup-with-ifid \
ksym-longterm-xfrm-migrate \
ksym-longterm-xfrm-migrate-state-find \
ksym-longterm-xfrm-msg-min \
ksym-longterm-xfrm-nat-keepalive-fini \
ksym-longterm-xfrm-nat-keepalive-init \
ksym-longterm-xfrm-output \
ksym-longterm-xfrm-output-resume \
ksym-longterm-xfrm-parse-spi \
ksym-longterm-xfrm-policy-alloc \
ksym-longterm-xfrm-policy-byid \
ksym-longterm-xfrm-policy-bysel-ctx \
ksym-longterm-xfrm-policy-delete \
ksym-longterm-xfrm-policy-destroy \
ksym-longterm-xfrm-policy-flush \
ksym-longterm-xfrm-policy-hash-rebuild \
ksym-longterm-xfrm-policy-insert \
ksym-longterm-xfrm-policy-register-afinfo \
ksym-longterm-xfrm-policy-unregister-afinfo \
ksym-longterm-xfrm-policy-walk \
ksym-longterm-xfrm-policy-walk-done \
ksym-longterm-xfrm-policy-walk-init \
ksym-longterm-xfrm-probe-algs \
ksym-longterm-xfrm-register-km \
ksym-longterm-xfrm-register-mode-cbs \
ksym-longterm-xfrm-register-type \
ksym-longterm-xfrm-register-type-offload \
ksym-longterm-xfrm-replay-seqhi \
ksym-longterm-xfrm-sad-getinfo \
ksym-longterm-xfrm-set-type-offload \
ksym-longterm-xfrm-spd-getinfo \
ksym-longterm-xfrm-state-add \
ksym-longterm-xfrm-state-afinfo-get-rcu \
ksym-longterm-xfrm-state-alloc \
ksym-longterm-xfrm-state-check-expire \
ksym-longterm-xfrm-state-delete \
ksym-longterm-xfrm-state-flush \
ksym-longterm-xfrm-state-free \
ksym-longterm-xfrm-state-insert \
ksym-longterm-xfrm-state-lookup \
ksym-longterm-xfrm-state-lookup-byaddr \
ksym-longterm-xfrm-state-lookup-byspi \
ksym-longterm-xfrm-state-migrate \
ksym-longterm-xfrm-state-mtu \
ksym-longterm-xfrm-state-register-afinfo \
ksym-longterm-xfrm-state-unregister-afinfo \
ksym-longterm-xfrm-state-update \
ksym-longterm-xfrm-state-walk \
ksym-longterm-xfrm-state-walk-done \
ksym-longterm-xfrm-state-walk-init \
ksym-longterm-xfrm-stateonly-find \
ksym-longterm-xfrm-trans-queue \
ksym-longterm-xfrm-trans-queue-net \
ksym-longterm-xfrm-unregister-km \
ksym-longterm-xfrm-unregister-mode-cbs \
ksym-longterm-xfrm-unregister-type \
ksym-longterm-xfrm-unregister-type-offload \
ksym-longterm-xfrm-user-policy \
ksym-longterm-xfrm4-gro-udp-encap-rcv \
ksym-longterm-xfrm4-protocol-deregister \
ksym-longterm-xfrm4-protocol-register \
ksym-longterm-xfrm4-rcv \
ksym-longterm-xfrm4-rcv-encap \
ksym-longterm-xfrm4-tunnel-check-size \
ksym-longterm-xfrm4-tunnel-deregister \
ksym-longterm-xfrm4-tunnel-register \
ksym-longterm-xfrm4-udp-encap-rcv \
ksym-longterm-xfrm6-input-addr \
ksym-longterm-xfrm6-protocol-deregister \
ksym-longterm-xfrm6-protocol-register \
ksym-longterm-xfrm6-rcv \
ksym-longterm-xfrm6-rcv-encap \
ksym-longterm-xfrm6-rcv-spi \
ksym-longterm-xfrm6-rcv-tnl \
ksym-longterm-xfrm6-tunnel-alloc-spi \
ksym-longterm-xfrm6-tunnel-check-size \
ksym-longterm-xfrm6-tunnel-deregister \
ksym-longterm-xfrm6-tunnel-register \
ksym-longterm-xfrm6-tunnel-spi-lookup \
ksym-longterm-xfrma-policy \
ksym-longterm-xgene-enet-phy-register \
ksym-longterm-xgene-mdio-rd-mac \
ksym-longterm-xgene-mdio-rgmii-read \
ksym-longterm-xgene-mdio-rgmii-write \
ksym-longterm-xgene-mdio-wr-mac \
ksym-longterm-xhci-add-endpoint \
ksym-longterm-xhci-check-bandwidth \
ksym-longterm-xhci-create-secondary-interrupter \
ksym-longterm-xhci-dbg-trace \
ksym-longterm-xhci-drop-endpoint \
ksym-longterm-xhci-ext-cap-init \
ksym-longterm-xhci-gen-setup \
ksym-longterm-xhci-get-endpoint-index \
ksym-longterm-xhci-get-ep-ctx \
ksym-longterm-xhci-hub-control \
ksym-longterm-xhci-init-driver \
ksym-longterm-xhci-initialize-ring-info \
ksym-longterm-xhci-msi-irq \
ksym-longterm-xhci-pci-common-probe \
ksym-longterm-xhci-pci-remove \
ksym-longterm-xhci-plat-pm-ops \
ksym-longterm-xhci-plat-probe \
ksym-longterm-xhci-plat-remove \
ksym-longterm-xhci-port-state-to-neutral \
ksym-longterm-xhci-portsc-readl \
ksym-longterm-xhci-portsc-writel \
ksym-longterm-xhci-remove-secondary-interrupter \
ksym-longterm-xhci-reset-bandwidth \
ksym-longterm-xhci-resume \
ksym-longterm-xhci-run \
ksym-longterm-xhci-shutdown \
ksym-longterm-xhci-sideband-add-endpoint \
ksym-longterm-xhci-sideband-check \
ksym-longterm-xhci-sideband-create-interrupter \
ksym-longterm-xhci-sideband-get-endpoint-buffer \
ksym-longterm-xhci-sideband-get-event-buffer \
ksym-longterm-xhci-sideband-interrupter-id \
ksym-longterm-xhci-sideband-notify-ep-ring-free \
ksym-longterm-xhci-sideband-register \
ksym-longterm-xhci-sideband-remove-endpoint \
ksym-longterm-xhci-sideband-remove-interrupter \
ksym-longterm-xhci-sideband-stop-endpoint \
ksym-longterm-xhci-sideband-unregister \
ksym-longterm-xhci-stop \
ksym-longterm-xhci-stop-endpoint-sync \
ksym-longterm-xhci-suspend \
ksym-longterm-xhci-update-hub-device \
ksym-longterm-xilinx-core-probe \
ksym-longterm-xilinx-vdma-channel-set-config \
ksym-longterm-xillybus-cleanup-chrdev \
ksym-longterm-xillybus-endpoint-discovery \
ksym-longterm-xillybus-endpoint-remove \
ksym-longterm-xillybus-find-inode \
ksym-longterm-xillybus-init-chrdev \
ksym-longterm-xillybus-init-endpoint \
ksym-longterm-xillybus-isr \
ksym-longterm-xlnx-register-event \
ksym-longterm-xlnx-unregister-event \
ksym-longterm-xor-block-inner-neon \
ksym-longterm-xor-blocks \
ksym-longterm-xp-alloc \
ksym-longterm-xp-alloc-batch \
ksym-longterm-xp-can-alloc \
ksym-longterm-xp-dma-map \
ksym-longterm-xp-dma-unmap \
ksym-longterm-xp-fill-cb \
ksym-longterm-xp-free \
ksym-longterm-xp-raw-get-ctx \
ksym-longterm-xp-raw-get-data \
ksym-longterm-xp-raw-get-dma \
ksym-longterm-xp-set-rxq-info \
ksym-longterm-xpcs-config-eee-mult-fact \
ksym-longterm-xpcs-create-fwnode \
ksym-longterm-xpcs-create-mdiodev \
ksym-longterm-xpcs-create-pcs-mdiodev \
ksym-longterm-xpcs-destroy \
ksym-longterm-xpcs-destroy-pcs \
ksym-longterm-xpcs-get-an-mode \
ksym-longterm-xpcs-to-phylink-pcs \
ksym-longterm-xprt-add-backlog \
ksym-longterm-xprt-add-backlog-noncongested \
ksym-longterm-xprt-adjust-cwnd \
ksym-longterm-xprt-alloc \
ksym-longterm-xprt-alloc-slot \
ksym-longterm-xprt-complete-rqst \
ksym-longterm-xprt-destroy-backchannel \
ksym-longterm-xprt-disconnect-done \
ksym-longterm-xprt-find-transport-ident \
ksym-longterm-xprt-force-disconnect \
ksym-longterm-xprt-free \
ksym-longterm-xprt-free-slot \
ksym-longterm-xprt-get \
ksym-longterm-xprt-lock-connect \
ksym-longterm-xprt-lookup-rqst \
ksym-longterm-xprt-pin-rqst \
ksym-longterm-xprt-put \
ksym-longterm-xprt-reconnect-backoff \
ksym-longterm-xprt-reconnect-delay \
ksym-longterm-xprt-register-transport \
ksym-longterm-xprt-release-rqst-cong \
ksym-longterm-xprt-release-xprt \
ksym-longterm-xprt-release-xprt-cong \
ksym-longterm-xprt-request-get-cong \
ksym-longterm-xprt-reserve-xprt \
ksym-longterm-xprt-reserve-xprt-cong \
ksym-longterm-xprt-setup-backchannel \
ksym-longterm-xprt-unlock-connect \
ksym-longterm-xprt-unpin-rqst \
ksym-longterm-xprt-unregister-transport \
ksym-longterm-xprt-update-rtt \
ksym-longterm-xprt-wait-for-buffer-space \
ksym-longterm-xprt-wait-for-reply-request-def \
ksym-longterm-xprt-wait-for-reply-request-rtt \
ksym-longterm-xprt-wake-pending-tasks \
ksym-longterm-xprt-wake-up-backlog \
ksym-longterm-xprt-write-space \
ksym-longterm-xprtiod-workqueue \
ksym-longterm-xrs7003e-info \
ksym-longterm-xrs7003f-info \
ksym-longterm-xrs7004e-info \
ksym-longterm-xrs7004f-info \
ksym-longterm-xrs700x-switch-alloc \
ksym-longterm-xrs700x-switch-register \
ksym-longterm-xrs700x-switch-remove \
ksym-longterm-xrs700x-switch-shutdown \
ksym-longterm-xsk-clear-rx-need-wakeup \
ksym-longterm-xsk-clear-tx-need-wakeup \
ksym-longterm-xsk-get-pool-from-qid \
ksym-longterm-xsk-set-rx-need-wakeup \
ksym-longterm-xsk-set-tx-need-wakeup \
ksym-longterm-xsk-tx-completed \
ksym-longterm-xsk-tx-peek-desc \
ksym-longterm-xsk-tx-peek-release-desc-batch \
ksym-longterm-xsk-tx-release \
ksym-longterm-xsk-uses-need-wakeup \
ksym-longterm-xspi-dirmap-write \
ksym-longterm-xt-alloc-entry-offsets \
ksym-longterm-xt-alloc-table-info \
ksym-longterm-xt-check-entry-offsets \
ksym-longterm-xt-check-match \
ksym-longterm-xt-check-proc-name \
ksym-longterm-xt-check-table-hooks \
ksym-longterm-xt-check-target \
ksym-longterm-xt-compat-add-offset \
ksym-longterm-xt-compat-calc-jump \
ksym-longterm-xt-compat-check-entry-offsets \
ksym-longterm-xt-compat-flush-offsets \
ksym-longterm-xt-compat-init-offsets \
ksym-longterm-xt-compat-lock \
ksym-longterm-xt-compat-match-from-user \
ksym-longterm-xt-compat-match-offset \
ksym-longterm-xt-compat-match-to-user \
ksym-longterm-xt-compat-target-from-user \
ksym-longterm-xt-compat-target-offset \
ksym-longterm-xt-compat-target-to-user \
ksym-longterm-xt-compat-unlock \
ksym-longterm-xt-copy-counters \
ksym-longterm-xt-counters-alloc \
ksym-longterm-xt-data-to-user \
ksym-longterm-xt-find-jump-offset \
ksym-longterm-xt-find-match \
ksym-longterm-xt-find-revision \
ksym-longterm-xt-find-table \
ksym-longterm-xt-find-table-lock \
ksym-longterm-xt-free-table-info \
ksym-longterm-xt-hook-ops-alloc \
ksym-longterm-xt-match-to-user \
ksym-longterm-xt-percpu-counter-alloc \
ksym-longterm-xt-percpu-counter-free \
ksym-longterm-xt-proto-fini \
ksym-longterm-xt-proto-init \
ksym-longterm-xt-rateest-lookup \
ksym-longterm-xt-rateest-put \
ksym-longterm-xt-recseq \
ksym-longterm-xt-register-match \
ksym-longterm-xt-register-matches \
ksym-longterm-xt-register-table \
ksym-longterm-xt-register-target \
ksym-longterm-xt-register-targets \
ksym-longterm-xt-register-template \
ksym-longterm-xt-replace-table \
ksym-longterm-xt-request-find-match \
ksym-longterm-xt-request-find-table-lock \
ksym-longterm-xt-request-find-target \
ksym-longterm-xt-table-unlock \
ksym-longterm-xt-target-to-user \
ksym-longterm-xt-tee-enabled \
ksym-longterm-xt-unregister-match \
ksym-longterm-xt-unregister-matches \
ksym-longterm-xt-unregister-table-exit \
ksym-longterm-xt-unregister-table-pre-exit \
ksym-longterm-xt-unregister-target \
ksym-longterm-xt-unregister-targets \
ksym-longterm-xt-unregister-template \
ksym-longterm-xvip-cleanup-resources \
ksym-longterm-xvip-clr-and-set \
ksym-longterm-xvip-clr-or-set \
ksym-longterm-xvip-enum-frame-size \
ksym-longterm-xvip-enum-mbus-code \
ksym-longterm-xvip-get-format-by-code \
ksym-longterm-xvip-get-format-by-fourcc \
ksym-longterm-xvip-init-resources \
ksym-longterm-xvip-of-get-format \
ksym-longterm-xvip-set-format-size \
ksym-longterm-xvtc-generator-start \
ksym-longterm-xvtc-generator-stop \
ksym-longterm-xvtc-of-get \
ksym-longterm-xvtc-put \
ksym-longterm-xxh32 \
ksym-longterm-xxh32-copy-state \
ksym-longterm-xxh32-reset \
ksym-longterm-xxh64 \
ksym-longterm-xxh64-copy-state \
ksym-longterm-xxh64-digest \
ksym-longterm-xxh64-reset \
ksym-longterm-xxh64-update \
ksym-longterm-xz-dec-end \
ksym-longterm-xz-dec-init \
ksym-longterm-xz-dec-microlzma-alloc \
ksym-longterm-xz-dec-microlzma-end \
ksym-longterm-xz-dec-microlzma-reset \
ksym-longterm-xz-dec-microlzma-run \
ksym-longterm-xz-dec-reset \
ksym-longterm-xz-dec-run \
ksym-longterm-yield \
ksym-longterm-yield-to \
ksym-longterm-yoga-c630-ec-read16 \
ksym-longterm-yoga-c630-ec-read8 \
ksym-longterm-yoga-c630-ec-register-notify \
ksym-longterm-yoga-c630-ec-ucsi-get-version \
ksym-longterm-yoga-c630-ec-ucsi-read \
ksym-longterm-yoga-c630-ec-ucsi-write \
ksym-longterm-yoga-c630-ec-unregister-notify \
ksym-longterm-zap-vma-ptes \
ksym-longterm-zd1301-demod-get-dvb-frontend \
ksym-longterm-zd1301-demod-get-i2c-adapter \
ksym-longterm-zero-fill-bio-iter \
ksym-longterm-zero-pfn \
ksym-longterm-zerocopy-sg-from-iter \
ksym-longterm-zgid \
ksym-longterm-zl10036-attach \
ksym-longterm-zl10039-attach \
ksym-longterm-zl10353-attach \
ksym-longterm-zl30731-chip-info \
ksym-longterm-zl30732-chip-info \
ksym-longterm-zl30733-chip-info \
ksym-longterm-zl30734-chip-info \
ksym-longterm-zl30735-chip-info \
ksym-longterm-zl3073x-dev-probe \
ksym-longterm-zl3073x-devm-alloc \
ksym-longterm-zl3073x-regmap-config \
ksym-longterm-zlib-deflate \
ksym-longterm-zlib-deflate-dfltcc-enabled \
ksym-longterm-zlib-deflate-workspacesize \
ksym-longterm-zlib-deflateEnd \
ksym-longterm-zlib-deflateInit2 \
ksym-longterm-zlib-deflateReset \
ksym-longterm-zlib-inflate \
ksym-longterm-zlib-inflate-blob \
ksym-longterm-zlib-inflate-workspacesize \
ksym-longterm-zlib-inflateEnd \
ksym-longterm-zlib-inflateIncomp \
ksym-longterm-zlib-inflateInit2 \
ksym-longterm-zlib-inflateReset \
ksym-longterm-zone-device-page-init \
ksym-longterm-zpa2326-isreg-precious \
ksym-longterm-zpa2326-isreg-readable \
ksym-longterm-zpa2326-isreg-writeable \
ksym-longterm-zpa2326-pm-ops \
ksym-longterm-zpa2326-probe \
ksym-longterm-zpa2326-remove \
ksym-longterm-zs-compact \
ksym-longterm-zs-create-pool \
ksym-longterm-zs-destroy-pool \
ksym-longterm-zs-free \
ksym-longterm-zs-get-total-pages \
ksym-longterm-zs-huge-class-size \
ksym-longterm-zs-lookup-class-index \
ksym-longterm-zs-malloc \
ksym-longterm-zs-obj-read-begin \
ksym-longterm-zs-obj-read-end \
ksym-longterm-zs-obj-write \
ksym-longterm-zs-pool-stats \
ksym-longterm-zstd-cctx-set-param \
ksym-longterm-zstd-cctx-workspace-bound \
ksym-longterm-zstd-cctx-workspace-bound-with-ext-seq-prod \
ksym-longterm-zstd-compress-bound \
ksym-longterm-zstd-compress-cctx \
ksym-longterm-zstd-compress-sequences-and-literals \
ksym-longterm-zstd-compress-stream \
ksym-longterm-zstd-compress-using-cdict \
ksym-longterm-zstd-create-cctx-advanced \
ksym-longterm-zstd-create-cdict-byreference \
ksym-longterm-zstd-create-dctx-advanced \
ksym-longterm-zstd-create-ddict-byreference \
ksym-longterm-zstd-cstream-workspace-bound \
ksym-longterm-zstd-cstream-workspace-bound-with-ext-seq-prod \
ksym-longterm-zstd-dctx-workspace-bound \
ksym-longterm-zstd-decompress-dctx \
ksym-longterm-zstd-decompress-stream \
ksym-longterm-zstd-decompress-using-ddict \
ksym-longterm-zstd-default-clevel \
ksym-longterm-zstd-dstream-workspace-bound \
ksym-longterm-zstd-end-stream \
ksym-longterm-zstd-find-frame-compressed-size \
ksym-longterm-zstd-flush-stream \
ksym-longterm-zstd-free-cctx \
ksym-longterm-zstd-free-cdict \
ksym-longterm-zstd-free-dctx \
ksym-longterm-zstd-free-ddict \
ksym-longterm-zstd-get-cparams \
ksym-longterm-zstd-get-error-code \
ksym-longterm-zstd-get-error-name \
ksym-longterm-zstd-get-frame-header \
ksym-longterm-zstd-get-params \
ksym-longterm-zstd-init-cctx \
ksym-longterm-zstd-init-cstream \
ksym-longterm-zstd-init-dctx \
ksym-longterm-zstd-init-dstream \
ksym-longterm-zstd-is-error \
ksym-longterm-zstd-max-clevel \
ksym-longterm-zstd-min-clevel \
ksym-longterm-zstd-register-sequence-producer \
ksym-longterm-zstd-reset-cstream \
ksym-longterm-zstd-reset-dstream \
ksym-longterm-zynqmp-pm-aes-engine \
ksym-longterm-zynqmp-pm-bootmode-read \
ksym-longterm-zynqmp-pm-bootmode-write \
ksym-longterm-zynqmp-pm-clock-disable \
ksym-longterm-zynqmp-pm-clock-enable \
ksym-longterm-zynqmp-pm-clock-getdivider \
ksym-longterm-zynqmp-pm-clock-getparent \
ksym-longterm-zynqmp-pm-clock-getstate \
ksym-longterm-zynqmp-pm-clock-setdivider \
ksym-longterm-zynqmp-pm-clock-setparent \
ksym-longterm-zynqmp-pm-efuse-access \
ksym-longterm-zynqmp-pm-feature \
ksym-longterm-zynqmp-pm-force-pwrdwn \
ksym-longterm-zynqmp-pm-fpga-get-config-status \
ksym-longterm-zynqmp-pm-fpga-get-status \
ksym-longterm-zynqmp-pm-fpga-load \
ksym-longterm-zynqmp-pm-get-api-version \
ksym-longterm-zynqmp-pm-get-chipid \
ksym-longterm-zynqmp-pm-get-family-info \
ksym-longterm-zynqmp-pm-get-pll-frac-data \
ksym-longterm-zynqmp-pm-get-pll-frac-mode \
ksym-longterm-zynqmp-pm-get-rpu-mode \
ksym-longterm-zynqmp-pm-invoke-fn \
ksym-longterm-zynqmp-pm-is-function-supported \
ksym-longterm-zynqmp-pm-load-pdi \
ksym-longterm-zynqmp-pm-ospi-mux-select \
ksym-longterm-zynqmp-pm-pinctrl-get-config \
ksym-longterm-zynqmp-pm-pinctrl-release \
ksym-longterm-zynqmp-pm-pinctrl-request \
ksym-longterm-zynqmp-pm-pinctrl-set-config \
ksym-longterm-zynqmp-pm-pinctrl-set-function \
ksym-longterm-zynqmp-pm-query-data \
ksym-longterm-zynqmp-pm-read-ggs \
ksym-longterm-zynqmp-pm-read-pggs \
ksym-longterm-zynqmp-pm-register-notifier \
ksym-longterm-zynqmp-pm-release-node \
ksym-longterm-zynqmp-pm-request-node \
ksym-longterm-zynqmp-pm-request-wake \
ksym-longterm-zynqmp-pm-reset-assert \
ksym-longterm-zynqmp-pm-reset-get-status \
ksym-longterm-zynqmp-pm-sd-dll-reset \
ksym-longterm-zynqmp-pm-set-gem-config \
ksym-longterm-zynqmp-pm-set-pll-frac-data \
ksym-longterm-zynqmp-pm-set-pll-frac-mode \
ksym-longterm-zynqmp-pm-set-requirement \
ksym-longterm-zynqmp-pm-set-rpu-mode \
ksym-longterm-zynqmp-pm-set-sd-config \
ksym-longterm-zynqmp-pm-set-sd-tapdelay \
ksym-longterm-zynqmp-pm-set-suspend-mode \
ksym-longterm-zynqmp-pm-set-tapdelay-bypass \
ksym-longterm-zynqmp-pm-set-tcm-config \
ksym-longterm-zynqmp-pm-sha-hash \
ksym-longterm-zynqmp-pm-write-ggs \
ksym-longterm-zynqmp-pm-write-pggs \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
awk \
coreutils \
distribution-release \
kmod-zstd \
modutils \
suse-kernel-rpm-scriptlets \
suse-module-tools"

inherit rpm
