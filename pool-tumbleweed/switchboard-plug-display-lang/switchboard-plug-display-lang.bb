SUMMARY = "Translations for package switchboard-plug-display"
DESCRIPTION = "Provides translations for the 'switchboard-plug-display' package."
LICENSE = "GPL-3.0-or-later"

PV = "8.0.3"

RPM_NAME = "switchboard-plug-display-lang-8.0.3-1.1.noarch.rpm"
RPM_HASH = "af2d4f435b5213bd995c63b71831c42d740e91ee8676333654a05e43a050c615dee9b232b94ed792b339a824a7b1837c153324d16fa43dbdb6238c3a8a845f89"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale-switchboard-plug-display-af \
locale-switchboard-plug-display-ar \
locale-switchboard-plug-display-as \
locale-switchboard-plug-display-ast \
locale-switchboard-plug-display-az \
locale-switchboard-plug-display-be \
locale-switchboard-plug-display-bg \
locale-switchboard-plug-display-bn \
locale-switchboard-plug-display-br \
locale-switchboard-plug-display-bs \
locale-switchboard-plug-display-ca \
locale-switchboard-plug-display-cs \
locale-switchboard-plug-display-cy \
locale-switchboard-plug-display-da \
locale-switchboard-plug-display-de \
locale-switchboard-plug-display-dz \
locale-switchboard-plug-display-el \
locale-switchboard-plug-display-en-AU \
locale-switchboard-plug-display-en-CA \
locale-switchboard-plug-display-en-GB \
locale-switchboard-plug-display-eo \
locale-switchboard-plug-display-es \
locale-switchboard-plug-display-et \
locale-switchboard-plug-display-eu \
locale-switchboard-plug-display-fa \
locale-switchboard-plug-display-fi \
locale-switchboard-plug-display-fr \
locale-switchboard-plug-display-fr-CA \
locale-switchboard-plug-display-ga \
locale-switchboard-plug-display-gd \
locale-switchboard-plug-display-gl \
locale-switchboard-plug-display-gu \
locale-switchboard-plug-display-he \
locale-switchboard-plug-display-hi \
locale-switchboard-plug-display-hr \
locale-switchboard-plug-display-hu \
locale-switchboard-plug-display-ia \
locale-switchboard-plug-display-id \
locale-switchboard-plug-display-is \
locale-switchboard-plug-display-it \
locale-switchboard-plug-display-ja \
locale-switchboard-plug-display-ka \
locale-switchboard-plug-display-kk \
locale-switchboard-plug-display-km \
locale-switchboard-plug-display-kn \
locale-switchboard-plug-display-ko \
locale-switchboard-plug-display-lt \
locale-switchboard-plug-display-lv \
locale-switchboard-plug-display-mk \
locale-switchboard-plug-display-ml \
locale-switchboard-plug-display-mr \
locale-switchboard-plug-display-ms \
locale-switchboard-plug-display-nb \
locale-switchboard-plug-display-ne \
locale-switchboard-plug-display-nl \
locale-switchboard-plug-display-nn \
locale-switchboard-plug-display-oc \
locale-switchboard-plug-display-or \
locale-switchboard-plug-display-pa \
locale-switchboard-plug-display-pl \
locale-switchboard-plug-display-pt \
locale-switchboard-plug-display-pt-BR \
locale-switchboard-plug-display-ro \
locale-switchboard-plug-display-ru \
locale-switchboard-plug-display-si \
locale-switchboard-plug-display-sk \
locale-switchboard-plug-display-sl \
locale-switchboard-plug-display-sq \
locale-switchboard-plug-display-sr \
locale-switchboard-plug-display-sv \
locale-switchboard-plug-display-ta \
locale-switchboard-plug-display-te \
locale-switchboard-plug-display-th \
locale-switchboard-plug-display-tr \
locale-switchboard-plug-display-ug \
locale-switchboard-plug-display-uk \
locale-switchboard-plug-display-vi \
locale-switchboard-plug-display-wa \
locale-switchboard-plug-display-zh \
locale-switchboard-plug-display-zh-CN \
locale-switchboard-plug-display-zh-TW \
switchboard-plug-display-lang \
switchboard-plug-display-lang-all"

RDEPENDS:${PN} += "switchboard-plug-display"

inherit rpm
