SUMMARY = "Translations for package libKF6GlobalAccel6"
DESCRIPTION = "Provides translations for the 'libKF6GlobalAccel6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6GlobalAccel6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "dd3c4370160b43ef12034e538d03efcf72de3f5a778cac0abbed23a04fa76fda18e7226599188363a7d0bad0b95e3fe59566628bc8d1a4909b4240591f9453b4"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6GlobalAccel6-lang \
libKF6GlobalAccel6-lang-all \
locale-libKF6GlobalAccel6-af \
locale-libKF6GlobalAccel6-ar \
locale-libKF6GlobalAccel6-as \
locale-libKF6GlobalAccel6-ast \
locale-libKF6GlobalAccel6-az \
locale-libKF6GlobalAccel6-be \
locale-libKF6GlobalAccel6-be@latin \
locale-libKF6GlobalAccel6-bg \
locale-libKF6GlobalAccel6-bn \
locale-libKF6GlobalAccel6-bn-IN \
locale-libKF6GlobalAccel6-br \
locale-libKF6GlobalAccel6-bs \
locale-libKF6GlobalAccel6-ca \
locale-libKF6GlobalAccel6-ca@valencia \
locale-libKF6GlobalAccel6-cs \
locale-libKF6GlobalAccel6-cy \
locale-libKF6GlobalAccel6-da \
locale-libKF6GlobalAccel6-de \
locale-libKF6GlobalAccel6-el \
locale-libKF6GlobalAccel6-en-GB \
locale-libKF6GlobalAccel6-eo \
locale-libKF6GlobalAccel6-es \
locale-libKF6GlobalAccel6-et \
locale-libKF6GlobalAccel6-eu \
locale-libKF6GlobalAccel6-fa \
locale-libKF6GlobalAccel6-fi \
locale-libKF6GlobalAccel6-fr \
locale-libKF6GlobalAccel6-ga \
locale-libKF6GlobalAccel6-gd \
locale-libKF6GlobalAccel6-gl \
locale-libKF6GlobalAccel6-gu \
locale-libKF6GlobalAccel6-he \
locale-libKF6GlobalAccel6-hi \
locale-libKF6GlobalAccel6-hr \
locale-libKF6GlobalAccel6-hu \
locale-libKF6GlobalAccel6-ia \
locale-libKF6GlobalAccel6-id \
locale-libKF6GlobalAccel6-is \
locale-libKF6GlobalAccel6-it \
locale-libKF6GlobalAccel6-ja \
locale-libKF6GlobalAccel6-ka \
locale-libKF6GlobalAccel6-kk \
locale-libKF6GlobalAccel6-km \
locale-libKF6GlobalAccel6-kn \
locale-libKF6GlobalAccel6-ko \
locale-libKF6GlobalAccel6-lt \
locale-libKF6GlobalAccel6-lv \
locale-libKF6GlobalAccel6-mai \
locale-libKF6GlobalAccel6-mk \
locale-libKF6GlobalAccel6-ml \
locale-libKF6GlobalAccel6-mr \
locale-libKF6GlobalAccel6-ms \
locale-libKF6GlobalAccel6-nb \
locale-libKF6GlobalAccel6-nds \
locale-libKF6GlobalAccel6-ne \
locale-libKF6GlobalAccel6-nl \
locale-libKF6GlobalAccel6-nn \
locale-libKF6GlobalAccel6-oc \
locale-libKF6GlobalAccel6-or \
locale-libKF6GlobalAccel6-pa \
locale-libKF6GlobalAccel6-pl \
locale-libKF6GlobalAccel6-pt \
locale-libKF6GlobalAccel6-pt-BR \
locale-libKF6GlobalAccel6-ro \
locale-libKF6GlobalAccel6-ru \
locale-libKF6GlobalAccel6-si \
locale-libKF6GlobalAccel6-sk \
locale-libKF6GlobalAccel6-sl \
locale-libKF6GlobalAccel6-sq \
locale-libKF6GlobalAccel6-sr \
locale-libKF6GlobalAccel6-sr@ijekavian \
locale-libKF6GlobalAccel6-sr@ijekavianlatin \
locale-libKF6GlobalAccel6-sr@latin \
locale-libKF6GlobalAccel6-sv \
locale-libKF6GlobalAccel6-ta \
locale-libKF6GlobalAccel6-te \
locale-libKF6GlobalAccel6-th \
locale-libKF6GlobalAccel6-tr \
locale-libKF6GlobalAccel6-ug \
locale-libKF6GlobalAccel6-uk \
locale-libKF6GlobalAccel6-vi \
locale-libKF6GlobalAccel6-wa \
locale-libKF6GlobalAccel6-zh-CN \
locale-libKF6GlobalAccel6-zh-HK \
locale-libKF6GlobalAccel6-zh-TW"

RDEPENDS:${PN} += "libKF6GlobalAccel6"

inherit rpm
