SUMMARY = "Development files for ocaml-ppxlib"
DESCRIPTION = "The ocaml-ppxlib-devel package contains libraries and signature files for \
developing applications that use ocaml-ppxlib."
LICENSE = "MIT"

PV = "0.38.0"

RPM_NAME = "ocaml-ppxlib-devel-0.38.0-1.3.aarch64.rpm"
RPM_HASH = "a20a5b1665d3d5a3b77a6b405f4465e00c08c860e06b32cfeeb7e83ee6564b597bc65d60b8c6c68211dac5fa9a7727e1b16963398510a5dfd6fe6eb652f1dc0c"

RPROVIDES:${PN} += "ocaml-Astlib \
ocaml-Astlib-- \
ocaml-Astlib--Ast-408 \
ocaml-Astlib--Ast-409 \
ocaml-Astlib--Ast-410 \
ocaml-Astlib--Ast-411 \
ocaml-Astlib--Ast-412 \
ocaml-Astlib--Ast-413 \
ocaml-Astlib--Ast-414 \
ocaml-Astlib--Ast-500 \
ocaml-Astlib--Ast-501 \
ocaml-Astlib--Ast-502 \
ocaml-Astlib--Ast-503 \
ocaml-Astlib--Ast-504 \
ocaml-Astlib--Ast-505 \
ocaml-Astlib--Ast-metadata \
ocaml-Astlib--Clean \
ocaml-Astlib--Config \
ocaml-Astlib--Encoding-502 \
ocaml-Astlib--Encoding-503 \
ocaml-Astlib--Encoding-504 \
ocaml-Astlib--Encoding-505 \
ocaml-Astlib--Keyword \
ocaml-Astlib--Location \
ocaml-Astlib--Longident \
ocaml-Astlib--Longident-504 \
ocaml-Astlib--Migrate-408-409 \
ocaml-Astlib--Migrate-409-408 \
ocaml-Astlib--Migrate-409-410 \
ocaml-Astlib--Migrate-410-409 \
ocaml-Astlib--Migrate-410-411 \
ocaml-Astlib--Migrate-411-410 \
ocaml-Astlib--Migrate-411-412 \
ocaml-Astlib--Migrate-412-411 \
ocaml-Astlib--Migrate-412-413 \
ocaml-Astlib--Migrate-413-412 \
ocaml-Astlib--Migrate-413-414 \
ocaml-Astlib--Migrate-414-413 \
ocaml-Astlib--Migrate-414-500 \
ocaml-Astlib--Migrate-500-414 \
ocaml-Astlib--Migrate-500-501 \
ocaml-Astlib--Migrate-501-500 \
ocaml-Astlib--Migrate-501-502 \
ocaml-Astlib--Migrate-502-501 \
ocaml-Astlib--Migrate-502-503 \
ocaml-Astlib--Migrate-503-502 \
ocaml-Astlib--Migrate-503-504 \
ocaml-Astlib--Migrate-504-503 \
ocaml-Astlib--Migrate-504-505 \
ocaml-Astlib--Migrate-505-504 \
ocaml-Astlib--Parse \
ocaml-Astlib--Pprintast \
ocaml-Astlib--Stdlib0 \
ocaml-Ppx-foo-deriver \
ocaml-Ppxlib \
ocaml-Ppxlib-- \
ocaml-Ppxlib--Ast-builder \
ocaml-Ppxlib--Ast-builder-generated \
ocaml-Ppxlib--Ast-builder-intf \
ocaml-Ppxlib--Ast-pattern \
ocaml-Ppxlib--Ast-pattern-generated \
ocaml-Ppxlib--Ast-pattern0 \
ocaml-Ppxlib--Ast-traverse \
ocaml-Ppxlib--Ast-traverse0 \
ocaml-Ppxlib--Attribute \
ocaml-Ppxlib--Caller-id \
ocaml-Ppxlib--Clean \
ocaml-Ppxlib--Code-matcher \
ocaml-Ppxlib--Code-path \
ocaml-Ppxlib--Common \
ocaml-Ppxlib--Context-free \
ocaml-Ppxlib--Deriving \
ocaml-Ppxlib--Driver \
ocaml-Ppxlib--Expansion-context \
ocaml-Ppxlib--Expansion-helpers \
ocaml-Ppxlib--Extension \
ocaml-Ppxlib--Ignore-unused-warning \
ocaml-Ppxlib--Import \
ocaml-Ppxlib--Keyword \
ocaml-Ppxlib--Loc \
ocaml-Ppxlib--Location \
ocaml-Ppxlib--Location-check \
ocaml-Ppxlib--Longident \
ocaml-Ppxlib--Merlin-helpers \
ocaml-Ppxlib--Name \
ocaml-Ppxlib--Options \
ocaml-Ppxlib--Pp-ast \
ocaml-Ppxlib--Quoter \
ocaml-Ppxlib--Reconcile \
ocaml-Ppxlib--Skip-hash-bang \
ocaml-Ppxlib--Spellcheck \
ocaml-Ppxlib--Utils \
ocaml-Ppxlib-ast \
ocaml-Ppxlib-ast-- \
ocaml-Ppxlib-ast--Ast \
ocaml-Ppxlib-ast--Ast-helper-lite \
ocaml-Ppxlib-ast--Import \
ocaml-Ppxlib-ast--Location-error \
ocaml-Ppxlib-ast--Stdlib0 \
ocaml-Ppxlib-ast--Versions \
ocaml-Ppxlib-ast--Warn \
ocaml-Ppxlib-metaquot \
ocaml-Ppxlib-metaquot-lifters \
ocaml-Ppxlib-print-diff \
ocaml-Ppxlib-runner \
ocaml-Ppxlib-runner--Ppx-driver-runner \
ocaml-Ppxlib-runner-as-ppx \
ocaml-Ppxlib-runner-as-ppx--Ppx-driver-runner-as-ppx \
ocaml-Ppxlib-traverse \
ocaml-Ppxlib-traverse-builtins \
ocaml-Stdppx \
ocaml-ppxlib-devel \
ocamlfind-ppxlib \
ocamlfind-ppxlib-tools \
ocamlfind-ppxlib.--private-- \
ocamlfind-ppxlib.--private--.ppx-foo-deriver \
ocamlfind-ppxlib.ast \
ocamlfind-ppxlib.astlib \
ocamlfind-ppxlib.metaquot \
ocamlfind-ppxlib.metaquot-lifters \
ocamlfind-ppxlib.print-diff \
ocamlfind-ppxlib.runner \
ocamlfind-ppxlib.runner-as-ppx \
ocamlfind-ppxlib.stdppx \
ocamlfind-ppxlib.traverse \
ocamlfind-ppxlib.traverse-builtins \
ocamlx-Astlib \
ocamlx-Astlib-- \
ocamlx-Astlib--Ast-408 \
ocamlx-Astlib--Ast-409 \
ocamlx-Astlib--Ast-410 \
ocamlx-Astlib--Ast-411 \
ocamlx-Astlib--Ast-412 \
ocamlx-Astlib--Ast-413 \
ocamlx-Astlib--Ast-414 \
ocamlx-Astlib--Ast-500 \
ocamlx-Astlib--Ast-501 \
ocamlx-Astlib--Ast-502 \
ocamlx-Astlib--Ast-503 \
ocamlx-Astlib--Ast-504 \
ocamlx-Astlib--Ast-505 \
ocamlx-Astlib--Ast-metadata \
ocamlx-Astlib--Clean \
ocamlx-Astlib--Config \
ocamlx-Astlib--Encoding-502 \
ocamlx-Astlib--Encoding-503 \
ocamlx-Astlib--Encoding-504 \
ocamlx-Astlib--Encoding-505 \
ocamlx-Astlib--Keyword \
ocamlx-Astlib--Location \
ocamlx-Astlib--Longident \
ocamlx-Astlib--Longident-504 \
ocamlx-Astlib--Migrate-408-409 \
ocamlx-Astlib--Migrate-409-408 \
ocamlx-Astlib--Migrate-409-410 \
ocamlx-Astlib--Migrate-410-409 \
ocamlx-Astlib--Migrate-410-411 \
ocamlx-Astlib--Migrate-411-410 \
ocamlx-Astlib--Migrate-411-412 \
ocamlx-Astlib--Migrate-412-411 \
ocamlx-Astlib--Migrate-412-413 \
ocamlx-Astlib--Migrate-413-412 \
ocamlx-Astlib--Migrate-413-414 \
ocamlx-Astlib--Migrate-414-413 \
ocamlx-Astlib--Migrate-414-500 \
ocamlx-Astlib--Migrate-500-414 \
ocamlx-Astlib--Migrate-500-501 \
ocamlx-Astlib--Migrate-501-500 \
ocamlx-Astlib--Migrate-501-502 \
ocamlx-Astlib--Migrate-502-501 \
ocamlx-Astlib--Migrate-502-503 \
ocamlx-Astlib--Migrate-503-502 \
ocamlx-Astlib--Migrate-503-504 \
ocamlx-Astlib--Migrate-504-503 \
ocamlx-Astlib--Migrate-504-505 \
ocamlx-Astlib--Migrate-505-504 \
ocamlx-Astlib--Parse \
ocamlx-Astlib--Pprintast \
ocamlx-Astlib--Stdlib0 \
ocamlx-Ppx-foo-deriver \
ocamlx-Ppxlib \
ocamlx-Ppxlib-- \
ocamlx-Ppxlib--Ast-builder \
ocamlx-Ppxlib--Ast-builder-generated \
ocamlx-Ppxlib--Ast-builder-intf \
ocamlx-Ppxlib--Ast-pattern \
ocamlx-Ppxlib--Ast-pattern-generated \
ocamlx-Ppxlib--Ast-pattern0 \
ocamlx-Ppxlib--Ast-traverse \
ocamlx-Ppxlib--Ast-traverse0 \
ocamlx-Ppxlib--Attribute \
ocamlx-Ppxlib--Caller-id \
ocamlx-Ppxlib--Clean \
ocamlx-Ppxlib--Code-matcher \
ocamlx-Ppxlib--Code-path \
ocamlx-Ppxlib--Common \
ocamlx-Ppxlib--Context-free \
ocamlx-Ppxlib--Deriving \
ocamlx-Ppxlib--Driver \
ocamlx-Ppxlib--Expansion-context \
ocamlx-Ppxlib--Expansion-helpers \
ocamlx-Ppxlib--Extension \
ocamlx-Ppxlib--Ignore-unused-warning \
ocamlx-Ppxlib--Import \
ocamlx-Ppxlib--Keyword \
ocamlx-Ppxlib--Loc \
ocamlx-Ppxlib--Location \
ocamlx-Ppxlib--Location-check \
ocamlx-Ppxlib--Longident \
ocamlx-Ppxlib--Merlin-helpers \
ocamlx-Ppxlib--Name \
ocamlx-Ppxlib--Options \
ocamlx-Ppxlib--Pp-ast \
ocamlx-Ppxlib--Quoter \
ocamlx-Ppxlib--Reconcile \
ocamlx-Ppxlib--Skip-hash-bang \
ocamlx-Ppxlib--Spellcheck \
ocamlx-Ppxlib--Utils \
ocamlx-Ppxlib-ast \
ocamlx-Ppxlib-ast-- \
ocamlx-Ppxlib-ast--Ast \
ocamlx-Ppxlib-ast--Ast-helper-lite \
ocamlx-Ppxlib-ast--Import \
ocamlx-Ppxlib-ast--Location-error \
ocamlx-Ppxlib-ast--Stdlib0 \
ocamlx-Ppxlib-ast--Versions \
ocamlx-Ppxlib-ast--Warn \
ocamlx-Ppxlib-metaquot \
ocamlx-Ppxlib-metaquot-lifters \
ocamlx-Ppxlib-print-diff \
ocamlx-Ppxlib-runner \
ocamlx-Ppxlib-runner--Ppx-driver-runner \
ocamlx-Ppxlib-runner-as-ppx \
ocamlx-Ppxlib-runner-as-ppx--Ppx-driver-runner-as-ppx \
ocamlx-Ppxlib-traverse \
ocamlx-Ppxlib-traverse-builtins \
ocamlx-Stdppx"

RDEPENDS:${PN} += "libc.so.6 \
libm.so.6 \
libzstd.so.1 \
ocaml-Ast-mapper \
ocaml-Asttypes \
ocaml-Build-path-prefix-map \
ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-CamlinternalOO \
ocaml-Clflags \
ocaml-Cmi-format \
ocaml-Compmisc \
ocaml-Config \
ocaml-Data-types \
ocaml-Env \
ocaml-Format-doc \
ocaml-Ident \
ocaml-Identifiable \
ocaml-Load-path \
ocaml-Location \
ocaml-Longident \
ocaml-Misc \
ocaml-Ocaml-common \
ocaml-Ocaml-shadow \
ocaml-Outcometree \
ocaml-Parse \
ocaml-Parsetree \
ocaml-Path \
ocaml-Pprintast \
ocaml-Ppx-derivers \
ocaml-Primitive \
ocaml-Sexplib0 \
ocaml-Sexplib0-- \
ocaml-Sexplib0--Sexp \
ocaml-Sexplib0--Sexp-conv \
ocaml-Sexplib0--Sexp-conv-grammar \
ocaml-Sexplib0--Sexp-grammar \
ocaml-Sexplib0--Sexpable \
ocaml-Shape \
ocaml-Stdlib \
ocaml-Stdlib--Arg \
ocaml-Stdlib--Array \
ocaml-Stdlib--ArrayLabels \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Bytes \
ocaml-Stdlib--BytesLabels \
ocaml-Stdlib--Char \
ocaml-Stdlib--Digest \
ocaml-Stdlib--Domain \
ocaml-Stdlib--Either \
ocaml-Stdlib--Filename \
ocaml-Stdlib--Format \
ocaml-Stdlib--Fun \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Int64 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--Lexing \
ocaml-Stdlib--List \
ocaml-Stdlib--ListLabels \
ocaml-Stdlib--Map \
ocaml-Stdlib--Nativeint \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Option \
ocaml-Stdlib--Printexc \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Result \
ocaml-Stdlib--Seq \
ocaml-Stdlib--Set \
ocaml-Stdlib--StdLabels \
ocaml-Stdlib--String \
ocaml-Stdlib--StringLabels \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar \
ocaml-Subst \
ocaml-Type-immediacy \
ocaml-Types \
ocaml-Unit-info \
ocaml-Warnings \
ocaml-ppxlib \
ocamlfind-compiler-libs.common \
ocamlfind-ocaml-compiler-libs.common \
ocamlfind-ocaml-compiler-libs.shadow \
ocamlfind-ppx-derivers \
ocamlfind-ppxlib \
ocamlfind-ppxlib.ast \
ocamlfind-ppxlib.astlib \
ocamlfind-ppxlib.metaquot-lifters \
ocamlfind-ppxlib.print-diff \
ocamlfind-ppxlib.stdppx \
ocamlfind-ppxlib.traverse-builtins \
ocamlfind-sexplib0 \
ocamlfind-stdlib-shims \
ocamlx-Ast-mapper \
ocamlx-CamlinternalLazy \
ocamlx-CamlinternalOO \
ocamlx-Clflags \
ocamlx-Compmisc \
ocamlx-Config \
ocamlx-Format-doc \
ocamlx-Location \
ocamlx-Misc \
ocamlx-Ocaml-shadow \
ocamlx-Parse \
ocamlx-Pprintast \
ocamlx-Ppx-derivers \
ocamlx-Sexplib0--Sexp \
ocamlx-Sexplib0--Sexp-conv \
ocamlx-Stdlib \
ocamlx-Stdlib--Arg \
ocamlx-Stdlib--Array \
ocamlx-Stdlib--ArrayLabels \
ocamlx-Stdlib--Buffer \
ocamlx-Stdlib--Bytes \
ocamlx-Stdlib--BytesLabels \
ocamlx-Stdlib--Char \
ocamlx-Stdlib--Filename \
ocamlx-Stdlib--Format \
ocamlx-Stdlib--Fun \
ocamlx-Stdlib--Hashtbl \
ocamlx-Stdlib--Int32 \
ocamlx-Stdlib--Int64 \
ocamlx-Stdlib--Lexing \
ocamlx-Stdlib--List \
ocamlx-Stdlib--ListLabels \
ocamlx-Stdlib--Map \
ocamlx-Stdlib--Nativeint \
ocamlx-Stdlib--Option \
ocamlx-Stdlib--Printexc \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--Set \
ocamlx-Stdlib--String \
ocamlx-Stdlib--StringLabels \
ocamlx-Stdlib--Sys"

inherit rpm
