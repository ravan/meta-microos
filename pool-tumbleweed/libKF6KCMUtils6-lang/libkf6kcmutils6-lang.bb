SUMMARY = "Translations for package libKF6KCMUtils6"
DESCRIPTION = "Provides translations for the 'libKF6KCMUtils6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6KCMUtils6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "719b0193e700710db875c6cb557d8cbdaadbf064b18042ab96f8ec84df059a1855af12f052c6d6811528672767ac59ab2878ba0c9a9fc8348d77d51e92926617"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6KCMUtils6-lang \
libKF6KCMUtils6-lang-all \
locale-libKF6KCMUtils6-af \
locale-libKF6KCMUtils6-ar \
locale-libKF6KCMUtils6-as \
locale-libKF6KCMUtils6-ast \
locale-libKF6KCMUtils6-az \
locale-libKF6KCMUtils6-be \
locale-libKF6KCMUtils6-be@latin \
locale-libKF6KCMUtils6-bg \
locale-libKF6KCMUtils6-bn \
locale-libKF6KCMUtils6-bn-IN \
locale-libKF6KCMUtils6-br \
locale-libKF6KCMUtils6-bs \
locale-libKF6KCMUtils6-ca \
locale-libKF6KCMUtils6-ca@valencia \
locale-libKF6KCMUtils6-cs \
locale-libKF6KCMUtils6-cy \
locale-libKF6KCMUtils6-da \
locale-libKF6KCMUtils6-de \
locale-libKF6KCMUtils6-el \
locale-libKF6KCMUtils6-en-GB \
locale-libKF6KCMUtils6-eo \
locale-libKF6KCMUtils6-es \
locale-libKF6KCMUtils6-et \
locale-libKF6KCMUtils6-eu \
locale-libKF6KCMUtils6-fa \
locale-libKF6KCMUtils6-fi \
locale-libKF6KCMUtils6-fr \
locale-libKF6KCMUtils6-ga \
locale-libKF6KCMUtils6-gd \
locale-libKF6KCMUtils6-gl \
locale-libKF6KCMUtils6-gu \
locale-libKF6KCMUtils6-he \
locale-libKF6KCMUtils6-hi \
locale-libKF6KCMUtils6-hr \
locale-libKF6KCMUtils6-hu \
locale-libKF6KCMUtils6-ia \
locale-libKF6KCMUtils6-id \
locale-libKF6KCMUtils6-is \
locale-libKF6KCMUtils6-it \
locale-libKF6KCMUtils6-ja \
locale-libKF6KCMUtils6-ka \
locale-libKF6KCMUtils6-kk \
locale-libKF6KCMUtils6-km \
locale-libKF6KCMUtils6-kn \
locale-libKF6KCMUtils6-ko \
locale-libKF6KCMUtils6-lt \
locale-libKF6KCMUtils6-lv \
locale-libKF6KCMUtils6-mai \
locale-libKF6KCMUtils6-mk \
locale-libKF6KCMUtils6-ml \
locale-libKF6KCMUtils6-mr \
locale-libKF6KCMUtils6-ms \
locale-libKF6KCMUtils6-nb \
locale-libKF6KCMUtils6-nds \
locale-libKF6KCMUtils6-ne \
locale-libKF6KCMUtils6-nl \
locale-libKF6KCMUtils6-nn \
locale-libKF6KCMUtils6-oc \
locale-libKF6KCMUtils6-or \
locale-libKF6KCMUtils6-pa \
locale-libKF6KCMUtils6-pl \
locale-libKF6KCMUtils6-pt \
locale-libKF6KCMUtils6-pt-BR \
locale-libKF6KCMUtils6-ro \
locale-libKF6KCMUtils6-ru \
locale-libKF6KCMUtils6-si \
locale-libKF6KCMUtils6-sk \
locale-libKF6KCMUtils6-sl \
locale-libKF6KCMUtils6-sq \
locale-libKF6KCMUtils6-sr \
locale-libKF6KCMUtils6-sr@ijekavian \
locale-libKF6KCMUtils6-sr@ijekavianlatin \
locale-libKF6KCMUtils6-sr@latin \
locale-libKF6KCMUtils6-sv \
locale-libKF6KCMUtils6-ta \
locale-libKF6KCMUtils6-te \
locale-libKF6KCMUtils6-th \
locale-libKF6KCMUtils6-tr \
locale-libKF6KCMUtils6-ug \
locale-libKF6KCMUtils6-uk \
locale-libKF6KCMUtils6-vi \
locale-libKF6KCMUtils6-wa \
locale-libKF6KCMUtils6-zh-CN \
locale-libKF6KCMUtils6-zh-HK \
locale-libKF6KCMUtils6-zh-TW"

RDEPENDS:${PN} += "libKF6KCMUtils6"

inherit rpm
