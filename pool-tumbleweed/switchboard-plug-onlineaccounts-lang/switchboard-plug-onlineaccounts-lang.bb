SUMMARY = "Translations for package switchboard-plug-onlineaccounts"
DESCRIPTION = "Provides translations for the 'switchboard-plug-onlineaccounts' package."
LICENSE = "GPL-3.0-or-later"

PV = "8.0.2"

RPM_NAME = "switchboard-plug-onlineaccounts-lang-8.0.2-1.5.noarch.rpm"
RPM_HASH = "6de5c46e834d17d6a3f29ec9669be65e1a5d45260f427aafb54a548e3ea77be9c025d89ee08a2adfff91bfbbbaf9617da7514610003bc861c538c783dbefe2b0"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale-switchboard-plug-onlineaccounts-af \
locale-switchboard-plug-onlineaccounts-ar \
locale-switchboard-plug-onlineaccounts-as \
locale-switchboard-plug-onlineaccounts-ast \
locale-switchboard-plug-onlineaccounts-az \
locale-switchboard-plug-onlineaccounts-be \
locale-switchboard-plug-onlineaccounts-bg \
locale-switchboard-plug-onlineaccounts-bn \
locale-switchboard-plug-onlineaccounts-br \
locale-switchboard-plug-onlineaccounts-bs \
locale-switchboard-plug-onlineaccounts-ca \
locale-switchboard-plug-onlineaccounts-cs \
locale-switchboard-plug-onlineaccounts-cy \
locale-switchboard-plug-onlineaccounts-da \
locale-switchboard-plug-onlineaccounts-de \
locale-switchboard-plug-onlineaccounts-dz \
locale-switchboard-plug-onlineaccounts-el \
locale-switchboard-plug-onlineaccounts-en-AU \
locale-switchboard-plug-onlineaccounts-en-CA \
locale-switchboard-plug-onlineaccounts-en-GB \
locale-switchboard-plug-onlineaccounts-eo \
locale-switchboard-plug-onlineaccounts-es \
locale-switchboard-plug-onlineaccounts-et \
locale-switchboard-plug-onlineaccounts-eu \
locale-switchboard-plug-onlineaccounts-fa \
locale-switchboard-plug-onlineaccounts-fi \
locale-switchboard-plug-onlineaccounts-fr \
locale-switchboard-plug-onlineaccounts-fr-CA \
locale-switchboard-plug-onlineaccounts-ga \
locale-switchboard-plug-onlineaccounts-gd \
locale-switchboard-plug-onlineaccounts-gl \
locale-switchboard-plug-onlineaccounts-gu \
locale-switchboard-plug-onlineaccounts-he \
locale-switchboard-plug-onlineaccounts-hi \
locale-switchboard-plug-onlineaccounts-hr \
locale-switchboard-plug-onlineaccounts-hu \
locale-switchboard-plug-onlineaccounts-ia \
locale-switchboard-plug-onlineaccounts-id \
locale-switchboard-plug-onlineaccounts-is \
locale-switchboard-plug-onlineaccounts-it \
locale-switchboard-plug-onlineaccounts-ja \
locale-switchboard-plug-onlineaccounts-ka \
locale-switchboard-plug-onlineaccounts-kk \
locale-switchboard-plug-onlineaccounts-km \
locale-switchboard-plug-onlineaccounts-kn \
locale-switchboard-plug-onlineaccounts-ko \
locale-switchboard-plug-onlineaccounts-lt \
locale-switchboard-plug-onlineaccounts-lv \
locale-switchboard-plug-onlineaccounts-mk \
locale-switchboard-plug-onlineaccounts-ml \
locale-switchboard-plug-onlineaccounts-mr \
locale-switchboard-plug-onlineaccounts-ms \
locale-switchboard-plug-onlineaccounts-nb \
locale-switchboard-plug-onlineaccounts-ne \
locale-switchboard-plug-onlineaccounts-nl \
locale-switchboard-plug-onlineaccounts-nn \
locale-switchboard-plug-onlineaccounts-oc \
locale-switchboard-plug-onlineaccounts-or \
locale-switchboard-plug-onlineaccounts-pa \
locale-switchboard-plug-onlineaccounts-pl \
locale-switchboard-plug-onlineaccounts-pt \
locale-switchboard-plug-onlineaccounts-pt-BR \
locale-switchboard-plug-onlineaccounts-ro \
locale-switchboard-plug-onlineaccounts-ru \
locale-switchboard-plug-onlineaccounts-si \
locale-switchboard-plug-onlineaccounts-sk \
locale-switchboard-plug-onlineaccounts-sl \
locale-switchboard-plug-onlineaccounts-sq \
locale-switchboard-plug-onlineaccounts-sr \
locale-switchboard-plug-onlineaccounts-sr@latin \
locale-switchboard-plug-onlineaccounts-sv \
locale-switchboard-plug-onlineaccounts-ta \
locale-switchboard-plug-onlineaccounts-te \
locale-switchboard-plug-onlineaccounts-th \
locale-switchboard-plug-onlineaccounts-tr \
locale-switchboard-plug-onlineaccounts-ug \
locale-switchboard-plug-onlineaccounts-uk \
locale-switchboard-plug-onlineaccounts-vi \
locale-switchboard-plug-onlineaccounts-wa \
locale-switchboard-plug-onlineaccounts-zh \
locale-switchboard-plug-onlineaccounts-zh-CN \
locale-switchboard-plug-onlineaccounts-zh-HK \
locale-switchboard-plug-onlineaccounts-zh-TW \
switchboard-plug-onlineaccounts-lang \
switchboard-plug-onlineaccounts-lang-all"

RDEPENDS:${PN} += "switchboard-plug-onlineaccounts"

inherit rpm
