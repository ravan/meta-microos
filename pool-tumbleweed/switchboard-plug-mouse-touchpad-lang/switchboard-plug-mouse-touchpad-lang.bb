SUMMARY = "Translations for package switchboard-plug-mouse-touchpad"
DESCRIPTION = "Provides translations for the 'switchboard-plug-mouse-touchpad' package."
LICENSE = "GPL-3.0-or-later"

PV = "8.1.0"

RPM_NAME = "switchboard-plug-mouse-touchpad-lang-8.1.0-1.3.noarch.rpm"
RPM_HASH = "f1b70b5ddadb6a7ce1e766dad4b31c5c474b8fa6eb3f40cacdf8b59e72f502b54458088f72b332aa991d3c58d0dd1aa6c0feea2865b169bb62fab8187542d9b3"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale-switchboard-plug-mouse-touchpad-af \
locale-switchboard-plug-mouse-touchpad-ar \
locale-switchboard-plug-mouse-touchpad-as \
locale-switchboard-plug-mouse-touchpad-ast \
locale-switchboard-plug-mouse-touchpad-az \
locale-switchboard-plug-mouse-touchpad-be \
locale-switchboard-plug-mouse-touchpad-bg \
locale-switchboard-plug-mouse-touchpad-bn \
locale-switchboard-plug-mouse-touchpad-br \
locale-switchboard-plug-mouse-touchpad-bs \
locale-switchboard-plug-mouse-touchpad-ca \
locale-switchboard-plug-mouse-touchpad-cs \
locale-switchboard-plug-mouse-touchpad-cy \
locale-switchboard-plug-mouse-touchpad-da \
locale-switchboard-plug-mouse-touchpad-de \
locale-switchboard-plug-mouse-touchpad-dz \
locale-switchboard-plug-mouse-touchpad-el \
locale-switchboard-plug-mouse-touchpad-en-AU \
locale-switchboard-plug-mouse-touchpad-en-CA \
locale-switchboard-plug-mouse-touchpad-en-GB \
locale-switchboard-plug-mouse-touchpad-eo \
locale-switchboard-plug-mouse-touchpad-es \
locale-switchboard-plug-mouse-touchpad-et \
locale-switchboard-plug-mouse-touchpad-eu \
locale-switchboard-plug-mouse-touchpad-fa \
locale-switchboard-plug-mouse-touchpad-fi \
locale-switchboard-plug-mouse-touchpad-fr \
locale-switchboard-plug-mouse-touchpad-fr-CA \
locale-switchboard-plug-mouse-touchpad-ga \
locale-switchboard-plug-mouse-touchpad-gd \
locale-switchboard-plug-mouse-touchpad-gl \
locale-switchboard-plug-mouse-touchpad-gu \
locale-switchboard-plug-mouse-touchpad-he \
locale-switchboard-plug-mouse-touchpad-hi \
locale-switchboard-plug-mouse-touchpad-hr \
locale-switchboard-plug-mouse-touchpad-hu \
locale-switchboard-plug-mouse-touchpad-ia \
locale-switchboard-plug-mouse-touchpad-id \
locale-switchboard-plug-mouse-touchpad-is \
locale-switchboard-plug-mouse-touchpad-it \
locale-switchboard-plug-mouse-touchpad-ja \
locale-switchboard-plug-mouse-touchpad-ka \
locale-switchboard-plug-mouse-touchpad-kk \
locale-switchboard-plug-mouse-touchpad-km \
locale-switchboard-plug-mouse-touchpad-kn \
locale-switchboard-plug-mouse-touchpad-ko \
locale-switchboard-plug-mouse-touchpad-lt \
locale-switchboard-plug-mouse-touchpad-lv \
locale-switchboard-plug-mouse-touchpad-mk \
locale-switchboard-plug-mouse-touchpad-ml \
locale-switchboard-plug-mouse-touchpad-mr \
locale-switchboard-plug-mouse-touchpad-ms \
locale-switchboard-plug-mouse-touchpad-nb \
locale-switchboard-plug-mouse-touchpad-ne \
locale-switchboard-plug-mouse-touchpad-nl \
locale-switchboard-plug-mouse-touchpad-nn \
locale-switchboard-plug-mouse-touchpad-oc \
locale-switchboard-plug-mouse-touchpad-or \
locale-switchboard-plug-mouse-touchpad-pa \
locale-switchboard-plug-mouse-touchpad-pl \
locale-switchboard-plug-mouse-touchpad-pt \
locale-switchboard-plug-mouse-touchpad-pt-BR \
locale-switchboard-plug-mouse-touchpad-ro \
locale-switchboard-plug-mouse-touchpad-ru \
locale-switchboard-plug-mouse-touchpad-si \
locale-switchboard-plug-mouse-touchpad-sk \
locale-switchboard-plug-mouse-touchpad-sl \
locale-switchboard-plug-mouse-touchpad-sq \
locale-switchboard-plug-mouse-touchpad-sr \
locale-switchboard-plug-mouse-touchpad-sv \
locale-switchboard-plug-mouse-touchpad-ta \
locale-switchboard-plug-mouse-touchpad-te \
locale-switchboard-plug-mouse-touchpad-th \
locale-switchboard-plug-mouse-touchpad-tr \
locale-switchboard-plug-mouse-touchpad-ug \
locale-switchboard-plug-mouse-touchpad-uk \
locale-switchboard-plug-mouse-touchpad-vi \
locale-switchboard-plug-mouse-touchpad-wa \
locale-switchboard-plug-mouse-touchpad-zh \
locale-switchboard-plug-mouse-touchpad-zh-CN \
locale-switchboard-plug-mouse-touchpad-zh-TW \
switchboard-plug-mouse-touchpad-lang \
switchboard-plug-mouse-touchpad-lang-all"

RDEPENDS:${PN} += "switchboard-plug-mouse-touchpad"

inherit rpm
