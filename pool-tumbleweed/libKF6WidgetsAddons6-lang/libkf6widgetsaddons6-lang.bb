SUMMARY = "Translations for package libKF6WidgetsAddons6"
DESCRIPTION = "Provides translations for the 'libKF6WidgetsAddons6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6WidgetsAddons6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "323238a80780b67e16c35e1025a7bfe5906f30c56ef1b3f781e7a2022ede3ca89657b86c07c4e24446b120a537beef260885fc336bd979d3a2aee52162b27ce0"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6WidgetsAddons6-lang \
libKF6WidgetsAddons6-lang-all \
locale-libKF6WidgetsAddons6-af \
locale-libKF6WidgetsAddons6-ar \
locale-libKF6WidgetsAddons6-as \
locale-libKF6WidgetsAddons6-ast \
locale-libKF6WidgetsAddons6-az \
locale-libKF6WidgetsAddons6-be \
locale-libKF6WidgetsAddons6-be@latin \
locale-libKF6WidgetsAddons6-bg \
locale-libKF6WidgetsAddons6-bn \
locale-libKF6WidgetsAddons6-bn-IN \
locale-libKF6WidgetsAddons6-br \
locale-libKF6WidgetsAddons6-bs \
locale-libKF6WidgetsAddons6-ca \
locale-libKF6WidgetsAddons6-ca@valencia \
locale-libKF6WidgetsAddons6-cs \
locale-libKF6WidgetsAddons6-cy \
locale-libKF6WidgetsAddons6-da \
locale-libKF6WidgetsAddons6-de \
locale-libKF6WidgetsAddons6-el \
locale-libKF6WidgetsAddons6-en \
locale-libKF6WidgetsAddons6-en-GB \
locale-libKF6WidgetsAddons6-eo \
locale-libKF6WidgetsAddons6-es \
locale-libKF6WidgetsAddons6-et \
locale-libKF6WidgetsAddons6-eu \
locale-libKF6WidgetsAddons6-fa \
locale-libKF6WidgetsAddons6-fi \
locale-libKF6WidgetsAddons6-fr \
locale-libKF6WidgetsAddons6-ga \
locale-libKF6WidgetsAddons6-gl \
locale-libKF6WidgetsAddons6-gu \
locale-libKF6WidgetsAddons6-he \
locale-libKF6WidgetsAddons6-hi \
locale-libKF6WidgetsAddons6-hr \
locale-libKF6WidgetsAddons6-hu \
locale-libKF6WidgetsAddons6-ia \
locale-libKF6WidgetsAddons6-id \
locale-libKF6WidgetsAddons6-is \
locale-libKF6WidgetsAddons6-it \
locale-libKF6WidgetsAddons6-ja \
locale-libKF6WidgetsAddons6-ka \
locale-libKF6WidgetsAddons6-kk \
locale-libKF6WidgetsAddons6-km \
locale-libKF6WidgetsAddons6-kn \
locale-libKF6WidgetsAddons6-ko \
locale-libKF6WidgetsAddons6-lt \
locale-libKF6WidgetsAddons6-lv \
locale-libKF6WidgetsAddons6-mai \
locale-libKF6WidgetsAddons6-mk \
locale-libKF6WidgetsAddons6-ml \
locale-libKF6WidgetsAddons6-mr \
locale-libKF6WidgetsAddons6-ms \
locale-libKF6WidgetsAddons6-nb \
locale-libKF6WidgetsAddons6-nds \
locale-libKF6WidgetsAddons6-ne \
locale-libKF6WidgetsAddons6-nl \
locale-libKF6WidgetsAddons6-nn \
locale-libKF6WidgetsAddons6-oc \
locale-libKF6WidgetsAddons6-or \
locale-libKF6WidgetsAddons6-pa \
locale-libKF6WidgetsAddons6-pl \
locale-libKF6WidgetsAddons6-pt \
locale-libKF6WidgetsAddons6-pt-BR \
locale-libKF6WidgetsAddons6-ro \
locale-libKF6WidgetsAddons6-ru \
locale-libKF6WidgetsAddons6-si \
locale-libKF6WidgetsAddons6-sk \
locale-libKF6WidgetsAddons6-sl \
locale-libKF6WidgetsAddons6-sq \
locale-libKF6WidgetsAddons6-sr \
locale-libKF6WidgetsAddons6-sr@ijekavian \
locale-libKF6WidgetsAddons6-sr@ijekavianlatin \
locale-libKF6WidgetsAddons6-sr@latin \
locale-libKF6WidgetsAddons6-sv \
locale-libKF6WidgetsAddons6-ta \
locale-libKF6WidgetsAddons6-te \
locale-libKF6WidgetsAddons6-th \
locale-libKF6WidgetsAddons6-tr \
locale-libKF6WidgetsAddons6-ug \
locale-libKF6WidgetsAddons6-uk \
locale-libKF6WidgetsAddons6-vi \
locale-libKF6WidgetsAddons6-wa \
locale-libKF6WidgetsAddons6-zh-CN \
locale-libKF6WidgetsAddons6-zh-HK \
locale-libKF6WidgetsAddons6-zh-TW"

RDEPENDS:${PN} += "libKF6WidgetsAddons6"

inherit rpm
