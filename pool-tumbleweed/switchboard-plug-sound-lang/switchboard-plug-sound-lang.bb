SUMMARY = "Translations for package switchboard-plug-sound"
DESCRIPTION = "Provides translations for the 'switchboard-plug-sound' package."
LICENSE = "GPL-3.0-or-later"

PV = "8.0.3"

RPM_NAME = "switchboard-plug-sound-lang-8.0.3-1.2.noarch.rpm"
RPM_HASH = "8a5df3737d1367eb2d6fc7940ed2de5556038ed009a6f599bc8c829dde21e6f7da78c46532fa9219a4c00cbbb9ac14de0f37d157aa7d59a0c77e8c845a808631"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale-switchboard-plug-sound-af \
locale-switchboard-plug-sound-ar \
locale-switchboard-plug-sound-as \
locale-switchboard-plug-sound-ast \
locale-switchboard-plug-sound-az \
locale-switchboard-plug-sound-be \
locale-switchboard-plug-sound-bg \
locale-switchboard-plug-sound-bn \
locale-switchboard-plug-sound-br \
locale-switchboard-plug-sound-bs \
locale-switchboard-plug-sound-ca \
locale-switchboard-plug-sound-cs \
locale-switchboard-plug-sound-cy \
locale-switchboard-plug-sound-da \
locale-switchboard-plug-sound-de \
locale-switchboard-plug-sound-dz \
locale-switchboard-plug-sound-el \
locale-switchboard-plug-sound-en-AU \
locale-switchboard-plug-sound-en-CA \
locale-switchboard-plug-sound-en-GB \
locale-switchboard-plug-sound-eo \
locale-switchboard-plug-sound-es \
locale-switchboard-plug-sound-et \
locale-switchboard-plug-sound-eu \
locale-switchboard-plug-sound-fa \
locale-switchboard-plug-sound-fi \
locale-switchboard-plug-sound-fr \
locale-switchboard-plug-sound-fr-CA \
locale-switchboard-plug-sound-ga \
locale-switchboard-plug-sound-gd \
locale-switchboard-plug-sound-gl \
locale-switchboard-plug-sound-gu \
locale-switchboard-plug-sound-he \
locale-switchboard-plug-sound-hi \
locale-switchboard-plug-sound-hr \
locale-switchboard-plug-sound-hu \
locale-switchboard-plug-sound-ia \
locale-switchboard-plug-sound-id \
locale-switchboard-plug-sound-is \
locale-switchboard-plug-sound-it \
locale-switchboard-plug-sound-ja \
locale-switchboard-plug-sound-ka \
locale-switchboard-plug-sound-kk \
locale-switchboard-plug-sound-km \
locale-switchboard-plug-sound-kn \
locale-switchboard-plug-sound-ko \
locale-switchboard-plug-sound-lt \
locale-switchboard-plug-sound-lv \
locale-switchboard-plug-sound-mk \
locale-switchboard-plug-sound-ml \
locale-switchboard-plug-sound-mr \
locale-switchboard-plug-sound-ms \
locale-switchboard-plug-sound-nb \
locale-switchboard-plug-sound-ne \
locale-switchboard-plug-sound-nl \
locale-switchboard-plug-sound-nn \
locale-switchboard-plug-sound-oc \
locale-switchboard-plug-sound-or \
locale-switchboard-plug-sound-pa \
locale-switchboard-plug-sound-pl \
locale-switchboard-plug-sound-pt \
locale-switchboard-plug-sound-pt-BR \
locale-switchboard-plug-sound-ro \
locale-switchboard-plug-sound-ru \
locale-switchboard-plug-sound-si \
locale-switchboard-plug-sound-sk \
locale-switchboard-plug-sound-sl \
locale-switchboard-plug-sound-sq \
locale-switchboard-plug-sound-sr \
locale-switchboard-plug-sound-sr@latin \
locale-switchboard-plug-sound-sv \
locale-switchboard-plug-sound-ta \
locale-switchboard-plug-sound-te \
locale-switchboard-plug-sound-th \
locale-switchboard-plug-sound-tr \
locale-switchboard-plug-sound-ug \
locale-switchboard-plug-sound-uk \
locale-switchboard-plug-sound-vi \
locale-switchboard-plug-sound-wa \
locale-switchboard-plug-sound-zh \
locale-switchboard-plug-sound-zh-CN \
locale-switchboard-plug-sound-zh-TW \
switchboard-plug-sound-lang \
switchboard-plug-sound-lang-all"

RDEPENDS:${PN} += "switchboard-plug-sound"

inherit rpm
