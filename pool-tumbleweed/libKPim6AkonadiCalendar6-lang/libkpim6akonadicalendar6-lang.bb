SUMMARY = "Translations for package libKPim6AkonadiCalendar6"
DESCRIPTION = "Provides translations for the 'libKPim6AkonadiCalendar6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6AkonadiCalendar6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "ea11dee2af5fc04286a95d55d0138e20c915ef1e1a2588c53ae1c85c24e954338c2398b159a793cb9524f8211bf12b8ba7c49164ad0176838fcd2d707e850171"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6AkonadiCalendar6-lang \
libKPim6AkonadiCalendar6-lang-all \
locale-libKPim6AkonadiCalendar6-ar \
locale-libKPim6AkonadiCalendar6-ast \
locale-libKPim6AkonadiCalendar6-az \
locale-libKPim6AkonadiCalendar6-bg \
locale-libKPim6AkonadiCalendar6-bs \
locale-libKPim6AkonadiCalendar6-ca \
locale-libKPim6AkonadiCalendar6-ca@valencia \
locale-libKPim6AkonadiCalendar6-cs \
locale-libKPim6AkonadiCalendar6-da \
locale-libKPim6AkonadiCalendar6-de \
locale-libKPim6AkonadiCalendar6-el \
locale-libKPim6AkonadiCalendar6-en-GB \
locale-libKPim6AkonadiCalendar6-eo \
locale-libKPim6AkonadiCalendar6-es \
locale-libKPim6AkonadiCalendar6-et \
locale-libKPim6AkonadiCalendar6-eu \
locale-libKPim6AkonadiCalendar6-fi \
locale-libKPim6AkonadiCalendar6-fr \
locale-libKPim6AkonadiCalendar6-ga \
locale-libKPim6AkonadiCalendar6-gl \
locale-libKPim6AkonadiCalendar6-he \
locale-libKPim6AkonadiCalendar6-hi \
locale-libKPim6AkonadiCalendar6-hu \
locale-libKPim6AkonadiCalendar6-ia \
locale-libKPim6AkonadiCalendar6-id \
locale-libKPim6AkonadiCalendar6-is \
locale-libKPim6AkonadiCalendar6-it \
locale-libKPim6AkonadiCalendar6-ja \
locale-libKPim6AkonadiCalendar6-ka \
locale-libKPim6AkonadiCalendar6-kk \
locale-libKPim6AkonadiCalendar6-km \
locale-libKPim6AkonadiCalendar6-ko \
locale-libKPim6AkonadiCalendar6-lt \
locale-libKPim6AkonadiCalendar6-lv \
locale-libKPim6AkonadiCalendar6-mai \
locale-libKPim6AkonadiCalendar6-mr \
locale-libKPim6AkonadiCalendar6-nb \
locale-libKPim6AkonadiCalendar6-nds \
locale-libKPim6AkonadiCalendar6-nl \
locale-libKPim6AkonadiCalendar6-pa \
locale-libKPim6AkonadiCalendar6-pl \
locale-libKPim6AkonadiCalendar6-pt \
locale-libKPim6AkonadiCalendar6-pt-BR \
locale-libKPim6AkonadiCalendar6-ro \
locale-libKPim6AkonadiCalendar6-ru \
locale-libKPim6AkonadiCalendar6-sk \
locale-libKPim6AkonadiCalendar6-sl \
locale-libKPim6AkonadiCalendar6-sq \
locale-libKPim6AkonadiCalendar6-sr \
locale-libKPim6AkonadiCalendar6-sr@ijekavian \
locale-libKPim6AkonadiCalendar6-sr@ijekavianlatin \
locale-libKPim6AkonadiCalendar6-sr@latin \
locale-libKPim6AkonadiCalendar6-sv \
locale-libKPim6AkonadiCalendar6-ta \
locale-libKPim6AkonadiCalendar6-tr \
locale-libKPim6AkonadiCalendar6-ug \
locale-libKPim6AkonadiCalendar6-uk \
locale-libKPim6AkonadiCalendar6-zh-CN \
locale-libKPim6AkonadiCalendar6-zh-TW"

RDEPENDS:${PN} += "libKPim6AkonadiCalendar6"

inherit rpm
