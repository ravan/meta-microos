SUMMARY = "Libre Bodoni fonts with LaTeX support"
DESCRIPTION = "The Libre Bodoni fonts are designed by Pablo Impallari and \
Rodrigo Fuenzalida, based on the 19th century Morris Fuller \
Benton's."
LICENSE = "OFL-1.1"

PV = "2026.226.svn64431"

RPM_NAME = "texlive-librebodoni-2026.226.svn64431-61.2.noarch.rpm"
RPM_HASH = "46b9f664ca23b05c336528408807695beb4ea3a3e3861ea00b298750d5e5e38f28d71979361bb7352f69f21725c42fd15a54710a6639e0aed1967fc01d38bc75"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1LibreBodoni-Inf.fd \
tex-LY1LibreBodoni-Sup.fd \
tex-LY1LibreBodoni-TLF.fd \
tex-LibreBodoni-Bold-inf-ly1--base.tfm \
tex-LibreBodoni-Bold-inf-ly1.tfm \
tex-LibreBodoni-Bold-inf-ly1.vf \
tex-LibreBodoni-Bold-inf-ot1.tfm \
tex-LibreBodoni-Bold-inf-t1--base.tfm \
tex-LibreBodoni-Bold-inf-t1.tfm \
tex-LibreBodoni-Bold-inf-t1.vf \
tex-LibreBodoni-Bold-sup-ly1--base.tfm \
tex-LibreBodoni-Bold-sup-ly1.tfm \
tex-LibreBodoni-Bold-sup-ly1.vf \
tex-LibreBodoni-Bold-sup-ot1.tfm \
tex-LibreBodoni-Bold-sup-t1--base.tfm \
tex-LibreBodoni-Bold-sup-t1.tfm \
tex-LibreBodoni-Bold-sup-t1.vf \
tex-LibreBodoni-Bold-tlf-ly1--base.tfm \
tex-LibreBodoni-Bold-tlf-ly1.tfm \
tex-LibreBodoni-Bold-tlf-ly1.vf \
tex-LibreBodoni-Bold-tlf-ot1.tfm \
tex-LibreBodoni-Bold-tlf-t1--base.tfm \
tex-LibreBodoni-Bold-tlf-t1.tfm \
tex-LibreBodoni-Bold-tlf-t1.vf \
tex-LibreBodoni-Bold-tlf-ts1--base.tfm \
tex-LibreBodoni-Bold-tlf-ts1.tfm \
tex-LibreBodoni-Bold-tlf-ts1.vf \
tex-LibreBodoni-BoldItalic-inf-ly1--base.tfm \
tex-LibreBodoni-BoldItalic-inf-ly1.tfm \
tex-LibreBodoni-BoldItalic-inf-ly1.vf \
tex-LibreBodoni-BoldItalic-inf-ot1.tfm \
tex-LibreBodoni-BoldItalic-inf-t1--base.tfm \
tex-LibreBodoni-BoldItalic-inf-t1.tfm \
tex-LibreBodoni-BoldItalic-inf-t1.vf \
tex-LibreBodoni-BoldItalic-sup-ly1--base.tfm \
tex-LibreBodoni-BoldItalic-sup-ly1.tfm \
tex-LibreBodoni-BoldItalic-sup-ly1.vf \
tex-LibreBodoni-BoldItalic-sup-ot1.tfm \
tex-LibreBodoni-BoldItalic-sup-t1--base.tfm \
tex-LibreBodoni-BoldItalic-sup-t1.tfm \
tex-LibreBodoni-BoldItalic-sup-t1.vf \
tex-LibreBodoni-BoldItalic-tlf-ly1--base.tfm \
tex-LibreBodoni-BoldItalic-tlf-ly1.tfm \
tex-LibreBodoni-BoldItalic-tlf-ly1.vf \
tex-LibreBodoni-BoldItalic-tlf-ot1.tfm \
tex-LibreBodoni-BoldItalic-tlf-t1--base.tfm \
tex-LibreBodoni-BoldItalic-tlf-t1.tfm \
tex-LibreBodoni-BoldItalic-tlf-t1.vf \
tex-LibreBodoni-BoldItalic-tlf-ts1--base.tfm \
tex-LibreBodoni-BoldItalic-tlf-ts1.tfm \
tex-LibreBodoni-BoldItalic-tlf-ts1.vf \
tex-LibreBodoni-Italic-inf-ly1--base.tfm \
tex-LibreBodoni-Italic-inf-ly1.tfm \
tex-LibreBodoni-Italic-inf-ly1.vf \
tex-LibreBodoni-Italic-inf-ot1.tfm \
tex-LibreBodoni-Italic-inf-t1--base.tfm \
tex-LibreBodoni-Italic-inf-t1.tfm \
tex-LibreBodoni-Italic-inf-t1.vf \
tex-LibreBodoni-Italic-sup-ly1--base.tfm \
tex-LibreBodoni-Italic-sup-ly1.tfm \
tex-LibreBodoni-Italic-sup-ly1.vf \
tex-LibreBodoni-Italic-sup-ot1.tfm \
tex-LibreBodoni-Italic-sup-t1--base.tfm \
tex-LibreBodoni-Italic-sup-t1.tfm \
tex-LibreBodoni-Italic-sup-t1.vf \
tex-LibreBodoni-Italic-tlf-ly1--base.tfm \
tex-LibreBodoni-Italic-tlf-ly1.tfm \
tex-LibreBodoni-Italic-tlf-ly1.vf \
tex-LibreBodoni-Italic-tlf-ot1.tfm \
tex-LibreBodoni-Italic-tlf-t1--base.tfm \
tex-LibreBodoni-Italic-tlf-t1.tfm \
tex-LibreBodoni-Italic-tlf-t1.vf \
tex-LibreBodoni-Italic-tlf-ts1--base.tfm \
tex-LibreBodoni-Italic-tlf-ts1.tfm \
tex-LibreBodoni-Italic-tlf-ts1.vf \
tex-LibreBodoni-Regular-inf-ly1--base.tfm \
tex-LibreBodoni-Regular-inf-ly1.tfm \
tex-LibreBodoni-Regular-inf-ly1.vf \
tex-LibreBodoni-Regular-inf-ot1.tfm \
tex-LibreBodoni-Regular-inf-t1--base.tfm \
tex-LibreBodoni-Regular-inf-t1.tfm \
tex-LibreBodoni-Regular-inf-t1.vf \
tex-LibreBodoni-Regular-sup-ly1--base.tfm \
tex-LibreBodoni-Regular-sup-ly1.tfm \
tex-LibreBodoni-Regular-sup-ly1.vf \
tex-LibreBodoni-Regular-sup-ot1.tfm \
tex-LibreBodoni-Regular-sup-t1--base.tfm \
tex-LibreBodoni-Regular-sup-t1.tfm \
tex-LibreBodoni-Regular-sup-t1.vf \
tex-LibreBodoni-Regular-tlf-ly1--base.tfm \
tex-LibreBodoni-Regular-tlf-ly1.tfm \
tex-LibreBodoni-Regular-tlf-ly1.vf \
tex-LibreBodoni-Regular-tlf-ot1.tfm \
tex-LibreBodoni-Regular-tlf-t1--base.tfm \
tex-LibreBodoni-Regular-tlf-t1.tfm \
tex-LibreBodoni-Regular-tlf-t1.vf \
tex-LibreBodoni-Regular-tlf-ts1--base.tfm \
tex-LibreBodoni-Regular-tlf-ts1.tfm \
tex-LibreBodoni-Regular-tlf-ts1.vf \
tex-LibreBodoni.map \
tex-LibreBodoni.sty \
tex-OT1LibreBodoni-Inf.fd \
tex-OT1LibreBodoni-Sup.fd \
tex-OT1LibreBodoni-TLF.fd \
tex-T1LibreBodoni-Inf.fd \
tex-T1LibreBodoni-Sup.fd \
tex-T1LibreBodoni-TLF.fd \
tex-TS1LibreBodoni-TLF.fd \
tex-lbd-2nc6ly.enc \
tex-lbd-dwvqiv.enc \
tex-lbd-fttd7q.enc \
tex-lbd-gxeqsi.enc \
tex-lbd-k2dfwc.enc \
tex-lbd-oaf34p.enc \
tex-lbd-pcwse4.enc \
tex-lbd-rpuqof.enc \
tex-lbd-yeotsr.enc \
tex-lbd-zpaflu.enc \
texlive-librebodoni"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifxetex.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-librebodoni-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
