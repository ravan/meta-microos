SUMMARY = "Translations for package libKF6JobWidgets6"
DESCRIPTION = "Provides translations for the 'libKF6JobWidgets6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6JobWidgets6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "8e473c3bf30ac03352ea511a89acfa8a1ff80d8e03d8ca82eaf6f56d586a2a5e3ac9455ffc5c0f0b8fc523424bde1bf966fb3a24fb8b57a77935d9959d80502d"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6JobWidgets6-lang \
libKF6JobWidgets6-lang-all \
locale-libKF6JobWidgets6-af \
locale-libKF6JobWidgets6-ar \
locale-libKF6JobWidgets6-as \
locale-libKF6JobWidgets6-ast \
locale-libKF6JobWidgets6-az \
locale-libKF6JobWidgets6-be \
locale-libKF6JobWidgets6-be@latin \
locale-libKF6JobWidgets6-bg \
locale-libKF6JobWidgets6-bn \
locale-libKF6JobWidgets6-bn-IN \
locale-libKF6JobWidgets6-br \
locale-libKF6JobWidgets6-bs \
locale-libKF6JobWidgets6-ca \
locale-libKF6JobWidgets6-ca@valencia \
locale-libKF6JobWidgets6-cs \
locale-libKF6JobWidgets6-cy \
locale-libKF6JobWidgets6-da \
locale-libKF6JobWidgets6-de \
locale-libKF6JobWidgets6-el \
locale-libKF6JobWidgets6-en \
locale-libKF6JobWidgets6-en-GB \
locale-libKF6JobWidgets6-eo \
locale-libKF6JobWidgets6-es \
locale-libKF6JobWidgets6-et \
locale-libKF6JobWidgets6-eu \
locale-libKF6JobWidgets6-fa \
locale-libKF6JobWidgets6-fi \
locale-libKF6JobWidgets6-fr \
locale-libKF6JobWidgets6-ga \
locale-libKF6JobWidgets6-gd \
locale-libKF6JobWidgets6-gl \
locale-libKF6JobWidgets6-gu \
locale-libKF6JobWidgets6-he \
locale-libKF6JobWidgets6-hi \
locale-libKF6JobWidgets6-hr \
locale-libKF6JobWidgets6-hu \
locale-libKF6JobWidgets6-ia \
locale-libKF6JobWidgets6-id \
locale-libKF6JobWidgets6-is \
locale-libKF6JobWidgets6-it \
locale-libKF6JobWidgets6-ja \
locale-libKF6JobWidgets6-ka \
locale-libKF6JobWidgets6-kk \
locale-libKF6JobWidgets6-km \
locale-libKF6JobWidgets6-kn \
locale-libKF6JobWidgets6-ko \
locale-libKF6JobWidgets6-lt \
locale-libKF6JobWidgets6-lv \
locale-libKF6JobWidgets6-mai \
locale-libKF6JobWidgets6-mk \
locale-libKF6JobWidgets6-ml \
locale-libKF6JobWidgets6-mr \
locale-libKF6JobWidgets6-ms \
locale-libKF6JobWidgets6-nb \
locale-libKF6JobWidgets6-nds \
locale-libKF6JobWidgets6-ne \
locale-libKF6JobWidgets6-nl \
locale-libKF6JobWidgets6-nn \
locale-libKF6JobWidgets6-oc \
locale-libKF6JobWidgets6-or \
locale-libKF6JobWidgets6-pa \
locale-libKF6JobWidgets6-pl \
locale-libKF6JobWidgets6-pt \
locale-libKF6JobWidgets6-pt-BR \
locale-libKF6JobWidgets6-ro \
locale-libKF6JobWidgets6-ru \
locale-libKF6JobWidgets6-si \
locale-libKF6JobWidgets6-sk \
locale-libKF6JobWidgets6-sl \
locale-libKF6JobWidgets6-sq \
locale-libKF6JobWidgets6-sr \
locale-libKF6JobWidgets6-sr@ijekavian \
locale-libKF6JobWidgets6-sr@ijekavianlatin \
locale-libKF6JobWidgets6-sr@latin \
locale-libKF6JobWidgets6-sv \
locale-libKF6JobWidgets6-ta \
locale-libKF6JobWidgets6-te \
locale-libKF6JobWidgets6-th \
locale-libKF6JobWidgets6-tr \
locale-libKF6JobWidgets6-ug \
locale-libKF6JobWidgets6-uk \
locale-libKF6JobWidgets6-vi \
locale-libKF6JobWidgets6-wa \
locale-libKF6JobWidgets6-zh-CN \
locale-libKF6JobWidgets6-zh-HK \
locale-libKF6JobWidgets6-zh-TW"

RDEPENDS:${PN} += "libKF6JobWidgets6"

inherit rpm
