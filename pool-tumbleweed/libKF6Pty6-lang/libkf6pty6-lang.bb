SUMMARY = "Translations for package libKF6Pty6"
DESCRIPTION = "Provides translations for the 'libKF6Pty6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6Pty6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "ad25139737907a25768c79458e7f430970227b243da583e9fa3cda7394b4fa4b59482be0ac3f518f6a60927399137b7df83be4a5a80c1fe1a0f215f574873aa8"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6Pty6-lang \
libKF6Pty6-lang-all \
locale-libKF6Pty6-af \
locale-libKF6Pty6-ar \
locale-libKF6Pty6-as \
locale-libKF6Pty6-ast \
locale-libKF6Pty6-az \
locale-libKF6Pty6-be \
locale-libKF6Pty6-be@latin \
locale-libKF6Pty6-bg \
locale-libKF6Pty6-bn \
locale-libKF6Pty6-bn-IN \
locale-libKF6Pty6-br \
locale-libKF6Pty6-bs \
locale-libKF6Pty6-ca \
locale-libKF6Pty6-ca@valencia \
locale-libKF6Pty6-cs \
locale-libKF6Pty6-cy \
locale-libKF6Pty6-da \
locale-libKF6Pty6-de \
locale-libKF6Pty6-el \
locale-libKF6Pty6-en-GB \
locale-libKF6Pty6-eo \
locale-libKF6Pty6-es \
locale-libKF6Pty6-et \
locale-libKF6Pty6-eu \
locale-libKF6Pty6-fa \
locale-libKF6Pty6-fi \
locale-libKF6Pty6-fr \
locale-libKF6Pty6-ga \
locale-libKF6Pty6-gd \
locale-libKF6Pty6-gl \
locale-libKF6Pty6-gu \
locale-libKF6Pty6-he \
locale-libKF6Pty6-hi \
locale-libKF6Pty6-hr \
locale-libKF6Pty6-hu \
locale-libKF6Pty6-ia \
locale-libKF6Pty6-id \
locale-libKF6Pty6-is \
locale-libKF6Pty6-it \
locale-libKF6Pty6-ja \
locale-libKF6Pty6-ka \
locale-libKF6Pty6-kk \
locale-libKF6Pty6-km \
locale-libKF6Pty6-kn \
locale-libKF6Pty6-ko \
locale-libKF6Pty6-lt \
locale-libKF6Pty6-lv \
locale-libKF6Pty6-mai \
locale-libKF6Pty6-mk \
locale-libKF6Pty6-ml \
locale-libKF6Pty6-mr \
locale-libKF6Pty6-ms \
locale-libKF6Pty6-nb \
locale-libKF6Pty6-nds \
locale-libKF6Pty6-ne \
locale-libKF6Pty6-nl \
locale-libKF6Pty6-nn \
locale-libKF6Pty6-oc \
locale-libKF6Pty6-or \
locale-libKF6Pty6-pa \
locale-libKF6Pty6-pl \
locale-libKF6Pty6-pt \
locale-libKF6Pty6-pt-BR \
locale-libKF6Pty6-ro \
locale-libKF6Pty6-ru \
locale-libKF6Pty6-si \
locale-libKF6Pty6-sk \
locale-libKF6Pty6-sl \
locale-libKF6Pty6-sq \
locale-libKF6Pty6-sr \
locale-libKF6Pty6-sr@ijekavian \
locale-libKF6Pty6-sr@ijekavianlatin \
locale-libKF6Pty6-sr@latin \
locale-libKF6Pty6-sv \
locale-libKF6Pty6-ta \
locale-libKF6Pty6-te \
locale-libKF6Pty6-th \
locale-libKF6Pty6-tr \
locale-libKF6Pty6-ug \
locale-libKF6Pty6-uk \
locale-libKF6Pty6-vi \
locale-libKF6Pty6-wa \
locale-libKF6Pty6-zh-CN \
locale-libKF6Pty6-zh-HK \
locale-libKF6Pty6-zh-TW"

RDEPENDS:${PN} += "libKF6Pty6"

inherit rpm
