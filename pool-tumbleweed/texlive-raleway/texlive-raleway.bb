SUMMARY = "Use Raleway with TeX(-alike) systems"
DESCRIPTION = "The package provides the Raleway family in an easy to use way. \
For XeLaTeX and LuaLaTeX users the original OpenType fonts are \
used. The entire font family is included."
LICENSE = "OFL-1.1"

PV = "2026.226.1.6svn77682"

RPM_NAME = "texlive-raleway-2026.226.1.6svn77682-60.4.noarch.rpm"
RPM_HASH = "06d7bdedca419cafbc58fb896c3a9ac8f972fb45530f50d49371b53d1e08a1e8a26c186120dc3d98a4c6f6bdd409c3f55dca6f61328d4d4c89c3f11942cf8ab8"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-LY1Raleway-Dnom.fd \
tex-LY1Raleway-Inf.fd \
tex-LY1Raleway-LF.fd \
tex-LY1Raleway-Numr.fd \
tex-LY1Raleway-OsF.fd \
tex-LY1Raleway-Sup.fd \
tex-OT1Raleway-Dnom.fd \
tex-OT1Raleway-Inf.fd \
tex-OT1Raleway-LF.fd \
tex-OT1Raleway-Numr.fd \
tex-OT1Raleway-OsF.fd \
tex-OT1Raleway-Sup.fd \
tex-Raleway-Black-dnom-ly1--base.tfm \
tex-Raleway-Black-dnom-ly1.tfm \
tex-Raleway-Black-dnom-ly1.vf \
tex-Raleway-Black-dnom-ot1.tfm \
tex-Raleway-Black-dnom-t1--base.tfm \
tex-Raleway-Black-dnom-t1.tfm \
tex-Raleway-Black-dnom-t1.vf \
tex-Raleway-Black-inf-ly1--base.tfm \
tex-Raleway-Black-inf-ly1.tfm \
tex-Raleway-Black-inf-ly1.vf \
tex-Raleway-Black-inf-ot1.tfm \
tex-Raleway-Black-inf-t1--base.tfm \
tex-Raleway-Black-inf-t1.tfm \
tex-Raleway-Black-inf-t1.vf \
tex-Raleway-Black-lf-ly1--base.tfm \
tex-Raleway-Black-lf-ly1.tfm \
tex-Raleway-Black-lf-ly1.vf \
tex-Raleway-Black-lf-ot1.tfm \
tex-Raleway-Black-lf-sc-ly1--base.tfm \
tex-Raleway-Black-lf-sc-ly1.tfm \
tex-Raleway-Black-lf-sc-ly1.vf \
tex-Raleway-Black-lf-sc-ot1--base.tfm \
tex-Raleway-Black-lf-sc-ot1.tfm \
tex-Raleway-Black-lf-sc-ot1.vf \
tex-Raleway-Black-lf-sc-t1--base.tfm \
tex-Raleway-Black-lf-sc-t1.tfm \
tex-Raleway-Black-lf-sc-t1.vf \
tex-Raleway-Black-lf-t1--base.tfm \
tex-Raleway-Black-lf-t1.tfm \
tex-Raleway-Black-lf-t1.vf \
tex-Raleway-Black-lf-ts1--base.tfm \
tex-Raleway-Black-lf-ts1.tfm \
tex-Raleway-Black-lf-ts1.vf \
tex-Raleway-Black-numr-ly1--base.tfm \
tex-Raleway-Black-numr-ly1.tfm \
tex-Raleway-Black-numr-ly1.vf \
tex-Raleway-Black-numr-ot1.tfm \
tex-Raleway-Black-numr-t1--base.tfm \
tex-Raleway-Black-numr-t1.tfm \
tex-Raleway-Black-numr-t1.vf \
tex-Raleway-Black-osf-ly1--base.tfm \
tex-Raleway-Black-osf-ly1.tfm \
tex-Raleway-Black-osf-ly1.vf \
tex-Raleway-Black-osf-ot1.tfm \
tex-Raleway-Black-osf-sc-ly1--base.tfm \
tex-Raleway-Black-osf-sc-ly1.tfm \
tex-Raleway-Black-osf-sc-ly1.vf \
tex-Raleway-Black-osf-sc-ot1--base.tfm \
tex-Raleway-Black-osf-sc-ot1.tfm \
tex-Raleway-Black-osf-sc-ot1.vf \
tex-Raleway-Black-osf-sc-t1--base.tfm \
tex-Raleway-Black-osf-sc-t1.tfm \
tex-Raleway-Black-osf-sc-t1.vf \
tex-Raleway-Black-osf-t1--base.tfm \
tex-Raleway-Black-osf-t1.tfm \
tex-Raleway-Black-osf-t1.vf \
tex-Raleway-Black-osf-ts1--base.tfm \
tex-Raleway-Black-osf-ts1.tfm \
tex-Raleway-Black-osf-ts1.vf \
tex-Raleway-Black-sup-ly1--base.tfm \
tex-Raleway-Black-sup-ly1.tfm \
tex-Raleway-Black-sup-ly1.vf \
tex-Raleway-Black-sup-ot1.tfm \
tex-Raleway-Black-sup-t1--base.tfm \
tex-Raleway-Black-sup-t1.tfm \
tex-Raleway-Black-sup-t1.vf \
tex-Raleway-BlackItalic-dnom-ly1--base.tfm \
tex-Raleway-BlackItalic-dnom-ly1.tfm \
tex-Raleway-BlackItalic-dnom-ly1.vf \
tex-Raleway-BlackItalic-dnom-ot1.tfm \
tex-Raleway-BlackItalic-dnom-t1--base.tfm \
tex-Raleway-BlackItalic-dnom-t1.tfm \
tex-Raleway-BlackItalic-dnom-t1.vf \
tex-Raleway-BlackItalic-inf-ly1--base.tfm \
tex-Raleway-BlackItalic-inf-ly1.tfm \
tex-Raleway-BlackItalic-inf-ly1.vf \
tex-Raleway-BlackItalic-inf-ot1.tfm \
tex-Raleway-BlackItalic-inf-t1--base.tfm \
tex-Raleway-BlackItalic-inf-t1.tfm \
tex-Raleway-BlackItalic-inf-t1.vf \
tex-Raleway-BlackItalic-numr-ly1--base.tfm \
tex-Raleway-BlackItalic-numr-ly1.tfm \
tex-Raleway-BlackItalic-numr-ly1.vf \
tex-Raleway-BlackItalic-numr-ot1.tfm \
tex-Raleway-BlackItalic-numr-t1--base.tfm \
tex-Raleway-BlackItalic-numr-t1.tfm \
tex-Raleway-BlackItalic-numr-t1.vf \
tex-Raleway-BlackItalic-osf-ly1--base.tfm \
tex-Raleway-BlackItalic-osf-ly1.tfm \
tex-Raleway-BlackItalic-osf-ly1.vf \
tex-Raleway-BlackItalic-osf-ot1.tfm \
tex-Raleway-BlackItalic-osf-sc-ly1--base.tfm \
tex-Raleway-BlackItalic-osf-sc-ly1.tfm \
tex-Raleway-BlackItalic-osf-sc-ly1.vf \
tex-Raleway-BlackItalic-osf-sc-ot1--base.tfm \
tex-Raleway-BlackItalic-osf-sc-ot1.tfm \
tex-Raleway-BlackItalic-osf-sc-ot1.vf \
tex-Raleway-BlackItalic-osf-sc-t1--base.tfm \
tex-Raleway-BlackItalic-osf-sc-t1.tfm \
tex-Raleway-BlackItalic-osf-sc-t1.vf \
tex-Raleway-BlackItalic-osf-t1--base.tfm \
tex-Raleway-BlackItalic-osf-t1.tfm \
tex-Raleway-BlackItalic-osf-t1.vf \
tex-Raleway-BlackItalic-osf-ts1--base.tfm \
tex-Raleway-BlackItalic-osf-ts1.tfm \
tex-Raleway-BlackItalic-osf-ts1.vf \
tex-Raleway-BlackItalic-sup-ly1--base.tfm \
tex-Raleway-BlackItalic-sup-ly1.tfm \
tex-Raleway-BlackItalic-sup-ly1.vf \
tex-Raleway-BlackItalic-sup-ot1.tfm \
tex-Raleway-BlackItalic-sup-t1--base.tfm \
tex-Raleway-BlackItalic-sup-t1.tfm \
tex-Raleway-BlackItalic-sup-t1.vf \
tex-Raleway-Bold-dnom-ly1--base.tfm \
tex-Raleway-Bold-dnom-ly1.tfm \
tex-Raleway-Bold-dnom-ly1.vf \
tex-Raleway-Bold-dnom-ot1.tfm \
tex-Raleway-Bold-dnom-t1--base.tfm \
tex-Raleway-Bold-dnom-t1.tfm \
tex-Raleway-Bold-dnom-t1.vf \
tex-Raleway-Bold-inf-ly1--base.tfm \
tex-Raleway-Bold-inf-ly1.tfm \
tex-Raleway-Bold-inf-ly1.vf \
tex-Raleway-Bold-inf-ot1.tfm \
tex-Raleway-Bold-inf-t1--base.tfm \
tex-Raleway-Bold-inf-t1.tfm \
tex-Raleway-Bold-inf-t1.vf \
tex-Raleway-Bold-lf-ly1--base.tfm \
tex-Raleway-Bold-lf-ly1.tfm \
tex-Raleway-Bold-lf-ly1.vf \
tex-Raleway-Bold-lf-ot1.tfm \
tex-Raleway-Bold-lf-sc-ly1--base.tfm \
tex-Raleway-Bold-lf-sc-ly1.tfm \
tex-Raleway-Bold-lf-sc-ly1.vf \
tex-Raleway-Bold-lf-sc-ot1--base.tfm \
tex-Raleway-Bold-lf-sc-ot1.tfm \
tex-Raleway-Bold-lf-sc-ot1.vf \
tex-Raleway-Bold-lf-sc-t1--base.tfm \
tex-Raleway-Bold-lf-sc-t1.tfm \
tex-Raleway-Bold-lf-sc-t1.vf \
tex-Raleway-Bold-lf-t1--base.tfm \
tex-Raleway-Bold-lf-t1.tfm \
tex-Raleway-Bold-lf-t1.vf \
tex-Raleway-Bold-lf-ts1--base.tfm \
tex-Raleway-Bold-lf-ts1.tfm \
tex-Raleway-Bold-lf-ts1.vf \
tex-Raleway-Bold-numr-ly1--base.tfm \
tex-Raleway-Bold-numr-ly1.tfm \
tex-Raleway-Bold-numr-ly1.vf \
tex-Raleway-Bold-numr-ot1.tfm \
tex-Raleway-Bold-numr-t1--base.tfm \
tex-Raleway-Bold-numr-t1.tfm \
tex-Raleway-Bold-numr-t1.vf \
tex-Raleway-Bold-osf-ly1--base.tfm \
tex-Raleway-Bold-osf-ly1.tfm \
tex-Raleway-Bold-osf-ly1.vf \
tex-Raleway-Bold-osf-ot1.tfm \
tex-Raleway-Bold-osf-sc-ly1--base.tfm \
tex-Raleway-Bold-osf-sc-ly1.tfm \
tex-Raleway-Bold-osf-sc-ly1.vf \
tex-Raleway-Bold-osf-sc-ot1--base.tfm \
tex-Raleway-Bold-osf-sc-ot1.tfm \
tex-Raleway-Bold-osf-sc-ot1.vf \
tex-Raleway-Bold-osf-sc-t1--base.tfm \
tex-Raleway-Bold-osf-sc-t1.tfm \
tex-Raleway-Bold-osf-sc-t1.vf \
tex-Raleway-Bold-osf-t1--base.tfm \
tex-Raleway-Bold-osf-t1.tfm \
tex-Raleway-Bold-osf-t1.vf \
tex-Raleway-Bold-osf-ts1--base.tfm \
tex-Raleway-Bold-osf-ts1.tfm \
tex-Raleway-Bold-osf-ts1.vf \
tex-Raleway-Bold-sup-ly1--base.tfm \
tex-Raleway-Bold-sup-ly1.tfm \
tex-Raleway-Bold-sup-ly1.vf \
tex-Raleway-Bold-sup-ot1.tfm \
tex-Raleway-Bold-sup-t1--base.tfm \
tex-Raleway-Bold-sup-t1.tfm \
tex-Raleway-Bold-sup-t1.vf \
tex-Raleway-BoldItalic-dnom-ly1--base.tfm \
tex-Raleway-BoldItalic-dnom-ly1.tfm \
tex-Raleway-BoldItalic-dnom-ly1.vf \
tex-Raleway-BoldItalic-dnom-ot1.tfm \
tex-Raleway-BoldItalic-dnom-t1--base.tfm \
tex-Raleway-BoldItalic-dnom-t1.tfm \
tex-Raleway-BoldItalic-dnom-t1.vf \
tex-Raleway-BoldItalic-inf-ly1--base.tfm \
tex-Raleway-BoldItalic-inf-ly1.tfm \
tex-Raleway-BoldItalic-inf-ly1.vf \
tex-Raleway-BoldItalic-inf-ot1.tfm \
tex-Raleway-BoldItalic-inf-t1--base.tfm \
tex-Raleway-BoldItalic-inf-t1.tfm \
tex-Raleway-BoldItalic-inf-t1.vf \
tex-Raleway-BoldItalic-numr-ly1--base.tfm \
tex-Raleway-BoldItalic-numr-ly1.tfm \
tex-Raleway-BoldItalic-numr-ly1.vf \
tex-Raleway-BoldItalic-numr-ot1.tfm \
tex-Raleway-BoldItalic-numr-t1--base.tfm \
tex-Raleway-BoldItalic-numr-t1.tfm \
tex-Raleway-BoldItalic-numr-t1.vf \
tex-Raleway-BoldItalic-osf-ly1--base.tfm \
tex-Raleway-BoldItalic-osf-ly1.tfm \
tex-Raleway-BoldItalic-osf-ly1.vf \
tex-Raleway-BoldItalic-osf-ot1.tfm \
tex-Raleway-BoldItalic-osf-sc-ly1--base.tfm \
tex-Raleway-BoldItalic-osf-sc-ly1.tfm \
tex-Raleway-BoldItalic-osf-sc-ly1.vf \
tex-Raleway-BoldItalic-osf-sc-ot1--base.tfm \
tex-Raleway-BoldItalic-osf-sc-ot1.tfm \
tex-Raleway-BoldItalic-osf-sc-ot1.vf \
tex-Raleway-BoldItalic-osf-sc-t1--base.tfm \
tex-Raleway-BoldItalic-osf-sc-t1.tfm \
tex-Raleway-BoldItalic-osf-sc-t1.vf \
tex-Raleway-BoldItalic-osf-t1--base.tfm \
tex-Raleway-BoldItalic-osf-t1.tfm \
tex-Raleway-BoldItalic-osf-t1.vf \
tex-Raleway-BoldItalic-osf-ts1--base.tfm \
tex-Raleway-BoldItalic-osf-ts1.tfm \
tex-Raleway-BoldItalic-osf-ts1.vf \
tex-Raleway-BoldItalic-sup-ly1--base.tfm \
tex-Raleway-BoldItalic-sup-ly1.tfm \
tex-Raleway-BoldItalic-sup-ly1.vf \
tex-Raleway-BoldItalic-sup-ot1.tfm \
tex-Raleway-BoldItalic-sup-t1--base.tfm \
tex-Raleway-BoldItalic-sup-t1.tfm \
tex-Raleway-BoldItalic-sup-t1.vf \
tex-Raleway-ExtraBold-dnom-ly1--base.tfm \
tex-Raleway-ExtraBold-dnom-ly1.tfm \
tex-Raleway-ExtraBold-dnom-ly1.vf \
tex-Raleway-ExtraBold-dnom-ot1.tfm \
tex-Raleway-ExtraBold-dnom-t1--base.tfm \
tex-Raleway-ExtraBold-dnom-t1.tfm \
tex-Raleway-ExtraBold-dnom-t1.vf \
tex-Raleway-ExtraBold-inf-ly1--base.tfm \
tex-Raleway-ExtraBold-inf-ly1.tfm \
tex-Raleway-ExtraBold-inf-ly1.vf \
tex-Raleway-ExtraBold-inf-ot1.tfm \
tex-Raleway-ExtraBold-inf-t1--base.tfm \
tex-Raleway-ExtraBold-inf-t1.tfm \
tex-Raleway-ExtraBold-inf-t1.vf \
tex-Raleway-ExtraBold-lf-ly1--base.tfm \
tex-Raleway-ExtraBold-lf-ly1.tfm \
tex-Raleway-ExtraBold-lf-ly1.vf \
tex-Raleway-ExtraBold-lf-ot1.tfm \
tex-Raleway-ExtraBold-lf-sc-ly1--base.tfm \
tex-Raleway-ExtraBold-lf-sc-ly1.tfm \
tex-Raleway-ExtraBold-lf-sc-ly1.vf \
tex-Raleway-ExtraBold-lf-sc-ot1--base.tfm \
tex-Raleway-ExtraBold-lf-sc-ot1.tfm \
tex-Raleway-ExtraBold-lf-sc-ot1.vf \
tex-Raleway-ExtraBold-lf-sc-t1--base.tfm \
tex-Raleway-ExtraBold-lf-sc-t1.tfm \
tex-Raleway-ExtraBold-lf-sc-t1.vf \
tex-Raleway-ExtraBold-lf-t1--base.tfm \
tex-Raleway-ExtraBold-lf-t1.tfm \
tex-Raleway-ExtraBold-lf-t1.vf \
tex-Raleway-ExtraBold-lf-ts1--base.tfm \
tex-Raleway-ExtraBold-lf-ts1.tfm \
tex-Raleway-ExtraBold-lf-ts1.vf \
tex-Raleway-ExtraBold-numr-ly1--base.tfm \
tex-Raleway-ExtraBold-numr-ly1.tfm \
tex-Raleway-ExtraBold-numr-ly1.vf \
tex-Raleway-ExtraBold-numr-ot1.tfm \
tex-Raleway-ExtraBold-numr-t1--base.tfm \
tex-Raleway-ExtraBold-numr-t1.tfm \
tex-Raleway-ExtraBold-numr-t1.vf \
tex-Raleway-ExtraBold-osf-ly1--base.tfm \
tex-Raleway-ExtraBold-osf-ly1.tfm \
tex-Raleway-ExtraBold-osf-ly1.vf \
tex-Raleway-ExtraBold-osf-ot1.tfm \
tex-Raleway-ExtraBold-osf-sc-ly1--base.tfm \
tex-Raleway-ExtraBold-osf-sc-ly1.tfm \
tex-Raleway-ExtraBold-osf-sc-ly1.vf \
tex-Raleway-ExtraBold-osf-sc-ot1--base.tfm \
tex-Raleway-ExtraBold-osf-sc-ot1.tfm \
tex-Raleway-ExtraBold-osf-sc-ot1.vf \
tex-Raleway-ExtraBold-osf-sc-t1--base.tfm \
tex-Raleway-ExtraBold-osf-sc-t1.tfm \
tex-Raleway-ExtraBold-osf-sc-t1.vf \
tex-Raleway-ExtraBold-osf-t1--base.tfm \
tex-Raleway-ExtraBold-osf-t1.tfm \
tex-Raleway-ExtraBold-osf-t1.vf \
tex-Raleway-ExtraBold-osf-ts1--base.tfm \
tex-Raleway-ExtraBold-osf-ts1.tfm \
tex-Raleway-ExtraBold-osf-ts1.vf \
tex-Raleway-ExtraBold-sup-ly1--base.tfm \
tex-Raleway-ExtraBold-sup-ly1.tfm \
tex-Raleway-ExtraBold-sup-ly1.vf \
tex-Raleway-ExtraBold-sup-ot1.tfm \
tex-Raleway-ExtraBold-sup-t1--base.tfm \
tex-Raleway-ExtraBold-sup-t1.tfm \
tex-Raleway-ExtraBold-sup-t1.vf \
tex-Raleway-ExtraBoldItalic-dnom-ly1--base.tfm \
tex-Raleway-ExtraBoldItalic-dnom-ly1.tfm \
tex-Raleway-ExtraBoldItalic-dnom-ly1.vf \
tex-Raleway-ExtraBoldItalic-dnom-ot1.tfm \
tex-Raleway-ExtraBoldItalic-dnom-t1--base.tfm \
tex-Raleway-ExtraBoldItalic-dnom-t1.tfm \
tex-Raleway-ExtraBoldItalic-dnom-t1.vf \
tex-Raleway-ExtraBoldItalic-inf-ly1--base.tfm \
tex-Raleway-ExtraBoldItalic-inf-ly1.tfm \
tex-Raleway-ExtraBoldItalic-inf-ly1.vf \
tex-Raleway-ExtraBoldItalic-inf-ot1.tfm \
tex-Raleway-ExtraBoldItalic-inf-t1--base.tfm \
tex-Raleway-ExtraBoldItalic-inf-t1.tfm \
tex-Raleway-ExtraBoldItalic-inf-t1.vf \
tex-Raleway-ExtraBoldItalic-numr-ly1--base.tfm \
tex-Raleway-ExtraBoldItalic-numr-ly1.tfm \
tex-Raleway-ExtraBoldItalic-numr-ly1.vf \
tex-Raleway-ExtraBoldItalic-numr-ot1.tfm \
tex-Raleway-ExtraBoldItalic-numr-t1--base.tfm \
tex-Raleway-ExtraBoldItalic-numr-t1.tfm \
tex-Raleway-ExtraBoldItalic-numr-t1.vf \
tex-Raleway-ExtraBoldItalic-osf-ly1--base.tfm \
tex-Raleway-ExtraBoldItalic-osf-ly1.tfm \
tex-Raleway-ExtraBoldItalic-osf-ly1.vf \
tex-Raleway-ExtraBoldItalic-osf-ot1.tfm \
tex-Raleway-ExtraBoldItalic-osf-sc-ly1--base.tfm \
tex-Raleway-ExtraBoldItalic-osf-sc-ly1.tfm \
tex-Raleway-ExtraBoldItalic-osf-sc-ly1.vf \
tex-Raleway-ExtraBoldItalic-osf-sc-ot1--base.tfm \
tex-Raleway-ExtraBoldItalic-osf-sc-ot1.tfm \
tex-Raleway-ExtraBoldItalic-osf-sc-ot1.vf \
tex-Raleway-ExtraBoldItalic-osf-sc-t1--base.tfm \
tex-Raleway-ExtraBoldItalic-osf-sc-t1.tfm \
tex-Raleway-ExtraBoldItalic-osf-sc-t1.vf \
tex-Raleway-ExtraBoldItalic-osf-t1--base.tfm \
tex-Raleway-ExtraBoldItalic-osf-t1.tfm \
tex-Raleway-ExtraBoldItalic-osf-t1.vf \
tex-Raleway-ExtraBoldItalic-osf-ts1--base.tfm \
tex-Raleway-ExtraBoldItalic-osf-ts1.tfm \
tex-Raleway-ExtraBoldItalic-osf-ts1.vf \
tex-Raleway-ExtraBoldItalic-sup-ly1--base.tfm \
tex-Raleway-ExtraBoldItalic-sup-ly1.tfm \
tex-Raleway-ExtraBoldItalic-sup-ly1.vf \
tex-Raleway-ExtraBoldItalic-sup-ot1.tfm \
tex-Raleway-ExtraBoldItalic-sup-t1--base.tfm \
tex-Raleway-ExtraBoldItalic-sup-t1.tfm \
tex-Raleway-ExtraBoldItalic-sup-t1.vf \
tex-Raleway-ExtraLight-dnom-ly1--base.tfm \
tex-Raleway-ExtraLight-dnom-ly1.tfm \
tex-Raleway-ExtraLight-dnom-ly1.vf \
tex-Raleway-ExtraLight-dnom-ot1.tfm \
tex-Raleway-ExtraLight-dnom-t1--base.tfm \
tex-Raleway-ExtraLight-dnom-t1.tfm \
tex-Raleway-ExtraLight-dnom-t1.vf \
tex-Raleway-ExtraLight-inf-ly1--base.tfm \
tex-Raleway-ExtraLight-inf-ly1.tfm \
tex-Raleway-ExtraLight-inf-ly1.vf \
tex-Raleway-ExtraLight-inf-ot1.tfm \
tex-Raleway-ExtraLight-inf-t1--base.tfm \
tex-Raleway-ExtraLight-inf-t1.tfm \
tex-Raleway-ExtraLight-inf-t1.vf \
tex-Raleway-ExtraLight-lf-ly1--base.tfm \
tex-Raleway-ExtraLight-lf-ly1.tfm \
tex-Raleway-ExtraLight-lf-ly1.vf \
tex-Raleway-ExtraLight-lf-ot1.tfm \
tex-Raleway-ExtraLight-lf-sc-ly1--base.tfm \
tex-Raleway-ExtraLight-lf-sc-ly1.tfm \
tex-Raleway-ExtraLight-lf-sc-ly1.vf \
tex-Raleway-ExtraLight-lf-sc-ot1--base.tfm \
tex-Raleway-ExtraLight-lf-sc-ot1.tfm \
tex-Raleway-ExtraLight-lf-sc-ot1.vf \
tex-Raleway-ExtraLight-lf-sc-t1--base.tfm \
tex-Raleway-ExtraLight-lf-sc-t1.tfm \
tex-Raleway-ExtraLight-lf-sc-t1.vf \
tex-Raleway-ExtraLight-lf-t1--base.tfm \
tex-Raleway-ExtraLight-lf-t1.tfm \
tex-Raleway-ExtraLight-lf-t1.vf \
tex-Raleway-ExtraLight-lf-ts1--base.tfm \
tex-Raleway-ExtraLight-lf-ts1.tfm \
tex-Raleway-ExtraLight-lf-ts1.vf \
tex-Raleway-ExtraLight-numr-ly1--base.tfm \
tex-Raleway-ExtraLight-numr-ly1.tfm \
tex-Raleway-ExtraLight-numr-ly1.vf \
tex-Raleway-ExtraLight-numr-ot1.tfm \
tex-Raleway-ExtraLight-numr-t1--base.tfm \
tex-Raleway-ExtraLight-numr-t1.tfm \
tex-Raleway-ExtraLight-numr-t1.vf \
tex-Raleway-ExtraLight-osf-ly1--base.tfm \
tex-Raleway-ExtraLight-osf-ly1.tfm \
tex-Raleway-ExtraLight-osf-ly1.vf \
tex-Raleway-ExtraLight-osf-ot1.tfm \
tex-Raleway-ExtraLight-osf-sc-ly1--base.tfm \
tex-Raleway-ExtraLight-osf-sc-ly1.tfm \
tex-Raleway-ExtraLight-osf-sc-ly1.vf \
tex-Raleway-ExtraLight-osf-sc-ot1--base.tfm \
tex-Raleway-ExtraLight-osf-sc-ot1.tfm \
tex-Raleway-ExtraLight-osf-sc-ot1.vf \
tex-Raleway-ExtraLight-osf-sc-t1--base.tfm \
tex-Raleway-ExtraLight-osf-sc-t1.tfm \
tex-Raleway-ExtraLight-osf-sc-t1.vf \
tex-Raleway-ExtraLight-osf-t1--base.tfm \
tex-Raleway-ExtraLight-osf-t1.tfm \
tex-Raleway-ExtraLight-osf-t1.vf \
tex-Raleway-ExtraLight-osf-ts1--base.tfm \
tex-Raleway-ExtraLight-osf-ts1.tfm \
tex-Raleway-ExtraLight-osf-ts1.vf \
tex-Raleway-ExtraLight-sup-ly1--base.tfm \
tex-Raleway-ExtraLight-sup-ly1.tfm \
tex-Raleway-ExtraLight-sup-ly1.vf \
tex-Raleway-ExtraLight-sup-ot1.tfm \
tex-Raleway-ExtraLight-sup-t1--base.tfm \
tex-Raleway-ExtraLight-sup-t1.tfm \
tex-Raleway-ExtraLight-sup-t1.vf \
tex-Raleway-ExtraLightItalic-dnom-ly1--base.tfm \
tex-Raleway-ExtraLightItalic-dnom-ly1.tfm \
tex-Raleway-ExtraLightItalic-dnom-ly1.vf \
tex-Raleway-ExtraLightItalic-dnom-ot1.tfm \
tex-Raleway-ExtraLightItalic-dnom-t1--base.tfm \
tex-Raleway-ExtraLightItalic-dnom-t1.tfm \
tex-Raleway-ExtraLightItalic-dnom-t1.vf \
tex-Raleway-ExtraLightItalic-inf-ly1--base.tfm \
tex-Raleway-ExtraLightItalic-inf-ly1.tfm \
tex-Raleway-ExtraLightItalic-inf-ly1.vf \
tex-Raleway-ExtraLightItalic-inf-ot1.tfm \
tex-Raleway-ExtraLightItalic-inf-t1--base.tfm \
tex-Raleway-ExtraLightItalic-inf-t1.tfm \
tex-Raleway-ExtraLightItalic-inf-t1.vf \
tex-Raleway-ExtraLightItalic-numr-ly1--base.tfm \
tex-Raleway-ExtraLightItalic-numr-ly1.tfm \
tex-Raleway-ExtraLightItalic-numr-ly1.vf \
tex-Raleway-ExtraLightItalic-numr-ot1.tfm \
tex-Raleway-ExtraLightItalic-numr-t1--base.tfm \
tex-Raleway-ExtraLightItalic-numr-t1.tfm \
tex-Raleway-ExtraLightItalic-numr-t1.vf \
tex-Raleway-ExtraLightItalic-osf-ly1--base.tfm \
tex-Raleway-ExtraLightItalic-osf-ly1.tfm \
tex-Raleway-ExtraLightItalic-osf-ly1.vf \
tex-Raleway-ExtraLightItalic-osf-ot1.tfm \
tex-Raleway-ExtraLightItalic-osf-sc-ly1--base.tfm \
tex-Raleway-ExtraLightItalic-osf-sc-ly1.tfm \
tex-Raleway-ExtraLightItalic-osf-sc-ly1.vf \
tex-Raleway-ExtraLightItalic-osf-sc-ot1--base.tfm \
tex-Raleway-ExtraLightItalic-osf-sc-ot1.tfm \
tex-Raleway-ExtraLightItalic-osf-sc-ot1.vf \
tex-Raleway-ExtraLightItalic-osf-sc-t1--base.tfm \
tex-Raleway-ExtraLightItalic-osf-sc-t1.tfm \
tex-Raleway-ExtraLightItalic-osf-sc-t1.vf \
tex-Raleway-ExtraLightItalic-osf-t1--base.tfm \
tex-Raleway-ExtraLightItalic-osf-t1.tfm \
tex-Raleway-ExtraLightItalic-osf-t1.vf \
tex-Raleway-ExtraLightItalic-osf-ts1--base.tfm \
tex-Raleway-ExtraLightItalic-osf-ts1.tfm \
tex-Raleway-ExtraLightItalic-osf-ts1.vf \
tex-Raleway-ExtraLightItalic-sup-ly1--base.tfm \
tex-Raleway-ExtraLightItalic-sup-ly1.tfm \
tex-Raleway-ExtraLightItalic-sup-ly1.vf \
tex-Raleway-ExtraLightItalic-sup-ot1.tfm \
tex-Raleway-ExtraLightItalic-sup-t1--base.tfm \
tex-Raleway-ExtraLightItalic-sup-t1.tfm \
tex-Raleway-ExtraLightItalic-sup-t1.vf \
tex-Raleway-Italic-dnom-ly1--base.tfm \
tex-Raleway-Italic-dnom-ly1.tfm \
tex-Raleway-Italic-dnom-ly1.vf \
tex-Raleway-Italic-dnom-ot1.tfm \
tex-Raleway-Italic-dnom-t1--base.tfm \
tex-Raleway-Italic-dnom-t1.tfm \
tex-Raleway-Italic-dnom-t1.vf \
tex-Raleway-Italic-inf-ly1--base.tfm \
tex-Raleway-Italic-inf-ly1.tfm \
tex-Raleway-Italic-inf-ly1.vf \
tex-Raleway-Italic-inf-ot1.tfm \
tex-Raleway-Italic-inf-t1--base.tfm \
tex-Raleway-Italic-inf-t1.tfm \
tex-Raleway-Italic-inf-t1.vf \
tex-Raleway-Italic-numr-ly1--base.tfm \
tex-Raleway-Italic-numr-ly1.tfm \
tex-Raleway-Italic-numr-ly1.vf \
tex-Raleway-Italic-numr-ot1.tfm \
tex-Raleway-Italic-numr-t1--base.tfm \
tex-Raleway-Italic-numr-t1.tfm \
tex-Raleway-Italic-numr-t1.vf \
tex-Raleway-Italic-osf-ly1--base.tfm \
tex-Raleway-Italic-osf-ly1.tfm \
tex-Raleway-Italic-osf-ly1.vf \
tex-Raleway-Italic-osf-ot1.tfm \
tex-Raleway-Italic-osf-sc-ly1--base.tfm \
tex-Raleway-Italic-osf-sc-ly1.tfm \
tex-Raleway-Italic-osf-sc-ly1.vf \
tex-Raleway-Italic-osf-sc-ot1--base.tfm \
tex-Raleway-Italic-osf-sc-ot1.tfm \
tex-Raleway-Italic-osf-sc-ot1.vf \
tex-Raleway-Italic-osf-sc-t1--base.tfm \
tex-Raleway-Italic-osf-sc-t1.tfm \
tex-Raleway-Italic-osf-sc-t1.vf \
tex-Raleway-Italic-osf-t1--base.tfm \
tex-Raleway-Italic-osf-t1.tfm \
tex-Raleway-Italic-osf-t1.vf \
tex-Raleway-Italic-osf-ts1--base.tfm \
tex-Raleway-Italic-osf-ts1.tfm \
tex-Raleway-Italic-osf-ts1.vf \
tex-Raleway-Italic-sup-ly1--base.tfm \
tex-Raleway-Italic-sup-ly1.tfm \
tex-Raleway-Italic-sup-ly1.vf \
tex-Raleway-Italic-sup-ot1.tfm \
tex-Raleway-Italic-sup-t1--base.tfm \
tex-Raleway-Italic-sup-t1.tfm \
tex-Raleway-Italic-sup-t1.vf \
tex-Raleway-Light-dnom-ly1--base.tfm \
tex-Raleway-Light-dnom-ly1.tfm \
tex-Raleway-Light-dnom-ly1.vf \
tex-Raleway-Light-dnom-ot1.tfm \
tex-Raleway-Light-dnom-t1--base.tfm \
tex-Raleway-Light-dnom-t1.tfm \
tex-Raleway-Light-dnom-t1.vf \
tex-Raleway-Light-inf-ly1--base.tfm \
tex-Raleway-Light-inf-ly1.tfm \
tex-Raleway-Light-inf-ly1.vf \
tex-Raleway-Light-inf-ot1.tfm \
tex-Raleway-Light-inf-t1--base.tfm \
tex-Raleway-Light-inf-t1.tfm \
tex-Raleway-Light-inf-t1.vf \
tex-Raleway-Light-lf-ly1--base.tfm \
tex-Raleway-Light-lf-ly1.tfm \
tex-Raleway-Light-lf-ly1.vf \
tex-Raleway-Light-lf-ot1.tfm \
tex-Raleway-Light-lf-sc-ly1--base.tfm \
tex-Raleway-Light-lf-sc-ly1.tfm \
tex-Raleway-Light-lf-sc-ly1.vf \
tex-Raleway-Light-lf-sc-ot1--base.tfm \
tex-Raleway-Light-lf-sc-ot1.tfm \
tex-Raleway-Light-lf-sc-ot1.vf \
tex-Raleway-Light-lf-sc-t1--base.tfm \
tex-Raleway-Light-lf-sc-t1.tfm \
tex-Raleway-Light-lf-sc-t1.vf \
tex-Raleway-Light-lf-t1--base.tfm \
tex-Raleway-Light-lf-t1.tfm \
tex-Raleway-Light-lf-t1.vf \
tex-Raleway-Light-lf-ts1--base.tfm \
tex-Raleway-Light-lf-ts1.tfm \
tex-Raleway-Light-lf-ts1.vf \
tex-Raleway-Light-numr-ly1--base.tfm \
tex-Raleway-Light-numr-ly1.tfm \
tex-Raleway-Light-numr-ly1.vf \
tex-Raleway-Light-numr-ot1.tfm \
tex-Raleway-Light-numr-t1--base.tfm \
tex-Raleway-Light-numr-t1.tfm \
tex-Raleway-Light-numr-t1.vf \
tex-Raleway-Light-osf-ly1--base.tfm \
tex-Raleway-Light-osf-ly1.tfm \
tex-Raleway-Light-osf-ly1.vf \
tex-Raleway-Light-osf-ot1.tfm \
tex-Raleway-Light-osf-sc-ly1--base.tfm \
tex-Raleway-Light-osf-sc-ly1.tfm \
tex-Raleway-Light-osf-sc-ly1.vf \
tex-Raleway-Light-osf-sc-ot1--base.tfm \
tex-Raleway-Light-osf-sc-ot1.tfm \
tex-Raleway-Light-osf-sc-ot1.vf \
tex-Raleway-Light-osf-sc-t1--base.tfm \
tex-Raleway-Light-osf-sc-t1.tfm \
tex-Raleway-Light-osf-sc-t1.vf \
tex-Raleway-Light-osf-t1--base.tfm \
tex-Raleway-Light-osf-t1.tfm \
tex-Raleway-Light-osf-t1.vf \
tex-Raleway-Light-osf-ts1--base.tfm \
tex-Raleway-Light-osf-ts1.tfm \
tex-Raleway-Light-osf-ts1.vf \
tex-Raleway-Light-sup-ly1--base.tfm \
tex-Raleway-Light-sup-ly1.tfm \
tex-Raleway-Light-sup-ly1.vf \
tex-Raleway-Light-sup-ot1.tfm \
tex-Raleway-Light-sup-t1--base.tfm \
tex-Raleway-Light-sup-t1.tfm \
tex-Raleway-Light-sup-t1.vf \
tex-Raleway-LightItalic-dnom-ly1--base.tfm \
tex-Raleway-LightItalic-dnom-ly1.tfm \
tex-Raleway-LightItalic-dnom-ly1.vf \
tex-Raleway-LightItalic-dnom-ot1.tfm \
tex-Raleway-LightItalic-dnom-t1--base.tfm \
tex-Raleway-LightItalic-dnom-t1.tfm \
tex-Raleway-LightItalic-dnom-t1.vf \
tex-Raleway-LightItalic-inf-ly1--base.tfm \
tex-Raleway-LightItalic-inf-ly1.tfm \
tex-Raleway-LightItalic-inf-ly1.vf \
tex-Raleway-LightItalic-inf-ot1.tfm \
tex-Raleway-LightItalic-inf-t1--base.tfm \
tex-Raleway-LightItalic-inf-t1.tfm \
tex-Raleway-LightItalic-inf-t1.vf \
tex-Raleway-LightItalic-numr-ly1--base.tfm \
tex-Raleway-LightItalic-numr-ly1.tfm \
tex-Raleway-LightItalic-numr-ly1.vf \
tex-Raleway-LightItalic-numr-ot1.tfm \
tex-Raleway-LightItalic-numr-t1--base.tfm \
tex-Raleway-LightItalic-numr-t1.tfm \
tex-Raleway-LightItalic-numr-t1.vf \
tex-Raleway-LightItalic-osf-ly1--base.tfm \
tex-Raleway-LightItalic-osf-ly1.tfm \
tex-Raleway-LightItalic-osf-ly1.vf \
tex-Raleway-LightItalic-osf-ot1.tfm \
tex-Raleway-LightItalic-osf-sc-ly1--base.tfm \
tex-Raleway-LightItalic-osf-sc-ly1.tfm \
tex-Raleway-LightItalic-osf-sc-ly1.vf \
tex-Raleway-LightItalic-osf-sc-ot1--base.tfm \
tex-Raleway-LightItalic-osf-sc-ot1.tfm \
tex-Raleway-LightItalic-osf-sc-ot1.vf \
tex-Raleway-LightItalic-osf-sc-t1--base.tfm \
tex-Raleway-LightItalic-osf-sc-t1.tfm \
tex-Raleway-LightItalic-osf-sc-t1.vf \
tex-Raleway-LightItalic-osf-t1--base.tfm \
tex-Raleway-LightItalic-osf-t1.tfm \
tex-Raleway-LightItalic-osf-t1.vf \
tex-Raleway-LightItalic-osf-ts1--base.tfm \
tex-Raleway-LightItalic-osf-ts1.tfm \
tex-Raleway-LightItalic-osf-ts1.vf \
tex-Raleway-LightItalic-sup-ly1--base.tfm \
tex-Raleway-LightItalic-sup-ly1.tfm \
tex-Raleway-LightItalic-sup-ly1.vf \
tex-Raleway-LightItalic-sup-ot1.tfm \
tex-Raleway-LightItalic-sup-t1--base.tfm \
tex-Raleway-LightItalic-sup-t1.tfm \
tex-Raleway-LightItalic-sup-t1.vf \
tex-Raleway-Medium-dnom-ly1--base.tfm \
tex-Raleway-Medium-dnom-ly1.tfm \
tex-Raleway-Medium-dnom-ly1.vf \
tex-Raleway-Medium-dnom-ot1.tfm \
tex-Raleway-Medium-dnom-t1--base.tfm \
tex-Raleway-Medium-dnom-t1.tfm \
tex-Raleway-Medium-dnom-t1.vf \
tex-Raleway-Medium-inf-ly1--base.tfm \
tex-Raleway-Medium-inf-ly1.tfm \
tex-Raleway-Medium-inf-ly1.vf \
tex-Raleway-Medium-inf-ot1.tfm \
tex-Raleway-Medium-inf-t1--base.tfm \
tex-Raleway-Medium-inf-t1.tfm \
tex-Raleway-Medium-inf-t1.vf \
tex-Raleway-Medium-lf-ly1--base.tfm \
tex-Raleway-Medium-lf-ly1.tfm \
tex-Raleway-Medium-lf-ly1.vf \
tex-Raleway-Medium-lf-ot1.tfm \
tex-Raleway-Medium-lf-sc-ly1--base.tfm \
tex-Raleway-Medium-lf-sc-ly1.tfm \
tex-Raleway-Medium-lf-sc-ly1.vf \
tex-Raleway-Medium-lf-sc-ot1--base.tfm \
tex-Raleway-Medium-lf-sc-ot1.tfm \
tex-Raleway-Medium-lf-sc-ot1.vf \
tex-Raleway-Medium-lf-sc-t1--base.tfm \
tex-Raleway-Medium-lf-sc-t1.tfm \
tex-Raleway-Medium-lf-sc-t1.vf \
tex-Raleway-Medium-lf-t1--base.tfm \
tex-Raleway-Medium-lf-t1.tfm \
tex-Raleway-Medium-lf-t1.vf \
tex-Raleway-Medium-lf-ts1--base.tfm \
tex-Raleway-Medium-lf-ts1.tfm \
tex-Raleway-Medium-lf-ts1.vf \
tex-Raleway-Medium-numr-ly1--base.tfm \
tex-Raleway-Medium-numr-ly1.tfm \
tex-Raleway-Medium-numr-ly1.vf \
tex-Raleway-Medium-numr-ot1.tfm \
tex-Raleway-Medium-numr-t1--base.tfm \
tex-Raleway-Medium-numr-t1.tfm \
tex-Raleway-Medium-numr-t1.vf \
tex-Raleway-Medium-osf-ly1--base.tfm \
tex-Raleway-Medium-osf-ly1.tfm \
tex-Raleway-Medium-osf-ly1.vf \
tex-Raleway-Medium-osf-ot1.tfm \
tex-Raleway-Medium-osf-sc-ly1--base.tfm \
tex-Raleway-Medium-osf-sc-ly1.tfm \
tex-Raleway-Medium-osf-sc-ly1.vf \
tex-Raleway-Medium-osf-sc-ot1--base.tfm \
tex-Raleway-Medium-osf-sc-ot1.tfm \
tex-Raleway-Medium-osf-sc-ot1.vf \
tex-Raleway-Medium-osf-sc-t1--base.tfm \
tex-Raleway-Medium-osf-sc-t1.tfm \
tex-Raleway-Medium-osf-sc-t1.vf \
tex-Raleway-Medium-osf-t1--base.tfm \
tex-Raleway-Medium-osf-t1.tfm \
tex-Raleway-Medium-osf-t1.vf \
tex-Raleway-Medium-osf-ts1--base.tfm \
tex-Raleway-Medium-osf-ts1.tfm \
tex-Raleway-Medium-osf-ts1.vf \
tex-Raleway-Medium-sup-ly1--base.tfm \
tex-Raleway-Medium-sup-ly1.tfm \
tex-Raleway-Medium-sup-ly1.vf \
tex-Raleway-Medium-sup-ot1.tfm \
tex-Raleway-Medium-sup-t1--base.tfm \
tex-Raleway-Medium-sup-t1.tfm \
tex-Raleway-Medium-sup-t1.vf \
tex-Raleway-MediumItalic-dnom-ly1--base.tfm \
tex-Raleway-MediumItalic-dnom-ly1.tfm \
tex-Raleway-MediumItalic-dnom-ly1.vf \
tex-Raleway-MediumItalic-dnom-ot1.tfm \
tex-Raleway-MediumItalic-dnom-t1--base.tfm \
tex-Raleway-MediumItalic-dnom-t1.tfm \
tex-Raleway-MediumItalic-dnom-t1.vf \
tex-Raleway-MediumItalic-inf-ly1--base.tfm \
tex-Raleway-MediumItalic-inf-ly1.tfm \
tex-Raleway-MediumItalic-inf-ly1.vf \
tex-Raleway-MediumItalic-inf-ot1.tfm \
tex-Raleway-MediumItalic-inf-t1--base.tfm \
tex-Raleway-MediumItalic-inf-t1.tfm \
tex-Raleway-MediumItalic-inf-t1.vf \
tex-Raleway-MediumItalic-numr-ly1--base.tfm \
tex-Raleway-MediumItalic-numr-ly1.tfm \
tex-Raleway-MediumItalic-numr-ly1.vf \
tex-Raleway-MediumItalic-numr-ot1.tfm \
tex-Raleway-MediumItalic-numr-t1--base.tfm \
tex-Raleway-MediumItalic-numr-t1.tfm \
tex-Raleway-MediumItalic-numr-t1.vf \
tex-Raleway-MediumItalic-osf-ly1--base.tfm \
tex-Raleway-MediumItalic-osf-ly1.tfm \
tex-Raleway-MediumItalic-osf-ly1.vf \
tex-Raleway-MediumItalic-osf-ot1.tfm \
tex-Raleway-MediumItalic-osf-sc-ly1--base.tfm \
tex-Raleway-MediumItalic-osf-sc-ly1.tfm \
tex-Raleway-MediumItalic-osf-sc-ly1.vf \
tex-Raleway-MediumItalic-osf-sc-ot1--base.tfm \
tex-Raleway-MediumItalic-osf-sc-ot1.tfm \
tex-Raleway-MediumItalic-osf-sc-ot1.vf \
tex-Raleway-MediumItalic-osf-sc-t1--base.tfm \
tex-Raleway-MediumItalic-osf-sc-t1.tfm \
tex-Raleway-MediumItalic-osf-sc-t1.vf \
tex-Raleway-MediumItalic-osf-t1--base.tfm \
tex-Raleway-MediumItalic-osf-t1.tfm \
tex-Raleway-MediumItalic-osf-t1.vf \
tex-Raleway-MediumItalic-osf-ts1--base.tfm \
tex-Raleway-MediumItalic-osf-ts1.tfm \
tex-Raleway-MediumItalic-osf-ts1.vf \
tex-Raleway-MediumItalic-sup-ly1--base.tfm \
tex-Raleway-MediumItalic-sup-ly1.tfm \
tex-Raleway-MediumItalic-sup-ly1.vf \
tex-Raleway-MediumItalic-sup-ot1.tfm \
tex-Raleway-MediumItalic-sup-t1--base.tfm \
tex-Raleway-MediumItalic-sup-t1.tfm \
tex-Raleway-MediumItalic-sup-t1.vf \
tex-Raleway-Regular-dnom-ly1--base.tfm \
tex-Raleway-Regular-dnom-ly1.tfm \
tex-Raleway-Regular-dnom-ly1.vf \
tex-Raleway-Regular-dnom-ot1.tfm \
tex-Raleway-Regular-dnom-t1--base.tfm \
tex-Raleway-Regular-dnom-t1.tfm \
tex-Raleway-Regular-dnom-t1.vf \
tex-Raleway-Regular-inf-ly1--base.tfm \
tex-Raleway-Regular-inf-ly1.tfm \
tex-Raleway-Regular-inf-ly1.vf \
tex-Raleway-Regular-inf-ot1.tfm \
tex-Raleway-Regular-inf-t1--base.tfm \
tex-Raleway-Regular-inf-t1.tfm \
tex-Raleway-Regular-inf-t1.vf \
tex-Raleway-Regular-lf-ly1--base.tfm \
tex-Raleway-Regular-lf-ly1.tfm \
tex-Raleway-Regular-lf-ly1.vf \
tex-Raleway-Regular-lf-ot1.tfm \
tex-Raleway-Regular-lf-sc-ly1--base.tfm \
tex-Raleway-Regular-lf-sc-ly1.tfm \
tex-Raleway-Regular-lf-sc-ly1.vf \
tex-Raleway-Regular-lf-sc-ot1--base.tfm \
tex-Raleway-Regular-lf-sc-ot1.tfm \
tex-Raleway-Regular-lf-sc-ot1.vf \
tex-Raleway-Regular-lf-sc-t1--base.tfm \
tex-Raleway-Regular-lf-sc-t1.tfm \
tex-Raleway-Regular-lf-sc-t1.vf \
tex-Raleway-Regular-lf-t1--base.tfm \
tex-Raleway-Regular-lf-t1.tfm \
tex-Raleway-Regular-lf-t1.vf \
tex-Raleway-Regular-lf-ts1--base.tfm \
tex-Raleway-Regular-lf-ts1.tfm \
tex-Raleway-Regular-lf-ts1.vf \
tex-Raleway-Regular-numr-ly1--base.tfm \
tex-Raleway-Regular-numr-ly1.tfm \
tex-Raleway-Regular-numr-ly1.vf \
tex-Raleway-Regular-numr-ot1.tfm \
tex-Raleway-Regular-numr-t1--base.tfm \
tex-Raleway-Regular-numr-t1.tfm \
tex-Raleway-Regular-numr-t1.vf \
tex-Raleway-Regular-osf-ly1--base.tfm \
tex-Raleway-Regular-osf-ly1.tfm \
tex-Raleway-Regular-osf-ly1.vf \
tex-Raleway-Regular-osf-ot1.tfm \
tex-Raleway-Regular-osf-sc-ly1--base.tfm \
tex-Raleway-Regular-osf-sc-ly1.tfm \
tex-Raleway-Regular-osf-sc-ly1.vf \
tex-Raleway-Regular-osf-sc-ot1--base.tfm \
tex-Raleway-Regular-osf-sc-ot1.tfm \
tex-Raleway-Regular-osf-sc-ot1.vf \
tex-Raleway-Regular-osf-sc-t1--base.tfm \
tex-Raleway-Regular-osf-sc-t1.tfm \
tex-Raleway-Regular-osf-sc-t1.vf \
tex-Raleway-Regular-osf-t1--base.tfm \
tex-Raleway-Regular-osf-t1.tfm \
tex-Raleway-Regular-osf-t1.vf \
tex-Raleway-Regular-osf-ts1--base.tfm \
tex-Raleway-Regular-osf-ts1.tfm \
tex-Raleway-Regular-osf-ts1.vf \
tex-Raleway-Regular-sup-ly1--base.tfm \
tex-Raleway-Regular-sup-ly1.tfm \
tex-Raleway-Regular-sup-ly1.vf \
tex-Raleway-Regular-sup-ot1.tfm \
tex-Raleway-Regular-sup-t1--base.tfm \
tex-Raleway-Regular-sup-t1.tfm \
tex-Raleway-Regular-sup-t1.vf \
tex-Raleway-SemiBold-dnom-ly1--base.tfm \
tex-Raleway-SemiBold-dnom-ly1.tfm \
tex-Raleway-SemiBold-dnom-ly1.vf \
tex-Raleway-SemiBold-dnom-ot1.tfm \
tex-Raleway-SemiBold-dnom-t1--base.tfm \
tex-Raleway-SemiBold-dnom-t1.tfm \
tex-Raleway-SemiBold-dnom-t1.vf \
tex-Raleway-SemiBold-inf-ly1--base.tfm \
tex-Raleway-SemiBold-inf-ly1.tfm \
tex-Raleway-SemiBold-inf-ly1.vf \
tex-Raleway-SemiBold-inf-ot1.tfm \
tex-Raleway-SemiBold-inf-t1--base.tfm \
tex-Raleway-SemiBold-inf-t1.tfm \
tex-Raleway-SemiBold-inf-t1.vf \
tex-Raleway-SemiBold-lf-ly1--base.tfm \
tex-Raleway-SemiBold-lf-ly1.tfm \
tex-Raleway-SemiBold-lf-ly1.vf \
tex-Raleway-SemiBold-lf-ot1.tfm \
tex-Raleway-SemiBold-lf-sc-ly1--base.tfm \
tex-Raleway-SemiBold-lf-sc-ly1.tfm \
tex-Raleway-SemiBold-lf-sc-ly1.vf \
tex-Raleway-SemiBold-lf-sc-ot1--base.tfm \
tex-Raleway-SemiBold-lf-sc-ot1.tfm \
tex-Raleway-SemiBold-lf-sc-ot1.vf \
tex-Raleway-SemiBold-lf-sc-t1--base.tfm \
tex-Raleway-SemiBold-lf-sc-t1.tfm \
tex-Raleway-SemiBold-lf-sc-t1.vf \
tex-Raleway-SemiBold-lf-t1--base.tfm \
tex-Raleway-SemiBold-lf-t1.tfm \
tex-Raleway-SemiBold-lf-t1.vf \
tex-Raleway-SemiBold-lf-ts1--base.tfm \
tex-Raleway-SemiBold-lf-ts1.tfm \
tex-Raleway-SemiBold-lf-ts1.vf \
tex-Raleway-SemiBold-numr-ly1--base.tfm \
tex-Raleway-SemiBold-numr-ly1.tfm \
tex-Raleway-SemiBold-numr-ly1.vf \
tex-Raleway-SemiBold-numr-ot1.tfm \
tex-Raleway-SemiBold-numr-t1--base.tfm \
tex-Raleway-SemiBold-numr-t1.tfm \
tex-Raleway-SemiBold-numr-t1.vf \
tex-Raleway-SemiBold-osf-ly1--base.tfm \
tex-Raleway-SemiBold-osf-ly1.tfm \
tex-Raleway-SemiBold-osf-ly1.vf \
tex-Raleway-SemiBold-osf-ot1.tfm \
tex-Raleway-SemiBold-osf-sc-ly1--base.tfm \
tex-Raleway-SemiBold-osf-sc-ly1.tfm \
tex-Raleway-SemiBold-osf-sc-ly1.vf \
tex-Raleway-SemiBold-osf-sc-ot1--base.tfm \
tex-Raleway-SemiBold-osf-sc-ot1.tfm \
tex-Raleway-SemiBold-osf-sc-ot1.vf \
tex-Raleway-SemiBold-osf-sc-t1--base.tfm \
tex-Raleway-SemiBold-osf-sc-t1.tfm \
tex-Raleway-SemiBold-osf-sc-t1.vf \
tex-Raleway-SemiBold-osf-t1--base.tfm \
tex-Raleway-SemiBold-osf-t1.tfm \
tex-Raleway-SemiBold-osf-t1.vf \
tex-Raleway-SemiBold-osf-ts1--base.tfm \
tex-Raleway-SemiBold-osf-ts1.tfm \
tex-Raleway-SemiBold-osf-ts1.vf \
tex-Raleway-SemiBold-sup-ly1--base.tfm \
tex-Raleway-SemiBold-sup-ly1.tfm \
tex-Raleway-SemiBold-sup-ly1.vf \
tex-Raleway-SemiBold-sup-ot1.tfm \
tex-Raleway-SemiBold-sup-t1--base.tfm \
tex-Raleway-SemiBold-sup-t1.tfm \
tex-Raleway-SemiBold-sup-t1.vf \
tex-Raleway-SemiBoldItalic-dnom-ly1--base.tfm \
tex-Raleway-SemiBoldItalic-dnom-ly1.tfm \
tex-Raleway-SemiBoldItalic-dnom-ly1.vf \
tex-Raleway-SemiBoldItalic-dnom-ot1.tfm \
tex-Raleway-SemiBoldItalic-dnom-t1--base.tfm \
tex-Raleway-SemiBoldItalic-dnom-t1.tfm \
tex-Raleway-SemiBoldItalic-dnom-t1.vf \
tex-Raleway-SemiBoldItalic-inf-ly1--base.tfm \
tex-Raleway-SemiBoldItalic-inf-ly1.tfm \
tex-Raleway-SemiBoldItalic-inf-ly1.vf \
tex-Raleway-SemiBoldItalic-inf-ot1.tfm \
tex-Raleway-SemiBoldItalic-inf-t1--base.tfm \
tex-Raleway-SemiBoldItalic-inf-t1.tfm \
tex-Raleway-SemiBoldItalic-inf-t1.vf \
tex-Raleway-SemiBoldItalic-numr-ly1--base.tfm \
tex-Raleway-SemiBoldItalic-numr-ly1.tfm \
tex-Raleway-SemiBoldItalic-numr-ly1.vf \
tex-Raleway-SemiBoldItalic-numr-ot1.tfm \
tex-Raleway-SemiBoldItalic-numr-t1--base.tfm \
tex-Raleway-SemiBoldItalic-numr-t1.tfm \
tex-Raleway-SemiBoldItalic-numr-t1.vf \
tex-Raleway-SemiBoldItalic-osf-ly1--base.tfm \
tex-Raleway-SemiBoldItalic-osf-ly1.tfm \
tex-Raleway-SemiBoldItalic-osf-ly1.vf \
tex-Raleway-SemiBoldItalic-osf-ot1.tfm \
tex-Raleway-SemiBoldItalic-osf-sc-ly1--base.tfm \
tex-Raleway-SemiBoldItalic-osf-sc-ly1.tfm \
tex-Raleway-SemiBoldItalic-osf-sc-ly1.vf \
tex-Raleway-SemiBoldItalic-osf-sc-ot1--base.tfm \
tex-Raleway-SemiBoldItalic-osf-sc-ot1.tfm \
tex-Raleway-SemiBoldItalic-osf-sc-ot1.vf \
tex-Raleway-SemiBoldItalic-osf-sc-t1--base.tfm \
tex-Raleway-SemiBoldItalic-osf-sc-t1.tfm \
tex-Raleway-SemiBoldItalic-osf-sc-t1.vf \
tex-Raleway-SemiBoldItalic-osf-t1--base.tfm \
tex-Raleway-SemiBoldItalic-osf-t1.tfm \
tex-Raleway-SemiBoldItalic-osf-t1.vf \
tex-Raleway-SemiBoldItalic-osf-ts1--base.tfm \
tex-Raleway-SemiBoldItalic-osf-ts1.tfm \
tex-Raleway-SemiBoldItalic-osf-ts1.vf \
tex-Raleway-SemiBoldItalic-sup-ly1--base.tfm \
tex-Raleway-SemiBoldItalic-sup-ly1.tfm \
tex-Raleway-SemiBoldItalic-sup-ly1.vf \
tex-Raleway-SemiBoldItalic-sup-ot1.tfm \
tex-Raleway-SemiBoldItalic-sup-t1--base.tfm \
tex-Raleway-SemiBoldItalic-sup-t1.tfm \
tex-Raleway-SemiBoldItalic-sup-t1.vf \
tex-Raleway-Thin-dnom-ly1--base.tfm \
tex-Raleway-Thin-dnom-ly1.tfm \
tex-Raleway-Thin-dnom-ly1.vf \
tex-Raleway-Thin-dnom-ot1.tfm \
tex-Raleway-Thin-dnom-t1--base.tfm \
tex-Raleway-Thin-dnom-t1.tfm \
tex-Raleway-Thin-dnom-t1.vf \
tex-Raleway-Thin-inf-ly1--base.tfm \
tex-Raleway-Thin-inf-ly1.tfm \
tex-Raleway-Thin-inf-ly1.vf \
tex-Raleway-Thin-inf-ot1.tfm \
tex-Raleway-Thin-inf-t1--base.tfm \
tex-Raleway-Thin-inf-t1.tfm \
tex-Raleway-Thin-inf-t1.vf \
tex-Raleway-Thin-lf-ly1--base.tfm \
tex-Raleway-Thin-lf-ly1.tfm \
tex-Raleway-Thin-lf-ly1.vf \
tex-Raleway-Thin-lf-ot1.tfm \
tex-Raleway-Thin-lf-sc-ly1--base.tfm \
tex-Raleway-Thin-lf-sc-ly1.tfm \
tex-Raleway-Thin-lf-sc-ly1.vf \
tex-Raleway-Thin-lf-sc-ot1--base.tfm \
tex-Raleway-Thin-lf-sc-ot1.tfm \
tex-Raleway-Thin-lf-sc-ot1.vf \
tex-Raleway-Thin-lf-sc-t1--base.tfm \
tex-Raleway-Thin-lf-sc-t1.tfm \
tex-Raleway-Thin-lf-sc-t1.vf \
tex-Raleway-Thin-lf-t1--base.tfm \
tex-Raleway-Thin-lf-t1.tfm \
tex-Raleway-Thin-lf-t1.vf \
tex-Raleway-Thin-lf-ts1--base.tfm \
tex-Raleway-Thin-lf-ts1.tfm \
tex-Raleway-Thin-lf-ts1.vf \
tex-Raleway-Thin-numr-ly1--base.tfm \
tex-Raleway-Thin-numr-ly1.tfm \
tex-Raleway-Thin-numr-ly1.vf \
tex-Raleway-Thin-numr-ot1.tfm \
tex-Raleway-Thin-numr-t1--base.tfm \
tex-Raleway-Thin-numr-t1.tfm \
tex-Raleway-Thin-numr-t1.vf \
tex-Raleway-Thin-osf-ly1--base.tfm \
tex-Raleway-Thin-osf-ly1.tfm \
tex-Raleway-Thin-osf-ly1.vf \
tex-Raleway-Thin-osf-ot1.tfm \
tex-Raleway-Thin-osf-sc-ly1--base.tfm \
tex-Raleway-Thin-osf-sc-ly1.tfm \
tex-Raleway-Thin-osf-sc-ly1.vf \
tex-Raleway-Thin-osf-sc-ot1--base.tfm \
tex-Raleway-Thin-osf-sc-ot1.tfm \
tex-Raleway-Thin-osf-sc-ot1.vf \
tex-Raleway-Thin-osf-sc-t1--base.tfm \
tex-Raleway-Thin-osf-sc-t1.tfm \
tex-Raleway-Thin-osf-sc-t1.vf \
tex-Raleway-Thin-osf-t1--base.tfm \
tex-Raleway-Thin-osf-t1.tfm \
tex-Raleway-Thin-osf-t1.vf \
tex-Raleway-Thin-osf-ts1--base.tfm \
tex-Raleway-Thin-osf-ts1.tfm \
tex-Raleway-Thin-osf-ts1.vf \
tex-Raleway-Thin-sup-ly1--base.tfm \
tex-Raleway-Thin-sup-ly1.tfm \
tex-Raleway-Thin-sup-ly1.vf \
tex-Raleway-Thin-sup-ot1.tfm \
tex-Raleway-Thin-sup-t1--base.tfm \
tex-Raleway-Thin-sup-t1.tfm \
tex-Raleway-Thin-sup-t1.vf \
tex-Raleway-ThinItalic-dnom-ly1--base.tfm \
tex-Raleway-ThinItalic-dnom-ly1.tfm \
tex-Raleway-ThinItalic-dnom-ly1.vf \
tex-Raleway-ThinItalic-dnom-ot1.tfm \
tex-Raleway-ThinItalic-dnom-t1--base.tfm \
tex-Raleway-ThinItalic-dnom-t1.tfm \
tex-Raleway-ThinItalic-dnom-t1.vf \
tex-Raleway-ThinItalic-inf-ly1--base.tfm \
tex-Raleway-ThinItalic-inf-ly1.tfm \
tex-Raleway-ThinItalic-inf-ly1.vf \
tex-Raleway-ThinItalic-inf-ot1.tfm \
tex-Raleway-ThinItalic-inf-t1--base.tfm \
tex-Raleway-ThinItalic-inf-t1.tfm \
tex-Raleway-ThinItalic-inf-t1.vf \
tex-Raleway-ThinItalic-numr-ly1--base.tfm \
tex-Raleway-ThinItalic-numr-ly1.tfm \
tex-Raleway-ThinItalic-numr-ly1.vf \
tex-Raleway-ThinItalic-numr-ot1.tfm \
tex-Raleway-ThinItalic-numr-t1--base.tfm \
tex-Raleway-ThinItalic-numr-t1.tfm \
tex-Raleway-ThinItalic-numr-t1.vf \
tex-Raleway-ThinItalic-osf-ly1--base.tfm \
tex-Raleway-ThinItalic-osf-ly1.tfm \
tex-Raleway-ThinItalic-osf-ly1.vf \
tex-Raleway-ThinItalic-osf-ot1.tfm \
tex-Raleway-ThinItalic-osf-sc-ly1--base.tfm \
tex-Raleway-ThinItalic-osf-sc-ly1.tfm \
tex-Raleway-ThinItalic-osf-sc-ly1.vf \
tex-Raleway-ThinItalic-osf-sc-ot1--base.tfm \
tex-Raleway-ThinItalic-osf-sc-ot1.tfm \
tex-Raleway-ThinItalic-osf-sc-ot1.vf \
tex-Raleway-ThinItalic-osf-sc-t1--base.tfm \
tex-Raleway-ThinItalic-osf-sc-t1.tfm \
tex-Raleway-ThinItalic-osf-sc-t1.vf \
tex-Raleway-ThinItalic-osf-t1--base.tfm \
tex-Raleway-ThinItalic-osf-t1.tfm \
tex-Raleway-ThinItalic-osf-t1.vf \
tex-Raleway-ThinItalic-osf-ts1--base.tfm \
tex-Raleway-ThinItalic-osf-ts1.tfm \
tex-Raleway-ThinItalic-osf-ts1.vf \
tex-Raleway-ThinItalic-sup-ly1--base.tfm \
tex-Raleway-ThinItalic-sup-ly1.tfm \
tex-Raleway-ThinItalic-sup-ly1.vf \
tex-Raleway-ThinItalic-sup-ot1.tfm \
tex-Raleway-ThinItalic-sup-t1--base.tfm \
tex-Raleway-ThinItalic-sup-t1.tfm \
tex-Raleway-ThinItalic-sup-t1.vf \
tex-Raleway.map \
tex-T1Raleway-Dnom.fd \
tex-T1Raleway-Inf.fd \
tex-T1Raleway-LF.fd \
tex-T1Raleway-Numr.fd \
tex-T1Raleway-OsF.fd \
tex-T1Raleway-Sup.fd \
tex-TS1Raleway-LF.fd \
tex-TS1Raleway-OsF.fd \
tex-a-2drkug.enc \
tex-a-3r74if.enc \
tex-a-3whmy5.enc \
tex-a-42iwzn.enc \
tex-a-4k4mmc.enc \
tex-a-7e5ed6.enc \
tex-a-amwcv2.enc \
tex-a-bo5gfl.enc \
tex-a-cbkfo7.enc \
tex-a-fcy5xz.enc \
tex-a-ifnzwv.enc \
tex-a-ij42cm.enc \
tex-a-itoun2.enc \
tex-a-jqcpay.enc \
tex-a-k7iqhv.enc \
tex-a-lzhlbi.enc \
tex-a-or44gx.enc \
tex-a-phsv7w.enc \
tex-a-pxhins.enc \
tex-a-qgc4kz.enc \
tex-a-rdowpq.enc \
tex-a-rkhchd.enc \
tex-a-su2n5p.enc \
tex-a-tq4ocg.enc \
tex-a-yhzmyq.enc \
tex-a-zx7ckg.enc \
tex-raleway-type1-autoinst.sty \
tex-raleway.sty \
texlive-raleway"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-ifluatex.sty \
tex-ifthen.sty \
tex-ifxetex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-raleway-fonts \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
