SUMMARY = "Translations for package switchboard-plug-about"
DESCRIPTION = "Provides translations for the 'switchboard-plug-about' package."
LICENSE = "GPL-3.0-or-later"

PV = "8.2.3"

RPM_NAME = "switchboard-plug-about-lang-8.2.3-1.2.noarch.rpm"
RPM_HASH = "d99fc55c193eba80028b25170766e0d0de2f5fd9c9e5a78905883f27d845c446d3baaf04b363d33e146e21220bc853b1a3736f0cfa7131d26c7f8e17adf8acd4"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale-switchboard-plug-about-af \
locale-switchboard-plug-about-ar \
locale-switchboard-plug-about-as \
locale-switchboard-plug-about-ast \
locale-switchboard-plug-about-az \
locale-switchboard-plug-about-be \
locale-switchboard-plug-about-bg \
locale-switchboard-plug-about-bn \
locale-switchboard-plug-about-br \
locale-switchboard-plug-about-bs \
locale-switchboard-plug-about-ca \
locale-switchboard-plug-about-cs \
locale-switchboard-plug-about-cy \
locale-switchboard-plug-about-da \
locale-switchboard-plug-about-de \
locale-switchboard-plug-about-dz \
locale-switchboard-plug-about-el \
locale-switchboard-plug-about-en-AU \
locale-switchboard-plug-about-en-CA \
locale-switchboard-plug-about-en-GB \
locale-switchboard-plug-about-eo \
locale-switchboard-plug-about-es \
locale-switchboard-plug-about-et \
locale-switchboard-plug-about-eu \
locale-switchboard-plug-about-fa \
locale-switchboard-plug-about-fi \
locale-switchboard-plug-about-fr \
locale-switchboard-plug-about-fr-CA \
locale-switchboard-plug-about-ga \
locale-switchboard-plug-about-gd \
locale-switchboard-plug-about-gl \
locale-switchboard-plug-about-gu \
locale-switchboard-plug-about-he \
locale-switchboard-plug-about-hi \
locale-switchboard-plug-about-hr \
locale-switchboard-plug-about-hu \
locale-switchboard-plug-about-ia \
locale-switchboard-plug-about-id \
locale-switchboard-plug-about-is \
locale-switchboard-plug-about-it \
locale-switchboard-plug-about-ja \
locale-switchboard-plug-about-ka \
locale-switchboard-plug-about-kk \
locale-switchboard-plug-about-km \
locale-switchboard-plug-about-kn \
locale-switchboard-plug-about-ko \
locale-switchboard-plug-about-lt \
locale-switchboard-plug-about-lv \
locale-switchboard-plug-about-mk \
locale-switchboard-plug-about-ml \
locale-switchboard-plug-about-mr \
locale-switchboard-plug-about-ms \
locale-switchboard-plug-about-nb \
locale-switchboard-plug-about-ne \
locale-switchboard-plug-about-nl \
locale-switchboard-plug-about-nn \
locale-switchboard-plug-about-oc \
locale-switchboard-plug-about-or \
locale-switchboard-plug-about-pa \
locale-switchboard-plug-about-pl \
locale-switchboard-plug-about-pt \
locale-switchboard-plug-about-pt-BR \
locale-switchboard-plug-about-ro \
locale-switchboard-plug-about-ru \
locale-switchboard-plug-about-si \
locale-switchboard-plug-about-sk \
locale-switchboard-plug-about-sl \
locale-switchboard-plug-about-sq \
locale-switchboard-plug-about-sr \
locale-switchboard-plug-about-sr@latin \
locale-switchboard-plug-about-sv \
locale-switchboard-plug-about-ta \
locale-switchboard-plug-about-te \
locale-switchboard-plug-about-th \
locale-switchboard-plug-about-tr \
locale-switchboard-plug-about-ug \
locale-switchboard-plug-about-uk \
locale-switchboard-plug-about-vi \
locale-switchboard-plug-about-wa \
locale-switchboard-plug-about-zh \
locale-switchboard-plug-about-zh-CN \
locale-switchboard-plug-about-zh-TW \
switchboard-plug-about-lang \
switchboard-plug-about-lang-all"

RDEPENDS:${PN} += "switchboard-plug-about"

inherit rpm
