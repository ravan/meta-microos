SUMMARY = "A TrueType and OpenType font family for mediaevalists"
DESCRIPTION = "Junicode is a TrueType/OpenType font family with many features \
for antiquarians (especially medievalists) based on typefaces \
used by the Oxford Press in the late 17th and early 18th \
centuries. It works well with Lua(La)TeX or Xe(La)TeX, but the \
basic textual features are also available with (pdf)LaTeX."
LICENSE = "OFL-1.1"

PV = "2026.226.2.218svn77682"

RPM_NAME = "texlive-junicode-2026.226.2.218svn77682-63.2.noarch.rpm"
RPM_HASH = "b4b9548df303d0c114e6ef0082aa53c10bf61fb953c6bd6c6ab87c75251ba8a974dbc73849a0e30f8a245b155804e82e21635e530042cc74daefeb9f82485b06"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-Junicode-Bold-inf-lgr.tfm \
tex-Junicode-Bold-inf-ly1.tfm \
tex-Junicode-Bold-inf-ot1.tfm \
tex-Junicode-Bold-inf-t1--base.tfm \
tex-Junicode-Bold-inf-t1.tfm \
tex-Junicode-Bold-inf-t1.vf \
tex-Junicode-Bold-lf-lgr.tfm \
tex-Junicode-Bold-lf-ly1.tfm \
tex-Junicode-Bold-lf-ot1.tfm \
tex-Junicode-Bold-lf-sc-lgr.tfm \
tex-Junicode-Bold-lf-sc-ly1--base.tfm \
tex-Junicode-Bold-lf-sc-ly1.tfm \
tex-Junicode-Bold-lf-sc-ly1.vf \
tex-Junicode-Bold-lf-sc-ot1--base.tfm \
tex-Junicode-Bold-lf-sc-ot1.tfm \
tex-Junicode-Bold-lf-sc-ot1.vf \
tex-Junicode-Bold-lf-sc-t1--base.tfm \
tex-Junicode-Bold-lf-sc-t1.tfm \
tex-Junicode-Bold-lf-sc-t1.vf \
tex-Junicode-Bold-lf-t1--base.tfm \
tex-Junicode-Bold-lf-t1.tfm \
tex-Junicode-Bold-lf-t1.vf \
tex-Junicode-Bold-lf-ts1--base.tfm \
tex-Junicode-Bold-lf-ts1.tfm \
tex-Junicode-Bold-lf-ts1.vf \
tex-Junicode-Bold-osf-lgr.tfm \
tex-Junicode-Bold-osf-ly1.tfm \
tex-Junicode-Bold-osf-ot1.tfm \
tex-Junicode-Bold-osf-sc-lgr.tfm \
tex-Junicode-Bold-osf-sc-ly1--base.tfm \
tex-Junicode-Bold-osf-sc-ly1.tfm \
tex-Junicode-Bold-osf-sc-ly1.vf \
tex-Junicode-Bold-osf-sc-ot1--base.tfm \
tex-Junicode-Bold-osf-sc-ot1.tfm \
tex-Junicode-Bold-osf-sc-ot1.vf \
tex-Junicode-Bold-osf-sc-t1--base.tfm \
tex-Junicode-Bold-osf-sc-t1.tfm \
tex-Junicode-Bold-osf-sc-t1.vf \
tex-Junicode-Bold-osf-t1--base.tfm \
tex-Junicode-Bold-osf-t1.tfm \
tex-Junicode-Bold-osf-t1.vf \
tex-Junicode-Bold-osf-ts1--base.tfm \
tex-Junicode-Bold-osf-ts1.tfm \
tex-Junicode-Bold-osf-ts1.vf \
tex-Junicode-Bold-sup-lgr.tfm \
tex-Junicode-Bold-sup-ly1.tfm \
tex-Junicode-Bold-sup-ot1.tfm \
tex-Junicode-Bold-sup-t1--base.tfm \
tex-Junicode-Bold-sup-t1.tfm \
tex-Junicode-Bold-sup-t1.vf \
tex-Junicode-Bold-tlf-lgr.tfm \
tex-Junicode-Bold-tlf-ly1.tfm \
tex-Junicode-Bold-tlf-ot1.tfm \
tex-Junicode-Bold-tlf-sc-lgr.tfm \
tex-Junicode-Bold-tlf-sc-ly1--base.tfm \
tex-Junicode-Bold-tlf-sc-ly1.tfm \
tex-Junicode-Bold-tlf-sc-ly1.vf \
tex-Junicode-Bold-tlf-sc-ot1--base.tfm \
tex-Junicode-Bold-tlf-sc-ot1.tfm \
tex-Junicode-Bold-tlf-sc-ot1.vf \
tex-Junicode-Bold-tlf-sc-t1--base.tfm \
tex-Junicode-Bold-tlf-sc-t1.tfm \
tex-Junicode-Bold-tlf-sc-t1.vf \
tex-Junicode-Bold-tlf-t1--base.tfm \
tex-Junicode-Bold-tlf-t1.tfm \
tex-Junicode-Bold-tlf-t1.vf \
tex-Junicode-Bold-tlf-ts1--base.tfm \
tex-Junicode-Bold-tlf-ts1.tfm \
tex-Junicode-Bold-tlf-ts1.vf \
tex-Junicode-Bold-tosf-lgr.tfm \
tex-Junicode-Bold-tosf-ly1.tfm \
tex-Junicode-Bold-tosf-ot1.tfm \
tex-Junicode-Bold-tosf-sc-lgr.tfm \
tex-Junicode-Bold-tosf-sc-ly1--base.tfm \
tex-Junicode-Bold-tosf-sc-ly1.tfm \
tex-Junicode-Bold-tosf-sc-ly1.vf \
tex-Junicode-Bold-tosf-sc-ot1--base.tfm \
tex-Junicode-Bold-tosf-sc-ot1.tfm \
tex-Junicode-Bold-tosf-sc-ot1.vf \
tex-Junicode-Bold-tosf-sc-t1--base.tfm \
tex-Junicode-Bold-tosf-sc-t1.tfm \
tex-Junicode-Bold-tosf-sc-t1.vf \
tex-Junicode-Bold-tosf-t1--base.tfm \
tex-Junicode-Bold-tosf-t1.tfm \
tex-Junicode-Bold-tosf-t1.vf \
tex-Junicode-Bold-tosf-ts1--base.tfm \
tex-Junicode-Bold-tosf-ts1.tfm \
tex-Junicode-Bold-tosf-ts1.vf \
tex-Junicode-BoldItalic-inf-lgr.tfm \
tex-Junicode-BoldItalic-inf-ly1.tfm \
tex-Junicode-BoldItalic-inf-ot1.tfm \
tex-Junicode-BoldItalic-inf-t1--base.tfm \
tex-Junicode-BoldItalic-inf-t1.tfm \
tex-Junicode-BoldItalic-inf-t1.vf \
tex-Junicode-BoldItalic-lf-lgr.tfm \
tex-Junicode-BoldItalic-lf-ly1.tfm \
tex-Junicode-BoldItalic-lf-ot1.tfm \
tex-Junicode-BoldItalic-lf-sc-lgr.tfm \
tex-Junicode-BoldItalic-lf-sc-ly1--base.tfm \
tex-Junicode-BoldItalic-lf-sc-ly1.tfm \
tex-Junicode-BoldItalic-lf-sc-ly1.vf \
tex-Junicode-BoldItalic-lf-sc-ot1--base.tfm \
tex-Junicode-BoldItalic-lf-sc-ot1.tfm \
tex-Junicode-BoldItalic-lf-sc-ot1.vf \
tex-Junicode-BoldItalic-lf-sc-t1--base.tfm \
tex-Junicode-BoldItalic-lf-sc-t1.tfm \
tex-Junicode-BoldItalic-lf-sc-t1.vf \
tex-Junicode-BoldItalic-lf-t1--base.tfm \
tex-Junicode-BoldItalic-lf-t1.tfm \
tex-Junicode-BoldItalic-lf-t1.vf \
tex-Junicode-BoldItalic-lf-ts1--base.tfm \
tex-Junicode-BoldItalic-lf-ts1.tfm \
tex-Junicode-BoldItalic-lf-ts1.vf \
tex-Junicode-BoldItalic-osf-lgr.tfm \
tex-Junicode-BoldItalic-osf-ly1.tfm \
tex-Junicode-BoldItalic-osf-ot1.tfm \
tex-Junicode-BoldItalic-osf-sc-lgr.tfm \
tex-Junicode-BoldItalic-osf-sc-ly1--base.tfm \
tex-Junicode-BoldItalic-osf-sc-ly1.tfm \
tex-Junicode-BoldItalic-osf-sc-ly1.vf \
tex-Junicode-BoldItalic-osf-sc-ot1--base.tfm \
tex-Junicode-BoldItalic-osf-sc-ot1.tfm \
tex-Junicode-BoldItalic-osf-sc-ot1.vf \
tex-Junicode-BoldItalic-osf-sc-t1--base.tfm \
tex-Junicode-BoldItalic-osf-sc-t1.tfm \
tex-Junicode-BoldItalic-osf-sc-t1.vf \
tex-Junicode-BoldItalic-osf-t1--base.tfm \
tex-Junicode-BoldItalic-osf-t1.tfm \
tex-Junicode-BoldItalic-osf-t1.vf \
tex-Junicode-BoldItalic-osf-ts1--base.tfm \
tex-Junicode-BoldItalic-osf-ts1.tfm \
tex-Junicode-BoldItalic-osf-ts1.vf \
tex-Junicode-BoldItalic-sup-lgr.tfm \
tex-Junicode-BoldItalic-sup-ly1.tfm \
tex-Junicode-BoldItalic-sup-ot1.tfm \
tex-Junicode-BoldItalic-sup-t1--base.tfm \
tex-Junicode-BoldItalic-sup-t1.tfm \
tex-Junicode-BoldItalic-sup-t1.vf \
tex-Junicode-BoldItalic-tlf-lgr.tfm \
tex-Junicode-BoldItalic-tlf-ly1.tfm \
tex-Junicode-BoldItalic-tlf-ot1.tfm \
tex-Junicode-BoldItalic-tlf-sc-lgr.tfm \
tex-Junicode-BoldItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-BoldItalic-tlf-sc-ly1.tfm \
tex-Junicode-BoldItalic-tlf-sc-ly1.vf \
tex-Junicode-BoldItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-BoldItalic-tlf-sc-ot1.tfm \
tex-Junicode-BoldItalic-tlf-sc-ot1.vf \
tex-Junicode-BoldItalic-tlf-sc-t1--base.tfm \
tex-Junicode-BoldItalic-tlf-sc-t1.tfm \
tex-Junicode-BoldItalic-tlf-sc-t1.vf \
tex-Junicode-BoldItalic-tlf-t1--base.tfm \
tex-Junicode-BoldItalic-tlf-t1.tfm \
tex-Junicode-BoldItalic-tlf-t1.vf \
tex-Junicode-BoldItalic-tlf-ts1--base.tfm \
tex-Junicode-BoldItalic-tlf-ts1.tfm \
tex-Junicode-BoldItalic-tlf-ts1.vf \
tex-Junicode-BoldItalic-tosf-lgr.tfm \
tex-Junicode-BoldItalic-tosf-ly1.tfm \
tex-Junicode-BoldItalic-tosf-ot1.tfm \
tex-Junicode-BoldItalic-tosf-sc-lgr.tfm \
tex-Junicode-BoldItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-BoldItalic-tosf-sc-ly1.tfm \
tex-Junicode-BoldItalic-tosf-sc-ly1.vf \
tex-Junicode-BoldItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-BoldItalic-tosf-sc-ot1.tfm \
tex-Junicode-BoldItalic-tosf-sc-ot1.vf \
tex-Junicode-BoldItalic-tosf-sc-t1--base.tfm \
tex-Junicode-BoldItalic-tosf-sc-t1.tfm \
tex-Junicode-BoldItalic-tosf-sc-t1.vf \
tex-Junicode-BoldItalic-tosf-t1--base.tfm \
tex-Junicode-BoldItalic-tosf-t1.tfm \
tex-Junicode-BoldItalic-tosf-t1.vf \
tex-Junicode-BoldItalic-tosf-ts1--base.tfm \
tex-Junicode-BoldItalic-tosf-ts1.tfm \
tex-Junicode-BoldItalic-tosf-ts1.vf \
tex-Junicode-Cond-inf-lgr.tfm \
tex-Junicode-Cond-inf-ly1.tfm \
tex-Junicode-Cond-inf-ot1.tfm \
tex-Junicode-Cond-inf-t1--base.tfm \
tex-Junicode-Cond-inf-t1.tfm \
tex-Junicode-Cond-inf-t1.vf \
tex-Junicode-Cond-lf-lgr.tfm \
tex-Junicode-Cond-lf-ly1.tfm \
tex-Junicode-Cond-lf-ot1.tfm \
tex-Junicode-Cond-lf-sc-lgr.tfm \
tex-Junicode-Cond-lf-sc-ly1--base.tfm \
tex-Junicode-Cond-lf-sc-ly1.tfm \
tex-Junicode-Cond-lf-sc-ly1.vf \
tex-Junicode-Cond-lf-sc-ot1--base.tfm \
tex-Junicode-Cond-lf-sc-ot1.tfm \
tex-Junicode-Cond-lf-sc-ot1.vf \
tex-Junicode-Cond-lf-sc-t1--base.tfm \
tex-Junicode-Cond-lf-sc-t1.tfm \
tex-Junicode-Cond-lf-sc-t1.vf \
tex-Junicode-Cond-lf-t1--base.tfm \
tex-Junicode-Cond-lf-t1.tfm \
tex-Junicode-Cond-lf-t1.vf \
tex-Junicode-Cond-lf-ts1--base.tfm \
tex-Junicode-Cond-lf-ts1.tfm \
tex-Junicode-Cond-lf-ts1.vf \
tex-Junicode-Cond-osf-lgr.tfm \
tex-Junicode-Cond-osf-ly1.tfm \
tex-Junicode-Cond-osf-ot1.tfm \
tex-Junicode-Cond-osf-sc-lgr.tfm \
tex-Junicode-Cond-osf-sc-ly1--base.tfm \
tex-Junicode-Cond-osf-sc-ly1.tfm \
tex-Junicode-Cond-osf-sc-ly1.vf \
tex-Junicode-Cond-osf-sc-ot1--base.tfm \
tex-Junicode-Cond-osf-sc-ot1.tfm \
tex-Junicode-Cond-osf-sc-ot1.vf \
tex-Junicode-Cond-osf-sc-t1--base.tfm \
tex-Junicode-Cond-osf-sc-t1.tfm \
tex-Junicode-Cond-osf-sc-t1.vf \
tex-Junicode-Cond-osf-t1--base.tfm \
tex-Junicode-Cond-osf-t1.tfm \
tex-Junicode-Cond-osf-t1.vf \
tex-Junicode-Cond-osf-ts1--base.tfm \
tex-Junicode-Cond-osf-ts1.tfm \
tex-Junicode-Cond-osf-ts1.vf \
tex-Junicode-Cond-sup-lgr.tfm \
tex-Junicode-Cond-sup-ly1.tfm \
tex-Junicode-Cond-sup-ot1.tfm \
tex-Junicode-Cond-sup-t1--base.tfm \
tex-Junicode-Cond-sup-t1.tfm \
tex-Junicode-Cond-sup-t1.vf \
tex-Junicode-Cond-tlf-lgr.tfm \
tex-Junicode-Cond-tlf-ly1.tfm \
tex-Junicode-Cond-tlf-ot1.tfm \
tex-Junicode-Cond-tlf-sc-lgr.tfm \
tex-Junicode-Cond-tlf-sc-ly1--base.tfm \
tex-Junicode-Cond-tlf-sc-ly1.tfm \
tex-Junicode-Cond-tlf-sc-ly1.vf \
tex-Junicode-Cond-tlf-sc-ot1--base.tfm \
tex-Junicode-Cond-tlf-sc-ot1.tfm \
tex-Junicode-Cond-tlf-sc-ot1.vf \
tex-Junicode-Cond-tlf-sc-t1--base.tfm \
tex-Junicode-Cond-tlf-sc-t1.tfm \
tex-Junicode-Cond-tlf-sc-t1.vf \
tex-Junicode-Cond-tlf-t1--base.tfm \
tex-Junicode-Cond-tlf-t1.tfm \
tex-Junicode-Cond-tlf-t1.vf \
tex-Junicode-Cond-tlf-ts1--base.tfm \
tex-Junicode-Cond-tlf-ts1.tfm \
tex-Junicode-Cond-tlf-ts1.vf \
tex-Junicode-Cond-tosf-lgr.tfm \
tex-Junicode-Cond-tosf-ly1.tfm \
tex-Junicode-Cond-tosf-ot1.tfm \
tex-Junicode-Cond-tosf-sc-lgr.tfm \
tex-Junicode-Cond-tosf-sc-ly1--base.tfm \
tex-Junicode-Cond-tosf-sc-ly1.tfm \
tex-Junicode-Cond-tosf-sc-ly1.vf \
tex-Junicode-Cond-tosf-sc-ot1--base.tfm \
tex-Junicode-Cond-tosf-sc-ot1.tfm \
tex-Junicode-Cond-tosf-sc-ot1.vf \
tex-Junicode-Cond-tosf-sc-t1--base.tfm \
tex-Junicode-Cond-tosf-sc-t1.tfm \
tex-Junicode-Cond-tosf-sc-t1.vf \
tex-Junicode-Cond-tosf-t1--base.tfm \
tex-Junicode-Cond-tosf-t1.tfm \
tex-Junicode-Cond-tosf-t1.vf \
tex-Junicode-Cond-tosf-ts1--base.tfm \
tex-Junicode-Cond-tosf-ts1.tfm \
tex-Junicode-Cond-tosf-ts1.vf \
tex-Junicode-CondItalic-inf-lgr.tfm \
tex-Junicode-CondItalic-inf-ly1.tfm \
tex-Junicode-CondItalic-inf-ot1.tfm \
tex-Junicode-CondItalic-inf-t1--base.tfm \
tex-Junicode-CondItalic-inf-t1.tfm \
tex-Junicode-CondItalic-inf-t1.vf \
tex-Junicode-CondItalic-lf-lgr.tfm \
tex-Junicode-CondItalic-lf-ly1.tfm \
tex-Junicode-CondItalic-lf-ot1.tfm \
tex-Junicode-CondItalic-lf-sc-lgr.tfm \
tex-Junicode-CondItalic-lf-sc-ly1--base.tfm \
tex-Junicode-CondItalic-lf-sc-ly1.tfm \
tex-Junicode-CondItalic-lf-sc-ly1.vf \
tex-Junicode-CondItalic-lf-sc-ot1--base.tfm \
tex-Junicode-CondItalic-lf-sc-ot1.tfm \
tex-Junicode-CondItalic-lf-sc-ot1.vf \
tex-Junicode-CondItalic-lf-sc-t1--base.tfm \
tex-Junicode-CondItalic-lf-sc-t1.tfm \
tex-Junicode-CondItalic-lf-sc-t1.vf \
tex-Junicode-CondItalic-lf-t1--base.tfm \
tex-Junicode-CondItalic-lf-t1.tfm \
tex-Junicode-CondItalic-lf-t1.vf \
tex-Junicode-CondItalic-lf-ts1--base.tfm \
tex-Junicode-CondItalic-lf-ts1.tfm \
tex-Junicode-CondItalic-lf-ts1.vf \
tex-Junicode-CondItalic-osf-lgr.tfm \
tex-Junicode-CondItalic-osf-ly1.tfm \
tex-Junicode-CondItalic-osf-ot1.tfm \
tex-Junicode-CondItalic-osf-sc-lgr.tfm \
tex-Junicode-CondItalic-osf-sc-ly1--base.tfm \
tex-Junicode-CondItalic-osf-sc-ly1.tfm \
tex-Junicode-CondItalic-osf-sc-ly1.vf \
tex-Junicode-CondItalic-osf-sc-ot1--base.tfm \
tex-Junicode-CondItalic-osf-sc-ot1.tfm \
tex-Junicode-CondItalic-osf-sc-ot1.vf \
tex-Junicode-CondItalic-osf-sc-t1--base.tfm \
tex-Junicode-CondItalic-osf-sc-t1.tfm \
tex-Junicode-CondItalic-osf-sc-t1.vf \
tex-Junicode-CondItalic-osf-t1--base.tfm \
tex-Junicode-CondItalic-osf-t1.tfm \
tex-Junicode-CondItalic-osf-t1.vf \
tex-Junicode-CondItalic-osf-ts1--base.tfm \
tex-Junicode-CondItalic-osf-ts1.tfm \
tex-Junicode-CondItalic-osf-ts1.vf \
tex-Junicode-CondItalic-sup-lgr.tfm \
tex-Junicode-CondItalic-sup-ly1.tfm \
tex-Junicode-CondItalic-sup-ot1.tfm \
tex-Junicode-CondItalic-sup-t1--base.tfm \
tex-Junicode-CondItalic-sup-t1.tfm \
tex-Junicode-CondItalic-sup-t1.vf \
tex-Junicode-CondItalic-tlf-lgr.tfm \
tex-Junicode-CondItalic-tlf-ly1.tfm \
tex-Junicode-CondItalic-tlf-ot1.tfm \
tex-Junicode-CondItalic-tlf-sc-lgr.tfm \
tex-Junicode-CondItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-CondItalic-tlf-sc-ly1.tfm \
tex-Junicode-CondItalic-tlf-sc-ly1.vf \
tex-Junicode-CondItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-CondItalic-tlf-sc-ot1.tfm \
tex-Junicode-CondItalic-tlf-sc-ot1.vf \
tex-Junicode-CondItalic-tlf-sc-t1--base.tfm \
tex-Junicode-CondItalic-tlf-sc-t1.tfm \
tex-Junicode-CondItalic-tlf-sc-t1.vf \
tex-Junicode-CondItalic-tlf-t1--base.tfm \
tex-Junicode-CondItalic-tlf-t1.tfm \
tex-Junicode-CondItalic-tlf-t1.vf \
tex-Junicode-CondItalic-tlf-ts1--base.tfm \
tex-Junicode-CondItalic-tlf-ts1.tfm \
tex-Junicode-CondItalic-tlf-ts1.vf \
tex-Junicode-CondItalic-tosf-lgr.tfm \
tex-Junicode-CondItalic-tosf-ly1.tfm \
tex-Junicode-CondItalic-tosf-ot1.tfm \
tex-Junicode-CondItalic-tosf-sc-lgr.tfm \
tex-Junicode-CondItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-CondItalic-tosf-sc-ly1.tfm \
tex-Junicode-CondItalic-tosf-sc-ly1.vf \
tex-Junicode-CondItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-CondItalic-tosf-sc-ot1.tfm \
tex-Junicode-CondItalic-tosf-sc-ot1.vf \
tex-Junicode-CondItalic-tosf-sc-t1--base.tfm \
tex-Junicode-CondItalic-tosf-sc-t1.tfm \
tex-Junicode-CondItalic-tosf-sc-t1.vf \
tex-Junicode-CondItalic-tosf-t1--base.tfm \
tex-Junicode-CondItalic-tosf-t1.tfm \
tex-Junicode-CondItalic-tosf-t1.vf \
tex-Junicode-CondItalic-tosf-ts1--base.tfm \
tex-Junicode-CondItalic-tosf-ts1.tfm \
tex-Junicode-CondItalic-tosf-ts1.vf \
tex-Junicode-CondLight-inf-lgr.tfm \
tex-Junicode-CondLight-inf-ly1.tfm \
tex-Junicode-CondLight-inf-ot1.tfm \
tex-Junicode-CondLight-inf-t1--base.tfm \
tex-Junicode-CondLight-inf-t1.tfm \
tex-Junicode-CondLight-inf-t1.vf \
tex-Junicode-CondLight-lf-lgr.tfm \
tex-Junicode-CondLight-lf-ly1.tfm \
tex-Junicode-CondLight-lf-ot1.tfm \
tex-Junicode-CondLight-lf-sc-lgr.tfm \
tex-Junicode-CondLight-lf-sc-ly1--base.tfm \
tex-Junicode-CondLight-lf-sc-ly1.tfm \
tex-Junicode-CondLight-lf-sc-ly1.vf \
tex-Junicode-CondLight-lf-sc-ot1--base.tfm \
tex-Junicode-CondLight-lf-sc-ot1.tfm \
tex-Junicode-CondLight-lf-sc-ot1.vf \
tex-Junicode-CondLight-lf-sc-t1--base.tfm \
tex-Junicode-CondLight-lf-sc-t1.tfm \
tex-Junicode-CondLight-lf-sc-t1.vf \
tex-Junicode-CondLight-lf-t1--base.tfm \
tex-Junicode-CondLight-lf-t1.tfm \
tex-Junicode-CondLight-lf-t1.vf \
tex-Junicode-CondLight-lf-ts1--base.tfm \
tex-Junicode-CondLight-lf-ts1.tfm \
tex-Junicode-CondLight-lf-ts1.vf \
tex-Junicode-CondLight-osf-lgr.tfm \
tex-Junicode-CondLight-osf-ly1.tfm \
tex-Junicode-CondLight-osf-ot1.tfm \
tex-Junicode-CondLight-osf-sc-lgr.tfm \
tex-Junicode-CondLight-osf-sc-ly1--base.tfm \
tex-Junicode-CondLight-osf-sc-ly1.tfm \
tex-Junicode-CondLight-osf-sc-ly1.vf \
tex-Junicode-CondLight-osf-sc-ot1--base.tfm \
tex-Junicode-CondLight-osf-sc-ot1.tfm \
tex-Junicode-CondLight-osf-sc-ot1.vf \
tex-Junicode-CondLight-osf-sc-t1--base.tfm \
tex-Junicode-CondLight-osf-sc-t1.tfm \
tex-Junicode-CondLight-osf-sc-t1.vf \
tex-Junicode-CondLight-osf-t1--base.tfm \
tex-Junicode-CondLight-osf-t1.tfm \
tex-Junicode-CondLight-osf-t1.vf \
tex-Junicode-CondLight-osf-ts1--base.tfm \
tex-Junicode-CondLight-osf-ts1.tfm \
tex-Junicode-CondLight-osf-ts1.vf \
tex-Junicode-CondLight-sup-lgr.tfm \
tex-Junicode-CondLight-sup-ly1.tfm \
tex-Junicode-CondLight-sup-ot1.tfm \
tex-Junicode-CondLight-sup-t1--base.tfm \
tex-Junicode-CondLight-sup-t1.tfm \
tex-Junicode-CondLight-sup-t1.vf \
tex-Junicode-CondLight-tlf-lgr.tfm \
tex-Junicode-CondLight-tlf-ly1.tfm \
tex-Junicode-CondLight-tlf-ot1.tfm \
tex-Junicode-CondLight-tlf-sc-lgr.tfm \
tex-Junicode-CondLight-tlf-sc-ly1--base.tfm \
tex-Junicode-CondLight-tlf-sc-ly1.tfm \
tex-Junicode-CondLight-tlf-sc-ly1.vf \
tex-Junicode-CondLight-tlf-sc-ot1--base.tfm \
tex-Junicode-CondLight-tlf-sc-ot1.tfm \
tex-Junicode-CondLight-tlf-sc-ot1.vf \
tex-Junicode-CondLight-tlf-sc-t1--base.tfm \
tex-Junicode-CondLight-tlf-sc-t1.tfm \
tex-Junicode-CondLight-tlf-sc-t1.vf \
tex-Junicode-CondLight-tlf-t1--base.tfm \
tex-Junicode-CondLight-tlf-t1.tfm \
tex-Junicode-CondLight-tlf-t1.vf \
tex-Junicode-CondLight-tlf-ts1--base.tfm \
tex-Junicode-CondLight-tlf-ts1.tfm \
tex-Junicode-CondLight-tlf-ts1.vf \
tex-Junicode-CondLight-tosf-lgr.tfm \
tex-Junicode-CondLight-tosf-ly1.tfm \
tex-Junicode-CondLight-tosf-ot1.tfm \
tex-Junicode-CondLight-tosf-sc-lgr.tfm \
tex-Junicode-CondLight-tosf-sc-ly1--base.tfm \
tex-Junicode-CondLight-tosf-sc-ly1.tfm \
tex-Junicode-CondLight-tosf-sc-ly1.vf \
tex-Junicode-CondLight-tosf-sc-ot1--base.tfm \
tex-Junicode-CondLight-tosf-sc-ot1.tfm \
tex-Junicode-CondLight-tosf-sc-ot1.vf \
tex-Junicode-CondLight-tosf-sc-t1--base.tfm \
tex-Junicode-CondLight-tosf-sc-t1.tfm \
tex-Junicode-CondLight-tosf-sc-t1.vf \
tex-Junicode-CondLight-tosf-t1--base.tfm \
tex-Junicode-CondLight-tosf-t1.tfm \
tex-Junicode-CondLight-tosf-t1.vf \
tex-Junicode-CondLight-tosf-ts1--base.tfm \
tex-Junicode-CondLight-tosf-ts1.tfm \
tex-Junicode-CondLight-tosf-ts1.vf \
tex-Junicode-CondLightItalic-inf-lgr.tfm \
tex-Junicode-CondLightItalic-inf-ly1.tfm \
tex-Junicode-CondLightItalic-inf-ot1.tfm \
tex-Junicode-CondLightItalic-inf-t1--base.tfm \
tex-Junicode-CondLightItalic-inf-t1.tfm \
tex-Junicode-CondLightItalic-inf-t1.vf \
tex-Junicode-CondLightItalic-lf-lgr.tfm \
tex-Junicode-CondLightItalic-lf-ly1.tfm \
tex-Junicode-CondLightItalic-lf-ot1.tfm \
tex-Junicode-CondLightItalic-lf-sc-lgr.tfm \
tex-Junicode-CondLightItalic-lf-sc-ly1--base.tfm \
tex-Junicode-CondLightItalic-lf-sc-ly1.tfm \
tex-Junicode-CondLightItalic-lf-sc-ly1.vf \
tex-Junicode-CondLightItalic-lf-sc-ot1--base.tfm \
tex-Junicode-CondLightItalic-lf-sc-ot1.tfm \
tex-Junicode-CondLightItalic-lf-sc-ot1.vf \
tex-Junicode-CondLightItalic-lf-sc-t1--base.tfm \
tex-Junicode-CondLightItalic-lf-sc-t1.tfm \
tex-Junicode-CondLightItalic-lf-sc-t1.vf \
tex-Junicode-CondLightItalic-lf-t1--base.tfm \
tex-Junicode-CondLightItalic-lf-t1.tfm \
tex-Junicode-CondLightItalic-lf-t1.vf \
tex-Junicode-CondLightItalic-lf-ts1--base.tfm \
tex-Junicode-CondLightItalic-lf-ts1.tfm \
tex-Junicode-CondLightItalic-lf-ts1.vf \
tex-Junicode-CondLightItalic-osf-lgr.tfm \
tex-Junicode-CondLightItalic-osf-ly1.tfm \
tex-Junicode-CondLightItalic-osf-ot1.tfm \
tex-Junicode-CondLightItalic-osf-sc-lgr.tfm \
tex-Junicode-CondLightItalic-osf-sc-ly1--base.tfm \
tex-Junicode-CondLightItalic-osf-sc-ly1.tfm \
tex-Junicode-CondLightItalic-osf-sc-ly1.vf \
tex-Junicode-CondLightItalic-osf-sc-ot1--base.tfm \
tex-Junicode-CondLightItalic-osf-sc-ot1.tfm \
tex-Junicode-CondLightItalic-osf-sc-ot1.vf \
tex-Junicode-CondLightItalic-osf-sc-t1--base.tfm \
tex-Junicode-CondLightItalic-osf-sc-t1.tfm \
tex-Junicode-CondLightItalic-osf-sc-t1.vf \
tex-Junicode-CondLightItalic-osf-t1--base.tfm \
tex-Junicode-CondLightItalic-osf-t1.tfm \
tex-Junicode-CondLightItalic-osf-t1.vf \
tex-Junicode-CondLightItalic-osf-ts1--base.tfm \
tex-Junicode-CondLightItalic-osf-ts1.tfm \
tex-Junicode-CondLightItalic-osf-ts1.vf \
tex-Junicode-CondLightItalic-sup-lgr.tfm \
tex-Junicode-CondLightItalic-sup-ly1.tfm \
tex-Junicode-CondLightItalic-sup-ot1.tfm \
tex-Junicode-CondLightItalic-sup-t1--base.tfm \
tex-Junicode-CondLightItalic-sup-t1.tfm \
tex-Junicode-CondLightItalic-sup-t1.vf \
tex-Junicode-CondLightItalic-tlf-lgr.tfm \
tex-Junicode-CondLightItalic-tlf-ly1.tfm \
tex-Junicode-CondLightItalic-tlf-ot1.tfm \
tex-Junicode-CondLightItalic-tlf-sc-lgr.tfm \
tex-Junicode-CondLightItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-CondLightItalic-tlf-sc-ly1.tfm \
tex-Junicode-CondLightItalic-tlf-sc-ly1.vf \
tex-Junicode-CondLightItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-CondLightItalic-tlf-sc-ot1.tfm \
tex-Junicode-CondLightItalic-tlf-sc-ot1.vf \
tex-Junicode-CondLightItalic-tlf-sc-t1--base.tfm \
tex-Junicode-CondLightItalic-tlf-sc-t1.tfm \
tex-Junicode-CondLightItalic-tlf-sc-t1.vf \
tex-Junicode-CondLightItalic-tlf-t1--base.tfm \
tex-Junicode-CondLightItalic-tlf-t1.tfm \
tex-Junicode-CondLightItalic-tlf-t1.vf \
tex-Junicode-CondLightItalic-tlf-ts1--base.tfm \
tex-Junicode-CondLightItalic-tlf-ts1.tfm \
tex-Junicode-CondLightItalic-tlf-ts1.vf \
tex-Junicode-CondLightItalic-tosf-lgr.tfm \
tex-Junicode-CondLightItalic-tosf-ly1.tfm \
tex-Junicode-CondLightItalic-tosf-ot1.tfm \
tex-Junicode-CondLightItalic-tosf-sc-lgr.tfm \
tex-Junicode-CondLightItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-CondLightItalic-tosf-sc-ly1.tfm \
tex-Junicode-CondLightItalic-tosf-sc-ly1.vf \
tex-Junicode-CondLightItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-CondLightItalic-tosf-sc-ot1.tfm \
tex-Junicode-CondLightItalic-tosf-sc-ot1.vf \
tex-Junicode-CondLightItalic-tosf-sc-t1--base.tfm \
tex-Junicode-CondLightItalic-tosf-sc-t1.tfm \
tex-Junicode-CondLightItalic-tosf-sc-t1.vf \
tex-Junicode-CondLightItalic-tosf-t1--base.tfm \
tex-Junicode-CondLightItalic-tosf-t1.tfm \
tex-Junicode-CondLightItalic-tosf-t1.vf \
tex-Junicode-CondLightItalic-tosf-ts1--base.tfm \
tex-Junicode-CondLightItalic-tosf-ts1.tfm \
tex-Junicode-CondLightItalic-tosf-ts1.vf \
tex-Junicode-CondMedium-inf-lgr.tfm \
tex-Junicode-CondMedium-inf-ly1.tfm \
tex-Junicode-CondMedium-inf-ot1.tfm \
tex-Junicode-CondMedium-inf-t1--base.tfm \
tex-Junicode-CondMedium-inf-t1.tfm \
tex-Junicode-CondMedium-inf-t1.vf \
tex-Junicode-CondMedium-lf-lgr.tfm \
tex-Junicode-CondMedium-lf-ly1.tfm \
tex-Junicode-CondMedium-lf-ot1.tfm \
tex-Junicode-CondMedium-lf-sc-lgr.tfm \
tex-Junicode-CondMedium-lf-sc-ly1--base.tfm \
tex-Junicode-CondMedium-lf-sc-ly1.tfm \
tex-Junicode-CondMedium-lf-sc-ly1.vf \
tex-Junicode-CondMedium-lf-sc-ot1--base.tfm \
tex-Junicode-CondMedium-lf-sc-ot1.tfm \
tex-Junicode-CondMedium-lf-sc-ot1.vf \
tex-Junicode-CondMedium-lf-sc-t1--base.tfm \
tex-Junicode-CondMedium-lf-sc-t1.tfm \
tex-Junicode-CondMedium-lf-sc-t1.vf \
tex-Junicode-CondMedium-lf-t1--base.tfm \
tex-Junicode-CondMedium-lf-t1.tfm \
tex-Junicode-CondMedium-lf-t1.vf \
tex-Junicode-CondMedium-lf-ts1--base.tfm \
tex-Junicode-CondMedium-lf-ts1.tfm \
tex-Junicode-CondMedium-lf-ts1.vf \
tex-Junicode-CondMedium-osf-lgr.tfm \
tex-Junicode-CondMedium-osf-ly1.tfm \
tex-Junicode-CondMedium-osf-ot1.tfm \
tex-Junicode-CondMedium-osf-sc-lgr.tfm \
tex-Junicode-CondMedium-osf-sc-ly1--base.tfm \
tex-Junicode-CondMedium-osf-sc-ly1.tfm \
tex-Junicode-CondMedium-osf-sc-ly1.vf \
tex-Junicode-CondMedium-osf-sc-ot1--base.tfm \
tex-Junicode-CondMedium-osf-sc-ot1.tfm \
tex-Junicode-CondMedium-osf-sc-ot1.vf \
tex-Junicode-CondMedium-osf-sc-t1--base.tfm \
tex-Junicode-CondMedium-osf-sc-t1.tfm \
tex-Junicode-CondMedium-osf-sc-t1.vf \
tex-Junicode-CondMedium-osf-t1--base.tfm \
tex-Junicode-CondMedium-osf-t1.tfm \
tex-Junicode-CondMedium-osf-t1.vf \
tex-Junicode-CondMedium-osf-ts1--base.tfm \
tex-Junicode-CondMedium-osf-ts1.tfm \
tex-Junicode-CondMedium-osf-ts1.vf \
tex-Junicode-CondMedium-sup-lgr.tfm \
tex-Junicode-CondMedium-sup-ly1.tfm \
tex-Junicode-CondMedium-sup-ot1.tfm \
tex-Junicode-CondMedium-sup-t1--base.tfm \
tex-Junicode-CondMedium-sup-t1.tfm \
tex-Junicode-CondMedium-sup-t1.vf \
tex-Junicode-CondMedium-tlf-lgr.tfm \
tex-Junicode-CondMedium-tlf-ly1.tfm \
tex-Junicode-CondMedium-tlf-ot1.tfm \
tex-Junicode-CondMedium-tlf-sc-lgr.tfm \
tex-Junicode-CondMedium-tlf-sc-ly1--base.tfm \
tex-Junicode-CondMedium-tlf-sc-ly1.tfm \
tex-Junicode-CondMedium-tlf-sc-ly1.vf \
tex-Junicode-CondMedium-tlf-sc-ot1--base.tfm \
tex-Junicode-CondMedium-tlf-sc-ot1.tfm \
tex-Junicode-CondMedium-tlf-sc-ot1.vf \
tex-Junicode-CondMedium-tlf-sc-t1--base.tfm \
tex-Junicode-CondMedium-tlf-sc-t1.tfm \
tex-Junicode-CondMedium-tlf-sc-t1.vf \
tex-Junicode-CondMedium-tlf-t1--base.tfm \
tex-Junicode-CondMedium-tlf-t1.tfm \
tex-Junicode-CondMedium-tlf-t1.vf \
tex-Junicode-CondMedium-tlf-ts1--base.tfm \
tex-Junicode-CondMedium-tlf-ts1.tfm \
tex-Junicode-CondMedium-tlf-ts1.vf \
tex-Junicode-CondMedium-tosf-lgr.tfm \
tex-Junicode-CondMedium-tosf-ly1.tfm \
tex-Junicode-CondMedium-tosf-ot1.tfm \
tex-Junicode-CondMedium-tosf-sc-lgr.tfm \
tex-Junicode-CondMedium-tosf-sc-ly1--base.tfm \
tex-Junicode-CondMedium-tosf-sc-ly1.tfm \
tex-Junicode-CondMedium-tosf-sc-ly1.vf \
tex-Junicode-CondMedium-tosf-sc-ot1--base.tfm \
tex-Junicode-CondMedium-tosf-sc-ot1.tfm \
tex-Junicode-CondMedium-tosf-sc-ot1.vf \
tex-Junicode-CondMedium-tosf-sc-t1--base.tfm \
tex-Junicode-CondMedium-tosf-sc-t1.tfm \
tex-Junicode-CondMedium-tosf-sc-t1.vf \
tex-Junicode-CondMedium-tosf-t1--base.tfm \
tex-Junicode-CondMedium-tosf-t1.tfm \
tex-Junicode-CondMedium-tosf-t1.vf \
tex-Junicode-CondMedium-tosf-ts1--base.tfm \
tex-Junicode-CondMedium-tosf-ts1.tfm \
tex-Junicode-CondMedium-tosf-ts1.vf \
tex-Junicode-CondMediumItalic-inf-lgr.tfm \
tex-Junicode-CondMediumItalic-inf-ly1.tfm \
tex-Junicode-CondMediumItalic-inf-ot1.tfm \
tex-Junicode-CondMediumItalic-inf-t1--base.tfm \
tex-Junicode-CondMediumItalic-inf-t1.tfm \
tex-Junicode-CondMediumItalic-inf-t1.vf \
tex-Junicode-CondMediumItalic-lf-lgr.tfm \
tex-Junicode-CondMediumItalic-lf-ly1.tfm \
tex-Junicode-CondMediumItalic-lf-ot1.tfm \
tex-Junicode-CondMediumItalic-lf-sc-lgr.tfm \
tex-Junicode-CondMediumItalic-lf-sc-ly1--base.tfm \
tex-Junicode-CondMediumItalic-lf-sc-ly1.tfm \
tex-Junicode-CondMediumItalic-lf-sc-ly1.vf \
tex-Junicode-CondMediumItalic-lf-sc-ot1--base.tfm \
tex-Junicode-CondMediumItalic-lf-sc-ot1.tfm \
tex-Junicode-CondMediumItalic-lf-sc-ot1.vf \
tex-Junicode-CondMediumItalic-lf-sc-t1--base.tfm \
tex-Junicode-CondMediumItalic-lf-sc-t1.tfm \
tex-Junicode-CondMediumItalic-lf-sc-t1.vf \
tex-Junicode-CondMediumItalic-lf-t1--base.tfm \
tex-Junicode-CondMediumItalic-lf-t1.tfm \
tex-Junicode-CondMediumItalic-lf-t1.vf \
tex-Junicode-CondMediumItalic-lf-ts1--base.tfm \
tex-Junicode-CondMediumItalic-lf-ts1.tfm \
tex-Junicode-CondMediumItalic-lf-ts1.vf \
tex-Junicode-CondMediumItalic-osf-lgr.tfm \
tex-Junicode-CondMediumItalic-osf-ly1.tfm \
tex-Junicode-CondMediumItalic-osf-ot1.tfm \
tex-Junicode-CondMediumItalic-osf-sc-lgr.tfm \
tex-Junicode-CondMediumItalic-osf-sc-ly1--base.tfm \
tex-Junicode-CondMediumItalic-osf-sc-ly1.tfm \
tex-Junicode-CondMediumItalic-osf-sc-ly1.vf \
tex-Junicode-CondMediumItalic-osf-sc-ot1--base.tfm \
tex-Junicode-CondMediumItalic-osf-sc-ot1.tfm \
tex-Junicode-CondMediumItalic-osf-sc-ot1.vf \
tex-Junicode-CondMediumItalic-osf-sc-t1--base.tfm \
tex-Junicode-CondMediumItalic-osf-sc-t1.tfm \
tex-Junicode-CondMediumItalic-osf-sc-t1.vf \
tex-Junicode-CondMediumItalic-osf-t1--base.tfm \
tex-Junicode-CondMediumItalic-osf-t1.tfm \
tex-Junicode-CondMediumItalic-osf-t1.vf \
tex-Junicode-CondMediumItalic-osf-ts1--base.tfm \
tex-Junicode-CondMediumItalic-osf-ts1.tfm \
tex-Junicode-CondMediumItalic-osf-ts1.vf \
tex-Junicode-CondMediumItalic-sup-lgr.tfm \
tex-Junicode-CondMediumItalic-sup-ly1.tfm \
tex-Junicode-CondMediumItalic-sup-ot1.tfm \
tex-Junicode-CondMediumItalic-sup-t1--base.tfm \
tex-Junicode-CondMediumItalic-sup-t1.tfm \
tex-Junicode-CondMediumItalic-sup-t1.vf \
tex-Junicode-CondMediumItalic-tlf-lgr.tfm \
tex-Junicode-CondMediumItalic-tlf-ly1.tfm \
tex-Junicode-CondMediumItalic-tlf-ot1.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-lgr.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-ly1.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-ly1.vf \
tex-Junicode-CondMediumItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-ot1.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-ot1.vf \
tex-Junicode-CondMediumItalic-tlf-sc-t1--base.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-t1.tfm \
tex-Junicode-CondMediumItalic-tlf-sc-t1.vf \
tex-Junicode-CondMediumItalic-tlf-t1--base.tfm \
tex-Junicode-CondMediumItalic-tlf-t1.tfm \
tex-Junicode-CondMediumItalic-tlf-t1.vf \
tex-Junicode-CondMediumItalic-tlf-ts1--base.tfm \
tex-Junicode-CondMediumItalic-tlf-ts1.tfm \
tex-Junicode-CondMediumItalic-tlf-ts1.vf \
tex-Junicode-CondMediumItalic-tosf-lgr.tfm \
tex-Junicode-CondMediumItalic-tosf-ly1.tfm \
tex-Junicode-CondMediumItalic-tosf-ot1.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-lgr.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-ly1.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-ly1.vf \
tex-Junicode-CondMediumItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-ot1.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-ot1.vf \
tex-Junicode-CondMediumItalic-tosf-sc-t1--base.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-t1.tfm \
tex-Junicode-CondMediumItalic-tosf-sc-t1.vf \
tex-Junicode-CondMediumItalic-tosf-t1--base.tfm \
tex-Junicode-CondMediumItalic-tosf-t1.tfm \
tex-Junicode-CondMediumItalic-tosf-t1.vf \
tex-Junicode-CondMediumItalic-tosf-ts1--base.tfm \
tex-Junicode-CondMediumItalic-tosf-ts1.tfm \
tex-Junicode-CondMediumItalic-tosf-ts1.vf \
tex-Junicode-Exp-inf-lgr.tfm \
tex-Junicode-Exp-inf-ly1.tfm \
tex-Junicode-Exp-inf-ot1.tfm \
tex-Junicode-Exp-inf-t1--base.tfm \
tex-Junicode-Exp-inf-t1.tfm \
tex-Junicode-Exp-inf-t1.vf \
tex-Junicode-Exp-lf-lgr.tfm \
tex-Junicode-Exp-lf-ly1.tfm \
tex-Junicode-Exp-lf-ot1.tfm \
tex-Junicode-Exp-lf-sc-lgr.tfm \
tex-Junicode-Exp-lf-sc-ly1--base.tfm \
tex-Junicode-Exp-lf-sc-ly1.tfm \
tex-Junicode-Exp-lf-sc-ly1.vf \
tex-Junicode-Exp-lf-sc-ot1--base.tfm \
tex-Junicode-Exp-lf-sc-ot1.tfm \
tex-Junicode-Exp-lf-sc-ot1.vf \
tex-Junicode-Exp-lf-sc-t1--base.tfm \
tex-Junicode-Exp-lf-sc-t1.tfm \
tex-Junicode-Exp-lf-sc-t1.vf \
tex-Junicode-Exp-lf-t1--base.tfm \
tex-Junicode-Exp-lf-t1.tfm \
tex-Junicode-Exp-lf-t1.vf \
tex-Junicode-Exp-lf-ts1--base.tfm \
tex-Junicode-Exp-lf-ts1.tfm \
tex-Junicode-Exp-lf-ts1.vf \
tex-Junicode-Exp-osf-lgr.tfm \
tex-Junicode-Exp-osf-ly1.tfm \
tex-Junicode-Exp-osf-ot1.tfm \
tex-Junicode-Exp-osf-sc-lgr.tfm \
tex-Junicode-Exp-osf-sc-ly1--base.tfm \
tex-Junicode-Exp-osf-sc-ly1.tfm \
tex-Junicode-Exp-osf-sc-ly1.vf \
tex-Junicode-Exp-osf-sc-ot1--base.tfm \
tex-Junicode-Exp-osf-sc-ot1.tfm \
tex-Junicode-Exp-osf-sc-ot1.vf \
tex-Junicode-Exp-osf-sc-t1--base.tfm \
tex-Junicode-Exp-osf-sc-t1.tfm \
tex-Junicode-Exp-osf-sc-t1.vf \
tex-Junicode-Exp-osf-t1--base.tfm \
tex-Junicode-Exp-osf-t1.tfm \
tex-Junicode-Exp-osf-t1.vf \
tex-Junicode-Exp-osf-ts1--base.tfm \
tex-Junicode-Exp-osf-ts1.tfm \
tex-Junicode-Exp-osf-ts1.vf \
tex-Junicode-Exp-sup-lgr.tfm \
tex-Junicode-Exp-sup-ly1.tfm \
tex-Junicode-Exp-sup-ot1.tfm \
tex-Junicode-Exp-sup-t1--base.tfm \
tex-Junicode-Exp-sup-t1.tfm \
tex-Junicode-Exp-sup-t1.vf \
tex-Junicode-Exp-tlf-lgr.tfm \
tex-Junicode-Exp-tlf-ly1.tfm \
tex-Junicode-Exp-tlf-ot1.tfm \
tex-Junicode-Exp-tlf-sc-lgr.tfm \
tex-Junicode-Exp-tlf-sc-ly1--base.tfm \
tex-Junicode-Exp-tlf-sc-ly1.tfm \
tex-Junicode-Exp-tlf-sc-ly1.vf \
tex-Junicode-Exp-tlf-sc-ot1--base.tfm \
tex-Junicode-Exp-tlf-sc-ot1.tfm \
tex-Junicode-Exp-tlf-sc-ot1.vf \
tex-Junicode-Exp-tlf-sc-t1--base.tfm \
tex-Junicode-Exp-tlf-sc-t1.tfm \
tex-Junicode-Exp-tlf-sc-t1.vf \
tex-Junicode-Exp-tlf-t1--base.tfm \
tex-Junicode-Exp-tlf-t1.tfm \
tex-Junicode-Exp-tlf-t1.vf \
tex-Junicode-Exp-tlf-ts1--base.tfm \
tex-Junicode-Exp-tlf-ts1.tfm \
tex-Junicode-Exp-tlf-ts1.vf \
tex-Junicode-Exp-tosf-lgr.tfm \
tex-Junicode-Exp-tosf-ly1.tfm \
tex-Junicode-Exp-tosf-ot1.tfm \
tex-Junicode-Exp-tosf-sc-lgr.tfm \
tex-Junicode-Exp-tosf-sc-ly1--base.tfm \
tex-Junicode-Exp-tosf-sc-ly1.tfm \
tex-Junicode-Exp-tosf-sc-ly1.vf \
tex-Junicode-Exp-tosf-sc-ot1--base.tfm \
tex-Junicode-Exp-tosf-sc-ot1.tfm \
tex-Junicode-Exp-tosf-sc-ot1.vf \
tex-Junicode-Exp-tosf-sc-t1--base.tfm \
tex-Junicode-Exp-tosf-sc-t1.tfm \
tex-Junicode-Exp-tosf-sc-t1.vf \
tex-Junicode-Exp-tosf-t1--base.tfm \
tex-Junicode-Exp-tosf-t1.tfm \
tex-Junicode-Exp-tosf-t1.vf \
tex-Junicode-Exp-tosf-ts1--base.tfm \
tex-Junicode-Exp-tosf-ts1.tfm \
tex-Junicode-Exp-tosf-ts1.vf \
tex-Junicode-ExpBold-inf-lgr.tfm \
tex-Junicode-ExpBold-inf-ly1.tfm \
tex-Junicode-ExpBold-inf-ot1.tfm \
tex-Junicode-ExpBold-inf-t1--base.tfm \
tex-Junicode-ExpBold-inf-t1.tfm \
tex-Junicode-ExpBold-inf-t1.vf \
tex-Junicode-ExpBold-lf-lgr.tfm \
tex-Junicode-ExpBold-lf-ly1.tfm \
tex-Junicode-ExpBold-lf-ot1.tfm \
tex-Junicode-ExpBold-lf-sc-lgr.tfm \
tex-Junicode-ExpBold-lf-sc-ly1--base.tfm \
tex-Junicode-ExpBold-lf-sc-ly1.tfm \
tex-Junicode-ExpBold-lf-sc-ly1.vf \
tex-Junicode-ExpBold-lf-sc-ot1--base.tfm \
tex-Junicode-ExpBold-lf-sc-ot1.tfm \
tex-Junicode-ExpBold-lf-sc-ot1.vf \
tex-Junicode-ExpBold-lf-sc-t1--base.tfm \
tex-Junicode-ExpBold-lf-sc-t1.tfm \
tex-Junicode-ExpBold-lf-sc-t1.vf \
tex-Junicode-ExpBold-lf-t1--base.tfm \
tex-Junicode-ExpBold-lf-t1.tfm \
tex-Junicode-ExpBold-lf-t1.vf \
tex-Junicode-ExpBold-lf-ts1--base.tfm \
tex-Junicode-ExpBold-lf-ts1.tfm \
tex-Junicode-ExpBold-lf-ts1.vf \
tex-Junicode-ExpBold-osf-lgr.tfm \
tex-Junicode-ExpBold-osf-ly1.tfm \
tex-Junicode-ExpBold-osf-ot1.tfm \
tex-Junicode-ExpBold-osf-sc-lgr.tfm \
tex-Junicode-ExpBold-osf-sc-ly1--base.tfm \
tex-Junicode-ExpBold-osf-sc-ly1.tfm \
tex-Junicode-ExpBold-osf-sc-ly1.vf \
tex-Junicode-ExpBold-osf-sc-ot1--base.tfm \
tex-Junicode-ExpBold-osf-sc-ot1.tfm \
tex-Junicode-ExpBold-osf-sc-ot1.vf \
tex-Junicode-ExpBold-osf-sc-t1--base.tfm \
tex-Junicode-ExpBold-osf-sc-t1.tfm \
tex-Junicode-ExpBold-osf-sc-t1.vf \
tex-Junicode-ExpBold-osf-t1--base.tfm \
tex-Junicode-ExpBold-osf-t1.tfm \
tex-Junicode-ExpBold-osf-t1.vf \
tex-Junicode-ExpBold-osf-ts1--base.tfm \
tex-Junicode-ExpBold-osf-ts1.tfm \
tex-Junicode-ExpBold-osf-ts1.vf \
tex-Junicode-ExpBold-sup-lgr.tfm \
tex-Junicode-ExpBold-sup-ly1.tfm \
tex-Junicode-ExpBold-sup-ot1.tfm \
tex-Junicode-ExpBold-sup-t1--base.tfm \
tex-Junicode-ExpBold-sup-t1.tfm \
tex-Junicode-ExpBold-sup-t1.vf \
tex-Junicode-ExpBold-tlf-lgr.tfm \
tex-Junicode-ExpBold-tlf-ly1.tfm \
tex-Junicode-ExpBold-tlf-ot1.tfm \
tex-Junicode-ExpBold-tlf-sc-lgr.tfm \
tex-Junicode-ExpBold-tlf-sc-ly1--base.tfm \
tex-Junicode-ExpBold-tlf-sc-ly1.tfm \
tex-Junicode-ExpBold-tlf-sc-ly1.vf \
tex-Junicode-ExpBold-tlf-sc-ot1--base.tfm \
tex-Junicode-ExpBold-tlf-sc-ot1.tfm \
tex-Junicode-ExpBold-tlf-sc-ot1.vf \
tex-Junicode-ExpBold-tlf-sc-t1--base.tfm \
tex-Junicode-ExpBold-tlf-sc-t1.tfm \
tex-Junicode-ExpBold-tlf-sc-t1.vf \
tex-Junicode-ExpBold-tlf-t1--base.tfm \
tex-Junicode-ExpBold-tlf-t1.tfm \
tex-Junicode-ExpBold-tlf-t1.vf \
tex-Junicode-ExpBold-tlf-ts1--base.tfm \
tex-Junicode-ExpBold-tlf-ts1.tfm \
tex-Junicode-ExpBold-tlf-ts1.vf \
tex-Junicode-ExpBold-tosf-lgr.tfm \
tex-Junicode-ExpBold-tosf-ly1.tfm \
tex-Junicode-ExpBold-tosf-ot1.tfm \
tex-Junicode-ExpBold-tosf-sc-lgr.tfm \
tex-Junicode-ExpBold-tosf-sc-ly1--base.tfm \
tex-Junicode-ExpBold-tosf-sc-ly1.tfm \
tex-Junicode-ExpBold-tosf-sc-ly1.vf \
tex-Junicode-ExpBold-tosf-sc-ot1--base.tfm \
tex-Junicode-ExpBold-tosf-sc-ot1.tfm \
tex-Junicode-ExpBold-tosf-sc-ot1.vf \
tex-Junicode-ExpBold-tosf-sc-t1--base.tfm \
tex-Junicode-ExpBold-tosf-sc-t1.tfm \
tex-Junicode-ExpBold-tosf-sc-t1.vf \
tex-Junicode-ExpBold-tosf-t1--base.tfm \
tex-Junicode-ExpBold-tosf-t1.tfm \
tex-Junicode-ExpBold-tosf-t1.vf \
tex-Junicode-ExpBold-tosf-ts1--base.tfm \
tex-Junicode-ExpBold-tosf-ts1.tfm \
tex-Junicode-ExpBold-tosf-ts1.vf \
tex-Junicode-ExpBoldItalic-inf-lgr.tfm \
tex-Junicode-ExpBoldItalic-inf-ly1.tfm \
tex-Junicode-ExpBoldItalic-inf-ot1.tfm \
tex-Junicode-ExpBoldItalic-inf-t1--base.tfm \
tex-Junicode-ExpBoldItalic-inf-t1.tfm \
tex-Junicode-ExpBoldItalic-inf-t1.vf \
tex-Junicode-ExpBoldItalic-lf-lgr.tfm \
tex-Junicode-ExpBoldItalic-lf-ly1.tfm \
tex-Junicode-ExpBoldItalic-lf-ot1.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-lgr.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-ly1--base.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-ly1.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-ly1.vf \
tex-Junicode-ExpBoldItalic-lf-sc-ot1--base.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-ot1.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-ot1.vf \
tex-Junicode-ExpBoldItalic-lf-sc-t1--base.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-t1.tfm \
tex-Junicode-ExpBoldItalic-lf-sc-t1.vf \
tex-Junicode-ExpBoldItalic-lf-t1--base.tfm \
tex-Junicode-ExpBoldItalic-lf-t1.tfm \
tex-Junicode-ExpBoldItalic-lf-t1.vf \
tex-Junicode-ExpBoldItalic-lf-ts1--base.tfm \
tex-Junicode-ExpBoldItalic-lf-ts1.tfm \
tex-Junicode-ExpBoldItalic-lf-ts1.vf \
tex-Junicode-ExpBoldItalic-osf-lgr.tfm \
tex-Junicode-ExpBoldItalic-osf-ly1.tfm \
tex-Junicode-ExpBoldItalic-osf-ot1.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-lgr.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-ly1--base.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-ly1.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-ly1.vf \
tex-Junicode-ExpBoldItalic-osf-sc-ot1--base.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-ot1.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-ot1.vf \
tex-Junicode-ExpBoldItalic-osf-sc-t1--base.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-t1.tfm \
tex-Junicode-ExpBoldItalic-osf-sc-t1.vf \
tex-Junicode-ExpBoldItalic-osf-t1--base.tfm \
tex-Junicode-ExpBoldItalic-osf-t1.tfm \
tex-Junicode-ExpBoldItalic-osf-t1.vf \
tex-Junicode-ExpBoldItalic-osf-ts1--base.tfm \
tex-Junicode-ExpBoldItalic-osf-ts1.tfm \
tex-Junicode-ExpBoldItalic-osf-ts1.vf \
tex-Junicode-ExpBoldItalic-sup-lgr.tfm \
tex-Junicode-ExpBoldItalic-sup-ly1.tfm \
tex-Junicode-ExpBoldItalic-sup-ot1.tfm \
tex-Junicode-ExpBoldItalic-sup-t1--base.tfm \
tex-Junicode-ExpBoldItalic-sup-t1.tfm \
tex-Junicode-ExpBoldItalic-sup-t1.vf \
tex-Junicode-ExpBoldItalic-tlf-lgr.tfm \
tex-Junicode-ExpBoldItalic-tlf-ly1.tfm \
tex-Junicode-ExpBoldItalic-tlf-ot1.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-lgr.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-ly1.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-ly1.vf \
tex-Junicode-ExpBoldItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-ot1.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-ot1.vf \
tex-Junicode-ExpBoldItalic-tlf-sc-t1--base.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-t1.tfm \
tex-Junicode-ExpBoldItalic-tlf-sc-t1.vf \
tex-Junicode-ExpBoldItalic-tlf-t1--base.tfm \
tex-Junicode-ExpBoldItalic-tlf-t1.tfm \
tex-Junicode-ExpBoldItalic-tlf-t1.vf \
tex-Junicode-ExpBoldItalic-tlf-ts1--base.tfm \
tex-Junicode-ExpBoldItalic-tlf-ts1.tfm \
tex-Junicode-ExpBoldItalic-tlf-ts1.vf \
tex-Junicode-ExpBoldItalic-tosf-lgr.tfm \
tex-Junicode-ExpBoldItalic-tosf-ly1.tfm \
tex-Junicode-ExpBoldItalic-tosf-ot1.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-lgr.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-ly1.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-ly1.vf \
tex-Junicode-ExpBoldItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-ot1.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-ot1.vf \
tex-Junicode-ExpBoldItalic-tosf-sc-t1--base.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-t1.tfm \
tex-Junicode-ExpBoldItalic-tosf-sc-t1.vf \
tex-Junicode-ExpBoldItalic-tosf-t1--base.tfm \
tex-Junicode-ExpBoldItalic-tosf-t1.tfm \
tex-Junicode-ExpBoldItalic-tosf-t1.vf \
tex-Junicode-ExpBoldItalic-tosf-ts1--base.tfm \
tex-Junicode-ExpBoldItalic-tosf-ts1.tfm \
tex-Junicode-ExpBoldItalic-tosf-ts1.vf \
tex-Junicode-ExpItalic-inf-lgr.tfm \
tex-Junicode-ExpItalic-inf-ly1.tfm \
tex-Junicode-ExpItalic-inf-ot1.tfm \
tex-Junicode-ExpItalic-inf-t1--base.tfm \
tex-Junicode-ExpItalic-inf-t1.tfm \
tex-Junicode-ExpItalic-inf-t1.vf \
tex-Junicode-ExpItalic-lf-lgr.tfm \
tex-Junicode-ExpItalic-lf-ly1.tfm \
tex-Junicode-ExpItalic-lf-ot1.tfm \
tex-Junicode-ExpItalic-lf-sc-lgr.tfm \
tex-Junicode-ExpItalic-lf-sc-ly1--base.tfm \
tex-Junicode-ExpItalic-lf-sc-ly1.tfm \
tex-Junicode-ExpItalic-lf-sc-ly1.vf \
tex-Junicode-ExpItalic-lf-sc-ot1--base.tfm \
tex-Junicode-ExpItalic-lf-sc-ot1.tfm \
tex-Junicode-ExpItalic-lf-sc-ot1.vf \
tex-Junicode-ExpItalic-lf-sc-t1--base.tfm \
tex-Junicode-ExpItalic-lf-sc-t1.tfm \
tex-Junicode-ExpItalic-lf-sc-t1.vf \
tex-Junicode-ExpItalic-lf-t1--base.tfm \
tex-Junicode-ExpItalic-lf-t1.tfm \
tex-Junicode-ExpItalic-lf-t1.vf \
tex-Junicode-ExpItalic-lf-ts1--base.tfm \
tex-Junicode-ExpItalic-lf-ts1.tfm \
tex-Junicode-ExpItalic-lf-ts1.vf \
tex-Junicode-ExpItalic-osf-lgr.tfm \
tex-Junicode-ExpItalic-osf-ly1.tfm \
tex-Junicode-ExpItalic-osf-ot1.tfm \
tex-Junicode-ExpItalic-osf-sc-lgr.tfm \
tex-Junicode-ExpItalic-osf-sc-ly1--base.tfm \
tex-Junicode-ExpItalic-osf-sc-ly1.tfm \
tex-Junicode-ExpItalic-osf-sc-ly1.vf \
tex-Junicode-ExpItalic-osf-sc-ot1--base.tfm \
tex-Junicode-ExpItalic-osf-sc-ot1.tfm \
tex-Junicode-ExpItalic-osf-sc-ot1.vf \
tex-Junicode-ExpItalic-osf-sc-t1--base.tfm \
tex-Junicode-ExpItalic-osf-sc-t1.tfm \
tex-Junicode-ExpItalic-osf-sc-t1.vf \
tex-Junicode-ExpItalic-osf-t1--base.tfm \
tex-Junicode-ExpItalic-osf-t1.tfm \
tex-Junicode-ExpItalic-osf-t1.vf \
tex-Junicode-ExpItalic-osf-ts1--base.tfm \
tex-Junicode-ExpItalic-osf-ts1.tfm \
tex-Junicode-ExpItalic-osf-ts1.vf \
tex-Junicode-ExpItalic-sup-lgr.tfm \
tex-Junicode-ExpItalic-sup-ly1.tfm \
tex-Junicode-ExpItalic-sup-ot1.tfm \
tex-Junicode-ExpItalic-sup-t1--base.tfm \
tex-Junicode-ExpItalic-sup-t1.tfm \
tex-Junicode-ExpItalic-sup-t1.vf \
tex-Junicode-ExpItalic-tlf-lgr.tfm \
tex-Junicode-ExpItalic-tlf-ly1.tfm \
tex-Junicode-ExpItalic-tlf-ot1.tfm \
tex-Junicode-ExpItalic-tlf-sc-lgr.tfm \
tex-Junicode-ExpItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-ExpItalic-tlf-sc-ly1.tfm \
tex-Junicode-ExpItalic-tlf-sc-ly1.vf \
tex-Junicode-ExpItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-ExpItalic-tlf-sc-ot1.tfm \
tex-Junicode-ExpItalic-tlf-sc-ot1.vf \
tex-Junicode-ExpItalic-tlf-sc-t1--base.tfm \
tex-Junicode-ExpItalic-tlf-sc-t1.tfm \
tex-Junicode-ExpItalic-tlf-sc-t1.vf \
tex-Junicode-ExpItalic-tlf-t1--base.tfm \
tex-Junicode-ExpItalic-tlf-t1.tfm \
tex-Junicode-ExpItalic-tlf-t1.vf \
tex-Junicode-ExpItalic-tlf-ts1--base.tfm \
tex-Junicode-ExpItalic-tlf-ts1.tfm \
tex-Junicode-ExpItalic-tlf-ts1.vf \
tex-Junicode-ExpItalic-tosf-lgr.tfm \
tex-Junicode-ExpItalic-tosf-ly1.tfm \
tex-Junicode-ExpItalic-tosf-ot1.tfm \
tex-Junicode-ExpItalic-tosf-sc-lgr.tfm \
tex-Junicode-ExpItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-ExpItalic-tosf-sc-ly1.tfm \
tex-Junicode-ExpItalic-tosf-sc-ly1.vf \
tex-Junicode-ExpItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-ExpItalic-tosf-sc-ot1.tfm \
tex-Junicode-ExpItalic-tosf-sc-ot1.vf \
tex-Junicode-ExpItalic-tosf-sc-t1--base.tfm \
tex-Junicode-ExpItalic-tosf-sc-t1.tfm \
tex-Junicode-ExpItalic-tosf-sc-t1.vf \
tex-Junicode-ExpItalic-tosf-t1--base.tfm \
tex-Junicode-ExpItalic-tosf-t1.tfm \
tex-Junicode-ExpItalic-tosf-t1.vf \
tex-Junicode-ExpItalic-tosf-ts1--base.tfm \
tex-Junicode-ExpItalic-tosf-ts1.tfm \
tex-Junicode-ExpItalic-tosf-ts1.vf \
tex-Junicode-ExpMedium-inf-lgr.tfm \
tex-Junicode-ExpMedium-inf-ly1.tfm \
tex-Junicode-ExpMedium-inf-ot1.tfm \
tex-Junicode-ExpMedium-inf-t1--base.tfm \
tex-Junicode-ExpMedium-inf-t1.tfm \
tex-Junicode-ExpMedium-inf-t1.vf \
tex-Junicode-ExpMedium-lf-lgr.tfm \
tex-Junicode-ExpMedium-lf-ly1.tfm \
tex-Junicode-ExpMedium-lf-ot1.tfm \
tex-Junicode-ExpMedium-lf-sc-lgr.tfm \
tex-Junicode-ExpMedium-lf-sc-ly1--base.tfm \
tex-Junicode-ExpMedium-lf-sc-ly1.tfm \
tex-Junicode-ExpMedium-lf-sc-ly1.vf \
tex-Junicode-ExpMedium-lf-sc-ot1--base.tfm \
tex-Junicode-ExpMedium-lf-sc-ot1.tfm \
tex-Junicode-ExpMedium-lf-sc-ot1.vf \
tex-Junicode-ExpMedium-lf-sc-t1--base.tfm \
tex-Junicode-ExpMedium-lf-sc-t1.tfm \
tex-Junicode-ExpMedium-lf-sc-t1.vf \
tex-Junicode-ExpMedium-lf-t1--base.tfm \
tex-Junicode-ExpMedium-lf-t1.tfm \
tex-Junicode-ExpMedium-lf-t1.vf \
tex-Junicode-ExpMedium-lf-ts1--base.tfm \
tex-Junicode-ExpMedium-lf-ts1.tfm \
tex-Junicode-ExpMedium-lf-ts1.vf \
tex-Junicode-ExpMedium-osf-lgr.tfm \
tex-Junicode-ExpMedium-osf-ly1.tfm \
tex-Junicode-ExpMedium-osf-ot1.tfm \
tex-Junicode-ExpMedium-osf-sc-lgr.tfm \
tex-Junicode-ExpMedium-osf-sc-ly1--base.tfm \
tex-Junicode-ExpMedium-osf-sc-ly1.tfm \
tex-Junicode-ExpMedium-osf-sc-ly1.vf \
tex-Junicode-ExpMedium-osf-sc-ot1--base.tfm \
tex-Junicode-ExpMedium-osf-sc-ot1.tfm \
tex-Junicode-ExpMedium-osf-sc-ot1.vf \
tex-Junicode-ExpMedium-osf-sc-t1--base.tfm \
tex-Junicode-ExpMedium-osf-sc-t1.tfm \
tex-Junicode-ExpMedium-osf-sc-t1.vf \
tex-Junicode-ExpMedium-osf-t1--base.tfm \
tex-Junicode-ExpMedium-osf-t1.tfm \
tex-Junicode-ExpMedium-osf-t1.vf \
tex-Junicode-ExpMedium-osf-ts1--base.tfm \
tex-Junicode-ExpMedium-osf-ts1.tfm \
tex-Junicode-ExpMedium-osf-ts1.vf \
tex-Junicode-ExpMedium-sup-lgr.tfm \
tex-Junicode-ExpMedium-sup-ly1.tfm \
tex-Junicode-ExpMedium-sup-ot1.tfm \
tex-Junicode-ExpMedium-sup-t1--base.tfm \
tex-Junicode-ExpMedium-sup-t1.tfm \
tex-Junicode-ExpMedium-sup-t1.vf \
tex-Junicode-ExpMedium-tlf-lgr.tfm \
tex-Junicode-ExpMedium-tlf-ly1.tfm \
tex-Junicode-ExpMedium-tlf-ot1.tfm \
tex-Junicode-ExpMedium-tlf-sc-lgr.tfm \
tex-Junicode-ExpMedium-tlf-sc-ly1--base.tfm \
tex-Junicode-ExpMedium-tlf-sc-ly1.tfm \
tex-Junicode-ExpMedium-tlf-sc-ly1.vf \
tex-Junicode-ExpMedium-tlf-sc-ot1--base.tfm \
tex-Junicode-ExpMedium-tlf-sc-ot1.tfm \
tex-Junicode-ExpMedium-tlf-sc-ot1.vf \
tex-Junicode-ExpMedium-tlf-sc-t1--base.tfm \
tex-Junicode-ExpMedium-tlf-sc-t1.tfm \
tex-Junicode-ExpMedium-tlf-sc-t1.vf \
tex-Junicode-ExpMedium-tlf-t1--base.tfm \
tex-Junicode-ExpMedium-tlf-t1.tfm \
tex-Junicode-ExpMedium-tlf-t1.vf \
tex-Junicode-ExpMedium-tlf-ts1--base.tfm \
tex-Junicode-ExpMedium-tlf-ts1.tfm \
tex-Junicode-ExpMedium-tlf-ts1.vf \
tex-Junicode-ExpMedium-tosf-lgr.tfm \
tex-Junicode-ExpMedium-tosf-ly1.tfm \
tex-Junicode-ExpMedium-tosf-ot1.tfm \
tex-Junicode-ExpMedium-tosf-sc-lgr.tfm \
tex-Junicode-ExpMedium-tosf-sc-ly1--base.tfm \
tex-Junicode-ExpMedium-tosf-sc-ly1.tfm \
tex-Junicode-ExpMedium-tosf-sc-ly1.vf \
tex-Junicode-ExpMedium-tosf-sc-ot1--base.tfm \
tex-Junicode-ExpMedium-tosf-sc-ot1.tfm \
tex-Junicode-ExpMedium-tosf-sc-ot1.vf \
tex-Junicode-ExpMedium-tosf-sc-t1--base.tfm \
tex-Junicode-ExpMedium-tosf-sc-t1.tfm \
tex-Junicode-ExpMedium-tosf-sc-t1.vf \
tex-Junicode-ExpMedium-tosf-t1--base.tfm \
tex-Junicode-ExpMedium-tosf-t1.tfm \
tex-Junicode-ExpMedium-tosf-t1.vf \
tex-Junicode-ExpMedium-tosf-ts1--base.tfm \
tex-Junicode-ExpMedium-tosf-ts1.tfm \
tex-Junicode-ExpMedium-tosf-ts1.vf \
tex-Junicode-ExpMediumItalic-inf-lgr.tfm \
tex-Junicode-ExpMediumItalic-inf-ly1.tfm \
tex-Junicode-ExpMediumItalic-inf-ot1.tfm \
tex-Junicode-ExpMediumItalic-inf-t1--base.tfm \
tex-Junicode-ExpMediumItalic-inf-t1.tfm \
tex-Junicode-ExpMediumItalic-inf-t1.vf \
tex-Junicode-ExpMediumItalic-lf-lgr.tfm \
tex-Junicode-ExpMediumItalic-lf-ly1.tfm \
tex-Junicode-ExpMediumItalic-lf-ot1.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-lgr.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-ly1--base.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-ly1.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-ly1.vf \
tex-Junicode-ExpMediumItalic-lf-sc-ot1--base.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-ot1.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-ot1.vf \
tex-Junicode-ExpMediumItalic-lf-sc-t1--base.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-t1.tfm \
tex-Junicode-ExpMediumItalic-lf-sc-t1.vf \
tex-Junicode-ExpMediumItalic-lf-t1--base.tfm \
tex-Junicode-ExpMediumItalic-lf-t1.tfm \
tex-Junicode-ExpMediumItalic-lf-t1.vf \
tex-Junicode-ExpMediumItalic-lf-ts1--base.tfm \
tex-Junicode-ExpMediumItalic-lf-ts1.tfm \
tex-Junicode-ExpMediumItalic-lf-ts1.vf \
tex-Junicode-ExpMediumItalic-osf-lgr.tfm \
tex-Junicode-ExpMediumItalic-osf-ly1.tfm \
tex-Junicode-ExpMediumItalic-osf-ot1.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-lgr.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-ly1--base.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-ly1.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-ly1.vf \
tex-Junicode-ExpMediumItalic-osf-sc-ot1--base.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-ot1.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-ot1.vf \
tex-Junicode-ExpMediumItalic-osf-sc-t1--base.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-t1.tfm \
tex-Junicode-ExpMediumItalic-osf-sc-t1.vf \
tex-Junicode-ExpMediumItalic-osf-t1--base.tfm \
tex-Junicode-ExpMediumItalic-osf-t1.tfm \
tex-Junicode-ExpMediumItalic-osf-t1.vf \
tex-Junicode-ExpMediumItalic-osf-ts1--base.tfm \
tex-Junicode-ExpMediumItalic-osf-ts1.tfm \
tex-Junicode-ExpMediumItalic-osf-ts1.vf \
tex-Junicode-ExpMediumItalic-sup-lgr.tfm \
tex-Junicode-ExpMediumItalic-sup-ly1.tfm \
tex-Junicode-ExpMediumItalic-sup-ot1.tfm \
tex-Junicode-ExpMediumItalic-sup-t1--base.tfm \
tex-Junicode-ExpMediumItalic-sup-t1.tfm \
tex-Junicode-ExpMediumItalic-sup-t1.vf \
tex-Junicode-ExpMediumItalic-tlf-lgr.tfm \
tex-Junicode-ExpMediumItalic-tlf-ly1.tfm \
tex-Junicode-ExpMediumItalic-tlf-ot1.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-lgr.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-ly1.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-ly1.vf \
tex-Junicode-ExpMediumItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-ot1.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-ot1.vf \
tex-Junicode-ExpMediumItalic-tlf-sc-t1--base.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-t1.tfm \
tex-Junicode-ExpMediumItalic-tlf-sc-t1.vf \
tex-Junicode-ExpMediumItalic-tlf-t1--base.tfm \
tex-Junicode-ExpMediumItalic-tlf-t1.tfm \
tex-Junicode-ExpMediumItalic-tlf-t1.vf \
tex-Junicode-ExpMediumItalic-tlf-ts1--base.tfm \
tex-Junicode-ExpMediumItalic-tlf-ts1.tfm \
tex-Junicode-ExpMediumItalic-tlf-ts1.vf \
tex-Junicode-ExpMediumItalic-tosf-lgr.tfm \
tex-Junicode-ExpMediumItalic-tosf-ly1.tfm \
tex-Junicode-ExpMediumItalic-tosf-ot1.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-lgr.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-ly1.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-ly1.vf \
tex-Junicode-ExpMediumItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-ot1.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-ot1.vf \
tex-Junicode-ExpMediumItalic-tosf-sc-t1--base.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-t1.tfm \
tex-Junicode-ExpMediumItalic-tosf-sc-t1.vf \
tex-Junicode-ExpMediumItalic-tosf-t1--base.tfm \
tex-Junicode-ExpMediumItalic-tosf-t1.tfm \
tex-Junicode-ExpMediumItalic-tosf-t1.vf \
tex-Junicode-ExpMediumItalic-tosf-ts1--base.tfm \
tex-Junicode-ExpMediumItalic-tosf-ts1.tfm \
tex-Junicode-ExpMediumItalic-tosf-ts1.vf \
tex-Junicode-ExpSmBold-inf-lgr.tfm \
tex-Junicode-ExpSmBold-inf-ly1.tfm \
tex-Junicode-ExpSmBold-inf-ot1.tfm \
tex-Junicode-ExpSmBold-inf-t1--base.tfm \
tex-Junicode-ExpSmBold-inf-t1.tfm \
tex-Junicode-ExpSmBold-inf-t1.vf \
tex-Junicode-ExpSmBold-lf-lgr.tfm \
tex-Junicode-ExpSmBold-lf-ly1.tfm \
tex-Junicode-ExpSmBold-lf-ot1.tfm \
tex-Junicode-ExpSmBold-lf-sc-lgr.tfm \
tex-Junicode-ExpSmBold-lf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBold-lf-sc-ly1.tfm \
tex-Junicode-ExpSmBold-lf-sc-ly1.vf \
tex-Junicode-ExpSmBold-lf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBold-lf-sc-ot1.tfm \
tex-Junicode-ExpSmBold-lf-sc-ot1.vf \
tex-Junicode-ExpSmBold-lf-sc-t1--base.tfm \
tex-Junicode-ExpSmBold-lf-sc-t1.tfm \
tex-Junicode-ExpSmBold-lf-sc-t1.vf \
tex-Junicode-ExpSmBold-lf-t1--base.tfm \
tex-Junicode-ExpSmBold-lf-t1.tfm \
tex-Junicode-ExpSmBold-lf-t1.vf \
tex-Junicode-ExpSmBold-lf-ts1--base.tfm \
tex-Junicode-ExpSmBold-lf-ts1.tfm \
tex-Junicode-ExpSmBold-lf-ts1.vf \
tex-Junicode-ExpSmBold-osf-lgr.tfm \
tex-Junicode-ExpSmBold-osf-ly1.tfm \
tex-Junicode-ExpSmBold-osf-ot1.tfm \
tex-Junicode-ExpSmBold-osf-sc-lgr.tfm \
tex-Junicode-ExpSmBold-osf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBold-osf-sc-ly1.tfm \
tex-Junicode-ExpSmBold-osf-sc-ly1.vf \
tex-Junicode-ExpSmBold-osf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBold-osf-sc-ot1.tfm \
tex-Junicode-ExpSmBold-osf-sc-ot1.vf \
tex-Junicode-ExpSmBold-osf-sc-t1--base.tfm \
tex-Junicode-ExpSmBold-osf-sc-t1.tfm \
tex-Junicode-ExpSmBold-osf-sc-t1.vf \
tex-Junicode-ExpSmBold-osf-t1--base.tfm \
tex-Junicode-ExpSmBold-osf-t1.tfm \
tex-Junicode-ExpSmBold-osf-t1.vf \
tex-Junicode-ExpSmBold-osf-ts1--base.tfm \
tex-Junicode-ExpSmBold-osf-ts1.tfm \
tex-Junicode-ExpSmBold-osf-ts1.vf \
tex-Junicode-ExpSmBold-sup-lgr.tfm \
tex-Junicode-ExpSmBold-sup-ly1.tfm \
tex-Junicode-ExpSmBold-sup-ot1.tfm \
tex-Junicode-ExpSmBold-sup-t1--base.tfm \
tex-Junicode-ExpSmBold-sup-t1.tfm \
tex-Junicode-ExpSmBold-sup-t1.vf \
tex-Junicode-ExpSmBold-tlf-lgr.tfm \
tex-Junicode-ExpSmBold-tlf-ly1.tfm \
tex-Junicode-ExpSmBold-tlf-ot1.tfm \
tex-Junicode-ExpSmBold-tlf-sc-lgr.tfm \
tex-Junicode-ExpSmBold-tlf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBold-tlf-sc-ly1.tfm \
tex-Junicode-ExpSmBold-tlf-sc-ly1.vf \
tex-Junicode-ExpSmBold-tlf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBold-tlf-sc-ot1.tfm \
tex-Junicode-ExpSmBold-tlf-sc-ot1.vf \
tex-Junicode-ExpSmBold-tlf-sc-t1--base.tfm \
tex-Junicode-ExpSmBold-tlf-sc-t1.tfm \
tex-Junicode-ExpSmBold-tlf-sc-t1.vf \
tex-Junicode-ExpSmBold-tlf-t1--base.tfm \
tex-Junicode-ExpSmBold-tlf-t1.tfm \
tex-Junicode-ExpSmBold-tlf-t1.vf \
tex-Junicode-ExpSmBold-tlf-ts1--base.tfm \
tex-Junicode-ExpSmBold-tlf-ts1.tfm \
tex-Junicode-ExpSmBold-tlf-ts1.vf \
tex-Junicode-ExpSmBold-tosf-lgr.tfm \
tex-Junicode-ExpSmBold-tosf-ly1.tfm \
tex-Junicode-ExpSmBold-tosf-ot1.tfm \
tex-Junicode-ExpSmBold-tosf-sc-lgr.tfm \
tex-Junicode-ExpSmBold-tosf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBold-tosf-sc-ly1.tfm \
tex-Junicode-ExpSmBold-tosf-sc-ly1.vf \
tex-Junicode-ExpSmBold-tosf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBold-tosf-sc-ot1.tfm \
tex-Junicode-ExpSmBold-tosf-sc-ot1.vf \
tex-Junicode-ExpSmBold-tosf-sc-t1--base.tfm \
tex-Junicode-ExpSmBold-tosf-sc-t1.tfm \
tex-Junicode-ExpSmBold-tosf-sc-t1.vf \
tex-Junicode-ExpSmBold-tosf-t1--base.tfm \
tex-Junicode-ExpSmBold-tosf-t1.tfm \
tex-Junicode-ExpSmBold-tosf-t1.vf \
tex-Junicode-ExpSmBold-tosf-ts1--base.tfm \
tex-Junicode-ExpSmBold-tosf-ts1.tfm \
tex-Junicode-ExpSmBold-tosf-ts1.vf \
tex-Junicode-ExpSmBoldItalic-inf-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-inf-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-inf-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-inf-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-inf-t1.tfm \
tex-Junicode-ExpSmBoldItalic-inf-t1.vf \
tex-Junicode-ExpSmBoldItalic-lf-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-lf-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-lf-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-ly1.vf \
tex-Junicode-ExpSmBoldItalic-lf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-ot1.vf \
tex-Junicode-ExpSmBoldItalic-lf-sc-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-t1.tfm \
tex-Junicode-ExpSmBoldItalic-lf-sc-t1.vf \
tex-Junicode-ExpSmBoldItalic-lf-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-lf-t1.tfm \
tex-Junicode-ExpSmBoldItalic-lf-t1.vf \
tex-Junicode-ExpSmBoldItalic-lf-ts1--base.tfm \
tex-Junicode-ExpSmBoldItalic-lf-ts1.tfm \
tex-Junicode-ExpSmBoldItalic-lf-ts1.vf \
tex-Junicode-ExpSmBoldItalic-osf-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-osf-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-osf-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-ly1.vf \
tex-Junicode-ExpSmBoldItalic-osf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-ot1.vf \
tex-Junicode-ExpSmBoldItalic-osf-sc-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-t1.tfm \
tex-Junicode-ExpSmBoldItalic-osf-sc-t1.vf \
tex-Junicode-ExpSmBoldItalic-osf-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-osf-t1.tfm \
tex-Junicode-ExpSmBoldItalic-osf-t1.vf \
tex-Junicode-ExpSmBoldItalic-osf-ts1--base.tfm \
tex-Junicode-ExpSmBoldItalic-osf-ts1.tfm \
tex-Junicode-ExpSmBoldItalic-osf-ts1.vf \
tex-Junicode-ExpSmBoldItalic-sup-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-sup-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-sup-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-sup-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-sup-t1.tfm \
tex-Junicode-ExpSmBoldItalic-sup-t1.vf \
tex-Junicode-ExpSmBoldItalic-tlf-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-ly1.vf \
tex-Junicode-ExpSmBoldItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-ot1.vf \
tex-Junicode-ExpSmBoldItalic-tlf-sc-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-t1.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-sc-t1.vf \
tex-Junicode-ExpSmBoldItalic-tlf-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-t1.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-t1.vf \
tex-Junicode-ExpSmBoldItalic-tlf-ts1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-ts1.tfm \
tex-Junicode-ExpSmBoldItalic-tlf-ts1.vf \
tex-Junicode-ExpSmBoldItalic-tosf-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-lgr.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-ly1.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-ly1.vf \
tex-Junicode-ExpSmBoldItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-ot1.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-ot1.vf \
tex-Junicode-ExpSmBoldItalic-tosf-sc-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-t1.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-sc-t1.vf \
tex-Junicode-ExpSmBoldItalic-tosf-t1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-t1.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-t1.vf \
tex-Junicode-ExpSmBoldItalic-tosf-ts1--base.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-ts1.tfm \
tex-Junicode-ExpSmBoldItalic-tosf-ts1.vf \
tex-Junicode-Italic-inf-lgr.tfm \
tex-Junicode-Italic-inf-ly1.tfm \
tex-Junicode-Italic-inf-ot1.tfm \
tex-Junicode-Italic-inf-t1--base.tfm \
tex-Junicode-Italic-inf-t1.tfm \
tex-Junicode-Italic-inf-t1.vf \
tex-Junicode-Italic-lf-lgr.tfm \
tex-Junicode-Italic-lf-ly1.tfm \
tex-Junicode-Italic-lf-ot1.tfm \
tex-Junicode-Italic-lf-sc-lgr.tfm \
tex-Junicode-Italic-lf-sc-ly1--base.tfm \
tex-Junicode-Italic-lf-sc-ly1.tfm \
tex-Junicode-Italic-lf-sc-ly1.vf \
tex-Junicode-Italic-lf-sc-ot1--base.tfm \
tex-Junicode-Italic-lf-sc-ot1.tfm \
tex-Junicode-Italic-lf-sc-ot1.vf \
tex-Junicode-Italic-lf-sc-t1--base.tfm \
tex-Junicode-Italic-lf-sc-t1.tfm \
tex-Junicode-Italic-lf-sc-t1.vf \
tex-Junicode-Italic-lf-t1--base.tfm \
tex-Junicode-Italic-lf-t1.tfm \
tex-Junicode-Italic-lf-t1.vf \
tex-Junicode-Italic-lf-ts1--base.tfm \
tex-Junicode-Italic-lf-ts1.tfm \
tex-Junicode-Italic-lf-ts1.vf \
tex-Junicode-Italic-osf-lgr.tfm \
tex-Junicode-Italic-osf-ly1.tfm \
tex-Junicode-Italic-osf-ot1.tfm \
tex-Junicode-Italic-osf-sc-lgr.tfm \
tex-Junicode-Italic-osf-sc-ly1--base.tfm \
tex-Junicode-Italic-osf-sc-ly1.tfm \
tex-Junicode-Italic-osf-sc-ly1.vf \
tex-Junicode-Italic-osf-sc-ot1--base.tfm \
tex-Junicode-Italic-osf-sc-ot1.tfm \
tex-Junicode-Italic-osf-sc-ot1.vf \
tex-Junicode-Italic-osf-sc-t1--base.tfm \
tex-Junicode-Italic-osf-sc-t1.tfm \
tex-Junicode-Italic-osf-sc-t1.vf \
tex-Junicode-Italic-osf-t1--base.tfm \
tex-Junicode-Italic-osf-t1.tfm \
tex-Junicode-Italic-osf-t1.vf \
tex-Junicode-Italic-osf-ts1--base.tfm \
tex-Junicode-Italic-osf-ts1.tfm \
tex-Junicode-Italic-osf-ts1.vf \
tex-Junicode-Italic-sup-lgr.tfm \
tex-Junicode-Italic-sup-ly1.tfm \
tex-Junicode-Italic-sup-ot1.tfm \
tex-Junicode-Italic-sup-t1--base.tfm \
tex-Junicode-Italic-sup-t1.tfm \
tex-Junicode-Italic-sup-t1.vf \
tex-Junicode-Italic-tlf-lgr.tfm \
tex-Junicode-Italic-tlf-ly1.tfm \
tex-Junicode-Italic-tlf-ot1.tfm \
tex-Junicode-Italic-tlf-sc-lgr.tfm \
tex-Junicode-Italic-tlf-sc-ly1--base.tfm \
tex-Junicode-Italic-tlf-sc-ly1.tfm \
tex-Junicode-Italic-tlf-sc-ly1.vf \
tex-Junicode-Italic-tlf-sc-ot1--base.tfm \
tex-Junicode-Italic-tlf-sc-ot1.tfm \
tex-Junicode-Italic-tlf-sc-ot1.vf \
tex-Junicode-Italic-tlf-sc-t1--base.tfm \
tex-Junicode-Italic-tlf-sc-t1.tfm \
tex-Junicode-Italic-tlf-sc-t1.vf \
tex-Junicode-Italic-tlf-t1--base.tfm \
tex-Junicode-Italic-tlf-t1.tfm \
tex-Junicode-Italic-tlf-t1.vf \
tex-Junicode-Italic-tlf-ts1--base.tfm \
tex-Junicode-Italic-tlf-ts1.tfm \
tex-Junicode-Italic-tlf-ts1.vf \
tex-Junicode-Italic-tosf-lgr.tfm \
tex-Junicode-Italic-tosf-ly1.tfm \
tex-Junicode-Italic-tosf-ot1.tfm \
tex-Junicode-Italic-tosf-sc-lgr.tfm \
tex-Junicode-Italic-tosf-sc-ly1--base.tfm \
tex-Junicode-Italic-tosf-sc-ly1.tfm \
tex-Junicode-Italic-tosf-sc-ly1.vf \
tex-Junicode-Italic-tosf-sc-ot1--base.tfm \
tex-Junicode-Italic-tosf-sc-ot1.tfm \
tex-Junicode-Italic-tosf-sc-ot1.vf \
tex-Junicode-Italic-tosf-sc-t1--base.tfm \
tex-Junicode-Italic-tosf-sc-t1.tfm \
tex-Junicode-Italic-tosf-sc-t1.vf \
tex-Junicode-Italic-tosf-t1--base.tfm \
tex-Junicode-Italic-tosf-t1.tfm \
tex-Junicode-Italic-tosf-t1.vf \
tex-Junicode-Italic-tosf-ts1--base.tfm \
tex-Junicode-Italic-tosf-ts1.tfm \
tex-Junicode-Italic-tosf-ts1.vf \
tex-Junicode-Light-inf-lgr.tfm \
tex-Junicode-Light-inf-ly1.tfm \
tex-Junicode-Light-inf-ot1.tfm \
tex-Junicode-Light-inf-t1--base.tfm \
tex-Junicode-Light-inf-t1.tfm \
tex-Junicode-Light-inf-t1.vf \
tex-Junicode-Light-lf-lgr.tfm \
tex-Junicode-Light-lf-ly1.tfm \
tex-Junicode-Light-lf-ot1.tfm \
tex-Junicode-Light-lf-sc-lgr.tfm \
tex-Junicode-Light-lf-sc-ly1--base.tfm \
tex-Junicode-Light-lf-sc-ly1.tfm \
tex-Junicode-Light-lf-sc-ly1.vf \
tex-Junicode-Light-lf-sc-ot1--base.tfm \
tex-Junicode-Light-lf-sc-ot1.tfm \
tex-Junicode-Light-lf-sc-ot1.vf \
tex-Junicode-Light-lf-sc-t1--base.tfm \
tex-Junicode-Light-lf-sc-t1.tfm \
tex-Junicode-Light-lf-sc-t1.vf \
tex-Junicode-Light-lf-t1--base.tfm \
tex-Junicode-Light-lf-t1.tfm \
tex-Junicode-Light-lf-t1.vf \
tex-Junicode-Light-lf-ts1--base.tfm \
tex-Junicode-Light-lf-ts1.tfm \
tex-Junicode-Light-lf-ts1.vf \
tex-Junicode-Light-osf-lgr.tfm \
tex-Junicode-Light-osf-ly1.tfm \
tex-Junicode-Light-osf-ot1.tfm \
tex-Junicode-Light-osf-sc-lgr.tfm \
tex-Junicode-Light-osf-sc-ly1--base.tfm \
tex-Junicode-Light-osf-sc-ly1.tfm \
tex-Junicode-Light-osf-sc-ly1.vf \
tex-Junicode-Light-osf-sc-ot1--base.tfm \
tex-Junicode-Light-osf-sc-ot1.tfm \
tex-Junicode-Light-osf-sc-ot1.vf \
tex-Junicode-Light-osf-sc-t1--base.tfm \
tex-Junicode-Light-osf-sc-t1.tfm \
tex-Junicode-Light-osf-sc-t1.vf \
tex-Junicode-Light-osf-t1--base.tfm \
tex-Junicode-Light-osf-t1.tfm \
tex-Junicode-Light-osf-t1.vf \
tex-Junicode-Light-osf-ts1--base.tfm \
tex-Junicode-Light-osf-ts1.tfm \
tex-Junicode-Light-osf-ts1.vf \
tex-Junicode-Light-sup-lgr.tfm \
tex-Junicode-Light-sup-ly1.tfm \
tex-Junicode-Light-sup-ot1.tfm \
tex-Junicode-Light-sup-t1--base.tfm \
tex-Junicode-Light-sup-t1.tfm \
tex-Junicode-Light-sup-t1.vf \
tex-Junicode-Light-tlf-lgr.tfm \
tex-Junicode-Light-tlf-ly1.tfm \
tex-Junicode-Light-tlf-ot1.tfm \
tex-Junicode-Light-tlf-sc-lgr.tfm \
tex-Junicode-Light-tlf-sc-ly1--base.tfm \
tex-Junicode-Light-tlf-sc-ly1.tfm \
tex-Junicode-Light-tlf-sc-ly1.vf \
tex-Junicode-Light-tlf-sc-ot1--base.tfm \
tex-Junicode-Light-tlf-sc-ot1.tfm \
tex-Junicode-Light-tlf-sc-ot1.vf \
tex-Junicode-Light-tlf-sc-t1--base.tfm \
tex-Junicode-Light-tlf-sc-t1.tfm \
tex-Junicode-Light-tlf-sc-t1.vf \
tex-Junicode-Light-tlf-t1--base.tfm \
tex-Junicode-Light-tlf-t1.tfm \
tex-Junicode-Light-tlf-t1.vf \
tex-Junicode-Light-tlf-ts1--base.tfm \
tex-Junicode-Light-tlf-ts1.tfm \
tex-Junicode-Light-tlf-ts1.vf \
tex-Junicode-Light-tosf-lgr.tfm \
tex-Junicode-Light-tosf-ly1.tfm \
tex-Junicode-Light-tosf-ot1.tfm \
tex-Junicode-Light-tosf-sc-lgr.tfm \
tex-Junicode-Light-tosf-sc-ly1--base.tfm \
tex-Junicode-Light-tosf-sc-ly1.tfm \
tex-Junicode-Light-tosf-sc-ly1.vf \
tex-Junicode-Light-tosf-sc-ot1--base.tfm \
tex-Junicode-Light-tosf-sc-ot1.tfm \
tex-Junicode-Light-tosf-sc-ot1.vf \
tex-Junicode-Light-tosf-sc-t1--base.tfm \
tex-Junicode-Light-tosf-sc-t1.tfm \
tex-Junicode-Light-tosf-sc-t1.vf \
tex-Junicode-Light-tosf-t1--base.tfm \
tex-Junicode-Light-tosf-t1.tfm \
tex-Junicode-Light-tosf-t1.vf \
tex-Junicode-Light-tosf-ts1--base.tfm \
tex-Junicode-Light-tosf-ts1.tfm \
tex-Junicode-Light-tosf-ts1.vf \
tex-Junicode-LightItalic-inf-lgr.tfm \
tex-Junicode-LightItalic-inf-ly1.tfm \
tex-Junicode-LightItalic-inf-ot1.tfm \
tex-Junicode-LightItalic-inf-t1--base.tfm \
tex-Junicode-LightItalic-inf-t1.tfm \
tex-Junicode-LightItalic-inf-t1.vf \
tex-Junicode-LightItalic-lf-lgr.tfm \
tex-Junicode-LightItalic-lf-ly1.tfm \
tex-Junicode-LightItalic-lf-ot1.tfm \
tex-Junicode-LightItalic-lf-sc-lgr.tfm \
tex-Junicode-LightItalic-lf-sc-ly1--base.tfm \
tex-Junicode-LightItalic-lf-sc-ly1.tfm \
tex-Junicode-LightItalic-lf-sc-ly1.vf \
tex-Junicode-LightItalic-lf-sc-ot1--base.tfm \
tex-Junicode-LightItalic-lf-sc-ot1.tfm \
tex-Junicode-LightItalic-lf-sc-ot1.vf \
tex-Junicode-LightItalic-lf-sc-t1--base.tfm \
tex-Junicode-LightItalic-lf-sc-t1.tfm \
tex-Junicode-LightItalic-lf-sc-t1.vf \
tex-Junicode-LightItalic-lf-t1--base.tfm \
tex-Junicode-LightItalic-lf-t1.tfm \
tex-Junicode-LightItalic-lf-t1.vf \
tex-Junicode-LightItalic-lf-ts1--base.tfm \
tex-Junicode-LightItalic-lf-ts1.tfm \
tex-Junicode-LightItalic-lf-ts1.vf \
tex-Junicode-LightItalic-osf-lgr.tfm \
tex-Junicode-LightItalic-osf-ly1.tfm \
tex-Junicode-LightItalic-osf-ot1.tfm \
tex-Junicode-LightItalic-osf-sc-lgr.tfm \
tex-Junicode-LightItalic-osf-sc-ly1--base.tfm \
tex-Junicode-LightItalic-osf-sc-ly1.tfm \
tex-Junicode-LightItalic-osf-sc-ly1.vf \
tex-Junicode-LightItalic-osf-sc-ot1--base.tfm \
tex-Junicode-LightItalic-osf-sc-ot1.tfm \
tex-Junicode-LightItalic-osf-sc-ot1.vf \
tex-Junicode-LightItalic-osf-sc-t1--base.tfm \
tex-Junicode-LightItalic-osf-sc-t1.tfm \
tex-Junicode-LightItalic-osf-sc-t1.vf \
tex-Junicode-LightItalic-osf-t1--base.tfm \
tex-Junicode-LightItalic-osf-t1.tfm \
tex-Junicode-LightItalic-osf-t1.vf \
tex-Junicode-LightItalic-osf-ts1--base.tfm \
tex-Junicode-LightItalic-osf-ts1.tfm \
tex-Junicode-LightItalic-osf-ts1.vf \
tex-Junicode-LightItalic-sup-lgr.tfm \
tex-Junicode-LightItalic-sup-ly1.tfm \
tex-Junicode-LightItalic-sup-ot1.tfm \
tex-Junicode-LightItalic-sup-t1--base.tfm \
tex-Junicode-LightItalic-sup-t1.tfm \
tex-Junicode-LightItalic-sup-t1.vf \
tex-Junicode-LightItalic-tlf-lgr.tfm \
tex-Junicode-LightItalic-tlf-ly1.tfm \
tex-Junicode-LightItalic-tlf-ot1.tfm \
tex-Junicode-LightItalic-tlf-sc-lgr.tfm \
tex-Junicode-LightItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-LightItalic-tlf-sc-ly1.tfm \
tex-Junicode-LightItalic-tlf-sc-ly1.vf \
tex-Junicode-LightItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-LightItalic-tlf-sc-ot1.tfm \
tex-Junicode-LightItalic-tlf-sc-ot1.vf \
tex-Junicode-LightItalic-tlf-sc-t1--base.tfm \
tex-Junicode-LightItalic-tlf-sc-t1.tfm \
tex-Junicode-LightItalic-tlf-sc-t1.vf \
tex-Junicode-LightItalic-tlf-t1--base.tfm \
tex-Junicode-LightItalic-tlf-t1.tfm \
tex-Junicode-LightItalic-tlf-t1.vf \
tex-Junicode-LightItalic-tlf-ts1--base.tfm \
tex-Junicode-LightItalic-tlf-ts1.tfm \
tex-Junicode-LightItalic-tlf-ts1.vf \
tex-Junicode-LightItalic-tosf-lgr.tfm \
tex-Junicode-LightItalic-tosf-ly1.tfm \
tex-Junicode-LightItalic-tosf-ot1.tfm \
tex-Junicode-LightItalic-tosf-sc-lgr.tfm \
tex-Junicode-LightItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-LightItalic-tosf-sc-ly1.tfm \
tex-Junicode-LightItalic-tosf-sc-ly1.vf \
tex-Junicode-LightItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-LightItalic-tosf-sc-ot1.tfm \
tex-Junicode-LightItalic-tosf-sc-ot1.vf \
tex-Junicode-LightItalic-tosf-sc-t1--base.tfm \
tex-Junicode-LightItalic-tosf-sc-t1.tfm \
tex-Junicode-LightItalic-tosf-sc-t1.vf \
tex-Junicode-LightItalic-tosf-t1--base.tfm \
tex-Junicode-LightItalic-tosf-t1.tfm \
tex-Junicode-LightItalic-tosf-t1.vf \
tex-Junicode-LightItalic-tosf-ts1--base.tfm \
tex-Junicode-LightItalic-tosf-ts1.tfm \
tex-Junicode-LightItalic-tosf-ts1.vf \
tex-Junicode-Medium-inf-lgr.tfm \
tex-Junicode-Medium-inf-ly1.tfm \
tex-Junicode-Medium-inf-ot1.tfm \
tex-Junicode-Medium-inf-t1--base.tfm \
tex-Junicode-Medium-inf-t1.tfm \
tex-Junicode-Medium-inf-t1.vf \
tex-Junicode-Medium-lf-lgr.tfm \
tex-Junicode-Medium-lf-ly1.tfm \
tex-Junicode-Medium-lf-ot1.tfm \
tex-Junicode-Medium-lf-sc-lgr.tfm \
tex-Junicode-Medium-lf-sc-ly1--base.tfm \
tex-Junicode-Medium-lf-sc-ly1.tfm \
tex-Junicode-Medium-lf-sc-ly1.vf \
tex-Junicode-Medium-lf-sc-ot1--base.tfm \
tex-Junicode-Medium-lf-sc-ot1.tfm \
tex-Junicode-Medium-lf-sc-ot1.vf \
tex-Junicode-Medium-lf-sc-t1--base.tfm \
tex-Junicode-Medium-lf-sc-t1.tfm \
tex-Junicode-Medium-lf-sc-t1.vf \
tex-Junicode-Medium-lf-t1--base.tfm \
tex-Junicode-Medium-lf-t1.tfm \
tex-Junicode-Medium-lf-t1.vf \
tex-Junicode-Medium-lf-ts1--base.tfm \
tex-Junicode-Medium-lf-ts1.tfm \
tex-Junicode-Medium-lf-ts1.vf \
tex-Junicode-Medium-osf-lgr.tfm \
tex-Junicode-Medium-osf-ly1.tfm \
tex-Junicode-Medium-osf-ot1.tfm \
tex-Junicode-Medium-osf-sc-lgr.tfm \
tex-Junicode-Medium-osf-sc-ly1--base.tfm \
tex-Junicode-Medium-osf-sc-ly1.tfm \
tex-Junicode-Medium-osf-sc-ly1.vf \
tex-Junicode-Medium-osf-sc-ot1--base.tfm \
tex-Junicode-Medium-osf-sc-ot1.tfm \
tex-Junicode-Medium-osf-sc-ot1.vf \
tex-Junicode-Medium-osf-sc-t1--base.tfm \
tex-Junicode-Medium-osf-sc-t1.tfm \
tex-Junicode-Medium-osf-sc-t1.vf \
tex-Junicode-Medium-osf-t1--base.tfm \
tex-Junicode-Medium-osf-t1.tfm \
tex-Junicode-Medium-osf-t1.vf \
tex-Junicode-Medium-osf-ts1--base.tfm \
tex-Junicode-Medium-osf-ts1.tfm \
tex-Junicode-Medium-osf-ts1.vf \
tex-Junicode-Medium-sup-lgr.tfm \
tex-Junicode-Medium-sup-ly1.tfm \
tex-Junicode-Medium-sup-ot1.tfm \
tex-Junicode-Medium-sup-t1--base.tfm \
tex-Junicode-Medium-sup-t1.tfm \
tex-Junicode-Medium-sup-t1.vf \
tex-Junicode-Medium-tlf-lgr.tfm \
tex-Junicode-Medium-tlf-ly1.tfm \
tex-Junicode-Medium-tlf-ot1.tfm \
tex-Junicode-Medium-tlf-sc-lgr.tfm \
tex-Junicode-Medium-tlf-sc-ly1--base.tfm \
tex-Junicode-Medium-tlf-sc-ly1.tfm \
tex-Junicode-Medium-tlf-sc-ly1.vf \
tex-Junicode-Medium-tlf-sc-ot1--base.tfm \
tex-Junicode-Medium-tlf-sc-ot1.tfm \
tex-Junicode-Medium-tlf-sc-ot1.vf \
tex-Junicode-Medium-tlf-sc-t1--base.tfm \
tex-Junicode-Medium-tlf-sc-t1.tfm \
tex-Junicode-Medium-tlf-sc-t1.vf \
tex-Junicode-Medium-tlf-t1--base.tfm \
tex-Junicode-Medium-tlf-t1.tfm \
tex-Junicode-Medium-tlf-t1.vf \
tex-Junicode-Medium-tlf-ts1--base.tfm \
tex-Junicode-Medium-tlf-ts1.tfm \
tex-Junicode-Medium-tlf-ts1.vf \
tex-Junicode-Medium-tosf-lgr.tfm \
tex-Junicode-Medium-tosf-ly1.tfm \
tex-Junicode-Medium-tosf-ot1.tfm \
tex-Junicode-Medium-tosf-sc-lgr.tfm \
tex-Junicode-Medium-tosf-sc-ly1--base.tfm \
tex-Junicode-Medium-tosf-sc-ly1.tfm \
tex-Junicode-Medium-tosf-sc-ly1.vf \
tex-Junicode-Medium-tosf-sc-ot1--base.tfm \
tex-Junicode-Medium-tosf-sc-ot1.tfm \
tex-Junicode-Medium-tosf-sc-ot1.vf \
tex-Junicode-Medium-tosf-sc-t1--base.tfm \
tex-Junicode-Medium-tosf-sc-t1.tfm \
tex-Junicode-Medium-tosf-sc-t1.vf \
tex-Junicode-Medium-tosf-t1--base.tfm \
tex-Junicode-Medium-tosf-t1.tfm \
tex-Junicode-Medium-tosf-t1.vf \
tex-Junicode-Medium-tosf-ts1--base.tfm \
tex-Junicode-Medium-tosf-ts1.tfm \
tex-Junicode-Medium-tosf-ts1.vf \
tex-Junicode-MediumItalic-inf-lgr.tfm \
tex-Junicode-MediumItalic-inf-ly1.tfm \
tex-Junicode-MediumItalic-inf-ot1.tfm \
tex-Junicode-MediumItalic-inf-t1--base.tfm \
tex-Junicode-MediumItalic-inf-t1.tfm \
tex-Junicode-MediumItalic-inf-t1.vf \
tex-Junicode-MediumItalic-lf-lgr.tfm \
tex-Junicode-MediumItalic-lf-ly1.tfm \
tex-Junicode-MediumItalic-lf-ot1.tfm \
tex-Junicode-MediumItalic-lf-sc-lgr.tfm \
tex-Junicode-MediumItalic-lf-sc-ly1--base.tfm \
tex-Junicode-MediumItalic-lf-sc-ly1.tfm \
tex-Junicode-MediumItalic-lf-sc-ly1.vf \
tex-Junicode-MediumItalic-lf-sc-ot1--base.tfm \
tex-Junicode-MediumItalic-lf-sc-ot1.tfm \
tex-Junicode-MediumItalic-lf-sc-ot1.vf \
tex-Junicode-MediumItalic-lf-sc-t1--base.tfm \
tex-Junicode-MediumItalic-lf-sc-t1.tfm \
tex-Junicode-MediumItalic-lf-sc-t1.vf \
tex-Junicode-MediumItalic-lf-t1--base.tfm \
tex-Junicode-MediumItalic-lf-t1.tfm \
tex-Junicode-MediumItalic-lf-t1.vf \
tex-Junicode-MediumItalic-lf-ts1--base.tfm \
tex-Junicode-MediumItalic-lf-ts1.tfm \
tex-Junicode-MediumItalic-lf-ts1.vf \
tex-Junicode-MediumItalic-osf-lgr.tfm \
tex-Junicode-MediumItalic-osf-ly1.tfm \
tex-Junicode-MediumItalic-osf-ot1.tfm \
tex-Junicode-MediumItalic-osf-sc-lgr.tfm \
tex-Junicode-MediumItalic-osf-sc-ly1--base.tfm \
tex-Junicode-MediumItalic-osf-sc-ly1.tfm \
tex-Junicode-MediumItalic-osf-sc-ly1.vf \
tex-Junicode-MediumItalic-osf-sc-ot1--base.tfm \
tex-Junicode-MediumItalic-osf-sc-ot1.tfm \
tex-Junicode-MediumItalic-osf-sc-ot1.vf \
tex-Junicode-MediumItalic-osf-sc-t1--base.tfm \
tex-Junicode-MediumItalic-osf-sc-t1.tfm \
tex-Junicode-MediumItalic-osf-sc-t1.vf \
tex-Junicode-MediumItalic-osf-t1--base.tfm \
tex-Junicode-MediumItalic-osf-t1.tfm \
tex-Junicode-MediumItalic-osf-t1.vf \
tex-Junicode-MediumItalic-osf-ts1--base.tfm \
tex-Junicode-MediumItalic-osf-ts1.tfm \
tex-Junicode-MediumItalic-osf-ts1.vf \
tex-Junicode-MediumItalic-sup-lgr.tfm \
tex-Junicode-MediumItalic-sup-ly1.tfm \
tex-Junicode-MediumItalic-sup-ot1.tfm \
tex-Junicode-MediumItalic-sup-t1--base.tfm \
tex-Junicode-MediumItalic-sup-t1.tfm \
tex-Junicode-MediumItalic-sup-t1.vf \
tex-Junicode-MediumItalic-tlf-lgr.tfm \
tex-Junicode-MediumItalic-tlf-ly1.tfm \
tex-Junicode-MediumItalic-tlf-ot1.tfm \
tex-Junicode-MediumItalic-tlf-sc-lgr.tfm \
tex-Junicode-MediumItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-MediumItalic-tlf-sc-ly1.tfm \
tex-Junicode-MediumItalic-tlf-sc-ly1.vf \
tex-Junicode-MediumItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-MediumItalic-tlf-sc-ot1.tfm \
tex-Junicode-MediumItalic-tlf-sc-ot1.vf \
tex-Junicode-MediumItalic-tlf-sc-t1--base.tfm \
tex-Junicode-MediumItalic-tlf-sc-t1.tfm \
tex-Junicode-MediumItalic-tlf-sc-t1.vf \
tex-Junicode-MediumItalic-tlf-t1--base.tfm \
tex-Junicode-MediumItalic-tlf-t1.tfm \
tex-Junicode-MediumItalic-tlf-t1.vf \
tex-Junicode-MediumItalic-tlf-ts1--base.tfm \
tex-Junicode-MediumItalic-tlf-ts1.tfm \
tex-Junicode-MediumItalic-tlf-ts1.vf \
tex-Junicode-MediumItalic-tosf-lgr.tfm \
tex-Junicode-MediumItalic-tosf-ly1.tfm \
tex-Junicode-MediumItalic-tosf-ot1.tfm \
tex-Junicode-MediumItalic-tosf-sc-lgr.tfm \
tex-Junicode-MediumItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-MediumItalic-tosf-sc-ly1.tfm \
tex-Junicode-MediumItalic-tosf-sc-ly1.vf \
tex-Junicode-MediumItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-MediumItalic-tosf-sc-ot1.tfm \
tex-Junicode-MediumItalic-tosf-sc-ot1.vf \
tex-Junicode-MediumItalic-tosf-sc-t1--base.tfm \
tex-Junicode-MediumItalic-tosf-sc-t1.tfm \
tex-Junicode-MediumItalic-tosf-sc-t1.vf \
tex-Junicode-MediumItalic-tosf-t1--base.tfm \
tex-Junicode-MediumItalic-tosf-t1.tfm \
tex-Junicode-MediumItalic-tosf-t1.vf \
tex-Junicode-MediumItalic-tosf-ts1--base.tfm \
tex-Junicode-MediumItalic-tosf-ts1.tfm \
tex-Junicode-MediumItalic-tosf-ts1.vf \
tex-Junicode-Regular-inf-lgr.tfm \
tex-Junicode-Regular-inf-ly1.tfm \
tex-Junicode-Regular-inf-ot1.tfm \
tex-Junicode-Regular-inf-t1--base.tfm \
tex-Junicode-Regular-inf-t1.tfm \
tex-Junicode-Regular-inf-t1.vf \
tex-Junicode-Regular-lf-lgr.tfm \
tex-Junicode-Regular-lf-ly1.tfm \
tex-Junicode-Regular-lf-ot1.tfm \
tex-Junicode-Regular-lf-sc-lgr.tfm \
tex-Junicode-Regular-lf-sc-ly1--base.tfm \
tex-Junicode-Regular-lf-sc-ly1.tfm \
tex-Junicode-Regular-lf-sc-ly1.vf \
tex-Junicode-Regular-lf-sc-ot1--base.tfm \
tex-Junicode-Regular-lf-sc-ot1.tfm \
tex-Junicode-Regular-lf-sc-ot1.vf \
tex-Junicode-Regular-lf-sc-t1--base.tfm \
tex-Junicode-Regular-lf-sc-t1.tfm \
tex-Junicode-Regular-lf-sc-t1.vf \
tex-Junicode-Regular-lf-t1--base.tfm \
tex-Junicode-Regular-lf-t1.tfm \
tex-Junicode-Regular-lf-t1.vf \
tex-Junicode-Regular-lf-ts1--base.tfm \
tex-Junicode-Regular-lf-ts1.tfm \
tex-Junicode-Regular-lf-ts1.vf \
tex-Junicode-Regular-osf-lgr.tfm \
tex-Junicode-Regular-osf-ly1.tfm \
tex-Junicode-Regular-osf-ot1.tfm \
tex-Junicode-Regular-osf-sc-lgr.tfm \
tex-Junicode-Regular-osf-sc-ly1--base.tfm \
tex-Junicode-Regular-osf-sc-ly1.tfm \
tex-Junicode-Regular-osf-sc-ly1.vf \
tex-Junicode-Regular-osf-sc-ot1--base.tfm \
tex-Junicode-Regular-osf-sc-ot1.tfm \
tex-Junicode-Regular-osf-sc-ot1.vf \
tex-Junicode-Regular-osf-sc-t1--base.tfm \
tex-Junicode-Regular-osf-sc-t1.tfm \
tex-Junicode-Regular-osf-sc-t1.vf \
tex-Junicode-Regular-osf-t1--base.tfm \
tex-Junicode-Regular-osf-t1.tfm \
tex-Junicode-Regular-osf-t1.vf \
tex-Junicode-Regular-osf-ts1--base.tfm \
tex-Junicode-Regular-osf-ts1.tfm \
tex-Junicode-Regular-osf-ts1.vf \
tex-Junicode-Regular-sup-lgr.tfm \
tex-Junicode-Regular-sup-ly1.tfm \
tex-Junicode-Regular-sup-ot1.tfm \
tex-Junicode-Regular-sup-t1--base.tfm \
tex-Junicode-Regular-sup-t1.tfm \
tex-Junicode-Regular-sup-t1.vf \
tex-Junicode-Regular-tlf-lgr.tfm \
tex-Junicode-Regular-tlf-ly1.tfm \
tex-Junicode-Regular-tlf-ot1.tfm \
tex-Junicode-Regular-tlf-sc-lgr.tfm \
tex-Junicode-Regular-tlf-sc-ly1--base.tfm \
tex-Junicode-Regular-tlf-sc-ly1.tfm \
tex-Junicode-Regular-tlf-sc-ly1.vf \
tex-Junicode-Regular-tlf-sc-ot1--base.tfm \
tex-Junicode-Regular-tlf-sc-ot1.tfm \
tex-Junicode-Regular-tlf-sc-ot1.vf \
tex-Junicode-Regular-tlf-sc-t1--base.tfm \
tex-Junicode-Regular-tlf-sc-t1.tfm \
tex-Junicode-Regular-tlf-sc-t1.vf \
tex-Junicode-Regular-tlf-t1--base.tfm \
tex-Junicode-Regular-tlf-t1.tfm \
tex-Junicode-Regular-tlf-t1.vf \
tex-Junicode-Regular-tlf-ts1--base.tfm \
tex-Junicode-Regular-tlf-ts1.tfm \
tex-Junicode-Regular-tlf-ts1.vf \
tex-Junicode-Regular-tosf-lgr.tfm \
tex-Junicode-Regular-tosf-ly1.tfm \
tex-Junicode-Regular-tosf-ot1.tfm \
tex-Junicode-Regular-tosf-sc-lgr.tfm \
tex-Junicode-Regular-tosf-sc-ly1--base.tfm \
tex-Junicode-Regular-tosf-sc-ly1.tfm \
tex-Junicode-Regular-tosf-sc-ly1.vf \
tex-Junicode-Regular-tosf-sc-ot1--base.tfm \
tex-Junicode-Regular-tosf-sc-ot1.tfm \
tex-Junicode-Regular-tosf-sc-ot1.vf \
tex-Junicode-Regular-tosf-sc-t1--base.tfm \
tex-Junicode-Regular-tosf-sc-t1.tfm \
tex-Junicode-Regular-tosf-sc-t1.vf \
tex-Junicode-Regular-tosf-t1--base.tfm \
tex-Junicode-Regular-tosf-t1.tfm \
tex-Junicode-Regular-tosf-t1.vf \
tex-Junicode-Regular-tosf-ts1--base.tfm \
tex-Junicode-Regular-tosf-ts1.tfm \
tex-Junicode-Regular-tosf-ts1.vf \
tex-Junicode-SmBold-inf-lgr.tfm \
tex-Junicode-SmBold-inf-ly1.tfm \
tex-Junicode-SmBold-inf-ot1.tfm \
tex-Junicode-SmBold-inf-t1--base.tfm \
tex-Junicode-SmBold-inf-t1.tfm \
tex-Junicode-SmBold-inf-t1.vf \
tex-Junicode-SmBold-lf-lgr.tfm \
tex-Junicode-SmBold-lf-ly1.tfm \
tex-Junicode-SmBold-lf-ot1.tfm \
tex-Junicode-SmBold-lf-sc-lgr.tfm \
tex-Junicode-SmBold-lf-sc-ly1--base.tfm \
tex-Junicode-SmBold-lf-sc-ly1.tfm \
tex-Junicode-SmBold-lf-sc-ly1.vf \
tex-Junicode-SmBold-lf-sc-ot1--base.tfm \
tex-Junicode-SmBold-lf-sc-ot1.tfm \
tex-Junicode-SmBold-lf-sc-ot1.vf \
tex-Junicode-SmBold-lf-sc-t1--base.tfm \
tex-Junicode-SmBold-lf-sc-t1.tfm \
tex-Junicode-SmBold-lf-sc-t1.vf \
tex-Junicode-SmBold-lf-t1--base.tfm \
tex-Junicode-SmBold-lf-t1.tfm \
tex-Junicode-SmBold-lf-t1.vf \
tex-Junicode-SmBold-lf-ts1--base.tfm \
tex-Junicode-SmBold-lf-ts1.tfm \
tex-Junicode-SmBold-lf-ts1.vf \
tex-Junicode-SmBold-osf-lgr.tfm \
tex-Junicode-SmBold-osf-ly1.tfm \
tex-Junicode-SmBold-osf-ot1.tfm \
tex-Junicode-SmBold-osf-sc-lgr.tfm \
tex-Junicode-SmBold-osf-sc-ly1--base.tfm \
tex-Junicode-SmBold-osf-sc-ly1.tfm \
tex-Junicode-SmBold-osf-sc-ly1.vf \
tex-Junicode-SmBold-osf-sc-ot1--base.tfm \
tex-Junicode-SmBold-osf-sc-ot1.tfm \
tex-Junicode-SmBold-osf-sc-ot1.vf \
tex-Junicode-SmBold-osf-sc-t1--base.tfm \
tex-Junicode-SmBold-osf-sc-t1.tfm \
tex-Junicode-SmBold-osf-sc-t1.vf \
tex-Junicode-SmBold-osf-t1--base.tfm \
tex-Junicode-SmBold-osf-t1.tfm \
tex-Junicode-SmBold-osf-t1.vf \
tex-Junicode-SmBold-osf-ts1--base.tfm \
tex-Junicode-SmBold-osf-ts1.tfm \
tex-Junicode-SmBold-osf-ts1.vf \
tex-Junicode-SmBold-sup-lgr.tfm \
tex-Junicode-SmBold-sup-ly1.tfm \
tex-Junicode-SmBold-sup-ot1.tfm \
tex-Junicode-SmBold-sup-t1--base.tfm \
tex-Junicode-SmBold-sup-t1.tfm \
tex-Junicode-SmBold-sup-t1.vf \
tex-Junicode-SmBold-tlf-lgr.tfm \
tex-Junicode-SmBold-tlf-ly1.tfm \
tex-Junicode-SmBold-tlf-ot1.tfm \
tex-Junicode-SmBold-tlf-sc-lgr.tfm \
tex-Junicode-SmBold-tlf-sc-ly1--base.tfm \
tex-Junicode-SmBold-tlf-sc-ly1.tfm \
tex-Junicode-SmBold-tlf-sc-ly1.vf \
tex-Junicode-SmBold-tlf-sc-ot1--base.tfm \
tex-Junicode-SmBold-tlf-sc-ot1.tfm \
tex-Junicode-SmBold-tlf-sc-ot1.vf \
tex-Junicode-SmBold-tlf-sc-t1--base.tfm \
tex-Junicode-SmBold-tlf-sc-t1.tfm \
tex-Junicode-SmBold-tlf-sc-t1.vf \
tex-Junicode-SmBold-tlf-t1--base.tfm \
tex-Junicode-SmBold-tlf-t1.tfm \
tex-Junicode-SmBold-tlf-t1.vf \
tex-Junicode-SmBold-tlf-ts1--base.tfm \
tex-Junicode-SmBold-tlf-ts1.tfm \
tex-Junicode-SmBold-tlf-ts1.vf \
tex-Junicode-SmBold-tosf-lgr.tfm \
tex-Junicode-SmBold-tosf-ly1.tfm \
tex-Junicode-SmBold-tosf-ot1.tfm \
tex-Junicode-SmBold-tosf-sc-lgr.tfm \
tex-Junicode-SmBold-tosf-sc-ly1--base.tfm \
tex-Junicode-SmBold-tosf-sc-ly1.tfm \
tex-Junicode-SmBold-tosf-sc-ly1.vf \
tex-Junicode-SmBold-tosf-sc-ot1--base.tfm \
tex-Junicode-SmBold-tosf-sc-ot1.tfm \
tex-Junicode-SmBold-tosf-sc-ot1.vf \
tex-Junicode-SmBold-tosf-sc-t1--base.tfm \
tex-Junicode-SmBold-tosf-sc-t1.tfm \
tex-Junicode-SmBold-tosf-sc-t1.vf \
tex-Junicode-SmBold-tosf-t1--base.tfm \
tex-Junicode-SmBold-tosf-t1.tfm \
tex-Junicode-SmBold-tosf-t1.vf \
tex-Junicode-SmBold-tosf-ts1--base.tfm \
tex-Junicode-SmBold-tosf-ts1.tfm \
tex-Junicode-SmBold-tosf-ts1.vf \
tex-Junicode-SmBoldItalic-inf-lgr.tfm \
tex-Junicode-SmBoldItalic-inf-ly1.tfm \
tex-Junicode-SmBoldItalic-inf-ot1.tfm \
tex-Junicode-SmBoldItalic-inf-t1--base.tfm \
tex-Junicode-SmBoldItalic-inf-t1.tfm \
tex-Junicode-SmBoldItalic-inf-t1.vf \
tex-Junicode-SmBoldItalic-lf-lgr.tfm \
tex-Junicode-SmBoldItalic-lf-ly1.tfm \
tex-Junicode-SmBoldItalic-lf-ot1.tfm \
tex-Junicode-SmBoldItalic-lf-sc-lgr.tfm \
tex-Junicode-SmBoldItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmBoldItalic-lf-sc-ly1.tfm \
tex-Junicode-SmBoldItalic-lf-sc-ly1.vf \
tex-Junicode-SmBoldItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmBoldItalic-lf-sc-ot1.tfm \
tex-Junicode-SmBoldItalic-lf-sc-ot1.vf \
tex-Junicode-SmBoldItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmBoldItalic-lf-sc-t1.tfm \
tex-Junicode-SmBoldItalic-lf-sc-t1.vf \
tex-Junicode-SmBoldItalic-lf-t1--base.tfm \
tex-Junicode-SmBoldItalic-lf-t1.tfm \
tex-Junicode-SmBoldItalic-lf-t1.vf \
tex-Junicode-SmBoldItalic-lf-ts1--base.tfm \
tex-Junicode-SmBoldItalic-lf-ts1.tfm \
tex-Junicode-SmBoldItalic-lf-ts1.vf \
tex-Junicode-SmBoldItalic-osf-lgr.tfm \
tex-Junicode-SmBoldItalic-osf-ly1.tfm \
tex-Junicode-SmBoldItalic-osf-ot1.tfm \
tex-Junicode-SmBoldItalic-osf-sc-lgr.tfm \
tex-Junicode-SmBoldItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmBoldItalic-osf-sc-ly1.tfm \
tex-Junicode-SmBoldItalic-osf-sc-ly1.vf \
tex-Junicode-SmBoldItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmBoldItalic-osf-sc-ot1.tfm \
tex-Junicode-SmBoldItalic-osf-sc-ot1.vf \
tex-Junicode-SmBoldItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmBoldItalic-osf-sc-t1.tfm \
tex-Junicode-SmBoldItalic-osf-sc-t1.vf \
tex-Junicode-SmBoldItalic-osf-t1--base.tfm \
tex-Junicode-SmBoldItalic-osf-t1.tfm \
tex-Junicode-SmBoldItalic-osf-t1.vf \
tex-Junicode-SmBoldItalic-osf-ts1--base.tfm \
tex-Junicode-SmBoldItalic-osf-ts1.tfm \
tex-Junicode-SmBoldItalic-osf-ts1.vf \
tex-Junicode-SmBoldItalic-sup-lgr.tfm \
tex-Junicode-SmBoldItalic-sup-ly1.tfm \
tex-Junicode-SmBoldItalic-sup-ot1.tfm \
tex-Junicode-SmBoldItalic-sup-t1--base.tfm \
tex-Junicode-SmBoldItalic-sup-t1.tfm \
tex-Junicode-SmBoldItalic-sup-t1.vf \
tex-Junicode-SmBoldItalic-tlf-lgr.tfm \
tex-Junicode-SmBoldItalic-tlf-ly1.tfm \
tex-Junicode-SmBoldItalic-tlf-ot1.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-ly1.vf \
tex-Junicode-SmBoldItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-ot1.vf \
tex-Junicode-SmBoldItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-t1.tfm \
tex-Junicode-SmBoldItalic-tlf-sc-t1.vf \
tex-Junicode-SmBoldItalic-tlf-t1--base.tfm \
tex-Junicode-SmBoldItalic-tlf-t1.tfm \
tex-Junicode-SmBoldItalic-tlf-t1.vf \
tex-Junicode-SmBoldItalic-tlf-ts1--base.tfm \
tex-Junicode-SmBoldItalic-tlf-ts1.tfm \
tex-Junicode-SmBoldItalic-tlf-ts1.vf \
tex-Junicode-SmBoldItalic-tosf-lgr.tfm \
tex-Junicode-SmBoldItalic-tosf-ly1.tfm \
tex-Junicode-SmBoldItalic-tosf-ot1.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-ly1.vf \
tex-Junicode-SmBoldItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-ot1.vf \
tex-Junicode-SmBoldItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-t1.tfm \
tex-Junicode-SmBoldItalic-tosf-sc-t1.vf \
tex-Junicode-SmBoldItalic-tosf-t1--base.tfm \
tex-Junicode-SmBoldItalic-tosf-t1.tfm \
tex-Junicode-SmBoldItalic-tosf-t1.vf \
tex-Junicode-SmBoldItalic-tosf-ts1--base.tfm \
tex-Junicode-SmBoldItalic-tosf-ts1.tfm \
tex-Junicode-SmBoldItalic-tosf-ts1.vf \
tex-Junicode-SmCond-inf-lgr.tfm \
tex-Junicode-SmCond-inf-ly1.tfm \
tex-Junicode-SmCond-inf-ot1.tfm \
tex-Junicode-SmCond-inf-t1--base.tfm \
tex-Junicode-SmCond-inf-t1.tfm \
tex-Junicode-SmCond-inf-t1.vf \
tex-Junicode-SmCond-lf-lgr.tfm \
tex-Junicode-SmCond-lf-ly1.tfm \
tex-Junicode-SmCond-lf-ot1.tfm \
tex-Junicode-SmCond-lf-sc-lgr.tfm \
tex-Junicode-SmCond-lf-sc-ly1--base.tfm \
tex-Junicode-SmCond-lf-sc-ly1.tfm \
tex-Junicode-SmCond-lf-sc-ly1.vf \
tex-Junicode-SmCond-lf-sc-ot1--base.tfm \
tex-Junicode-SmCond-lf-sc-ot1.tfm \
tex-Junicode-SmCond-lf-sc-ot1.vf \
tex-Junicode-SmCond-lf-sc-t1--base.tfm \
tex-Junicode-SmCond-lf-sc-t1.tfm \
tex-Junicode-SmCond-lf-sc-t1.vf \
tex-Junicode-SmCond-lf-t1--base.tfm \
tex-Junicode-SmCond-lf-t1.tfm \
tex-Junicode-SmCond-lf-t1.vf \
tex-Junicode-SmCond-lf-ts1--base.tfm \
tex-Junicode-SmCond-lf-ts1.tfm \
tex-Junicode-SmCond-lf-ts1.vf \
tex-Junicode-SmCond-osf-lgr.tfm \
tex-Junicode-SmCond-osf-ly1.tfm \
tex-Junicode-SmCond-osf-ot1.tfm \
tex-Junicode-SmCond-osf-sc-lgr.tfm \
tex-Junicode-SmCond-osf-sc-ly1--base.tfm \
tex-Junicode-SmCond-osf-sc-ly1.tfm \
tex-Junicode-SmCond-osf-sc-ly1.vf \
tex-Junicode-SmCond-osf-sc-ot1--base.tfm \
tex-Junicode-SmCond-osf-sc-ot1.tfm \
tex-Junicode-SmCond-osf-sc-ot1.vf \
tex-Junicode-SmCond-osf-sc-t1--base.tfm \
tex-Junicode-SmCond-osf-sc-t1.tfm \
tex-Junicode-SmCond-osf-sc-t1.vf \
tex-Junicode-SmCond-osf-t1--base.tfm \
tex-Junicode-SmCond-osf-t1.tfm \
tex-Junicode-SmCond-osf-t1.vf \
tex-Junicode-SmCond-osf-ts1--base.tfm \
tex-Junicode-SmCond-osf-ts1.tfm \
tex-Junicode-SmCond-osf-ts1.vf \
tex-Junicode-SmCond-sup-lgr.tfm \
tex-Junicode-SmCond-sup-ly1.tfm \
tex-Junicode-SmCond-sup-ot1.tfm \
tex-Junicode-SmCond-sup-t1--base.tfm \
tex-Junicode-SmCond-sup-t1.tfm \
tex-Junicode-SmCond-sup-t1.vf \
tex-Junicode-SmCond-tlf-lgr.tfm \
tex-Junicode-SmCond-tlf-ly1.tfm \
tex-Junicode-SmCond-tlf-ot1.tfm \
tex-Junicode-SmCond-tlf-sc-lgr.tfm \
tex-Junicode-SmCond-tlf-sc-ly1--base.tfm \
tex-Junicode-SmCond-tlf-sc-ly1.tfm \
tex-Junicode-SmCond-tlf-sc-ly1.vf \
tex-Junicode-SmCond-tlf-sc-ot1--base.tfm \
tex-Junicode-SmCond-tlf-sc-ot1.tfm \
tex-Junicode-SmCond-tlf-sc-ot1.vf \
tex-Junicode-SmCond-tlf-sc-t1--base.tfm \
tex-Junicode-SmCond-tlf-sc-t1.tfm \
tex-Junicode-SmCond-tlf-sc-t1.vf \
tex-Junicode-SmCond-tlf-t1--base.tfm \
tex-Junicode-SmCond-tlf-t1.tfm \
tex-Junicode-SmCond-tlf-t1.vf \
tex-Junicode-SmCond-tlf-ts1--base.tfm \
tex-Junicode-SmCond-tlf-ts1.tfm \
tex-Junicode-SmCond-tlf-ts1.vf \
tex-Junicode-SmCond-tosf-lgr.tfm \
tex-Junicode-SmCond-tosf-ly1.tfm \
tex-Junicode-SmCond-tosf-ot1.tfm \
tex-Junicode-SmCond-tosf-sc-lgr.tfm \
tex-Junicode-SmCond-tosf-sc-ly1--base.tfm \
tex-Junicode-SmCond-tosf-sc-ly1.tfm \
tex-Junicode-SmCond-tosf-sc-ly1.vf \
tex-Junicode-SmCond-tosf-sc-ot1--base.tfm \
tex-Junicode-SmCond-tosf-sc-ot1.tfm \
tex-Junicode-SmCond-tosf-sc-ot1.vf \
tex-Junicode-SmCond-tosf-sc-t1--base.tfm \
tex-Junicode-SmCond-tosf-sc-t1.tfm \
tex-Junicode-SmCond-tosf-sc-t1.vf \
tex-Junicode-SmCond-tosf-t1--base.tfm \
tex-Junicode-SmCond-tosf-t1.tfm \
tex-Junicode-SmCond-tosf-t1.vf \
tex-Junicode-SmCond-tosf-ts1--base.tfm \
tex-Junicode-SmCond-tosf-ts1.tfm \
tex-Junicode-SmCond-tosf-ts1.vf \
tex-Junicode-SmCondItalic-inf-lgr.tfm \
tex-Junicode-SmCondItalic-inf-ly1.tfm \
tex-Junicode-SmCondItalic-inf-ot1.tfm \
tex-Junicode-SmCondItalic-inf-t1--base.tfm \
tex-Junicode-SmCondItalic-inf-t1.tfm \
tex-Junicode-SmCondItalic-inf-t1.vf \
tex-Junicode-SmCondItalic-lf-lgr.tfm \
tex-Junicode-SmCondItalic-lf-ly1.tfm \
tex-Junicode-SmCondItalic-lf-ot1.tfm \
tex-Junicode-SmCondItalic-lf-sc-lgr.tfm \
tex-Junicode-SmCondItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmCondItalic-lf-sc-ly1.tfm \
tex-Junicode-SmCondItalic-lf-sc-ly1.vf \
tex-Junicode-SmCondItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmCondItalic-lf-sc-ot1.tfm \
tex-Junicode-SmCondItalic-lf-sc-ot1.vf \
tex-Junicode-SmCondItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmCondItalic-lf-sc-t1.tfm \
tex-Junicode-SmCondItalic-lf-sc-t1.vf \
tex-Junicode-SmCondItalic-lf-t1--base.tfm \
tex-Junicode-SmCondItalic-lf-t1.tfm \
tex-Junicode-SmCondItalic-lf-t1.vf \
tex-Junicode-SmCondItalic-lf-ts1--base.tfm \
tex-Junicode-SmCondItalic-lf-ts1.tfm \
tex-Junicode-SmCondItalic-lf-ts1.vf \
tex-Junicode-SmCondItalic-osf-lgr.tfm \
tex-Junicode-SmCondItalic-osf-ly1.tfm \
tex-Junicode-SmCondItalic-osf-ot1.tfm \
tex-Junicode-SmCondItalic-osf-sc-lgr.tfm \
tex-Junicode-SmCondItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmCondItalic-osf-sc-ly1.tfm \
tex-Junicode-SmCondItalic-osf-sc-ly1.vf \
tex-Junicode-SmCondItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmCondItalic-osf-sc-ot1.tfm \
tex-Junicode-SmCondItalic-osf-sc-ot1.vf \
tex-Junicode-SmCondItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmCondItalic-osf-sc-t1.tfm \
tex-Junicode-SmCondItalic-osf-sc-t1.vf \
tex-Junicode-SmCondItalic-osf-t1--base.tfm \
tex-Junicode-SmCondItalic-osf-t1.tfm \
tex-Junicode-SmCondItalic-osf-t1.vf \
tex-Junicode-SmCondItalic-osf-ts1--base.tfm \
tex-Junicode-SmCondItalic-osf-ts1.tfm \
tex-Junicode-SmCondItalic-osf-ts1.vf \
tex-Junicode-SmCondItalic-sup-lgr.tfm \
tex-Junicode-SmCondItalic-sup-ly1.tfm \
tex-Junicode-SmCondItalic-sup-ot1.tfm \
tex-Junicode-SmCondItalic-sup-t1--base.tfm \
tex-Junicode-SmCondItalic-sup-t1.tfm \
tex-Junicode-SmCondItalic-sup-t1.vf \
tex-Junicode-SmCondItalic-tlf-lgr.tfm \
tex-Junicode-SmCondItalic-tlf-ly1.tfm \
tex-Junicode-SmCondItalic-tlf-ot1.tfm \
tex-Junicode-SmCondItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmCondItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmCondItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmCondItalic-tlf-sc-ly1.vf \
tex-Junicode-SmCondItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmCondItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmCondItalic-tlf-sc-ot1.vf \
tex-Junicode-SmCondItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmCondItalic-tlf-sc-t1.tfm \
tex-Junicode-SmCondItalic-tlf-sc-t1.vf \
tex-Junicode-SmCondItalic-tlf-t1--base.tfm \
tex-Junicode-SmCondItalic-tlf-t1.tfm \
tex-Junicode-SmCondItalic-tlf-t1.vf \
tex-Junicode-SmCondItalic-tlf-ts1--base.tfm \
tex-Junicode-SmCondItalic-tlf-ts1.tfm \
tex-Junicode-SmCondItalic-tlf-ts1.vf \
tex-Junicode-SmCondItalic-tosf-lgr.tfm \
tex-Junicode-SmCondItalic-tosf-ly1.tfm \
tex-Junicode-SmCondItalic-tosf-ot1.tfm \
tex-Junicode-SmCondItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmCondItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmCondItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmCondItalic-tosf-sc-ly1.vf \
tex-Junicode-SmCondItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmCondItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmCondItalic-tosf-sc-ot1.vf \
tex-Junicode-SmCondItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmCondItalic-tosf-sc-t1.tfm \
tex-Junicode-SmCondItalic-tosf-sc-t1.vf \
tex-Junicode-SmCondItalic-tosf-t1--base.tfm \
tex-Junicode-SmCondItalic-tosf-t1.tfm \
tex-Junicode-SmCondItalic-tosf-t1.vf \
tex-Junicode-SmCondItalic-tosf-ts1--base.tfm \
tex-Junicode-SmCondItalic-tosf-ts1.tfm \
tex-Junicode-SmCondItalic-tosf-ts1.vf \
tex-Junicode-SmCondLight-inf-lgr.tfm \
tex-Junicode-SmCondLight-inf-ly1.tfm \
tex-Junicode-SmCondLight-inf-ot1.tfm \
tex-Junicode-SmCondLight-inf-t1--base.tfm \
tex-Junicode-SmCondLight-inf-t1.tfm \
tex-Junicode-SmCondLight-inf-t1.vf \
tex-Junicode-SmCondLight-lf-lgr.tfm \
tex-Junicode-SmCondLight-lf-ly1.tfm \
tex-Junicode-SmCondLight-lf-ot1.tfm \
tex-Junicode-SmCondLight-lf-sc-lgr.tfm \
tex-Junicode-SmCondLight-lf-sc-ly1--base.tfm \
tex-Junicode-SmCondLight-lf-sc-ly1.tfm \
tex-Junicode-SmCondLight-lf-sc-ly1.vf \
tex-Junicode-SmCondLight-lf-sc-ot1--base.tfm \
tex-Junicode-SmCondLight-lf-sc-ot1.tfm \
tex-Junicode-SmCondLight-lf-sc-ot1.vf \
tex-Junicode-SmCondLight-lf-sc-t1--base.tfm \
tex-Junicode-SmCondLight-lf-sc-t1.tfm \
tex-Junicode-SmCondLight-lf-sc-t1.vf \
tex-Junicode-SmCondLight-lf-t1--base.tfm \
tex-Junicode-SmCondLight-lf-t1.tfm \
tex-Junicode-SmCondLight-lf-t1.vf \
tex-Junicode-SmCondLight-lf-ts1--base.tfm \
tex-Junicode-SmCondLight-lf-ts1.tfm \
tex-Junicode-SmCondLight-lf-ts1.vf \
tex-Junicode-SmCondLight-osf-lgr.tfm \
tex-Junicode-SmCondLight-osf-ly1.tfm \
tex-Junicode-SmCondLight-osf-ot1.tfm \
tex-Junicode-SmCondLight-osf-sc-lgr.tfm \
tex-Junicode-SmCondLight-osf-sc-ly1--base.tfm \
tex-Junicode-SmCondLight-osf-sc-ly1.tfm \
tex-Junicode-SmCondLight-osf-sc-ly1.vf \
tex-Junicode-SmCondLight-osf-sc-ot1--base.tfm \
tex-Junicode-SmCondLight-osf-sc-ot1.tfm \
tex-Junicode-SmCondLight-osf-sc-ot1.vf \
tex-Junicode-SmCondLight-osf-sc-t1--base.tfm \
tex-Junicode-SmCondLight-osf-sc-t1.tfm \
tex-Junicode-SmCondLight-osf-sc-t1.vf \
tex-Junicode-SmCondLight-osf-t1--base.tfm \
tex-Junicode-SmCondLight-osf-t1.tfm \
tex-Junicode-SmCondLight-osf-t1.vf \
tex-Junicode-SmCondLight-osf-ts1--base.tfm \
tex-Junicode-SmCondLight-osf-ts1.tfm \
tex-Junicode-SmCondLight-osf-ts1.vf \
tex-Junicode-SmCondLight-sup-lgr.tfm \
tex-Junicode-SmCondLight-sup-ly1.tfm \
tex-Junicode-SmCondLight-sup-ot1.tfm \
tex-Junicode-SmCondLight-sup-t1--base.tfm \
tex-Junicode-SmCondLight-sup-t1.tfm \
tex-Junicode-SmCondLight-sup-t1.vf \
tex-Junicode-SmCondLight-tlf-lgr.tfm \
tex-Junicode-SmCondLight-tlf-ly1.tfm \
tex-Junicode-SmCondLight-tlf-ot1.tfm \
tex-Junicode-SmCondLight-tlf-sc-lgr.tfm \
tex-Junicode-SmCondLight-tlf-sc-ly1--base.tfm \
tex-Junicode-SmCondLight-tlf-sc-ly1.tfm \
tex-Junicode-SmCondLight-tlf-sc-ly1.vf \
tex-Junicode-SmCondLight-tlf-sc-ot1--base.tfm \
tex-Junicode-SmCondLight-tlf-sc-ot1.tfm \
tex-Junicode-SmCondLight-tlf-sc-ot1.vf \
tex-Junicode-SmCondLight-tlf-sc-t1--base.tfm \
tex-Junicode-SmCondLight-tlf-sc-t1.tfm \
tex-Junicode-SmCondLight-tlf-sc-t1.vf \
tex-Junicode-SmCondLight-tlf-t1--base.tfm \
tex-Junicode-SmCondLight-tlf-t1.tfm \
tex-Junicode-SmCondLight-tlf-t1.vf \
tex-Junicode-SmCondLight-tlf-ts1--base.tfm \
tex-Junicode-SmCondLight-tlf-ts1.tfm \
tex-Junicode-SmCondLight-tlf-ts1.vf \
tex-Junicode-SmCondLight-tosf-lgr.tfm \
tex-Junicode-SmCondLight-tosf-ly1.tfm \
tex-Junicode-SmCondLight-tosf-ot1.tfm \
tex-Junicode-SmCondLight-tosf-sc-lgr.tfm \
tex-Junicode-SmCondLight-tosf-sc-ly1--base.tfm \
tex-Junicode-SmCondLight-tosf-sc-ly1.tfm \
tex-Junicode-SmCondLight-tosf-sc-ly1.vf \
tex-Junicode-SmCondLight-tosf-sc-ot1--base.tfm \
tex-Junicode-SmCondLight-tosf-sc-ot1.tfm \
tex-Junicode-SmCondLight-tosf-sc-ot1.vf \
tex-Junicode-SmCondLight-tosf-sc-t1--base.tfm \
tex-Junicode-SmCondLight-tosf-sc-t1.tfm \
tex-Junicode-SmCondLight-tosf-sc-t1.vf \
tex-Junicode-SmCondLight-tosf-t1--base.tfm \
tex-Junicode-SmCondLight-tosf-t1.tfm \
tex-Junicode-SmCondLight-tosf-t1.vf \
tex-Junicode-SmCondLight-tosf-ts1--base.tfm \
tex-Junicode-SmCondLight-tosf-ts1.tfm \
tex-Junicode-SmCondLight-tosf-ts1.vf \
tex-Junicode-SmCondLightItalic-inf-lgr.tfm \
tex-Junicode-SmCondLightItalic-inf-ly1.tfm \
tex-Junicode-SmCondLightItalic-inf-ot1.tfm \
tex-Junicode-SmCondLightItalic-inf-t1--base.tfm \
tex-Junicode-SmCondLightItalic-inf-t1.tfm \
tex-Junicode-SmCondLightItalic-inf-t1.vf \
tex-Junicode-SmCondLightItalic-lf-lgr.tfm \
tex-Junicode-SmCondLightItalic-lf-ly1.tfm \
tex-Junicode-SmCondLightItalic-lf-ot1.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-lgr.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-ly1.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-ly1.vf \
tex-Junicode-SmCondLightItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-ot1.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-ot1.vf \
tex-Junicode-SmCondLightItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-t1.tfm \
tex-Junicode-SmCondLightItalic-lf-sc-t1.vf \
tex-Junicode-SmCondLightItalic-lf-t1--base.tfm \
tex-Junicode-SmCondLightItalic-lf-t1.tfm \
tex-Junicode-SmCondLightItalic-lf-t1.vf \
tex-Junicode-SmCondLightItalic-lf-ts1--base.tfm \
tex-Junicode-SmCondLightItalic-lf-ts1.tfm \
tex-Junicode-SmCondLightItalic-lf-ts1.vf \
tex-Junicode-SmCondLightItalic-osf-lgr.tfm \
tex-Junicode-SmCondLightItalic-osf-ly1.tfm \
tex-Junicode-SmCondLightItalic-osf-ot1.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-lgr.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-ly1.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-ly1.vf \
tex-Junicode-SmCondLightItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-ot1.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-ot1.vf \
tex-Junicode-SmCondLightItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-t1.tfm \
tex-Junicode-SmCondLightItalic-osf-sc-t1.vf \
tex-Junicode-SmCondLightItalic-osf-t1--base.tfm \
tex-Junicode-SmCondLightItalic-osf-t1.tfm \
tex-Junicode-SmCondLightItalic-osf-t1.vf \
tex-Junicode-SmCondLightItalic-osf-ts1--base.tfm \
tex-Junicode-SmCondLightItalic-osf-ts1.tfm \
tex-Junicode-SmCondLightItalic-osf-ts1.vf \
tex-Junicode-SmCondLightItalic-sup-lgr.tfm \
tex-Junicode-SmCondLightItalic-sup-ly1.tfm \
tex-Junicode-SmCondLightItalic-sup-ot1.tfm \
tex-Junicode-SmCondLightItalic-sup-t1--base.tfm \
tex-Junicode-SmCondLightItalic-sup-t1.tfm \
tex-Junicode-SmCondLightItalic-sup-t1.vf \
tex-Junicode-SmCondLightItalic-tlf-lgr.tfm \
tex-Junicode-SmCondLightItalic-tlf-ly1.tfm \
tex-Junicode-SmCondLightItalic-tlf-ot1.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-ly1.vf \
tex-Junicode-SmCondLightItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-ot1.vf \
tex-Junicode-SmCondLightItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-t1.tfm \
tex-Junicode-SmCondLightItalic-tlf-sc-t1.vf \
tex-Junicode-SmCondLightItalic-tlf-t1--base.tfm \
tex-Junicode-SmCondLightItalic-tlf-t1.tfm \
tex-Junicode-SmCondLightItalic-tlf-t1.vf \
tex-Junicode-SmCondLightItalic-tlf-ts1--base.tfm \
tex-Junicode-SmCondLightItalic-tlf-ts1.tfm \
tex-Junicode-SmCondLightItalic-tlf-ts1.vf \
tex-Junicode-SmCondLightItalic-tosf-lgr.tfm \
tex-Junicode-SmCondLightItalic-tosf-ly1.tfm \
tex-Junicode-SmCondLightItalic-tosf-ot1.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-ly1.vf \
tex-Junicode-SmCondLightItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-ot1.vf \
tex-Junicode-SmCondLightItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-t1.tfm \
tex-Junicode-SmCondLightItalic-tosf-sc-t1.vf \
tex-Junicode-SmCondLightItalic-tosf-t1--base.tfm \
tex-Junicode-SmCondLightItalic-tosf-t1.tfm \
tex-Junicode-SmCondLightItalic-tosf-t1.vf \
tex-Junicode-SmCondLightItalic-tosf-ts1--base.tfm \
tex-Junicode-SmCondLightItalic-tosf-ts1.tfm \
tex-Junicode-SmCondLightItalic-tosf-ts1.vf \
tex-Junicode-SmCondMedium-inf-lgr.tfm \
tex-Junicode-SmCondMedium-inf-ly1.tfm \
tex-Junicode-SmCondMedium-inf-ot1.tfm \
tex-Junicode-SmCondMedium-inf-t1--base.tfm \
tex-Junicode-SmCondMedium-inf-t1.tfm \
tex-Junicode-SmCondMedium-inf-t1.vf \
tex-Junicode-SmCondMedium-lf-lgr.tfm \
tex-Junicode-SmCondMedium-lf-ly1.tfm \
tex-Junicode-SmCondMedium-lf-ot1.tfm \
tex-Junicode-SmCondMedium-lf-sc-lgr.tfm \
tex-Junicode-SmCondMedium-lf-sc-ly1--base.tfm \
tex-Junicode-SmCondMedium-lf-sc-ly1.tfm \
tex-Junicode-SmCondMedium-lf-sc-ly1.vf \
tex-Junicode-SmCondMedium-lf-sc-ot1--base.tfm \
tex-Junicode-SmCondMedium-lf-sc-ot1.tfm \
tex-Junicode-SmCondMedium-lf-sc-ot1.vf \
tex-Junicode-SmCondMedium-lf-sc-t1--base.tfm \
tex-Junicode-SmCondMedium-lf-sc-t1.tfm \
tex-Junicode-SmCondMedium-lf-sc-t1.vf \
tex-Junicode-SmCondMedium-lf-t1--base.tfm \
tex-Junicode-SmCondMedium-lf-t1.tfm \
tex-Junicode-SmCondMedium-lf-t1.vf \
tex-Junicode-SmCondMedium-lf-ts1--base.tfm \
tex-Junicode-SmCondMedium-lf-ts1.tfm \
tex-Junicode-SmCondMedium-lf-ts1.vf \
tex-Junicode-SmCondMedium-osf-lgr.tfm \
tex-Junicode-SmCondMedium-osf-ly1.tfm \
tex-Junicode-SmCondMedium-osf-ot1.tfm \
tex-Junicode-SmCondMedium-osf-sc-lgr.tfm \
tex-Junicode-SmCondMedium-osf-sc-ly1--base.tfm \
tex-Junicode-SmCondMedium-osf-sc-ly1.tfm \
tex-Junicode-SmCondMedium-osf-sc-ly1.vf \
tex-Junicode-SmCondMedium-osf-sc-ot1--base.tfm \
tex-Junicode-SmCondMedium-osf-sc-ot1.tfm \
tex-Junicode-SmCondMedium-osf-sc-ot1.vf \
tex-Junicode-SmCondMedium-osf-sc-t1--base.tfm \
tex-Junicode-SmCondMedium-osf-sc-t1.tfm \
tex-Junicode-SmCondMedium-osf-sc-t1.vf \
tex-Junicode-SmCondMedium-osf-t1--base.tfm \
tex-Junicode-SmCondMedium-osf-t1.tfm \
tex-Junicode-SmCondMedium-osf-t1.vf \
tex-Junicode-SmCondMedium-osf-ts1--base.tfm \
tex-Junicode-SmCondMedium-osf-ts1.tfm \
tex-Junicode-SmCondMedium-osf-ts1.vf \
tex-Junicode-SmCondMedium-sup-lgr.tfm \
tex-Junicode-SmCondMedium-sup-ly1.tfm \
tex-Junicode-SmCondMedium-sup-ot1.tfm \
tex-Junicode-SmCondMedium-sup-t1--base.tfm \
tex-Junicode-SmCondMedium-sup-t1.tfm \
tex-Junicode-SmCondMedium-sup-t1.vf \
tex-Junicode-SmCondMedium-tlf-lgr.tfm \
tex-Junicode-SmCondMedium-tlf-ly1.tfm \
tex-Junicode-SmCondMedium-tlf-ot1.tfm \
tex-Junicode-SmCondMedium-tlf-sc-lgr.tfm \
tex-Junicode-SmCondMedium-tlf-sc-ly1--base.tfm \
tex-Junicode-SmCondMedium-tlf-sc-ly1.tfm \
tex-Junicode-SmCondMedium-tlf-sc-ly1.vf \
tex-Junicode-SmCondMedium-tlf-sc-ot1--base.tfm \
tex-Junicode-SmCondMedium-tlf-sc-ot1.tfm \
tex-Junicode-SmCondMedium-tlf-sc-ot1.vf \
tex-Junicode-SmCondMedium-tlf-sc-t1--base.tfm \
tex-Junicode-SmCondMedium-tlf-sc-t1.tfm \
tex-Junicode-SmCondMedium-tlf-sc-t1.vf \
tex-Junicode-SmCondMedium-tlf-t1--base.tfm \
tex-Junicode-SmCondMedium-tlf-t1.tfm \
tex-Junicode-SmCondMedium-tlf-t1.vf \
tex-Junicode-SmCondMedium-tlf-ts1--base.tfm \
tex-Junicode-SmCondMedium-tlf-ts1.tfm \
tex-Junicode-SmCondMedium-tlf-ts1.vf \
tex-Junicode-SmCondMedium-tosf-lgr.tfm \
tex-Junicode-SmCondMedium-tosf-ly1.tfm \
tex-Junicode-SmCondMedium-tosf-ot1.tfm \
tex-Junicode-SmCondMedium-tosf-sc-lgr.tfm \
tex-Junicode-SmCondMedium-tosf-sc-ly1--base.tfm \
tex-Junicode-SmCondMedium-tosf-sc-ly1.tfm \
tex-Junicode-SmCondMedium-tosf-sc-ly1.vf \
tex-Junicode-SmCondMedium-tosf-sc-ot1--base.tfm \
tex-Junicode-SmCondMedium-tosf-sc-ot1.tfm \
tex-Junicode-SmCondMedium-tosf-sc-ot1.vf \
tex-Junicode-SmCondMedium-tosf-sc-t1--base.tfm \
tex-Junicode-SmCondMedium-tosf-sc-t1.tfm \
tex-Junicode-SmCondMedium-tosf-sc-t1.vf \
tex-Junicode-SmCondMedium-tosf-t1--base.tfm \
tex-Junicode-SmCondMedium-tosf-t1.tfm \
tex-Junicode-SmCondMedium-tosf-t1.vf \
tex-Junicode-SmCondMedium-tosf-ts1--base.tfm \
tex-Junicode-SmCondMedium-tosf-ts1.tfm \
tex-Junicode-SmCondMedium-tosf-ts1.vf \
tex-Junicode-SmCondMediumItalic-inf-lgr.tfm \
tex-Junicode-SmCondMediumItalic-inf-ly1.tfm \
tex-Junicode-SmCondMediumItalic-inf-ot1.tfm \
tex-Junicode-SmCondMediumItalic-inf-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-inf-t1.tfm \
tex-Junicode-SmCondMediumItalic-inf-t1.vf \
tex-Junicode-SmCondMediumItalic-lf-lgr.tfm \
tex-Junicode-SmCondMediumItalic-lf-ly1.tfm \
tex-Junicode-SmCondMediumItalic-lf-ot1.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-lgr.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-ly1.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-ly1.vf \
tex-Junicode-SmCondMediumItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-ot1.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-ot1.vf \
tex-Junicode-SmCondMediumItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-t1.tfm \
tex-Junicode-SmCondMediumItalic-lf-sc-t1.vf \
tex-Junicode-SmCondMediumItalic-lf-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-lf-t1.tfm \
tex-Junicode-SmCondMediumItalic-lf-t1.vf \
tex-Junicode-SmCondMediumItalic-lf-ts1--base.tfm \
tex-Junicode-SmCondMediumItalic-lf-ts1.tfm \
tex-Junicode-SmCondMediumItalic-lf-ts1.vf \
tex-Junicode-SmCondMediumItalic-osf-lgr.tfm \
tex-Junicode-SmCondMediumItalic-osf-ly1.tfm \
tex-Junicode-SmCondMediumItalic-osf-ot1.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-lgr.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-ly1.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-ly1.vf \
tex-Junicode-SmCondMediumItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-ot1.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-ot1.vf \
tex-Junicode-SmCondMediumItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-t1.tfm \
tex-Junicode-SmCondMediumItalic-osf-sc-t1.vf \
tex-Junicode-SmCondMediumItalic-osf-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-osf-t1.tfm \
tex-Junicode-SmCondMediumItalic-osf-t1.vf \
tex-Junicode-SmCondMediumItalic-osf-ts1--base.tfm \
tex-Junicode-SmCondMediumItalic-osf-ts1.tfm \
tex-Junicode-SmCondMediumItalic-osf-ts1.vf \
tex-Junicode-SmCondMediumItalic-sup-lgr.tfm \
tex-Junicode-SmCondMediumItalic-sup-ly1.tfm \
tex-Junicode-SmCondMediumItalic-sup-ot1.tfm \
tex-Junicode-SmCondMediumItalic-sup-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-sup-t1.tfm \
tex-Junicode-SmCondMediumItalic-sup-t1.vf \
tex-Junicode-SmCondMediumItalic-tlf-lgr.tfm \
tex-Junicode-SmCondMediumItalic-tlf-ly1.tfm \
tex-Junicode-SmCondMediumItalic-tlf-ot1.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-ly1.vf \
tex-Junicode-SmCondMediumItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-ot1.vf \
tex-Junicode-SmCondMediumItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-t1.tfm \
tex-Junicode-SmCondMediumItalic-tlf-sc-t1.vf \
tex-Junicode-SmCondMediumItalic-tlf-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-tlf-t1.tfm \
tex-Junicode-SmCondMediumItalic-tlf-t1.vf \
tex-Junicode-SmCondMediumItalic-tlf-ts1--base.tfm \
tex-Junicode-SmCondMediumItalic-tlf-ts1.tfm \
tex-Junicode-SmCondMediumItalic-tlf-ts1.vf \
tex-Junicode-SmCondMediumItalic-tosf-lgr.tfm \
tex-Junicode-SmCondMediumItalic-tosf-ly1.tfm \
tex-Junicode-SmCondMediumItalic-tosf-ot1.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-ly1.vf \
tex-Junicode-SmCondMediumItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-ot1.vf \
tex-Junicode-SmCondMediumItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-t1.tfm \
tex-Junicode-SmCondMediumItalic-tosf-sc-t1.vf \
tex-Junicode-SmCondMediumItalic-tosf-t1--base.tfm \
tex-Junicode-SmCondMediumItalic-tosf-t1.tfm \
tex-Junicode-SmCondMediumItalic-tosf-t1.vf \
tex-Junicode-SmCondMediumItalic-tosf-ts1--base.tfm \
tex-Junicode-SmCondMediumItalic-tosf-ts1.tfm \
tex-Junicode-SmCondMediumItalic-tosf-ts1.vf \
tex-Junicode-SmExp-inf-lgr.tfm \
tex-Junicode-SmExp-inf-ly1.tfm \
tex-Junicode-SmExp-inf-ot1.tfm \
tex-Junicode-SmExp-inf-t1--base.tfm \
tex-Junicode-SmExp-inf-t1.tfm \
tex-Junicode-SmExp-inf-t1.vf \
tex-Junicode-SmExp-lf-lgr.tfm \
tex-Junicode-SmExp-lf-ly1.tfm \
tex-Junicode-SmExp-lf-ot1.tfm \
tex-Junicode-SmExp-lf-sc-lgr.tfm \
tex-Junicode-SmExp-lf-sc-ly1--base.tfm \
tex-Junicode-SmExp-lf-sc-ly1.tfm \
tex-Junicode-SmExp-lf-sc-ly1.vf \
tex-Junicode-SmExp-lf-sc-ot1--base.tfm \
tex-Junicode-SmExp-lf-sc-ot1.tfm \
tex-Junicode-SmExp-lf-sc-ot1.vf \
tex-Junicode-SmExp-lf-sc-t1--base.tfm \
tex-Junicode-SmExp-lf-sc-t1.tfm \
tex-Junicode-SmExp-lf-sc-t1.vf \
tex-Junicode-SmExp-lf-t1--base.tfm \
tex-Junicode-SmExp-lf-t1.tfm \
tex-Junicode-SmExp-lf-t1.vf \
tex-Junicode-SmExp-lf-ts1--base.tfm \
tex-Junicode-SmExp-lf-ts1.tfm \
tex-Junicode-SmExp-lf-ts1.vf \
tex-Junicode-SmExp-osf-lgr.tfm \
tex-Junicode-SmExp-osf-ly1.tfm \
tex-Junicode-SmExp-osf-ot1.tfm \
tex-Junicode-SmExp-osf-sc-lgr.tfm \
tex-Junicode-SmExp-osf-sc-ly1--base.tfm \
tex-Junicode-SmExp-osf-sc-ly1.tfm \
tex-Junicode-SmExp-osf-sc-ly1.vf \
tex-Junicode-SmExp-osf-sc-ot1--base.tfm \
tex-Junicode-SmExp-osf-sc-ot1.tfm \
tex-Junicode-SmExp-osf-sc-ot1.vf \
tex-Junicode-SmExp-osf-sc-t1--base.tfm \
tex-Junicode-SmExp-osf-sc-t1.tfm \
tex-Junicode-SmExp-osf-sc-t1.vf \
tex-Junicode-SmExp-osf-t1--base.tfm \
tex-Junicode-SmExp-osf-t1.tfm \
tex-Junicode-SmExp-osf-t1.vf \
tex-Junicode-SmExp-osf-ts1--base.tfm \
tex-Junicode-SmExp-osf-ts1.tfm \
tex-Junicode-SmExp-osf-ts1.vf \
tex-Junicode-SmExp-sup-lgr.tfm \
tex-Junicode-SmExp-sup-ly1.tfm \
tex-Junicode-SmExp-sup-ot1.tfm \
tex-Junicode-SmExp-sup-t1--base.tfm \
tex-Junicode-SmExp-sup-t1.tfm \
tex-Junicode-SmExp-sup-t1.vf \
tex-Junicode-SmExp-tlf-lgr.tfm \
tex-Junicode-SmExp-tlf-ly1.tfm \
tex-Junicode-SmExp-tlf-ot1.tfm \
tex-Junicode-SmExp-tlf-sc-lgr.tfm \
tex-Junicode-SmExp-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExp-tlf-sc-ly1.tfm \
tex-Junicode-SmExp-tlf-sc-ly1.vf \
tex-Junicode-SmExp-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExp-tlf-sc-ot1.tfm \
tex-Junicode-SmExp-tlf-sc-ot1.vf \
tex-Junicode-SmExp-tlf-sc-t1--base.tfm \
tex-Junicode-SmExp-tlf-sc-t1.tfm \
tex-Junicode-SmExp-tlf-sc-t1.vf \
tex-Junicode-SmExp-tlf-t1--base.tfm \
tex-Junicode-SmExp-tlf-t1.tfm \
tex-Junicode-SmExp-tlf-t1.vf \
tex-Junicode-SmExp-tlf-ts1--base.tfm \
tex-Junicode-SmExp-tlf-ts1.tfm \
tex-Junicode-SmExp-tlf-ts1.vf \
tex-Junicode-SmExp-tosf-lgr.tfm \
tex-Junicode-SmExp-tosf-ly1.tfm \
tex-Junicode-SmExp-tosf-ot1.tfm \
tex-Junicode-SmExp-tosf-sc-lgr.tfm \
tex-Junicode-SmExp-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExp-tosf-sc-ly1.tfm \
tex-Junicode-SmExp-tosf-sc-ly1.vf \
tex-Junicode-SmExp-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExp-tosf-sc-ot1.tfm \
tex-Junicode-SmExp-tosf-sc-ot1.vf \
tex-Junicode-SmExp-tosf-sc-t1--base.tfm \
tex-Junicode-SmExp-tosf-sc-t1.tfm \
tex-Junicode-SmExp-tosf-sc-t1.vf \
tex-Junicode-SmExp-tosf-t1--base.tfm \
tex-Junicode-SmExp-tosf-t1.tfm \
tex-Junicode-SmExp-tosf-t1.vf \
tex-Junicode-SmExp-tosf-ts1--base.tfm \
tex-Junicode-SmExp-tosf-ts1.tfm \
tex-Junicode-SmExp-tosf-ts1.vf \
tex-Junicode-SmExpBold-inf-lgr.tfm \
tex-Junicode-SmExpBold-inf-ly1.tfm \
tex-Junicode-SmExpBold-inf-ot1.tfm \
tex-Junicode-SmExpBold-inf-t1--base.tfm \
tex-Junicode-SmExpBold-inf-t1.tfm \
tex-Junicode-SmExpBold-inf-t1.vf \
tex-Junicode-SmExpBold-lf-lgr.tfm \
tex-Junicode-SmExpBold-lf-ly1.tfm \
tex-Junicode-SmExpBold-lf-ot1.tfm \
tex-Junicode-SmExpBold-lf-sc-lgr.tfm \
tex-Junicode-SmExpBold-lf-sc-ly1--base.tfm \
tex-Junicode-SmExpBold-lf-sc-ly1.tfm \
tex-Junicode-SmExpBold-lf-sc-ly1.vf \
tex-Junicode-SmExpBold-lf-sc-ot1--base.tfm \
tex-Junicode-SmExpBold-lf-sc-ot1.tfm \
tex-Junicode-SmExpBold-lf-sc-ot1.vf \
tex-Junicode-SmExpBold-lf-sc-t1--base.tfm \
tex-Junicode-SmExpBold-lf-sc-t1.tfm \
tex-Junicode-SmExpBold-lf-sc-t1.vf \
tex-Junicode-SmExpBold-lf-t1--base.tfm \
tex-Junicode-SmExpBold-lf-t1.tfm \
tex-Junicode-SmExpBold-lf-t1.vf \
tex-Junicode-SmExpBold-lf-ts1--base.tfm \
tex-Junicode-SmExpBold-lf-ts1.tfm \
tex-Junicode-SmExpBold-lf-ts1.vf \
tex-Junicode-SmExpBold-osf-lgr.tfm \
tex-Junicode-SmExpBold-osf-ly1.tfm \
tex-Junicode-SmExpBold-osf-ot1.tfm \
tex-Junicode-SmExpBold-osf-sc-lgr.tfm \
tex-Junicode-SmExpBold-osf-sc-ly1--base.tfm \
tex-Junicode-SmExpBold-osf-sc-ly1.tfm \
tex-Junicode-SmExpBold-osf-sc-ly1.vf \
tex-Junicode-SmExpBold-osf-sc-ot1--base.tfm \
tex-Junicode-SmExpBold-osf-sc-ot1.tfm \
tex-Junicode-SmExpBold-osf-sc-ot1.vf \
tex-Junicode-SmExpBold-osf-sc-t1--base.tfm \
tex-Junicode-SmExpBold-osf-sc-t1.tfm \
tex-Junicode-SmExpBold-osf-sc-t1.vf \
tex-Junicode-SmExpBold-osf-t1--base.tfm \
tex-Junicode-SmExpBold-osf-t1.tfm \
tex-Junicode-SmExpBold-osf-t1.vf \
tex-Junicode-SmExpBold-osf-ts1--base.tfm \
tex-Junicode-SmExpBold-osf-ts1.tfm \
tex-Junicode-SmExpBold-osf-ts1.vf \
tex-Junicode-SmExpBold-sup-lgr.tfm \
tex-Junicode-SmExpBold-sup-ly1.tfm \
tex-Junicode-SmExpBold-sup-ot1.tfm \
tex-Junicode-SmExpBold-sup-t1--base.tfm \
tex-Junicode-SmExpBold-sup-t1.tfm \
tex-Junicode-SmExpBold-sup-t1.vf \
tex-Junicode-SmExpBold-tlf-lgr.tfm \
tex-Junicode-SmExpBold-tlf-ly1.tfm \
tex-Junicode-SmExpBold-tlf-ot1.tfm \
tex-Junicode-SmExpBold-tlf-sc-lgr.tfm \
tex-Junicode-SmExpBold-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExpBold-tlf-sc-ly1.tfm \
tex-Junicode-SmExpBold-tlf-sc-ly1.vf \
tex-Junicode-SmExpBold-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExpBold-tlf-sc-ot1.tfm \
tex-Junicode-SmExpBold-tlf-sc-ot1.vf \
tex-Junicode-SmExpBold-tlf-sc-t1--base.tfm \
tex-Junicode-SmExpBold-tlf-sc-t1.tfm \
tex-Junicode-SmExpBold-tlf-sc-t1.vf \
tex-Junicode-SmExpBold-tlf-t1--base.tfm \
tex-Junicode-SmExpBold-tlf-t1.tfm \
tex-Junicode-SmExpBold-tlf-t1.vf \
tex-Junicode-SmExpBold-tlf-ts1--base.tfm \
tex-Junicode-SmExpBold-tlf-ts1.tfm \
tex-Junicode-SmExpBold-tlf-ts1.vf \
tex-Junicode-SmExpBold-tosf-lgr.tfm \
tex-Junicode-SmExpBold-tosf-ly1.tfm \
tex-Junicode-SmExpBold-tosf-ot1.tfm \
tex-Junicode-SmExpBold-tosf-sc-lgr.tfm \
tex-Junicode-SmExpBold-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExpBold-tosf-sc-ly1.tfm \
tex-Junicode-SmExpBold-tosf-sc-ly1.vf \
tex-Junicode-SmExpBold-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExpBold-tosf-sc-ot1.tfm \
tex-Junicode-SmExpBold-tosf-sc-ot1.vf \
tex-Junicode-SmExpBold-tosf-sc-t1--base.tfm \
tex-Junicode-SmExpBold-tosf-sc-t1.tfm \
tex-Junicode-SmExpBold-tosf-sc-t1.vf \
tex-Junicode-SmExpBold-tosf-t1--base.tfm \
tex-Junicode-SmExpBold-tosf-t1.tfm \
tex-Junicode-SmExpBold-tosf-t1.vf \
tex-Junicode-SmExpBold-tosf-ts1--base.tfm \
tex-Junicode-SmExpBold-tosf-ts1.tfm \
tex-Junicode-SmExpBold-tosf-ts1.vf \
tex-Junicode-SmExpBoldItalic-inf-lgr.tfm \
tex-Junicode-SmExpBoldItalic-inf-ly1.tfm \
tex-Junicode-SmExpBoldItalic-inf-ot1.tfm \
tex-Junicode-SmExpBoldItalic-inf-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-inf-t1.tfm \
tex-Junicode-SmExpBoldItalic-inf-t1.vf \
tex-Junicode-SmExpBoldItalic-lf-lgr.tfm \
tex-Junicode-SmExpBoldItalic-lf-ly1.tfm \
tex-Junicode-SmExpBoldItalic-lf-ot1.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-lgr.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-ly1.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-ly1.vf \
tex-Junicode-SmExpBoldItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-ot1.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-ot1.vf \
tex-Junicode-SmExpBoldItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-t1.tfm \
tex-Junicode-SmExpBoldItalic-lf-sc-t1.vf \
tex-Junicode-SmExpBoldItalic-lf-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-lf-t1.tfm \
tex-Junicode-SmExpBoldItalic-lf-t1.vf \
tex-Junicode-SmExpBoldItalic-lf-ts1--base.tfm \
tex-Junicode-SmExpBoldItalic-lf-ts1.tfm \
tex-Junicode-SmExpBoldItalic-lf-ts1.vf \
tex-Junicode-SmExpBoldItalic-osf-lgr.tfm \
tex-Junicode-SmExpBoldItalic-osf-ly1.tfm \
tex-Junicode-SmExpBoldItalic-osf-ot1.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-lgr.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-ly1.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-ly1.vf \
tex-Junicode-SmExpBoldItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-ot1.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-ot1.vf \
tex-Junicode-SmExpBoldItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-t1.tfm \
tex-Junicode-SmExpBoldItalic-osf-sc-t1.vf \
tex-Junicode-SmExpBoldItalic-osf-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-osf-t1.tfm \
tex-Junicode-SmExpBoldItalic-osf-t1.vf \
tex-Junicode-SmExpBoldItalic-osf-ts1--base.tfm \
tex-Junicode-SmExpBoldItalic-osf-ts1.tfm \
tex-Junicode-SmExpBoldItalic-osf-ts1.vf \
tex-Junicode-SmExpBoldItalic-sup-lgr.tfm \
tex-Junicode-SmExpBoldItalic-sup-ly1.tfm \
tex-Junicode-SmExpBoldItalic-sup-ot1.tfm \
tex-Junicode-SmExpBoldItalic-sup-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-sup-t1.tfm \
tex-Junicode-SmExpBoldItalic-sup-t1.vf \
tex-Junicode-SmExpBoldItalic-tlf-lgr.tfm \
tex-Junicode-SmExpBoldItalic-tlf-ly1.tfm \
tex-Junicode-SmExpBoldItalic-tlf-ot1.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-ly1.vf \
tex-Junicode-SmExpBoldItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-ot1.vf \
tex-Junicode-SmExpBoldItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-t1.tfm \
tex-Junicode-SmExpBoldItalic-tlf-sc-t1.vf \
tex-Junicode-SmExpBoldItalic-tlf-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-tlf-t1.tfm \
tex-Junicode-SmExpBoldItalic-tlf-t1.vf \
tex-Junicode-SmExpBoldItalic-tlf-ts1--base.tfm \
tex-Junicode-SmExpBoldItalic-tlf-ts1.tfm \
tex-Junicode-SmExpBoldItalic-tlf-ts1.vf \
tex-Junicode-SmExpBoldItalic-tosf-lgr.tfm \
tex-Junicode-SmExpBoldItalic-tosf-ly1.tfm \
tex-Junicode-SmExpBoldItalic-tosf-ot1.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-ly1.vf \
tex-Junicode-SmExpBoldItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-ot1.vf \
tex-Junicode-SmExpBoldItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-t1.tfm \
tex-Junicode-SmExpBoldItalic-tosf-sc-t1.vf \
tex-Junicode-SmExpBoldItalic-tosf-t1--base.tfm \
tex-Junicode-SmExpBoldItalic-tosf-t1.tfm \
tex-Junicode-SmExpBoldItalic-tosf-t1.vf \
tex-Junicode-SmExpBoldItalic-tosf-ts1--base.tfm \
tex-Junicode-SmExpBoldItalic-tosf-ts1.tfm \
tex-Junicode-SmExpBoldItalic-tosf-ts1.vf \
tex-Junicode-SmExpItalic-inf-lgr.tfm \
tex-Junicode-SmExpItalic-inf-ly1.tfm \
tex-Junicode-SmExpItalic-inf-ot1.tfm \
tex-Junicode-SmExpItalic-inf-t1--base.tfm \
tex-Junicode-SmExpItalic-inf-t1.tfm \
tex-Junicode-SmExpItalic-inf-t1.vf \
tex-Junicode-SmExpItalic-lf-lgr.tfm \
tex-Junicode-SmExpItalic-lf-ly1.tfm \
tex-Junicode-SmExpItalic-lf-ot1.tfm \
tex-Junicode-SmExpItalic-lf-sc-lgr.tfm \
tex-Junicode-SmExpItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmExpItalic-lf-sc-ly1.tfm \
tex-Junicode-SmExpItalic-lf-sc-ly1.vf \
tex-Junicode-SmExpItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmExpItalic-lf-sc-ot1.tfm \
tex-Junicode-SmExpItalic-lf-sc-ot1.vf \
tex-Junicode-SmExpItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmExpItalic-lf-sc-t1.tfm \
tex-Junicode-SmExpItalic-lf-sc-t1.vf \
tex-Junicode-SmExpItalic-lf-t1--base.tfm \
tex-Junicode-SmExpItalic-lf-t1.tfm \
tex-Junicode-SmExpItalic-lf-t1.vf \
tex-Junicode-SmExpItalic-lf-ts1--base.tfm \
tex-Junicode-SmExpItalic-lf-ts1.tfm \
tex-Junicode-SmExpItalic-lf-ts1.vf \
tex-Junicode-SmExpItalic-osf-lgr.tfm \
tex-Junicode-SmExpItalic-osf-ly1.tfm \
tex-Junicode-SmExpItalic-osf-ot1.tfm \
tex-Junicode-SmExpItalic-osf-sc-lgr.tfm \
tex-Junicode-SmExpItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmExpItalic-osf-sc-ly1.tfm \
tex-Junicode-SmExpItalic-osf-sc-ly1.vf \
tex-Junicode-SmExpItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmExpItalic-osf-sc-ot1.tfm \
tex-Junicode-SmExpItalic-osf-sc-ot1.vf \
tex-Junicode-SmExpItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmExpItalic-osf-sc-t1.tfm \
tex-Junicode-SmExpItalic-osf-sc-t1.vf \
tex-Junicode-SmExpItalic-osf-t1--base.tfm \
tex-Junicode-SmExpItalic-osf-t1.tfm \
tex-Junicode-SmExpItalic-osf-t1.vf \
tex-Junicode-SmExpItalic-osf-ts1--base.tfm \
tex-Junicode-SmExpItalic-osf-ts1.tfm \
tex-Junicode-SmExpItalic-osf-ts1.vf \
tex-Junicode-SmExpItalic-sup-lgr.tfm \
tex-Junicode-SmExpItalic-sup-ly1.tfm \
tex-Junicode-SmExpItalic-sup-ot1.tfm \
tex-Junicode-SmExpItalic-sup-t1--base.tfm \
tex-Junicode-SmExpItalic-sup-t1.tfm \
tex-Junicode-SmExpItalic-sup-t1.vf \
tex-Junicode-SmExpItalic-tlf-lgr.tfm \
tex-Junicode-SmExpItalic-tlf-ly1.tfm \
tex-Junicode-SmExpItalic-tlf-ot1.tfm \
tex-Junicode-SmExpItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmExpItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExpItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmExpItalic-tlf-sc-ly1.vf \
tex-Junicode-SmExpItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExpItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmExpItalic-tlf-sc-ot1.vf \
tex-Junicode-SmExpItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmExpItalic-tlf-sc-t1.tfm \
tex-Junicode-SmExpItalic-tlf-sc-t1.vf \
tex-Junicode-SmExpItalic-tlf-t1--base.tfm \
tex-Junicode-SmExpItalic-tlf-t1.tfm \
tex-Junicode-SmExpItalic-tlf-t1.vf \
tex-Junicode-SmExpItalic-tlf-ts1--base.tfm \
tex-Junicode-SmExpItalic-tlf-ts1.tfm \
tex-Junicode-SmExpItalic-tlf-ts1.vf \
tex-Junicode-SmExpItalic-tosf-lgr.tfm \
tex-Junicode-SmExpItalic-tosf-ly1.tfm \
tex-Junicode-SmExpItalic-tosf-ot1.tfm \
tex-Junicode-SmExpItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmExpItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExpItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmExpItalic-tosf-sc-ly1.vf \
tex-Junicode-SmExpItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExpItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmExpItalic-tosf-sc-ot1.vf \
tex-Junicode-SmExpItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmExpItalic-tosf-sc-t1.tfm \
tex-Junicode-SmExpItalic-tosf-sc-t1.vf \
tex-Junicode-SmExpItalic-tosf-t1--base.tfm \
tex-Junicode-SmExpItalic-tosf-t1.tfm \
tex-Junicode-SmExpItalic-tosf-t1.vf \
tex-Junicode-SmExpItalic-tosf-ts1--base.tfm \
tex-Junicode-SmExpItalic-tosf-ts1.tfm \
tex-Junicode-SmExpItalic-tosf-ts1.vf \
tex-Junicode-SmExpMedium-inf-lgr.tfm \
tex-Junicode-SmExpMedium-inf-ly1.tfm \
tex-Junicode-SmExpMedium-inf-ot1.tfm \
tex-Junicode-SmExpMedium-inf-t1--base.tfm \
tex-Junicode-SmExpMedium-inf-t1.tfm \
tex-Junicode-SmExpMedium-inf-t1.vf \
tex-Junicode-SmExpMedium-lf-lgr.tfm \
tex-Junicode-SmExpMedium-lf-ly1.tfm \
tex-Junicode-SmExpMedium-lf-ot1.tfm \
tex-Junicode-SmExpMedium-lf-sc-lgr.tfm \
tex-Junicode-SmExpMedium-lf-sc-ly1--base.tfm \
tex-Junicode-SmExpMedium-lf-sc-ly1.tfm \
tex-Junicode-SmExpMedium-lf-sc-ly1.vf \
tex-Junicode-SmExpMedium-lf-sc-ot1--base.tfm \
tex-Junicode-SmExpMedium-lf-sc-ot1.tfm \
tex-Junicode-SmExpMedium-lf-sc-ot1.vf \
tex-Junicode-SmExpMedium-lf-sc-t1--base.tfm \
tex-Junicode-SmExpMedium-lf-sc-t1.tfm \
tex-Junicode-SmExpMedium-lf-sc-t1.vf \
tex-Junicode-SmExpMedium-lf-t1--base.tfm \
tex-Junicode-SmExpMedium-lf-t1.tfm \
tex-Junicode-SmExpMedium-lf-t1.vf \
tex-Junicode-SmExpMedium-lf-ts1--base.tfm \
tex-Junicode-SmExpMedium-lf-ts1.tfm \
tex-Junicode-SmExpMedium-lf-ts1.vf \
tex-Junicode-SmExpMedium-osf-lgr.tfm \
tex-Junicode-SmExpMedium-osf-ly1.tfm \
tex-Junicode-SmExpMedium-osf-ot1.tfm \
tex-Junicode-SmExpMedium-osf-sc-lgr.tfm \
tex-Junicode-SmExpMedium-osf-sc-ly1--base.tfm \
tex-Junicode-SmExpMedium-osf-sc-ly1.tfm \
tex-Junicode-SmExpMedium-osf-sc-ly1.vf \
tex-Junicode-SmExpMedium-osf-sc-ot1--base.tfm \
tex-Junicode-SmExpMedium-osf-sc-ot1.tfm \
tex-Junicode-SmExpMedium-osf-sc-ot1.vf \
tex-Junicode-SmExpMedium-osf-sc-t1--base.tfm \
tex-Junicode-SmExpMedium-osf-sc-t1.tfm \
tex-Junicode-SmExpMedium-osf-sc-t1.vf \
tex-Junicode-SmExpMedium-osf-t1--base.tfm \
tex-Junicode-SmExpMedium-osf-t1.tfm \
tex-Junicode-SmExpMedium-osf-t1.vf \
tex-Junicode-SmExpMedium-osf-ts1--base.tfm \
tex-Junicode-SmExpMedium-osf-ts1.tfm \
tex-Junicode-SmExpMedium-osf-ts1.vf \
tex-Junicode-SmExpMedium-sup-lgr.tfm \
tex-Junicode-SmExpMedium-sup-ly1.tfm \
tex-Junicode-SmExpMedium-sup-ot1.tfm \
tex-Junicode-SmExpMedium-sup-t1--base.tfm \
tex-Junicode-SmExpMedium-sup-t1.tfm \
tex-Junicode-SmExpMedium-sup-t1.vf \
tex-Junicode-SmExpMedium-tlf-lgr.tfm \
tex-Junicode-SmExpMedium-tlf-ly1.tfm \
tex-Junicode-SmExpMedium-tlf-ot1.tfm \
tex-Junicode-SmExpMedium-tlf-sc-lgr.tfm \
tex-Junicode-SmExpMedium-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExpMedium-tlf-sc-ly1.tfm \
tex-Junicode-SmExpMedium-tlf-sc-ly1.vf \
tex-Junicode-SmExpMedium-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExpMedium-tlf-sc-ot1.tfm \
tex-Junicode-SmExpMedium-tlf-sc-ot1.vf \
tex-Junicode-SmExpMedium-tlf-sc-t1--base.tfm \
tex-Junicode-SmExpMedium-tlf-sc-t1.tfm \
tex-Junicode-SmExpMedium-tlf-sc-t1.vf \
tex-Junicode-SmExpMedium-tlf-t1--base.tfm \
tex-Junicode-SmExpMedium-tlf-t1.tfm \
tex-Junicode-SmExpMedium-tlf-t1.vf \
tex-Junicode-SmExpMedium-tlf-ts1--base.tfm \
tex-Junicode-SmExpMedium-tlf-ts1.tfm \
tex-Junicode-SmExpMedium-tlf-ts1.vf \
tex-Junicode-SmExpMedium-tosf-lgr.tfm \
tex-Junicode-SmExpMedium-tosf-ly1.tfm \
tex-Junicode-SmExpMedium-tosf-ot1.tfm \
tex-Junicode-SmExpMedium-tosf-sc-lgr.tfm \
tex-Junicode-SmExpMedium-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExpMedium-tosf-sc-ly1.tfm \
tex-Junicode-SmExpMedium-tosf-sc-ly1.vf \
tex-Junicode-SmExpMedium-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExpMedium-tosf-sc-ot1.tfm \
tex-Junicode-SmExpMedium-tosf-sc-ot1.vf \
tex-Junicode-SmExpMedium-tosf-sc-t1--base.tfm \
tex-Junicode-SmExpMedium-tosf-sc-t1.tfm \
tex-Junicode-SmExpMedium-tosf-sc-t1.vf \
tex-Junicode-SmExpMedium-tosf-t1--base.tfm \
tex-Junicode-SmExpMedium-tosf-t1.tfm \
tex-Junicode-SmExpMedium-tosf-t1.vf \
tex-Junicode-SmExpMedium-tosf-ts1--base.tfm \
tex-Junicode-SmExpMedium-tosf-ts1.tfm \
tex-Junicode-SmExpMedium-tosf-ts1.vf \
tex-Junicode-SmExpMediumItalic-inf-lgr.tfm \
tex-Junicode-SmExpMediumItalic-inf-ly1.tfm \
tex-Junicode-SmExpMediumItalic-inf-ot1.tfm \
tex-Junicode-SmExpMediumItalic-inf-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-inf-t1.tfm \
tex-Junicode-SmExpMediumItalic-inf-t1.vf \
tex-Junicode-SmExpMediumItalic-lf-lgr.tfm \
tex-Junicode-SmExpMediumItalic-lf-ly1.tfm \
tex-Junicode-SmExpMediumItalic-lf-ot1.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-lgr.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-ly1.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-ly1.vf \
tex-Junicode-SmExpMediumItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-ot1.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-ot1.vf \
tex-Junicode-SmExpMediumItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-t1.tfm \
tex-Junicode-SmExpMediumItalic-lf-sc-t1.vf \
tex-Junicode-SmExpMediumItalic-lf-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-lf-t1.tfm \
tex-Junicode-SmExpMediumItalic-lf-t1.vf \
tex-Junicode-SmExpMediumItalic-lf-ts1--base.tfm \
tex-Junicode-SmExpMediumItalic-lf-ts1.tfm \
tex-Junicode-SmExpMediumItalic-lf-ts1.vf \
tex-Junicode-SmExpMediumItalic-osf-lgr.tfm \
tex-Junicode-SmExpMediumItalic-osf-ly1.tfm \
tex-Junicode-SmExpMediumItalic-osf-ot1.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-lgr.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-ly1.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-ly1.vf \
tex-Junicode-SmExpMediumItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-ot1.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-ot1.vf \
tex-Junicode-SmExpMediumItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-t1.tfm \
tex-Junicode-SmExpMediumItalic-osf-sc-t1.vf \
tex-Junicode-SmExpMediumItalic-osf-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-osf-t1.tfm \
tex-Junicode-SmExpMediumItalic-osf-t1.vf \
tex-Junicode-SmExpMediumItalic-osf-ts1--base.tfm \
tex-Junicode-SmExpMediumItalic-osf-ts1.tfm \
tex-Junicode-SmExpMediumItalic-osf-ts1.vf \
tex-Junicode-SmExpMediumItalic-sup-lgr.tfm \
tex-Junicode-SmExpMediumItalic-sup-ly1.tfm \
tex-Junicode-SmExpMediumItalic-sup-ot1.tfm \
tex-Junicode-SmExpMediumItalic-sup-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-sup-t1.tfm \
tex-Junicode-SmExpMediumItalic-sup-t1.vf \
tex-Junicode-SmExpMediumItalic-tlf-lgr.tfm \
tex-Junicode-SmExpMediumItalic-tlf-ly1.tfm \
tex-Junicode-SmExpMediumItalic-tlf-ot1.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-ly1.vf \
tex-Junicode-SmExpMediumItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-ot1.vf \
tex-Junicode-SmExpMediumItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-t1.tfm \
tex-Junicode-SmExpMediumItalic-tlf-sc-t1.vf \
tex-Junicode-SmExpMediumItalic-tlf-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-tlf-t1.tfm \
tex-Junicode-SmExpMediumItalic-tlf-t1.vf \
tex-Junicode-SmExpMediumItalic-tlf-ts1--base.tfm \
tex-Junicode-SmExpMediumItalic-tlf-ts1.tfm \
tex-Junicode-SmExpMediumItalic-tlf-ts1.vf \
tex-Junicode-SmExpMediumItalic-tosf-lgr.tfm \
tex-Junicode-SmExpMediumItalic-tosf-ly1.tfm \
tex-Junicode-SmExpMediumItalic-tosf-ot1.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-ly1.vf \
tex-Junicode-SmExpMediumItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-ot1.vf \
tex-Junicode-SmExpMediumItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-t1.tfm \
tex-Junicode-SmExpMediumItalic-tosf-sc-t1.vf \
tex-Junicode-SmExpMediumItalic-tosf-t1--base.tfm \
tex-Junicode-SmExpMediumItalic-tosf-t1.tfm \
tex-Junicode-SmExpMediumItalic-tosf-t1.vf \
tex-Junicode-SmExpMediumItalic-tosf-ts1--base.tfm \
tex-Junicode-SmExpMediumItalic-tosf-ts1.tfm \
tex-Junicode-SmExpMediumItalic-tosf-ts1.vf \
tex-Junicode-SmExpSmBold-inf-lgr.tfm \
tex-Junicode-SmExpSmBold-inf-ly1.tfm \
tex-Junicode-SmExpSmBold-inf-ot1.tfm \
tex-Junicode-SmExpSmBold-inf-t1--base.tfm \
tex-Junicode-SmExpSmBold-inf-t1.tfm \
tex-Junicode-SmExpSmBold-inf-t1.vf \
tex-Junicode-SmExpSmBold-lf-lgr.tfm \
tex-Junicode-SmExpSmBold-lf-ly1.tfm \
tex-Junicode-SmExpSmBold-lf-ot1.tfm \
tex-Junicode-SmExpSmBold-lf-sc-lgr.tfm \
tex-Junicode-SmExpSmBold-lf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBold-lf-sc-ly1.tfm \
tex-Junicode-SmExpSmBold-lf-sc-ly1.vf \
tex-Junicode-SmExpSmBold-lf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBold-lf-sc-ot1.tfm \
tex-Junicode-SmExpSmBold-lf-sc-ot1.vf \
tex-Junicode-SmExpSmBold-lf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBold-lf-sc-t1.tfm \
tex-Junicode-SmExpSmBold-lf-sc-t1.vf \
tex-Junicode-SmExpSmBold-lf-t1--base.tfm \
tex-Junicode-SmExpSmBold-lf-t1.tfm \
tex-Junicode-SmExpSmBold-lf-t1.vf \
tex-Junicode-SmExpSmBold-lf-ts1--base.tfm \
tex-Junicode-SmExpSmBold-lf-ts1.tfm \
tex-Junicode-SmExpSmBold-lf-ts1.vf \
tex-Junicode-SmExpSmBold-osf-lgr.tfm \
tex-Junicode-SmExpSmBold-osf-ly1.tfm \
tex-Junicode-SmExpSmBold-osf-ot1.tfm \
tex-Junicode-SmExpSmBold-osf-sc-lgr.tfm \
tex-Junicode-SmExpSmBold-osf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBold-osf-sc-ly1.tfm \
tex-Junicode-SmExpSmBold-osf-sc-ly1.vf \
tex-Junicode-SmExpSmBold-osf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBold-osf-sc-ot1.tfm \
tex-Junicode-SmExpSmBold-osf-sc-ot1.vf \
tex-Junicode-SmExpSmBold-osf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBold-osf-sc-t1.tfm \
tex-Junicode-SmExpSmBold-osf-sc-t1.vf \
tex-Junicode-SmExpSmBold-osf-t1--base.tfm \
tex-Junicode-SmExpSmBold-osf-t1.tfm \
tex-Junicode-SmExpSmBold-osf-t1.vf \
tex-Junicode-SmExpSmBold-osf-ts1--base.tfm \
tex-Junicode-SmExpSmBold-osf-ts1.tfm \
tex-Junicode-SmExpSmBold-osf-ts1.vf \
tex-Junicode-SmExpSmBold-sup-lgr.tfm \
tex-Junicode-SmExpSmBold-sup-ly1.tfm \
tex-Junicode-SmExpSmBold-sup-ot1.tfm \
tex-Junicode-SmExpSmBold-sup-t1--base.tfm \
tex-Junicode-SmExpSmBold-sup-t1.tfm \
tex-Junicode-SmExpSmBold-sup-t1.vf \
tex-Junicode-SmExpSmBold-tlf-lgr.tfm \
tex-Junicode-SmExpSmBold-tlf-ly1.tfm \
tex-Junicode-SmExpSmBold-tlf-ot1.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-lgr.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-ly1.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-ly1.vf \
tex-Junicode-SmExpSmBold-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-ot1.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-ot1.vf \
tex-Junicode-SmExpSmBold-tlf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-t1.tfm \
tex-Junicode-SmExpSmBold-tlf-sc-t1.vf \
tex-Junicode-SmExpSmBold-tlf-t1--base.tfm \
tex-Junicode-SmExpSmBold-tlf-t1.tfm \
tex-Junicode-SmExpSmBold-tlf-t1.vf \
tex-Junicode-SmExpSmBold-tlf-ts1--base.tfm \
tex-Junicode-SmExpSmBold-tlf-ts1.tfm \
tex-Junicode-SmExpSmBold-tlf-ts1.vf \
tex-Junicode-SmExpSmBold-tosf-lgr.tfm \
tex-Junicode-SmExpSmBold-tosf-ly1.tfm \
tex-Junicode-SmExpSmBold-tosf-ot1.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-lgr.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-ly1.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-ly1.vf \
tex-Junicode-SmExpSmBold-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-ot1.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-ot1.vf \
tex-Junicode-SmExpSmBold-tosf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-t1.tfm \
tex-Junicode-SmExpSmBold-tosf-sc-t1.vf \
tex-Junicode-SmExpSmBold-tosf-t1--base.tfm \
tex-Junicode-SmExpSmBold-tosf-t1.tfm \
tex-Junicode-SmExpSmBold-tosf-t1.vf \
tex-Junicode-SmExpSmBold-tosf-ts1--base.tfm \
tex-Junicode-SmExpSmBold-tosf-ts1.tfm \
tex-Junicode-SmExpSmBold-tosf-ts1.vf \
tex-Junicode-SmExpSmBoldItalic-inf-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-inf-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-inf-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-inf-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-inf-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-inf-t1.vf \
tex-Junicode-SmExpSmBoldItalic-lf-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-ly1.vf \
tex-Junicode-SmExpSmBoldItalic-lf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-ot1.vf \
tex-Junicode-SmExpSmBoldItalic-lf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-sc-t1.vf \
tex-Junicode-SmExpSmBoldItalic-lf-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-t1.vf \
tex-Junicode-SmExpSmBoldItalic-lf-ts1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-ts1.tfm \
tex-Junicode-SmExpSmBoldItalic-lf-ts1.vf \
tex-Junicode-SmExpSmBoldItalic-osf-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-ly1.vf \
tex-Junicode-SmExpSmBoldItalic-osf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-ot1.vf \
tex-Junicode-SmExpSmBoldItalic-osf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-sc-t1.vf \
tex-Junicode-SmExpSmBoldItalic-osf-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-t1.vf \
tex-Junicode-SmExpSmBoldItalic-osf-ts1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-ts1.tfm \
tex-Junicode-SmExpSmBoldItalic-osf-ts1.vf \
tex-Junicode-SmExpSmBoldItalic-sup-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-sup-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-sup-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-sup-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-sup-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-sup-t1.vf \
tex-Junicode-SmExpSmBoldItalic-tlf-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-ly1.vf \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-ot1.vf \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-sc-t1.vf \
tex-Junicode-SmExpSmBoldItalic-tlf-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-t1.vf \
tex-Junicode-SmExpSmBoldItalic-tlf-ts1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-ts1.tfm \
tex-Junicode-SmExpSmBoldItalic-tlf-ts1.vf \
tex-Junicode-SmExpSmBoldItalic-tosf-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-lgr.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-ly1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-ly1.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-ly1.vf \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-ot1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-ot1.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-ot1.vf \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-sc-t1.vf \
tex-Junicode-SmExpSmBoldItalic-tosf-t1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-t1.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-t1.vf \
tex-Junicode-SmExpSmBoldItalic-tosf-ts1--base.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-ts1.tfm \
tex-Junicode-SmExpSmBoldItalic-tosf-ts1.vf \
tex-Junicode.map \
tex-LGRJunicode-Inf.fd \
tex-LGRJunicode-LF.fd \
tex-LGRJunicode-OsF.fd \
tex-LGRJunicode-Sup.fd \
tex-LGRJunicode-TLF.fd \
tex-LGRJunicode-TOsF.fd \
tex-LY1Junicode-Inf.fd \
tex-LY1Junicode-LF.fd \
tex-LY1Junicode-OsF.fd \
tex-LY1Junicode-Sup.fd \
tex-LY1Junicode-TLF.fd \
tex-LY1Junicode-TOsF.fd \
tex-OT1Junicode-Inf.fd \
tex-OT1Junicode-LF.fd \
tex-OT1Junicode-OsF.fd \
tex-OT1Junicode-Sup.fd \
tex-OT1Junicode-TLF.fd \
tex-OT1Junicode-TOsF.fd \
tex-T1Junicode-Inf.fd \
tex-T1Junicode-LF.fd \
tex-T1Junicode-OsF.fd \
tex-T1Junicode-Sup.fd \
tex-T1Junicode-TLF.fd \
tex-T1Junicode-TOsF.fd \
tex-TS1Junicode-LF.fd \
tex-TS1Junicode-OsF.fd \
tex-TS1Junicode-TLF.fd \
tex-TS1Junicode-TOsF.fd \
tex-jncd-27di5y.enc \
tex-jncd-2aq47o.enc \
tex-jncd-3unpvd.enc \
tex-jncd-4jweaq.enc \
tex-jncd-4nafnj.enc \
tex-jncd-535mcm.enc \
tex-jncd-5maokn.enc \
tex-jncd-6gzl7p.enc \
tex-jncd-6kirfz.enc \
tex-jncd-6rba5y.enc \
tex-jncd-7vqqnw.enc \
tex-jncd-a5ibfp.enc \
tex-jncd-a7t5q2.enc \
tex-jncd-atb2gm.enc \
tex-jncd-b56ouc.enc \
tex-jncd-bfrhni.enc \
tex-jncd-bv2bzh.enc \
tex-jncd-c4gqgp.enc \
tex-jncd-cqfg4n.enc \
tex-jncd-d4fdw6.enc \
tex-jncd-dbackh.enc \
tex-jncd-dujor5.enc \
tex-jncd-dw56zz.enc \
tex-jncd-dydq3d.enc \
tex-jncd-e2angy.enc \
tex-jncd-emnsm7.enc \
tex-jncd-feq2lu.enc \
tex-jncd-ffg555.enc \
tex-jncd-fjcuys.enc \
tex-jncd-h6pbdf.enc \
tex-jncd-hwfs67.enc \
tex-jncd-ilb24p.enc \
tex-jncd-ippaj2.enc \
tex-jncd-jp6lmu.enc \
tex-jncd-jzgsbc.enc \
tex-jncd-k3ujjp.enc \
tex-jncd-ki56qe.enc \
tex-jncd-kkgraz.enc \
tex-jncd-kp7hrt.enc \
tex-jncd-ks4jez.enc \
tex-jncd-kw5ar3.enc \
tex-jncd-ldcvmr.enc \
tex-jncd-ldhven.enc \
tex-jncd-m6dmed.enc \
tex-jncd-mgrjl5.enc \
tex-jncd-ncilqg.enc \
tex-jncd-nghkwv.enc \
tex-jncd-ocpawb.enc \
tex-jncd-ooeuag.enc \
tex-jncd-p7ome7.enc \
tex-jncd-pkcvuk.enc \
tex-jncd-pnqwzk.enc \
tex-jncd-puklei.enc \
tex-jncd-qgnsub.enc \
tex-jncd-qnurlo.enc \
tex-jncd-rewzl7.enc \
tex-jncd-rvrggq.enc \
tex-jncd-rx5biu.enc \
tex-jncd-soeko7.enc \
tex-jncd-t7d4ag.enc \
tex-jncd-tbdiwj.enc \
tex-jncd-tcp3yr.enc \
tex-jncd-w7viv7.enc \
tex-jncd-wozfbb.enc \
tex-jncd-wusj3d.enc \
tex-jncd-wydlop.enc \
tex-jncd-x4ubxh.enc \
tex-jncd-y2gbot.enc \
tex-jncd-y7uwzw.enc \
tex-jncd-yojtrq.enc \
tex-jncd-ypv3zg.enc \
tex-jncd-yyvuk6.enc \
tex-jncd-zbyjbp.enc \
tex-junicode.sty \
texlive-junicode"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-fontspec.sty \
tex-iftex.sty \
tex-mweights.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
texlive \
texlive-filesystem \
texlive-junicode-fonts \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
