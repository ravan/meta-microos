SUMMARY = "Best Mega Pack 1+3"
DESCRIPTION = "Bestplugins Mega Pack 1+3 contains dozens of guitar sounds from famous bands."
LICENSE = "GPL-2.0-or-later"

PV = "0.47.0"

RPM_NAME = "bestplugins-0.47.0-2.3.aarch64.rpm"
RPM_HASH = "efb3ceaa6772dc80363c66290d394d690fd53db1b3b9c36e440149a00e69229343a19d5bc04a2a936b865439e13c9276dd4d93bde6ca86b531fa41eac0441031"

RPROVIDES:${PN} += "bestplugins"

RDEPENDS:${PN} += ""

inherit rpm
