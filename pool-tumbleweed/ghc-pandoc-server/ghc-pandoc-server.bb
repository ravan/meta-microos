SUMMARY = "Pandoc document conversion as an HTTP servant-server"
DESCRIPTION = "Pandoc-server provides pandoc's document conversion functions in an HTTP \
server."
LICENSE = "GPL-2.0-or-later"

PV = "0.1.3"

RPM_NAME = "ghc-pandoc-server-0.1.3-1.5.aarch64.rpm"
RPM_HASH = "830c3645e42aa0cf15a67acf8112953ca3a3dd950ca514c427f62cde4b7a95160c9ada563a871eea4f904b918dddee23f5f378ff71136b474f4e47c05c4c8884"

RPROVIDES:${PN} += "ghc-pandoc-server \
libHSpandoc-server-0.1.3-7sXM3AcGDIwBkeoEopIjq-ghc9.12.4.so"

RDEPENDS:${PN} += "libHSGlob-0.10.2-AdAJXGIwHNdL3rTZGPrj2r-ghc9.12.4.so \
libHSHUnit-1.6.2.0-HyPyPtOZKKe7vLdGCWHz7V-ghc9.12.4.so \
libHSJuicyPixels-3.3.9-IB5FNR8B0oDG4pRl7Jn2Mb-ghc9.12.4.so \
libHSOneTuple-0.4.3-6DcV56rVPgKHcnOuxvKUVo-ghc9.12.4.so \
libHSOnly-0.1-JTlBo1y3Iulx07n0z4y7-ghc9.12.4.so \
libHSQuickCheck-2.15.0.1-BiJUyvfspYF6JuhHRqpj7J-ghc9.12.4.so \
libHSStateVar-1.2.2-Fp8KJyjTxyjFvIxRBzfDbA-ghc9.12.4.so \
libHSaeson-2.2.5.0-3Moj34uePe8JCj0xjS5ggN-ghc9.12.4.so \
libHSaeson-pretty-0.8.11-KCQLeDLfEIvAXp36rOTTo7-ghc9.12.4.so \
libHSansi-terminal-1.1.5-KiVHPj6W9e81bxE9dBsVtZ-ghc9.12.4.so \
libHSansi-terminal-types-1.1.3-Cca3c5mUWg4AnUjMARf0p6-ghc9.12.4.so \
libHSappar-0.1.8-WSZSnBitxp1mS4dOP2hyq-ghc9.12.4.so \
libHSarray-0.5.8.0-2a42-ghc9.12.4.so \
libHSasciidoc-0.1.0.3-4LJxutGyvv2BedgmDvJWRc-ghc9.12.4.so \
libHSassoc-1.1.1-7ZKlIzFkmc1FQCJcpfYrTi-ghc9.12.4.so \
libHSasync-2.2.6-4fW0sXrepSt4QxgAnnLVB6-ghc9.12.4.so \
libHSattoparsec-0.14.4-DCHy075kASN7LSOqkXsGoX-attoparsec-internal-ghc9.12.4.so \
libHSattoparsec-0.14.4-IG7JFX7g1aObGVedAHYv7-ghc9.12.4.so \
libHSauto-update-0.2.6-2tH9dVxiiOkBVROYgrOYPc-ghc9.12.4.so \
libHSbase-4.21.2.0-8844-ghc9.12.4.so \
libHSbase-compat-0.14.1-KqldihVKqBMDOTSpHrHMJy-ghc9.12.4.so \
libHSbase-orphans-0.9.4-2vMgOxDXOniBrPCxqNGyGO-ghc9.12.4.so \
libHSbase-unicode-symbols-0.2.4.2-EOprbUpnIOv3U10zkWCZPk-ghc9.12.4.so \
libHSbase16-1.0-GqCyVT5DfwtBcN8MC2i0Li-ghc9.12.4.so \
libHSbase16-bytestring-1.0.2.0-IiVu4f3aSfMH2rpDgRP1QL-ghc9.12.4.so \
libHSbase64-1.0-Ca310PwaD9pGmjzA3S4jr6-ghc9.12.4.so \
libHSbase64-bytestring-1.2.1.0-9fPiMCS8Y4g8itFjJTGk2y-ghc9.12.4.so \
libHSbifunctors-5.6.3-9Dfko6C8LIIe8HG4zoeag-ghc9.12.4.so \
libHSbinary-0.8.9.3-9861-ghc9.12.4.so \
libHSbitvec-1.1.6.0-AtnZIEu4pqlECh34uLjm5P-ghc9.12.4.so \
libHSblaze-builder-0.4.4.1-DHhu3j9nndC9LUZIrPJCEG-ghc9.12.4.so \
libHSblaze-html-0.9.2.0-93B80xR5emg3yG3V6J7j6o-ghc9.12.4.so \
libHSblaze-markup-0.8.3.0-K4FwMBPUUgu9TB66ALCxf7-ghc9.12.4.so \
libHSboring-0.2.2.1-8s8A4hTb7xgDndEEz6qoTw-ghc9.12.4.so \
libHSbsb-http-chunked-0.0.0.4-5cZHaHeIaQxIWhD1tKvYpE-ghc9.12.4.so \
libHSbyteorder-1.0.4-2KwV8jNH81I9JBUzKyr4X2-ghc9.12.4.so \
libHSbytestring-0.12.2.0-65be-ghc9.12.4.so \
libHScall-stack-0.4.0-5oZIckzxOZr1eMyD6xWtI3-ghc9.12.4.so \
libHScase-insensitive-1.2.1.0-8WhhA2fjmpX8lBECkgmLqC-ghc9.12.4.so \
libHScassava-0.5.4.1-8IyxQgBHHLo5YfhT4Ar4sR-ghc9.12.4.so \
libHScborg-0.2.10.0-64S0XwCJRqFCXzW08346EZ-ghc9.12.4.so \
libHScereal-0.5.8.3-9RjPyVhfWFC69r1oCUPmww-ghc9.12.4.so \
libHScharacter-ps-0.1-GfoAEUDpxFcFC0QreRJRaJ-ghc9.12.4.so \
libHSciteproc-0.13.0.1-Ccf9E6t5yTGAMbIo1yftDS-ghc9.12.4.so \
libHScolour-2.3.7-LuxtbazHK7IK55ldBice4c-ghc9.12.4.so \
libHScommonmark-0.3-Hb0ZVJyoQFw1ynqgbLue51-ghc9.12.4.so \
libHScommonmark-extensions-0.2.7-1mQ1nSXKMfxCcwI2Hy1vjF-ghc9.12.4.so \
libHScommonmark-pandoc-0.3-LD3VUAgig8i7h5XtC6wGuG-ghc9.12.4.so \
libHScomonad-5.0.10-Adp50yscRn74SK6wUdL7QP-ghc9.12.4.so \
libHSconduit-1.3.6.1-DuJaiNNDon54jV6QjcNayt-ghc9.12.4.so \
libHSconduit-extra-1.3.8-7wpnn7nJp1SI8VsobZmenc-ghc9.12.4.so \
libHSconstraints-0.14.4-7xyUtqfmnIL5WxGRWAAF5a-ghc9.12.4.so \
libHScontainers-0.7-d5e1-ghc9.12.4.so \
libHScontravariant-1.5.6-7FVTzec2jegEwzkeRkQOi4-ghc9.12.4.so \
libHScookie-0.5.1-ICQl8upm830Ct2nb3AM1Ft-ghc9.12.4.so \
libHScryptohash-md5-0.11.101.0-BL71FgcwkvtHLdWrK6WsDS-ghc9.12.4.so \
libHScrypton-1.1.4-CRp9zIWu5CJCaPWpwBhIPB-ghc9.12.4.so \
libHScrypton-asn1-encoding-0.10.0-DTeXuctQn7g1wG1ZsDTxi1-ghc9.12.4.so \
libHScrypton-asn1-parse-0.10.0-K1qlVX8i1EIBhJkdyloxeJ-ghc9.12.4.so \
libHScrypton-asn1-types-0.4.1-LmR9a0v0hFeGm5Drmsi7UB-ghc9.12.4.so \
libHScrypton-connection-0.4.6-EpYbEhgynWEHAydR26M0y-ghc9.12.4.so \
libHScrypton-pem-0.3.0-EDGHx08iNeQDGxg4A2t7ij-ghc9.12.4.so \
libHScrypton-socks-0.6.2-ArLwOvrWYIxHawSNyZavl9-ghc9.12.4.so \
libHScrypton-x509-1.9.1-haGktaKI8uFy9MudMqGII-ghc9.12.4.so \
libHScrypton-x509-store-1.9.0-El9KTdTEmh914oZcyIi6oh-ghc9.12.4.so \
libHScrypton-x509-system-1.9.0-Kgk4Pc4QdTa954ljhsveQp-ghc9.12.4.so \
libHScrypton-x509-validation-1.9.1-A5KE59wkqBYCYMNBGaEl3l-ghc9.12.4.so \
libHSdata-default-0.8.0.2-E5U3DddOalL1fqy98B4vdZ-ghc9.12.4.so \
libHSdata-default-class-0.2.0.0-3moOzwNUrN6FLgYZMunU62-ghc9.12.4.so \
libHSdata-fix-0.3.4-CgM6sqdDt42GirAgfXjM4z-ghc9.12.4.so \
libHSdec-0.0.6-9n55jO9wFkCDcYlO4DYA9w-ghc9.12.4.so \
libHSdeepseq-1.5.1.0-1350-ghc9.12.4.so \
libHSdigest-0.0.2.1-KdJahDzYM113RUTsWm7UXN-ghc9.12.4.so \
libHSdirectory-1.3.10.1-b1d7-ghc9.12.4.so \
libHSdistributive-0.6.3-9lg1Hxwh2KlJVxh3zQCgyL-ghc9.12.4.so \
libHSdjot-0.1.4-544S34r37OfBfrOQhQH0gD-ghc9.12.4.so \
libHSdlist-1.0-24EafZnoZk8EE7HqnP59eC-ghc9.12.4.so \
libHSdoclayout-0.5.0.3-6oU5Og9jiD67xwlm4qJ1ii-ghc9.12.4.so \
libHSdoctemplates-0.11.0.1-IzKaCnMe41UBaZntO1p87J-ghc9.12.4.so \
libHSeasy-file-0.2.5-HaH29sPzevuLIcTD4Zvwg0-ghc9.12.4.so \
libHSech-config-0.0.1-Dq8pFxp7oP5KsTo31dxOND-ghc9.12.4.so \
libHSemojis-0.1.5-AZAxFgnk0gPLtmkqpmmj2s-ghc9.12.4.so \
libHSexceptions-0.10.12-f655-ghc9.12.4.so \
libHSfast-logger-3.2.6-JkXOEB4fbDV8mDlAr0wMkH-ghc9.12.4.so \
libHSfile-embed-0.0.16.0-JqsWezc6wrB9rh480YKWnn-ghc9.12.4.so \
libHSfile-io-0.1.6-8374-ghc9.12.4.so \
libHSfilepath-1.5.5.0-b25b-ghc9.12.4.so \
libHSgenerics-sop-0.5.1.4-AvLlDZ30DmSAgpFaUKsIGG-ghc9.12.4.so \
libHSghc-bignum-1.3-03b0-ghc9.12.4.so \
libHSghc-boot-th-9.12.4-0605-ghc9.12.4.so \
libHSghc-internal-9.1204.0-f1e1-ghc9.12.4.so \
libHSghc-prim-0.13.0-f55c-ghc9.12.4.so \
libHSgridtables-0.1.1.0-KsHUhKw0ygq7hJHkhQZNzX-ghc9.12.4.so \
libHShaddock-library-1.11.0-799c-ghc9.12.4.so \
libHShalf-0.3.3-7uW8H7RguCn8iNkagLajaD-ghc9.12.4.so \
libHShashable-1.5.1.0-csiQUH7RkN8TUlZyJbFpr-ghc9.12.4.so \
libHShaskell-lexer-1.2.1-4PpJ3cUTICwEJqFuz43JwQ-ghc9.12.4.so \
libHShpke-0.1.0-FWQ67GYIQQ2GKLielMsG9n-ghc9.12.4.so \
libHShttp-api-data-0.6.3-I1ef71ZD4mvBWZMbbifsIw-ghc9.12.4.so \
libHShttp-client-0.7.19-4BIOUl8FXXcE32miDzHR9M-ghc9.12.4.so \
libHShttp-client-tls-0.4.0-D4cx6zdDU3O6iLaLdAAVnV-ghc9.12.4.so \
libHShttp-date-0.0.11-6QGoEWt5iWVBVu6inZxd9J-ghc9.12.4.so \
libHShttp-media-0.8.1.1-CGZiZUC7By82YjYrR6pIDk-ghc9.12.4.so \
libHShttp-semantics-0.3.0-D5AfX4HSpBm3DHrTNQ2Sqe-ghc9.12.4.so \
libHShttp-types-0.12.5-FL2i1xGcqPq49wgWtgpOPM-ghc9.12.4.so \
libHShttp2-5.3.10-I2wENTFww6Z7L3LiFVkQpl-ghc9.12.4.so \
libHSindexed-traversable-0.1.5-JylwuAInS9n4ImeZ4JChDW-ghc9.12.4.so \
libHSindexed-traversable-instances-0.1.2.1-6YpZT8gBjiD9ssAaPGVbKH-ghc9.12.4.so \
libHSinteger-conversion-0.1.1-HaWNFfmKaxu3271U3IJ8uO-ghc9.12.4.so \
libHSinteger-gmp-1.1-09fd-ghc9.12.4.so \
libHSinteger-logarithms-1.0.5-7oN15VqsexT8F3DIJBcPo2-ghc9.12.4.so \
libHSiproute-1.7.15-E8DjYDi46DFHUJbuCQco8p-ghc9.12.4.so \
libHSipynb-0.2-FFISJjoqmq33DtDQybniaE-ghc9.12.4.so \
libHSjira-wiki-markup-1.5.1-98GFxAn8YwIIHGuEhvyDFl-ghc9.12.4.so \
libHSlibyaml-0.1.4-E4bvPREJvp6KOHEKYnSP5s-ghc9.12.4.so \
libHSmime-types-0.1.2.2-6XnqAsimqz1GLkPrdggNkp-ghc9.12.4.so \
libHSmlkem-0.2.1.0-I3LOwjV1LZnU6D8hY2Ok5-ghc9.12.4.so \
libHSmmorph-1.2.2-8rdXPOqza0cFiQFk7Wz51h-ghc9.12.4.so \
libHSmonad-control-1.0.3.1-EAQeykrh4iCEl5x3Heycqt-ghc9.12.4.so \
libHSmono-traversable-1.0.21.0-7NlL4qRFn1MB3sC5GPCjes-ghc9.12.4.so \
libHSmtl-2.3.2-37ef-ghc9.12.4.so \
libHSnetwork-3.2.8.0-HuXYLk4qLzHK9Hhg0VTDpI-ghc9.12.4.so \
libHSnetwork-byte-order-0.1.8-2e5INl5ljJtIwuBIoNgv18-ghc9.12.4.so \
libHSnetwork-control-0.1.7-A85ociXgUcsEREzO9qpors-ghc9.12.4.so \
libHSnetwork-uri-2.6.4.2-BA29PoG9pX1EAcGKolsVh8-ghc9.12.4.so \
libHSold-locale-1.0.0.7-DplRrAcnBM96ijBftoXSc5-ghc9.12.4.so \
libHSold-time-1.1.1.0-LOMYAgPdxtNFCxdl8604aX-ghc9.12.4.so \
libHSoptparse-applicative-0.19.0.0-GyrRSLDSSh1GQCxnTYbnDq-ghc9.12.4.so \
libHSordered-containers-0.2.4-AerqY0uBw917ksiEkklhVb-ghc9.12.4.so \
libHSos-string-2.0.10-5320-ghc9.12.4.so \
libHSpandoc-3.10-3FNhTvSQPq5K7XNe2M6XFp-xml-light-ghc9.12.4.so \
libHSpandoc-3.10-JLto7RkhLOI6KJZumkARl-ghc9.12.4.so \
libHSpandoc-types-1.23.1.2-ChVVUkZ84FqF7WWwilaI65-ghc9.12.4.so \
libHSparsec-3.1.18.0-be05-ghc9.12.4.so \
libHSpretty-1.1.3.6-b7fd-ghc9.12.4.so \
libHSpretty-show-1.10-9HKVlh92Ga177833HqSrwq-ghc9.12.4.so \
libHSprettyprinter-1.7.2-I8Z9oIqYCiwIS8uRvukUd0-ghc9.12.4.so \
libHSprettyprinter-ansi-terminal-1.1.4-IMyc3qw4SO1C4KUUC4JLom-ghc9.12.4.so \
libHSprimitive-0.9.1.0-Ez30Vu7tivmF28X1123Css-ghc9.12.4.so \
libHSprocess-1.6.26.1-905d-ghc9.12.4.so \
libHSpsqueues-0.2.8.3-LV1BnLV5SZeHAyWb6kEDRu-ghc9.12.4.so \
libHSram-0.22.0-4Io46KcWliV5ncwh4lemlr-ghc9.12.4.so \
libHSrandom-1.3.1-JfaDd4Q5FuLKGb9yRr3GDh-ghc9.12.4.so \
libHSrecv-0.1.1-9tN4UPJrbcvHykqBUpm2ul-ghc9.12.4.so \
libHSregex-base-0.94.0.3-1XPR6520nrRCZPbnaVzsF0-ghc9.12.4.so \
libHSregex-tdfa-1.3.2.5-DS5gfI36p0L6e0JJtc3gfd-ghc9.12.4.so \
libHSresourcet-1.3.0-F8ZRgExkptBLIQxE9m0AZE-ghc9.12.4.so \
libHSsafe-0.3.21-AzRUUYeJ47sQc55olWnva-ghc9.12.4.so \
libHSscientific-0.3.8.1-EfN6leGWc5k1t5YPK2dkVk-ghc9.12.4.so \
libHSsemialign-1.3.1.1-2gupAkHqo8uDH6Y43n5yi0-ghc9.12.4.so \
libHSsemigroupoids-6.0.2-B6Y5GIvJ2JI8mXJpMQTJaF-ghc9.12.4.so \
libHSserialise-0.2.6.1-IhsMlR98JASD6tuC7PEMx7-ghc9.12.4.so \
libHSservant-0.20.3.0-AuNk1SYjBzoHus6V4PFhXb-ghc9.12.4.so \
libHSservant-server-0.20.3.0-EUZLoQT6Id58gnaZtFsp96-ghc9.12.4.so \
libHSsimple-sendfile-0.2.32-1TxnJXytdne4UoBrRdi39p-ghc9.12.4.so \
libHSsingleton-bool-0.1.8-HY7gfyx2MgbLc4ChWl2rDv-ghc9.12.4.so \
libHSskylighting-0.14.7-K7tduWH6oDI3SHlt3x5zoz-ghc9.12.4.so \
libHSskylighting-core-0.14.7-HkvmMdabOkA2nMBfVgE9uo-ghc9.12.4.so \
libHSskylighting-format-ansi-0.1-CknB8O3hJJk2idRwuOLFgG-ghc9.12.4.so \
libHSskylighting-format-blaze-html-0.1.2-8KLHTNpYrUCBAqffmTPiOR-ghc9.12.4.so \
libHSskylighting-format-context-0.1.0.2-EzEDygUtfEzGScwK06ebkH-ghc9.12.4.so \
libHSskylighting-format-latex-0.1-1TNSCzX0YGK3X45liMm1xQ-ghc9.12.4.so \
libHSskylighting-format-typst-0.1-EVTf55sbYfZHcIDokFEiNE-ghc9.12.4.so \
libHSsome-1.0.6-8u6QsVxyLEPKKVYkZL0j6j-ghc9.12.4.so \
libHSsop-core-0.5.0.2-JbzyU3U5Jc9a9b8Omhy6m-ghc9.12.4.so \
libHSsplit-0.2.5-DF0qBqNymX3Hv5Ta0307xc-ghc9.12.4.so \
libHSsplitmix-0.1.3.2-4FIxgclJzmILwETMtGxhg4-ghc9.12.4.so \
libHSstm-2.5.3.1-6d74-ghc9.12.4.so \
libHSstreaming-commons-0.2.3.1-LJ82XapHNc8JLhXXxelQgC-ghc9.12.4.so \
libHSstrict-0.5.1-9s5NAvHzvkrI18NRIQgFhz-ghc9.12.4.so \
libHSsyb-0.7.4-6fi78MDXPhtHdqjdF3SBYJ-ghc9.12.4.so \
libHStagged-0.8.10-H6Ef5dd4ktu4CIJjtjtwM7-ghc9.12.4.so \
libHStagsoup-0.14.8-10TuRISnkEwKwhRg5mGRCv-ghc9.12.4.so \
libHStemplate-haskell-2.23.0.0-358a-ghc9.12.4.so \
libHStemporary-1.3-2Osk9MNG2oU9jER7tTbSTz-ghc9.12.4.so \
libHStexmath-0.13.1.2-EtUAetkdjsPLSCg4vaSXlD-ghc9.12.4.so \
libHStext-2.1.4-cf23-ghc9.12.4.so \
libHStext-conversions-0.3.1.1-20nmORR03VHGl8svDWla5t-ghc9.12.4.so \
libHStext-iso8601-0.1.1.1-6Bjz9eUSPP1K02pEWpeews-ghc9.12.4.so \
libHStext-short-0.1.6.1-K3gVAGEPLemvxyg6g1yq-ghc9.12.4.so \
libHSth-abstraction-0.7.2.0-LVMuWnluhDI5se4FHUInw7-ghc9.12.4.so \
libHSth-compat-0.1.7-A4ZdivYymzPCDISaa5LNtp-ghc9.12.4.so \
libHSth-lift-0.8.7-C08bSURuEXt2IuYgZMzZEc-ghc9.12.4.so \
libHSth-lift-instances-0.1.20-A0nCC2bmuVRHGZj0nSUeyw-ghc9.12.4.so \
libHSthese-1.2.1-IItOvRyyn8cFsXxaqiOQHG-ghc9.12.4.so \
libHStime-1.14-a7dc-ghc9.12.4.so \
libHStime-compat-1.9.9-2vndaypoxzm5lJpcdxrQvS-ghc9.12.4.so \
libHStime-hourglass-0.3.0-3eH7mx2lN21L13Pl8jWv6l-ghc9.12.4.so \
libHStime-manager-0.2.4-H8vBuVTBThX7XPtYuadAK4-ghc9.12.4.so \
libHStls-2.4.3-9EoJ6T6XUplFSFHrhcQuuh-ghc9.12.4.so \
libHStoml-parser-2.0.2.0-5orbE5KlUlGF8qGuEq1R69-ghc9.12.4.so \
libHStransformers-0.6.3.0-4709-ghc9.12.4.so \
libHStransformers-base-0.4.6.1-AexBYmHB9CZDEWAojzlCzB-ghc9.12.4.so \
libHStransformers-compat-0.7.2-Je4epVh1rXP8zT22dFNkMW-ghc9.12.4.so \
libHStyped-process-0.2.13.0-Igkw9DqKpM63tp2LRi4SDw-ghc9.12.4.so \
libHStypst-0.10-8KAGliP0h3p8xNVP0a5115-ghc9.12.4.so \
libHStypst-symbols-0.2-DAnODvBkUY47mTgQn4NVCA-ghc9.12.4.so \
libHSunicode-collation-0.1.3.7-15abqneWG6p19BxNVdLS7C-ghc9.12.4.so \
libHSunicode-data-0.6.0-L8MzYkzbuQvKbpFsnfTHmj-ghc9.12.4.so \
libHSunicode-transforms-0.4.0.1-KtQjAe86DCEJDcpSXQHRSI-ghc9.12.4.so \
libHSuniplate-1.6.13-FhUIjk7rCCk8dCOMm0dejl-ghc9.12.4.so \
libHSunix-2.8.8.0-178a-ghc9.12.4.so \
libHSunix-compat-0.7.4.1-4v781Gok1KY8Kg7jV1j1vn-ghc9.12.4.so \
libHSunix-time-0.4.17-BauOeKKKj6kENMTfxOVI2q-ghc9.12.4.so \
libHSunliftio-core-0.2.1.0-HFUY5mS3bsg3RW1edumY92-ghc9.12.4.so \
libHSunordered-containers-0.2.21-BkBQHKMtdH7EKz6YnT01Lu-ghc9.12.4.so \
libHSutf8-string-1.0.2-FCJm07Id8m53KWoTjjdHEG-ghc9.12.4.so \
libHSuuid-types-1.0.6.1-Hjv8dqZq3Ya2vXZL2YjpUd-ghc9.12.4.so \
libHSvault-0.3.2.0-GYOqPpJA2DW5Qz2IFtkvei-ghc9.12.4.so \
libHSvector-0.13.2.0-F8givqpU8HnLN0O3dVdeWE-ghc9.12.4.so \
libHSvector-algorithms-0.9.1.0-KRcdYzVzgLOFSifxDHEL6p-ghc9.12.4.so \
libHSvector-stream-0.1.0.1-FXRnPnZDT7tJ4JCMEuh1XF-ghc9.12.4.so \
libHSwai-3.2.4-Is1UVC1czjX2cAufnl3tJW-ghc9.12.4.so \
libHSwai-app-static-3.1.9.1-79h1qWsU2OJ8maZZtyFIQX-ghc9.12.4.so \
libHSwai-cors-0.2.7-2KEC2j0rC3VACXCCYdkSR7-ghc9.12.4.so \
libHSwai-extra-3.1.18-ITQet8OpxGX98ABokzjnL2-ghc9.12.4.so \
libHSwai-logger-2.5.0-3cHzLKgypSbCdVbvyxsJiz-ghc9.12.4.so \
libHSwarp-3.4.9-4LBlVKyJZyS6kjQUEE5DAG-ghc9.12.4.so \
libHSwitherable-0.5-9N1HkgvlVrcAVLkWTGxi2z-ghc9.12.4.so \
libHSword8-0.1.3-DJye6up9iU5LN32ihJcMva-ghc9.12.4.so \
libHSxml-1.3.14-JuCOsTtMISWPxn2nU4HVl-ghc9.12.4.so \
libHSxml-conduit-1.10.1.0-Jdtas0kp0k3Ah1vCZSqZl4-ghc9.12.4.so \
libHSxml-types-0.3.8-35OA2z37X8M4UCRyGooeYw-ghc9.12.4.so \
libHSyaml-0.11.11.2-DNw228htw8L33w1OC1EWSt-ghc9.12.4.so \
libHSzip-archive-0.4.3.2-7LOPKgQ3Ei9AA5FjkJE7vc-ghc9.12.4.so \
libHSzlib-0.7.1.1-9wvDfX7JlnE99sTdZLYOpU-ghc9.12.4.so \
libc.so.6 \
libgmp.so.10 \
libm.so.6 \
libyaml-0.so.2 \
libz.so.1"

inherit rpm
