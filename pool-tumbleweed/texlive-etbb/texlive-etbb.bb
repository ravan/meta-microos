SUMMARY = "An expansion of Edward Tufte's ET-Bembo family"
DESCRIPTION = "Based on Daniel Benjamin Miller's XETBook, which expanded \
Tufte's ETBook, the family name for the Bembo-like font family \
he commissioned for his books, ETbb expands its features to \
include a full set of figure styles, small caps in all styles, \
superior letters and figures, inferior figures, a new capital \
Sharp S with small caps version, along with macros to activate \
these features in LaTeX. Both otf and pfb are provided."
LICENSE = "LPPL-1.0"

PV = "2026.226.1.057svn69098"

RPM_NAME = "texlive-etbb-2026.226.1.057svn69098-59.2.noarch.rpm"
RPM_HASH = "e2c8822e793906f8b51db499c6cd9853a67d25545e39bcb3947376a4623d9f7506b4d8a203685cb8dd620a19efe2e6d04998eda23d508f708b947f61752ec7a5"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-ETbb-Bold-dnom-ly1--base.tfm \
tex-ETbb-Bold-dnom-ly1.tfm \
tex-ETbb-Bold-dnom-ly1.vf \
tex-ETbb-Bold-dnom-ot1.tfm \
tex-ETbb-Bold-dnom-t1--base.tfm \
tex-ETbb-Bold-dnom-t1.tfm \
tex-ETbb-Bold-dnom-t1.vf \
tex-ETbb-Bold-inf-ly1--base.tfm \
tex-ETbb-Bold-inf-ly1.tfm \
tex-ETbb-Bold-inf-ly1.vf \
tex-ETbb-Bold-inf-ot1.tfm \
tex-ETbb-Bold-inf-t1--base.tfm \
tex-ETbb-Bold-inf-t1.tfm \
tex-ETbb-Bold-inf-t1.vf \
tex-ETbb-Bold-lf-ly1--base.tfm \
tex-ETbb-Bold-lf-ly1.tfm \
tex-ETbb-Bold-lf-ly1.vf \
tex-ETbb-Bold-lf-ot1.tfm \
tex-ETbb-Bold-lf-sc-ly1--base.tfm \
tex-ETbb-Bold-lf-sc-ly1.tfm \
tex-ETbb-Bold-lf-sc-ly1.vf \
tex-ETbb-Bold-lf-sc-ot1--base.tfm \
tex-ETbb-Bold-lf-sc-ot1.tfm \
tex-ETbb-Bold-lf-sc-ot1.vf \
tex-ETbb-Bold-lf-sc-t1--base.tfm \
tex-ETbb-Bold-lf-sc-t1.tfm \
tex-ETbb-Bold-lf-sc-t1.vf \
tex-ETbb-Bold-lf-swash-ly1--base.tfm \
tex-ETbb-Bold-lf-swash-ly1.tfm \
tex-ETbb-Bold-lf-swash-ly1.vf \
tex-ETbb-Bold-lf-swash-ot1.tfm \
tex-ETbb-Bold-lf-swash-t1--base.tfm \
tex-ETbb-Bold-lf-swash-t1.tfm \
tex-ETbb-Bold-lf-swash-t1.vf \
tex-ETbb-Bold-lf-t1--base.tfm \
tex-ETbb-Bold-lf-t1.tfm \
tex-ETbb-Bold-lf-t1.vf \
tex-ETbb-Bold-lf-ts1--base.tfm \
tex-ETbb-Bold-lf-ts1.tfm \
tex-ETbb-Bold-lf-ts1.vf \
tex-ETbb-Bold-osf-ly1--base.tfm \
tex-ETbb-Bold-osf-ly1.tfm \
tex-ETbb-Bold-osf-ly1.vf \
tex-ETbb-Bold-osf-ot1.tfm \
tex-ETbb-Bold-osf-sc-ly1--base.tfm \
tex-ETbb-Bold-osf-sc-ly1.tfm \
tex-ETbb-Bold-osf-sc-ly1.vf \
tex-ETbb-Bold-osf-sc-ot1--base.tfm \
tex-ETbb-Bold-osf-sc-ot1.tfm \
tex-ETbb-Bold-osf-sc-ot1.vf \
tex-ETbb-Bold-osf-sc-t1--base.tfm \
tex-ETbb-Bold-osf-sc-t1.tfm \
tex-ETbb-Bold-osf-sc-t1.vf \
tex-ETbb-Bold-osf-swash-ly1--base.tfm \
tex-ETbb-Bold-osf-swash-ly1.tfm \
tex-ETbb-Bold-osf-swash-ly1.vf \
tex-ETbb-Bold-osf-swash-ot1.tfm \
tex-ETbb-Bold-osf-swash-t1--base.tfm \
tex-ETbb-Bold-osf-swash-t1.tfm \
tex-ETbb-Bold-osf-swash-t1.vf \
tex-ETbb-Bold-osf-t1--base.tfm \
tex-ETbb-Bold-osf-t1.tfm \
tex-ETbb-Bold-osf-t1.vf \
tex-ETbb-Bold-osf-ts1--base.tfm \
tex-ETbb-Bold-osf-ts1.tfm \
tex-ETbb-Bold-osf-ts1.vf \
tex-ETbb-Bold-sup-ly1--base.tfm \
tex-ETbb-Bold-sup-ly1.tfm \
tex-ETbb-Bold-sup-ly1.vf \
tex-ETbb-Bold-sup-ot1.tfm \
tex-ETbb-Bold-sup-t1--base.tfm \
tex-ETbb-Bold-sup-t1.tfm \
tex-ETbb-Bold-sup-t1.vf \
tex-ETbb-Bold-tlf-ly1--base.tfm \
tex-ETbb-Bold-tlf-ly1.tfm \
tex-ETbb-Bold-tlf-ly1.vf \
tex-ETbb-Bold-tlf-ot1.tfm \
tex-ETbb-Bold-tlf-sc-ly1--base.tfm \
tex-ETbb-Bold-tlf-sc-ly1.tfm \
tex-ETbb-Bold-tlf-sc-ly1.vf \
tex-ETbb-Bold-tlf-sc-ot1--base.tfm \
tex-ETbb-Bold-tlf-sc-ot1.tfm \
tex-ETbb-Bold-tlf-sc-ot1.vf \
tex-ETbb-Bold-tlf-sc-t1--base.tfm \
tex-ETbb-Bold-tlf-sc-t1.tfm \
tex-ETbb-Bold-tlf-sc-t1.vf \
tex-ETbb-Bold-tlf-swash-ly1--base.tfm \
tex-ETbb-Bold-tlf-swash-ly1.tfm \
tex-ETbb-Bold-tlf-swash-ly1.vf \
tex-ETbb-Bold-tlf-swash-ot1.tfm \
tex-ETbb-Bold-tlf-swash-t1--base.tfm \
tex-ETbb-Bold-tlf-swash-t1.tfm \
tex-ETbb-Bold-tlf-swash-t1.vf \
tex-ETbb-Bold-tlf-t1--base.tfm \
tex-ETbb-Bold-tlf-t1.tfm \
tex-ETbb-Bold-tlf-t1.vf \
tex-ETbb-Bold-tlf-ts1--base.tfm \
tex-ETbb-Bold-tlf-ts1.tfm \
tex-ETbb-Bold-tlf-ts1.vf \
tex-ETbb-Bold-tosf-ly1--base.tfm \
tex-ETbb-Bold-tosf-ly1.tfm \
tex-ETbb-Bold-tosf-ly1.vf \
tex-ETbb-Bold-tosf-ot1.tfm \
tex-ETbb-Bold-tosf-sc-ly1--base.tfm \
tex-ETbb-Bold-tosf-sc-ly1.tfm \
tex-ETbb-Bold-tosf-sc-ly1.vf \
tex-ETbb-Bold-tosf-sc-ot1--base.tfm \
tex-ETbb-Bold-tosf-sc-ot1.tfm \
tex-ETbb-Bold-tosf-sc-ot1.vf \
tex-ETbb-Bold-tosf-sc-t1--base.tfm \
tex-ETbb-Bold-tosf-sc-t1.tfm \
tex-ETbb-Bold-tosf-sc-t1.vf \
tex-ETbb-Bold-tosf-swash-ly1--base.tfm \
tex-ETbb-Bold-tosf-swash-ly1.tfm \
tex-ETbb-Bold-tosf-swash-ly1.vf \
tex-ETbb-Bold-tosf-swash-ot1.tfm \
tex-ETbb-Bold-tosf-swash-t1--base.tfm \
tex-ETbb-Bold-tosf-swash-t1.tfm \
tex-ETbb-Bold-tosf-swash-t1.vf \
tex-ETbb-Bold-tosf-t1--base.tfm \
tex-ETbb-Bold-tosf-t1.tfm \
tex-ETbb-Bold-tosf-t1.vf \
tex-ETbb-Bold-tosf-ts1--base.tfm \
tex-ETbb-Bold-tosf-ts1.tfm \
tex-ETbb-Bold-tosf-ts1.vf \
tex-ETbb-BoldItalic-dnom-ly1--base.tfm \
tex-ETbb-BoldItalic-dnom-ly1.tfm \
tex-ETbb-BoldItalic-dnom-ly1.vf \
tex-ETbb-BoldItalic-dnom-ot1.tfm \
tex-ETbb-BoldItalic-dnom-t1--base.tfm \
tex-ETbb-BoldItalic-dnom-t1.tfm \
tex-ETbb-BoldItalic-dnom-t1.vf \
tex-ETbb-BoldItalic-inf-ly1--base.tfm \
tex-ETbb-BoldItalic-inf-ly1.tfm \
tex-ETbb-BoldItalic-inf-ly1.vf \
tex-ETbb-BoldItalic-inf-ot1.tfm \
tex-ETbb-BoldItalic-inf-t1--base.tfm \
tex-ETbb-BoldItalic-inf-t1.tfm \
tex-ETbb-BoldItalic-inf-t1.vf \
tex-ETbb-BoldItalic-lf-ly1--base.tfm \
tex-ETbb-BoldItalic-lf-ly1.tfm \
tex-ETbb-BoldItalic-lf-ly1.vf \
tex-ETbb-BoldItalic-lf-ot1.tfm \
tex-ETbb-BoldItalic-lf-sc-ly1--base.tfm \
tex-ETbb-BoldItalic-lf-sc-ly1.tfm \
tex-ETbb-BoldItalic-lf-sc-ly1.vf \
tex-ETbb-BoldItalic-lf-sc-ot1--base.tfm \
tex-ETbb-BoldItalic-lf-sc-ot1.tfm \
tex-ETbb-BoldItalic-lf-sc-ot1.vf \
tex-ETbb-BoldItalic-lf-sc-t1--base.tfm \
tex-ETbb-BoldItalic-lf-sc-t1.tfm \
tex-ETbb-BoldItalic-lf-sc-t1.vf \
tex-ETbb-BoldItalic-lf-swash-ly1--base.tfm \
tex-ETbb-BoldItalic-lf-swash-ly1.tfm \
tex-ETbb-BoldItalic-lf-swash-ly1.vf \
tex-ETbb-BoldItalic-lf-swash-ot1.tfm \
tex-ETbb-BoldItalic-lf-swash-t1--base.tfm \
tex-ETbb-BoldItalic-lf-swash-t1.tfm \
tex-ETbb-BoldItalic-lf-swash-t1.vf \
tex-ETbb-BoldItalic-lf-t1--base.tfm \
tex-ETbb-BoldItalic-lf-t1.tfm \
tex-ETbb-BoldItalic-lf-t1.vf \
tex-ETbb-BoldItalic-lf-ts1--base.tfm \
tex-ETbb-BoldItalic-lf-ts1.tfm \
tex-ETbb-BoldItalic-lf-ts1.vf \
tex-ETbb-BoldItalic-osf-ly1--base.tfm \
tex-ETbb-BoldItalic-osf-ly1.tfm \
tex-ETbb-BoldItalic-osf-ly1.vf \
tex-ETbb-BoldItalic-osf-ot1.tfm \
tex-ETbb-BoldItalic-osf-sc-ly1--base.tfm \
tex-ETbb-BoldItalic-osf-sc-ly1.tfm \
tex-ETbb-BoldItalic-osf-sc-ly1.vf \
tex-ETbb-BoldItalic-osf-sc-ot1--base.tfm \
tex-ETbb-BoldItalic-osf-sc-ot1.tfm \
tex-ETbb-BoldItalic-osf-sc-ot1.vf \
tex-ETbb-BoldItalic-osf-sc-t1--base.tfm \
tex-ETbb-BoldItalic-osf-sc-t1.tfm \
tex-ETbb-BoldItalic-osf-sc-t1.vf \
tex-ETbb-BoldItalic-osf-swash-ly1--base.tfm \
tex-ETbb-BoldItalic-osf-swash-ly1.tfm \
tex-ETbb-BoldItalic-osf-swash-ly1.vf \
tex-ETbb-BoldItalic-osf-swash-ot1.tfm \
tex-ETbb-BoldItalic-osf-swash-t1--base.tfm \
tex-ETbb-BoldItalic-osf-swash-t1.tfm \
tex-ETbb-BoldItalic-osf-swash-t1.vf \
tex-ETbb-BoldItalic-osf-t1--base.tfm \
tex-ETbb-BoldItalic-osf-t1.tfm \
tex-ETbb-BoldItalic-osf-t1.vf \
tex-ETbb-BoldItalic-osf-ts1--base.tfm \
tex-ETbb-BoldItalic-osf-ts1.tfm \
tex-ETbb-BoldItalic-osf-ts1.vf \
tex-ETbb-BoldItalic-sup-ly1--base.tfm \
tex-ETbb-BoldItalic-sup-ly1.tfm \
tex-ETbb-BoldItalic-sup-ly1.vf \
tex-ETbb-BoldItalic-sup-ot1.tfm \
tex-ETbb-BoldItalic-sup-t1--base.tfm \
tex-ETbb-BoldItalic-sup-t1.tfm \
tex-ETbb-BoldItalic-sup-t1.vf \
tex-ETbb-BoldItalic-tlf-ly1--base.tfm \
tex-ETbb-BoldItalic-tlf-ly1.tfm \
tex-ETbb-BoldItalic-tlf-ly1.vf \
tex-ETbb-BoldItalic-tlf-ot1.tfm \
tex-ETbb-BoldItalic-tlf-sc-ly1--base.tfm \
tex-ETbb-BoldItalic-tlf-sc-ly1.tfm \
tex-ETbb-BoldItalic-tlf-sc-ly1.vf \
tex-ETbb-BoldItalic-tlf-sc-ot1--base.tfm \
tex-ETbb-BoldItalic-tlf-sc-ot1.tfm \
tex-ETbb-BoldItalic-tlf-sc-ot1.vf \
tex-ETbb-BoldItalic-tlf-sc-t1--base.tfm \
tex-ETbb-BoldItalic-tlf-sc-t1.tfm \
tex-ETbb-BoldItalic-tlf-sc-t1.vf \
tex-ETbb-BoldItalic-tlf-swash-ly1--base.tfm \
tex-ETbb-BoldItalic-tlf-swash-ly1.tfm \
tex-ETbb-BoldItalic-tlf-swash-ly1.vf \
tex-ETbb-BoldItalic-tlf-swash-ot1.tfm \
tex-ETbb-BoldItalic-tlf-swash-t1--base.tfm \
tex-ETbb-BoldItalic-tlf-swash-t1.tfm \
tex-ETbb-BoldItalic-tlf-swash-t1.vf \
tex-ETbb-BoldItalic-tlf-t1--base.tfm \
tex-ETbb-BoldItalic-tlf-t1.tfm \
tex-ETbb-BoldItalic-tlf-t1.vf \
tex-ETbb-BoldItalic-tlf-ts1--base.tfm \
tex-ETbb-BoldItalic-tlf-ts1.tfm \
tex-ETbb-BoldItalic-tlf-ts1.vf \
tex-ETbb-BoldItalic-tosf-ly1--base.tfm \
tex-ETbb-BoldItalic-tosf-ly1.tfm \
tex-ETbb-BoldItalic-tosf-ly1.vf \
tex-ETbb-BoldItalic-tosf-ot1.tfm \
tex-ETbb-BoldItalic-tosf-sc-ly1--base.tfm \
tex-ETbb-BoldItalic-tosf-sc-ly1.tfm \
tex-ETbb-BoldItalic-tosf-sc-ly1.vf \
tex-ETbb-BoldItalic-tosf-sc-ot1--base.tfm \
tex-ETbb-BoldItalic-tosf-sc-ot1.tfm \
tex-ETbb-BoldItalic-tosf-sc-ot1.vf \
tex-ETbb-BoldItalic-tosf-sc-t1--base.tfm \
tex-ETbb-BoldItalic-tosf-sc-t1.tfm \
tex-ETbb-BoldItalic-tosf-sc-t1.vf \
tex-ETbb-BoldItalic-tosf-swash-ly1--base.tfm \
tex-ETbb-BoldItalic-tosf-swash-ly1.tfm \
tex-ETbb-BoldItalic-tosf-swash-ly1.vf \
tex-ETbb-BoldItalic-tosf-swash-ot1.tfm \
tex-ETbb-BoldItalic-tosf-swash-t1--base.tfm \
tex-ETbb-BoldItalic-tosf-swash-t1.tfm \
tex-ETbb-BoldItalic-tosf-swash-t1.vf \
tex-ETbb-BoldItalic-tosf-t1--base.tfm \
tex-ETbb-BoldItalic-tosf-t1.tfm \
tex-ETbb-BoldItalic-tosf-t1.vf \
tex-ETbb-BoldItalic-tosf-ts1--base.tfm \
tex-ETbb-BoldItalic-tosf-ts1.tfm \
tex-ETbb-BoldItalic-tosf-ts1.vf \
tex-ETbb-Italic-dnom-ly1--base.tfm \
tex-ETbb-Italic-dnom-ly1.tfm \
tex-ETbb-Italic-dnom-ly1.vf \
tex-ETbb-Italic-dnom-ot1.tfm \
tex-ETbb-Italic-dnom-t1--base.tfm \
tex-ETbb-Italic-dnom-t1.tfm \
tex-ETbb-Italic-dnom-t1.vf \
tex-ETbb-Italic-inf-ly1--base.tfm \
tex-ETbb-Italic-inf-ly1.tfm \
tex-ETbb-Italic-inf-ly1.vf \
tex-ETbb-Italic-inf-ot1.tfm \
tex-ETbb-Italic-inf-t1--base.tfm \
tex-ETbb-Italic-inf-t1.tfm \
tex-ETbb-Italic-inf-t1.vf \
tex-ETbb-Italic-lf-ly1--base.tfm \
tex-ETbb-Italic-lf-ly1.tfm \
tex-ETbb-Italic-lf-ly1.vf \
tex-ETbb-Italic-lf-ot1.tfm \
tex-ETbb-Italic-lf-sc-ly1--base.tfm \
tex-ETbb-Italic-lf-sc-ly1.tfm \
tex-ETbb-Italic-lf-sc-ly1.vf \
tex-ETbb-Italic-lf-sc-ot1--base.tfm \
tex-ETbb-Italic-lf-sc-ot1.tfm \
tex-ETbb-Italic-lf-sc-ot1.vf \
tex-ETbb-Italic-lf-sc-t1--base.tfm \
tex-ETbb-Italic-lf-sc-t1.tfm \
tex-ETbb-Italic-lf-sc-t1.vf \
tex-ETbb-Italic-lf-swash-ly1--base.tfm \
tex-ETbb-Italic-lf-swash-ly1.tfm \
tex-ETbb-Italic-lf-swash-ly1.vf \
tex-ETbb-Italic-lf-swash-ot1.tfm \
tex-ETbb-Italic-lf-swash-t1--base.tfm \
tex-ETbb-Italic-lf-swash-t1.tfm \
tex-ETbb-Italic-lf-swash-t1.vf \
tex-ETbb-Italic-lf-t1--base.tfm \
tex-ETbb-Italic-lf-t1.tfm \
tex-ETbb-Italic-lf-t1.vf \
tex-ETbb-Italic-lf-ts1--base.tfm \
tex-ETbb-Italic-lf-ts1.tfm \
tex-ETbb-Italic-lf-ts1.vf \
tex-ETbb-Italic-osf-ly1--base.tfm \
tex-ETbb-Italic-osf-ly1.tfm \
tex-ETbb-Italic-osf-ly1.vf \
tex-ETbb-Italic-osf-ot1.tfm \
tex-ETbb-Italic-osf-sc-ly1--base.tfm \
tex-ETbb-Italic-osf-sc-ly1.tfm \
tex-ETbb-Italic-osf-sc-ly1.vf \
tex-ETbb-Italic-osf-sc-ot1--base.tfm \
tex-ETbb-Italic-osf-sc-ot1.tfm \
tex-ETbb-Italic-osf-sc-ot1.vf \
tex-ETbb-Italic-osf-sc-t1--base.tfm \
tex-ETbb-Italic-osf-sc-t1.tfm \
tex-ETbb-Italic-osf-sc-t1.vf \
tex-ETbb-Italic-osf-swash-ly1--base.tfm \
tex-ETbb-Italic-osf-swash-ly1.tfm \
tex-ETbb-Italic-osf-swash-ly1.vf \
tex-ETbb-Italic-osf-swash-ot1.tfm \
tex-ETbb-Italic-osf-swash-t1--base.tfm \
tex-ETbb-Italic-osf-swash-t1.tfm \
tex-ETbb-Italic-osf-swash-t1.vf \
tex-ETbb-Italic-osf-t1--base.tfm \
tex-ETbb-Italic-osf-t1.tfm \
tex-ETbb-Italic-osf-t1.vf \
tex-ETbb-Italic-osf-ts1--base.tfm \
tex-ETbb-Italic-osf-ts1.tfm \
tex-ETbb-Italic-osf-ts1.vf \
tex-ETbb-Italic-sup-ly1--base.tfm \
tex-ETbb-Italic-sup-ly1.tfm \
tex-ETbb-Italic-sup-ly1.vf \
tex-ETbb-Italic-sup-ot1.tfm \
tex-ETbb-Italic-sup-t1--base.tfm \
tex-ETbb-Italic-sup-t1.tfm \
tex-ETbb-Italic-sup-t1.vf \
tex-ETbb-Italic-tlf-ly1--base.tfm \
tex-ETbb-Italic-tlf-ly1.tfm \
tex-ETbb-Italic-tlf-ly1.vf \
tex-ETbb-Italic-tlf-ot1.tfm \
tex-ETbb-Italic-tlf-sc-ly1--base.tfm \
tex-ETbb-Italic-tlf-sc-ly1.tfm \
tex-ETbb-Italic-tlf-sc-ly1.vf \
tex-ETbb-Italic-tlf-sc-ot1--base.tfm \
tex-ETbb-Italic-tlf-sc-ot1.tfm \
tex-ETbb-Italic-tlf-sc-ot1.vf \
tex-ETbb-Italic-tlf-sc-t1--base.tfm \
tex-ETbb-Italic-tlf-sc-t1.tfm \
tex-ETbb-Italic-tlf-sc-t1.vf \
tex-ETbb-Italic-tlf-swash-ly1--base.tfm \
tex-ETbb-Italic-tlf-swash-ly1.tfm \
tex-ETbb-Italic-tlf-swash-ly1.vf \
tex-ETbb-Italic-tlf-swash-ot1.tfm \
tex-ETbb-Italic-tlf-swash-t1--base.tfm \
tex-ETbb-Italic-tlf-swash-t1.tfm \
tex-ETbb-Italic-tlf-swash-t1.vf \
tex-ETbb-Italic-tlf-t1--base.tfm \
tex-ETbb-Italic-tlf-t1.tfm \
tex-ETbb-Italic-tlf-t1.vf \
tex-ETbb-Italic-tlf-ts1--base.tfm \
tex-ETbb-Italic-tlf-ts1.tfm \
tex-ETbb-Italic-tlf-ts1.vf \
tex-ETbb-Italic-tosf-ly1--base.tfm \
tex-ETbb-Italic-tosf-ly1.tfm \
tex-ETbb-Italic-tosf-ly1.vf \
tex-ETbb-Italic-tosf-ot1.tfm \
tex-ETbb-Italic-tosf-sc-ly1--base.tfm \
tex-ETbb-Italic-tosf-sc-ly1.tfm \
tex-ETbb-Italic-tosf-sc-ly1.vf \
tex-ETbb-Italic-tosf-sc-ot1--base.tfm \
tex-ETbb-Italic-tosf-sc-ot1.tfm \
tex-ETbb-Italic-tosf-sc-ot1.vf \
tex-ETbb-Italic-tosf-sc-t1--base.tfm \
tex-ETbb-Italic-tosf-sc-t1.tfm \
tex-ETbb-Italic-tosf-sc-t1.vf \
tex-ETbb-Italic-tosf-swash-ly1--base.tfm \
tex-ETbb-Italic-tosf-swash-ly1.tfm \
tex-ETbb-Italic-tosf-swash-ly1.vf \
tex-ETbb-Italic-tosf-swash-ot1.tfm \
tex-ETbb-Italic-tosf-swash-t1--base.tfm \
tex-ETbb-Italic-tosf-swash-t1.tfm \
tex-ETbb-Italic-tosf-swash-t1.vf \
tex-ETbb-Italic-tosf-t1--base.tfm \
tex-ETbb-Italic-tosf-t1.tfm \
tex-ETbb-Italic-tosf-t1.vf \
tex-ETbb-Italic-tosf-ts1--base.tfm \
tex-ETbb-Italic-tosf-ts1.tfm \
tex-ETbb-Italic-tosf-ts1.vf \
tex-ETbb-Regular-dnom-ly1--base.tfm \
tex-ETbb-Regular-dnom-ly1.tfm \
tex-ETbb-Regular-dnom-ly1.vf \
tex-ETbb-Regular-dnom-ot1.tfm \
tex-ETbb-Regular-dnom-t1--base.tfm \
tex-ETbb-Regular-dnom-t1.tfm \
tex-ETbb-Regular-dnom-t1.vf \
tex-ETbb-Regular-inf-ly1--base.tfm \
tex-ETbb-Regular-inf-ly1.tfm \
tex-ETbb-Regular-inf-ly1.vf \
tex-ETbb-Regular-inf-ot1.tfm \
tex-ETbb-Regular-inf-t1--base.tfm \
tex-ETbb-Regular-inf-t1.tfm \
tex-ETbb-Regular-inf-t1.vf \
tex-ETbb-Regular-lf-ly1--base.tfm \
tex-ETbb-Regular-lf-ly1.tfm \
tex-ETbb-Regular-lf-ly1.vf \
tex-ETbb-Regular-lf-ot1.tfm \
tex-ETbb-Regular-lf-sc-ly1--base.tfm \
tex-ETbb-Regular-lf-sc-ly1.tfm \
tex-ETbb-Regular-lf-sc-ly1.vf \
tex-ETbb-Regular-lf-sc-ot1--base.tfm \
tex-ETbb-Regular-lf-sc-ot1.tfm \
tex-ETbb-Regular-lf-sc-ot1.vf \
tex-ETbb-Regular-lf-sc-t1--base.tfm \
tex-ETbb-Regular-lf-sc-t1.tfm \
tex-ETbb-Regular-lf-sc-t1.vf \
tex-ETbb-Regular-lf-swash-ly1--base.tfm \
tex-ETbb-Regular-lf-swash-ly1.tfm \
tex-ETbb-Regular-lf-swash-ly1.vf \
tex-ETbb-Regular-lf-swash-ot1.tfm \
tex-ETbb-Regular-lf-swash-t1--base.tfm \
tex-ETbb-Regular-lf-swash-t1.tfm \
tex-ETbb-Regular-lf-swash-t1.vf \
tex-ETbb-Regular-lf-t1--base.tfm \
tex-ETbb-Regular-lf-t1.tfm \
tex-ETbb-Regular-lf-t1.vf \
tex-ETbb-Regular-lf-ts1--base.tfm \
tex-ETbb-Regular-lf-ts1.tfm \
tex-ETbb-Regular-lf-ts1.vf \
tex-ETbb-Regular-osf-ly1--base.tfm \
tex-ETbb-Regular-osf-ly1.tfm \
tex-ETbb-Regular-osf-ly1.vf \
tex-ETbb-Regular-osf-ot1.tfm \
tex-ETbb-Regular-osf-sc-ly1--base.tfm \
tex-ETbb-Regular-osf-sc-ly1.tfm \
tex-ETbb-Regular-osf-sc-ly1.vf \
tex-ETbb-Regular-osf-sc-ot1--base.tfm \
tex-ETbb-Regular-osf-sc-ot1.tfm \
tex-ETbb-Regular-osf-sc-ot1.vf \
tex-ETbb-Regular-osf-sc-t1--base.tfm \
tex-ETbb-Regular-osf-sc-t1.tfm \
tex-ETbb-Regular-osf-sc-t1.vf \
tex-ETbb-Regular-osf-swash-ly1--base.tfm \
tex-ETbb-Regular-osf-swash-ly1.tfm \
tex-ETbb-Regular-osf-swash-ly1.vf \
tex-ETbb-Regular-osf-swash-ot1.tfm \
tex-ETbb-Regular-osf-swash-t1--base.tfm \
tex-ETbb-Regular-osf-swash-t1.tfm \
tex-ETbb-Regular-osf-swash-t1.vf \
tex-ETbb-Regular-osf-t1--base.tfm \
tex-ETbb-Regular-osf-t1.tfm \
tex-ETbb-Regular-osf-t1.vf \
tex-ETbb-Regular-osf-ts1--base.tfm \
tex-ETbb-Regular-osf-ts1.tfm \
tex-ETbb-Regular-osf-ts1.vf \
tex-ETbb-Regular-sup-ly1--base.tfm \
tex-ETbb-Regular-sup-ly1.tfm \
tex-ETbb-Regular-sup-ly1.vf \
tex-ETbb-Regular-sup-ot1.tfm \
tex-ETbb-Regular-sup-t1--base.tfm \
tex-ETbb-Regular-sup-t1.tfm \
tex-ETbb-Regular-sup-t1.vf \
tex-ETbb-Regular-tlf-ly1--base.tfm \
tex-ETbb-Regular-tlf-ly1.tfm \
tex-ETbb-Regular-tlf-ly1.vf \
tex-ETbb-Regular-tlf-ot1.tfm \
tex-ETbb-Regular-tlf-sc-ly1--base.tfm \
tex-ETbb-Regular-tlf-sc-ly1.tfm \
tex-ETbb-Regular-tlf-sc-ly1.vf \
tex-ETbb-Regular-tlf-sc-ot1--base.tfm \
tex-ETbb-Regular-tlf-sc-ot1.tfm \
tex-ETbb-Regular-tlf-sc-ot1.vf \
tex-ETbb-Regular-tlf-sc-t1--base.tfm \
tex-ETbb-Regular-tlf-sc-t1.tfm \
tex-ETbb-Regular-tlf-sc-t1.vf \
tex-ETbb-Regular-tlf-swash-ly1--base.tfm \
tex-ETbb-Regular-tlf-swash-ly1.tfm \
tex-ETbb-Regular-tlf-swash-ly1.vf \
tex-ETbb-Regular-tlf-swash-ot1.tfm \
tex-ETbb-Regular-tlf-swash-t1--base.tfm \
tex-ETbb-Regular-tlf-swash-t1.tfm \
tex-ETbb-Regular-tlf-swash-t1.vf \
tex-ETbb-Regular-tlf-t1--base.tfm \
tex-ETbb-Regular-tlf-t1.tfm \
tex-ETbb-Regular-tlf-t1.vf \
tex-ETbb-Regular-tlf-ts1--base.tfm \
tex-ETbb-Regular-tlf-ts1.tfm \
tex-ETbb-Regular-tlf-ts1.vf \
tex-ETbb-Regular-tosf-ly1--base.tfm \
tex-ETbb-Regular-tosf-ly1.tfm \
tex-ETbb-Regular-tosf-ly1.vf \
tex-ETbb-Regular-tosf-ot1.tfm \
tex-ETbb-Regular-tosf-sc-ly1--base.tfm \
tex-ETbb-Regular-tosf-sc-ly1.tfm \
tex-ETbb-Regular-tosf-sc-ly1.vf \
tex-ETbb-Regular-tosf-sc-ot1--base.tfm \
tex-ETbb-Regular-tosf-sc-ot1.tfm \
tex-ETbb-Regular-tosf-sc-ot1.vf \
tex-ETbb-Regular-tosf-sc-t1--base.tfm \
tex-ETbb-Regular-tosf-sc-t1.tfm \
tex-ETbb-Regular-tosf-sc-t1.vf \
tex-ETbb-Regular-tosf-swash-ly1--base.tfm \
tex-ETbb-Regular-tosf-swash-ly1.tfm \
tex-ETbb-Regular-tosf-swash-ly1.vf \
tex-ETbb-Regular-tosf-swash-ot1.tfm \
tex-ETbb-Regular-tosf-swash-t1--base.tfm \
tex-ETbb-Regular-tosf-swash-t1.tfm \
tex-ETbb-Regular-tosf-swash-t1.vf \
tex-ETbb-Regular-tosf-t1--base.tfm \
tex-ETbb-Regular-tosf-t1.tfm \
tex-ETbb-Regular-tosf-t1.vf \
tex-ETbb-Regular-tosf-ts1--base.tfm \
tex-ETbb-Regular-tosf-ts1.tfm \
tex-ETbb-Regular-tosf-ts1.vf \
tex-ETbb.map \
tex-ETbb.sty \
tex-Etbb1-Bold-lf-sc-t1--base.tfm \
tex-Etbb1-Bold-lf-sc-t1.tfm \
tex-Etbb1-Bold-lf-sc-t1.vf \
tex-Etbb1-Bold-lf-swash-t1--base.tfm \
tex-Etbb1-Bold-lf-swash-t1.tfm \
tex-Etbb1-Bold-lf-swash-t1.vf \
tex-Etbb1-Bold-lf-t1--base.tfm \
tex-Etbb1-Bold-lf-t1.tfm \
tex-Etbb1-Bold-lf-t1.vf \
tex-Etbb1-Bold-osf-sc-t1--base.tfm \
tex-Etbb1-Bold-osf-sc-t1.tfm \
tex-Etbb1-Bold-osf-sc-t1.vf \
tex-Etbb1-Bold-osf-swash-t1--base.tfm \
tex-Etbb1-Bold-osf-swash-t1.tfm \
tex-Etbb1-Bold-osf-swash-t1.vf \
tex-Etbb1-Bold-osf-t1--base.tfm \
tex-Etbb1-Bold-osf-t1.tfm \
tex-Etbb1-Bold-osf-t1.vf \
tex-Etbb1-Bold-tlf-sc-t1--base.tfm \
tex-Etbb1-Bold-tlf-sc-t1.tfm \
tex-Etbb1-Bold-tlf-sc-t1.vf \
tex-Etbb1-Bold-tlf-swash-t1--base.tfm \
tex-Etbb1-Bold-tlf-swash-t1.tfm \
tex-Etbb1-Bold-tlf-swash-t1.vf \
tex-Etbb1-Bold-tlf-t1--base.tfm \
tex-Etbb1-Bold-tlf-t1.tfm \
tex-Etbb1-Bold-tlf-t1.vf \
tex-Etbb1-Bold-tosf-sc-t1--base.tfm \
tex-Etbb1-Bold-tosf-sc-t1.tfm \
tex-Etbb1-Bold-tosf-sc-t1.vf \
tex-Etbb1-Bold-tosf-swash-t1--base.tfm \
tex-Etbb1-Bold-tosf-swash-t1.tfm \
tex-Etbb1-Bold-tosf-swash-t1.vf \
tex-Etbb1-Bold-tosf-t1--base.tfm \
tex-Etbb1-Bold-tosf-t1.tfm \
tex-Etbb1-Bold-tosf-t1.vf \
tex-Etbb1-BoldItalic-lf-sc-t1--base.tfm \
tex-Etbb1-BoldItalic-lf-sc-t1.tfm \
tex-Etbb1-BoldItalic-lf-sc-t1.vf \
tex-Etbb1-BoldItalic-lf-swash-t1--base.tfm \
tex-Etbb1-BoldItalic-lf-swash-t1.tfm \
tex-Etbb1-BoldItalic-lf-swash-t1.vf \
tex-Etbb1-BoldItalic-lf-t1--base.tfm \
tex-Etbb1-BoldItalic-lf-t1.tfm \
tex-Etbb1-BoldItalic-lf-t1.vf \
tex-Etbb1-BoldItalic-osf-sc-t1--base.tfm \
tex-Etbb1-BoldItalic-osf-sc-t1.tfm \
tex-Etbb1-BoldItalic-osf-sc-t1.vf \
tex-Etbb1-BoldItalic-osf-swash-t1--base.tfm \
tex-Etbb1-BoldItalic-osf-swash-t1.tfm \
tex-Etbb1-BoldItalic-osf-swash-t1.vf \
tex-Etbb1-BoldItalic-osf-t1--base.tfm \
tex-Etbb1-BoldItalic-osf-t1.tfm \
tex-Etbb1-BoldItalic-osf-t1.vf \
tex-Etbb1-BoldItalic-tlf-sc-t1--base.tfm \
tex-Etbb1-BoldItalic-tlf-sc-t1.tfm \
tex-Etbb1-BoldItalic-tlf-sc-t1.vf \
tex-Etbb1-BoldItalic-tlf-swash-t1--base.tfm \
tex-Etbb1-BoldItalic-tlf-swash-t1.tfm \
tex-Etbb1-BoldItalic-tlf-swash-t1.vf \
tex-Etbb1-BoldItalic-tlf-t1--base.tfm \
tex-Etbb1-BoldItalic-tlf-t1.tfm \
tex-Etbb1-BoldItalic-tlf-t1.vf \
tex-Etbb1-BoldItalic-tosf-sc-t1--base.tfm \
tex-Etbb1-BoldItalic-tosf-sc-t1.tfm \
tex-Etbb1-BoldItalic-tosf-sc-t1.vf \
tex-Etbb1-BoldItalic-tosf-swash-t1--base.tfm \
tex-Etbb1-BoldItalic-tosf-swash-t1.tfm \
tex-Etbb1-BoldItalic-tosf-swash-t1.vf \
tex-Etbb1-BoldItalic-tosf-t1--base.tfm \
tex-Etbb1-BoldItalic-tosf-t1.tfm \
tex-Etbb1-BoldItalic-tosf-t1.vf \
tex-Etbb1-Italic-lf-sc-t1--base.tfm \
tex-Etbb1-Italic-lf-sc-t1.tfm \
tex-Etbb1-Italic-lf-sc-t1.vf \
tex-Etbb1-Italic-lf-swash-t1--base.tfm \
tex-Etbb1-Italic-lf-swash-t1.tfm \
tex-Etbb1-Italic-lf-swash-t1.vf \
tex-Etbb1-Italic-lf-t1--base.tfm \
tex-Etbb1-Italic-lf-t1.tfm \
tex-Etbb1-Italic-lf-t1.vf \
tex-Etbb1-Italic-osf-sc-t1--base.tfm \
tex-Etbb1-Italic-osf-sc-t1.tfm \
tex-Etbb1-Italic-osf-sc-t1.vf \
tex-Etbb1-Italic-osf-swash-t1--base.tfm \
tex-Etbb1-Italic-osf-swash-t1.tfm \
tex-Etbb1-Italic-osf-swash-t1.vf \
tex-Etbb1-Italic-osf-t1--base.tfm \
tex-Etbb1-Italic-osf-t1.tfm \
tex-Etbb1-Italic-osf-t1.vf \
tex-Etbb1-Italic-tlf-sc-t1--base.tfm \
tex-Etbb1-Italic-tlf-sc-t1.tfm \
tex-Etbb1-Italic-tlf-sc-t1.vf \
tex-Etbb1-Italic-tlf-swash-t1--base.tfm \
tex-Etbb1-Italic-tlf-swash-t1.tfm \
tex-Etbb1-Italic-tlf-swash-t1.vf \
tex-Etbb1-Italic-tlf-t1--base.tfm \
tex-Etbb1-Italic-tlf-t1.tfm \
tex-Etbb1-Italic-tlf-t1.vf \
tex-Etbb1-Italic-tosf-sc-t1--base.tfm \
tex-Etbb1-Italic-tosf-sc-t1.tfm \
tex-Etbb1-Italic-tosf-sc-t1.vf \
tex-Etbb1-Italic-tosf-swash-t1--base.tfm \
tex-Etbb1-Italic-tosf-swash-t1.tfm \
tex-Etbb1-Italic-tosf-swash-t1.vf \
tex-Etbb1-Italic-tosf-t1--base.tfm \
tex-Etbb1-Italic-tosf-t1.tfm \
tex-Etbb1-Italic-tosf-t1.vf \
tex-Etbb1-Regular-lf-sc-t1--base.tfm \
tex-Etbb1-Regular-lf-sc-t1.tfm \
tex-Etbb1-Regular-lf-sc-t1.vf \
tex-Etbb1-Regular-lf-swash-t1--base.tfm \
tex-Etbb1-Regular-lf-swash-t1.tfm \
tex-Etbb1-Regular-lf-swash-t1.vf \
tex-Etbb1-Regular-lf-t1--base.tfm \
tex-Etbb1-Regular-lf-t1.tfm \
tex-Etbb1-Regular-lf-t1.vf \
tex-Etbb1-Regular-osf-sc-t1--base.tfm \
tex-Etbb1-Regular-osf-sc-t1.tfm \
tex-Etbb1-Regular-osf-sc-t1.vf \
tex-Etbb1-Regular-osf-swash-t1--base.tfm \
tex-Etbb1-Regular-osf-swash-t1.tfm \
tex-Etbb1-Regular-osf-swash-t1.vf \
tex-Etbb1-Regular-osf-t1--base.tfm \
tex-Etbb1-Regular-osf-t1.tfm \
tex-Etbb1-Regular-osf-t1.vf \
tex-Etbb1-Regular-tlf-sc-t1--base.tfm \
tex-Etbb1-Regular-tlf-sc-t1.tfm \
tex-Etbb1-Regular-tlf-sc-t1.vf \
tex-Etbb1-Regular-tlf-swash-t1--base.tfm \
tex-Etbb1-Regular-tlf-swash-t1.tfm \
tex-Etbb1-Regular-tlf-swash-t1.vf \
tex-Etbb1-Regular-tlf-t1--base.tfm \
tex-Etbb1-Regular-tlf-t1.tfm \
tex-Etbb1-Regular-tlf-t1.vf \
tex-Etbb1-Regular-tosf-sc-t1--base.tfm \
tex-Etbb1-Regular-tosf-sc-t1.tfm \
tex-Etbb1-Regular-tosf-sc-t1.vf \
tex-Etbb1-Regular-tosf-swash-t1--base.tfm \
tex-Etbb1-Regular-tosf-swash-t1.tfm \
tex-Etbb1-Regular-tosf-swash-t1.vf \
tex-Etbb1-Regular-tosf-t1--base.tfm \
tex-Etbb1-Regular-tosf-t1.tfm \
tex-Etbb1-Regular-tosf-t1.vf \
tex-LY1ETbb-Dnom.fd \
tex-LY1ETbb-Inf.fd \
tex-LY1ETbb-LF.fd \
tex-LY1ETbb-OsF.fd \
tex-LY1ETbb-Sup.fd \
tex-LY1ETbb-TLF.fd \
tex-LY1ETbb-TOsF.fd \
tex-OT1ETbb-Dnom.fd \
tex-OT1ETbb-Inf.fd \
tex-OT1ETbb-LF.fd \
tex-OT1ETbb-OsF.fd \
tex-OT1ETbb-Sup.fd \
tex-OT1ETbb-TLF.fd \
tex-OT1ETbb-TOsF.fd \
tex-T1ETbb-Dnom.fd \
tex-T1ETbb-Inf.fd \
tex-T1ETbb-LF.fd \
tex-T1ETbb-OsF.fd \
tex-T1ETbb-Sup.fd \
tex-T1ETbb-TLF.fd \
tex-T1ETbb-TOsF.fd \
tex-TS1ETbb-LF.fd \
tex-TS1ETbb-OsF.fd \
tex-TS1ETbb-TLF.fd \
tex-TS1ETbb-TOsF.fd \
tex-etbb-2evihr.enc \
tex-etbb-2jcuij.enc \
tex-etbb-2pvdgb.enc \
tex-etbb-2ynk4h.enc \
tex-etbb-3ccbvp.enc \
tex-etbb-3ggaku.enc \
tex-etbb-3obh62.enc \
tex-etbb-3oxvdm.enc \
tex-etbb-3pymqv.enc \
tex-etbb-3wz3qz.enc \
tex-etbb-3ygfa2.enc \
tex-etbb-42bwpg.enc \
tex-etbb-43bfhj.enc \
tex-etbb-4o3pf4.enc \
tex-etbb-4sxvu4.enc \
tex-etbb-4xv7ax.enc \
tex-etbb-5ckwl5.enc \
tex-etbb-5drz2o.enc \
tex-etbb-5e3mdj.enc \
tex-etbb-5kr4wb.enc \
tex-etbb-65swoa.enc \
tex-etbb-6bhqsy.enc \
tex-etbb-6dkfmm.enc \
tex-etbb-6z6nrw.enc \
tex-etbb-7dlbn4.enc \
tex-etbb-7ipmvr.enc \
tex-etbb-7kk2uu.enc \
tex-etbb-7pzsmk.enc \
tex-etbb-7t4ywj.enc \
tex-etbb-7tqudy.enc \
tex-etbb-7uz5xh.enc \
tex-etbb-atf2m5.enc \
tex-etbb-b2o2dl.enc \
tex-etbb-b2vu4i.enc \
tex-etbb-bb5xlm.enc \
tex-etbb-bldwqe.enc \
tex-etbb-bphtu4.enc \
tex-etbb-cdb5sw.enc \
tex-etbb-cyo6pa.enc \
tex-etbb-cyp5f5.enc \
tex-etbb-dkuysn.enc \
tex-etbb-dsxhqj.enc \
tex-etbb-dwljvi.enc \
tex-etbb-e7zo2o.enc \
tex-etbb-ebvn3n.enc \
tex-etbb-ehl4wc.enc \
tex-etbb-eqc2ac.enc \
tex-etbb-eqlboo.enc \
tex-etbb-gqyyyo.enc \
tex-etbb-gteq3q.enc \
tex-etbb-gyqlcl.enc \
tex-etbb-gyyqg5.enc \
tex-etbb-hah5or.enc \
tex-etbb-hdnox5.enc \
tex-etbb-hn62ay.enc \
tex-etbb-i2z4ax.enc \
tex-etbb-ieilg7.enc \
tex-etbb-ikqcds.enc \
tex-etbb-izxro2.enc \
tex-etbb-j43iwo.enc \
tex-etbb-jzyw2l.enc \
tex-etbb-kvzzr3.enc \
tex-etbb-mgm6re.enc \
tex-etbb-mpvq56.enc \
tex-etbb-nlcvfz.enc \
tex-etbb-num7wi.enc \
tex-etbb-nvfc5y.enc \
tex-etbb-nwvjis.enc \
tex-etbb-nxs5xb.enc \
tex-etbb-oe3mzn.enc \
tex-etbb-of7vre.enc \
tex-etbb-oftnmv.enc \
tex-etbb-on6j27.enc \
tex-etbb-ow4ien.enc \
tex-etbb-oynaqb.enc \
tex-etbb-pdqx2z.enc \
tex-etbb-pmy6fd.enc \
tex-etbb-pqh27d.enc \
tex-etbb-pvrda3.enc \
tex-etbb-pw624q.enc \
tex-etbb-qs5ujs.enc \
tex-etbb-rp26cd.enc \
tex-etbb-rzlqzq.enc \
tex-etbb-sb7odk.enc \
tex-etbb-sjtq2a.enc \
tex-etbb-ujzbb6.enc \
tex-etbb-v2vezk.enc \
tex-etbb-vqghpl.enc \
tex-etbb-vtabip.enc \
tex-etbb-whwnxi.enc \
tex-etbb-wozstu.enc \
tex-etbb-xaqh3v.enc \
tex-etbb-xch2ue.enc \
tex-etbb-xnvkfi.enc \
tex-etbb-y6dqd4.enc \
tex-etbb-yadlkl.enc \
tex-etbb-yiqwpu.enc \
tex-etbb-ys5ff2.enc \
tex-etbb-ytzykv.enc \
tex-etbb-yziesh.enc \
tex-etbb-yzoycr.enc \
tex-etbb-zmodpr.enc \
tex-etbb1-3ccbvp.enc \
tex-etbb1-3ggaku.enc \
tex-etbb1-6bhqsy.enc \
tex-etbb1-6dkfmm.enc \
tex-etbb1-eqc2ac.enc \
tex-etbb1-hah5or.enc \
tex-etbb1-mgm6re.enc \
tex-etbb1-pvrda3.enc \
tex-etbb1-sb7odk.enc \
tex-etbb1-vtabip.enc \
tex-etbb1-xaqh3v.enc \
tex-etbb1-yziesh.enc \
texlive-etbb"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-etoolbox.sty \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifetex.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-scalefnt.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
tex-xstring.sty \
texlive \
texlive-etbb-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
