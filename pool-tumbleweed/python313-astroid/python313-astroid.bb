SUMMARY = "Representation of Python source as an AST for pylint"
DESCRIPTION = "This module provides a common base representation of Python source code for \
projects such as pychecker, pyreverse, pylint. The development of this library \
is governed by pylint's needs. \
 \
It provides a compatible representation which comes from the _ast \
module. It rebuilds the tree generated by the builtin _ast module by \
recursively walking down the AST and building an extended ast. The new \
node classes have additional methods and attributes for different \
usages. They include some support for static inference and local name \
scopes. Furthermore, astroid builds partial trees by inspecting living \
objects."
LICENSE = "LGPL-2.1-or-later"

PV = "4.3.1"

RPM_NAME = "python313-astroid-4.3.1-1.1.noarch.rpm"
RPM_HASH = "65a7e3b39644ab362028b970bccb63c3e5ce12ceb764c32574779f9a8e369f37bcfb40ed8268b977f1733f4260968688b51c29a99f9c34f312e47bb6927fe307"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3-astroid \
python3.13dist-astroid \
python313-astroid \
python3dist-astroid"

RDEPENDS:${PN} += "python-abi"

inherit rpm
