SUMMARY = "Translations for package libKF6XmlGui6"
DESCRIPTION = "Provides translations for the 'libKF6XmlGui6' package."
LICENSE = "LGPL-2.1-or-later & GPL-2.0-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6XmlGui6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "6c8476a6dca646870485b6863ae4569ef16037b78162bbd7ab2ad5ed5a2e6fed2b86f39b4cd5b55bda4ac15e23da0fa083f3fe4068c344a1cfa8e09d29a4f395"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6XmlGui6-lang \
libKF6XmlGui6-lang-all \
locale-libKF6XmlGui6-af \
locale-libKF6XmlGui6-ar \
locale-libKF6XmlGui6-as \
locale-libKF6XmlGui6-ast \
locale-libKF6XmlGui6-az \
locale-libKF6XmlGui6-be \
locale-libKF6XmlGui6-be@latin \
locale-libKF6XmlGui6-bg \
locale-libKF6XmlGui6-bn \
locale-libKF6XmlGui6-bn-IN \
locale-libKF6XmlGui6-br \
locale-libKF6XmlGui6-bs \
locale-libKF6XmlGui6-ca \
locale-libKF6XmlGui6-ca@valencia \
locale-libKF6XmlGui6-cs \
locale-libKF6XmlGui6-cy \
locale-libKF6XmlGui6-da \
locale-libKF6XmlGui6-de \
locale-libKF6XmlGui6-el \
locale-libKF6XmlGui6-en-GB \
locale-libKF6XmlGui6-eo \
locale-libKF6XmlGui6-es \
locale-libKF6XmlGui6-et \
locale-libKF6XmlGui6-eu \
locale-libKF6XmlGui6-fa \
locale-libKF6XmlGui6-fi \
locale-libKF6XmlGui6-fr \
locale-libKF6XmlGui6-ga \
locale-libKF6XmlGui6-gd \
locale-libKF6XmlGui6-gl \
locale-libKF6XmlGui6-gu \
locale-libKF6XmlGui6-he \
locale-libKF6XmlGui6-hi \
locale-libKF6XmlGui6-hr \
locale-libKF6XmlGui6-hu \
locale-libKF6XmlGui6-ia \
locale-libKF6XmlGui6-id \
locale-libKF6XmlGui6-is \
locale-libKF6XmlGui6-it \
locale-libKF6XmlGui6-ja \
locale-libKF6XmlGui6-ka \
locale-libKF6XmlGui6-kk \
locale-libKF6XmlGui6-km \
locale-libKF6XmlGui6-kn \
locale-libKF6XmlGui6-ko \
locale-libKF6XmlGui6-lt \
locale-libKF6XmlGui6-lv \
locale-libKF6XmlGui6-mai \
locale-libKF6XmlGui6-mk \
locale-libKF6XmlGui6-ml \
locale-libKF6XmlGui6-mr \
locale-libKF6XmlGui6-ms \
locale-libKF6XmlGui6-nb \
locale-libKF6XmlGui6-nds \
locale-libKF6XmlGui6-ne \
locale-libKF6XmlGui6-nl \
locale-libKF6XmlGui6-nn \
locale-libKF6XmlGui6-oc \
locale-libKF6XmlGui6-or \
locale-libKF6XmlGui6-pa \
locale-libKF6XmlGui6-pl \
locale-libKF6XmlGui6-pt \
locale-libKF6XmlGui6-pt-BR \
locale-libKF6XmlGui6-ro \
locale-libKF6XmlGui6-ru \
locale-libKF6XmlGui6-si \
locale-libKF6XmlGui6-sk \
locale-libKF6XmlGui6-sl \
locale-libKF6XmlGui6-sq \
locale-libKF6XmlGui6-sr \
locale-libKF6XmlGui6-sr@ijekavian \
locale-libKF6XmlGui6-sr@ijekavianlatin \
locale-libKF6XmlGui6-sr@latin \
locale-libKF6XmlGui6-sv \
locale-libKF6XmlGui6-ta \
locale-libKF6XmlGui6-te \
locale-libKF6XmlGui6-th \
locale-libKF6XmlGui6-tr \
locale-libKF6XmlGui6-ug \
locale-libKF6XmlGui6-uk \
locale-libKF6XmlGui6-vi \
locale-libKF6XmlGui6-wa \
locale-libKF6XmlGui6-zh-CN \
locale-libKF6XmlGui6-zh-HK \
locale-libKF6XmlGui6-zh-TW"

RDEPENDS:${PN} += "libKF6XmlGui6"

inherit rpm
