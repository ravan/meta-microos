SUMMARY = "A key-value document command parser"
DESCRIPTION = "This package provides a key-value interface, \\Ccool, on top of \
xparse's document command parser. Global options control input \
processing and its expansion. By default, they are set to meet \
likely requirements, depending on context: the selected \
language, and which of text and math mode is active. These \
options can be overridden inline. This versatility could find \
its use, for example, to encode notational conventions (such as \
\\Real - \\mathbb{R}) at the point where they are introduced in \
the document ('Let R denote real numbers'). Polymorphic \
commands can be generated by parameterizing the keys (for \
instance, one parameter value for style, another for a \
property). User input to \\Ccool can optionally be serialized. \
This can useful for typesetting documents sharing the same \
notation."
LICENSE = "LPPL-1.0"

PV = "2026.226.3.2svn76924"

RPM_NAME = "texlive-ccool-2026.226.3.2svn76924-59.2.noarch.rpm"
RPM_HASH = "20917af5f7d648921ecc01c2dce13109827c20aa138b1e314ba61439dacbf3ba57e8955c912db3c9ed7f203dc5a1bbe8c90728e918d43dd5c10e22c87d05fc98"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-ccool.sty \
texlive-ccool"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-expl3.sty \
tex-l3keys2e.sty \
tex-lambdax.sty \
tex-xparse.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
