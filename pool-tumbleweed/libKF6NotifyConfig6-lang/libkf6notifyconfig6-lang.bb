SUMMARY = "Translations for package libKF6NotifyConfig6"
DESCRIPTION = "Provides translations for the 'libKF6NotifyConfig6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6NotifyConfig6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "a86aa40aa9b283eff23b26bbd49bc7894e40e40ea904927d791e7f515acea5392d1830374696accd40b171b0d0b5fbdf8810baff70364eb25ba8bef451950939"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6NotifyConfig6-lang \
libKF6NotifyConfig6-lang-all \
locale-libKF6NotifyConfig6-af \
locale-libKF6NotifyConfig6-ar \
locale-libKF6NotifyConfig6-as \
locale-libKF6NotifyConfig6-ast \
locale-libKF6NotifyConfig6-az \
locale-libKF6NotifyConfig6-be \
locale-libKF6NotifyConfig6-be@latin \
locale-libKF6NotifyConfig6-bg \
locale-libKF6NotifyConfig6-bn \
locale-libKF6NotifyConfig6-bn-IN \
locale-libKF6NotifyConfig6-br \
locale-libKF6NotifyConfig6-bs \
locale-libKF6NotifyConfig6-ca \
locale-libKF6NotifyConfig6-ca@valencia \
locale-libKF6NotifyConfig6-cs \
locale-libKF6NotifyConfig6-cy \
locale-libKF6NotifyConfig6-da \
locale-libKF6NotifyConfig6-de \
locale-libKF6NotifyConfig6-el \
locale-libKF6NotifyConfig6-en-GB \
locale-libKF6NotifyConfig6-eo \
locale-libKF6NotifyConfig6-es \
locale-libKF6NotifyConfig6-et \
locale-libKF6NotifyConfig6-eu \
locale-libKF6NotifyConfig6-fa \
locale-libKF6NotifyConfig6-fi \
locale-libKF6NotifyConfig6-fr \
locale-libKF6NotifyConfig6-ga \
locale-libKF6NotifyConfig6-gd \
locale-libKF6NotifyConfig6-gl \
locale-libKF6NotifyConfig6-gu \
locale-libKF6NotifyConfig6-he \
locale-libKF6NotifyConfig6-hi \
locale-libKF6NotifyConfig6-hr \
locale-libKF6NotifyConfig6-hu \
locale-libKF6NotifyConfig6-ia \
locale-libKF6NotifyConfig6-id \
locale-libKF6NotifyConfig6-is \
locale-libKF6NotifyConfig6-it \
locale-libKF6NotifyConfig6-ja \
locale-libKF6NotifyConfig6-ka \
locale-libKF6NotifyConfig6-kk \
locale-libKF6NotifyConfig6-km \
locale-libKF6NotifyConfig6-kn \
locale-libKF6NotifyConfig6-ko \
locale-libKF6NotifyConfig6-lt \
locale-libKF6NotifyConfig6-lv \
locale-libKF6NotifyConfig6-mai \
locale-libKF6NotifyConfig6-mk \
locale-libKF6NotifyConfig6-ml \
locale-libKF6NotifyConfig6-mr \
locale-libKF6NotifyConfig6-ms \
locale-libKF6NotifyConfig6-nb \
locale-libKF6NotifyConfig6-nds \
locale-libKF6NotifyConfig6-ne \
locale-libKF6NotifyConfig6-nl \
locale-libKF6NotifyConfig6-nn \
locale-libKF6NotifyConfig6-oc \
locale-libKF6NotifyConfig6-or \
locale-libKF6NotifyConfig6-pa \
locale-libKF6NotifyConfig6-pl \
locale-libKF6NotifyConfig6-pt \
locale-libKF6NotifyConfig6-pt-BR \
locale-libKF6NotifyConfig6-ro \
locale-libKF6NotifyConfig6-ru \
locale-libKF6NotifyConfig6-si \
locale-libKF6NotifyConfig6-sk \
locale-libKF6NotifyConfig6-sl \
locale-libKF6NotifyConfig6-sq \
locale-libKF6NotifyConfig6-sr \
locale-libKF6NotifyConfig6-sr@ijekavian \
locale-libKF6NotifyConfig6-sr@ijekavianlatin \
locale-libKF6NotifyConfig6-sr@latin \
locale-libKF6NotifyConfig6-sv \
locale-libKF6NotifyConfig6-ta \
locale-libKF6NotifyConfig6-te \
locale-libKF6NotifyConfig6-th \
locale-libKF6NotifyConfig6-tr \
locale-libKF6NotifyConfig6-ug \
locale-libKF6NotifyConfig6-uk \
locale-libKF6NotifyConfig6-vi \
locale-libKF6NotifyConfig6-wa \
locale-libKF6NotifyConfig6-zh-CN \
locale-libKF6NotifyConfig6-zh-HK \
locale-libKF6NotifyConfig6-zh-TW"

RDEPENDS:${PN} += "libKF6NotifyConfig6"

inherit rpm
