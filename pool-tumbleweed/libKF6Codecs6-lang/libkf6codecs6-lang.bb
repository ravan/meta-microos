SUMMARY = "Translations for package libKF6Codecs6"
DESCRIPTION = "Provides translations for the 'libKF6Codecs6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6Codecs6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "828d9df6a06768368eeef7ef1016af895714ab216ad434c8bd403e7bd28293c248125e10ac73f91be518d154b5776ef71466ae4d5e3902002f70af1ba5d72013"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6Codecs6-lang \
libKF6Codecs6-lang-all \
locale-libKF6Codecs6-af \
locale-libKF6Codecs6-ar \
locale-libKF6Codecs6-as \
locale-libKF6Codecs6-ast \
locale-libKF6Codecs6-az \
locale-libKF6Codecs6-be \
locale-libKF6Codecs6-be@latin \
locale-libKF6Codecs6-bg \
locale-libKF6Codecs6-bn \
locale-libKF6Codecs6-bn-IN \
locale-libKF6Codecs6-br \
locale-libKF6Codecs6-bs \
locale-libKF6Codecs6-ca \
locale-libKF6Codecs6-ca@valencia \
locale-libKF6Codecs6-cs \
locale-libKF6Codecs6-cy \
locale-libKF6Codecs6-da \
locale-libKF6Codecs6-de \
locale-libKF6Codecs6-el \
locale-libKF6Codecs6-en-GB \
locale-libKF6Codecs6-eo \
locale-libKF6Codecs6-es \
locale-libKF6Codecs6-et \
locale-libKF6Codecs6-eu \
locale-libKF6Codecs6-fa \
locale-libKF6Codecs6-fi \
locale-libKF6Codecs6-fr \
locale-libKF6Codecs6-ga \
locale-libKF6Codecs6-gd \
locale-libKF6Codecs6-gl \
locale-libKF6Codecs6-gu \
locale-libKF6Codecs6-he \
locale-libKF6Codecs6-hi \
locale-libKF6Codecs6-hr \
locale-libKF6Codecs6-hu \
locale-libKF6Codecs6-ia \
locale-libKF6Codecs6-id \
locale-libKF6Codecs6-is \
locale-libKF6Codecs6-it \
locale-libKF6Codecs6-ja \
locale-libKF6Codecs6-ka \
locale-libKF6Codecs6-kk \
locale-libKF6Codecs6-km \
locale-libKF6Codecs6-kn \
locale-libKF6Codecs6-ko \
locale-libKF6Codecs6-lt \
locale-libKF6Codecs6-lv \
locale-libKF6Codecs6-mai \
locale-libKF6Codecs6-mk \
locale-libKF6Codecs6-ml \
locale-libKF6Codecs6-mr \
locale-libKF6Codecs6-ms \
locale-libKF6Codecs6-nb \
locale-libKF6Codecs6-nds \
locale-libKF6Codecs6-ne \
locale-libKF6Codecs6-nl \
locale-libKF6Codecs6-nn \
locale-libKF6Codecs6-oc \
locale-libKF6Codecs6-or \
locale-libKF6Codecs6-pa \
locale-libKF6Codecs6-pl \
locale-libKF6Codecs6-pt \
locale-libKF6Codecs6-pt-BR \
locale-libKF6Codecs6-ro \
locale-libKF6Codecs6-ru \
locale-libKF6Codecs6-si \
locale-libKF6Codecs6-sk \
locale-libKF6Codecs6-sl \
locale-libKF6Codecs6-sq \
locale-libKF6Codecs6-sr \
locale-libKF6Codecs6-sr@ijekavian \
locale-libKF6Codecs6-sr@ijekavianlatin \
locale-libKF6Codecs6-sr@latin \
locale-libKF6Codecs6-sv \
locale-libKF6Codecs6-ta \
locale-libKF6Codecs6-te \
locale-libKF6Codecs6-th \
locale-libKF6Codecs6-tr \
locale-libKF6Codecs6-ug \
locale-libKF6Codecs6-uk \
locale-libKF6Codecs6-vi \
locale-libKF6Codecs6-wa \
locale-libKF6Codecs6-zh-CN \
locale-libKF6Codecs6-zh-HK \
locale-libKF6Codecs6-zh-TW"

RDEPENDS:${PN} += "libKF6Codecs6"

inherit rpm
