SUMMARY = "Translations for package xdg-desktop-portal-pantheon"
DESCRIPTION = "Provides translations for the 'xdg-desktop-portal-pantheon' package."
LICENSE = "GPL-3.0-or-later"

PV = "8.2.0"

RPM_NAME = "xdg-desktop-portal-pantheon-lang-8.2.0-1.2.noarch.rpm"
RPM_HASH = "4f7b795b0a37a0242d2116b6f3e2d99148fcd9f39e715bf6061f0af55f37b81351e20fb0a51ff373b2baa6a884a1e386ebc66d5367285b2a2c7917e291a2a666"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale-xdg-desktop-portal-pantheon-af \
locale-xdg-desktop-portal-pantheon-ar \
locale-xdg-desktop-portal-pantheon-as \
locale-xdg-desktop-portal-pantheon-ast \
locale-xdg-desktop-portal-pantheon-az \
locale-xdg-desktop-portal-pantheon-be \
locale-xdg-desktop-portal-pantheon-bg \
locale-xdg-desktop-portal-pantheon-bn \
locale-xdg-desktop-portal-pantheon-br \
locale-xdg-desktop-portal-pantheon-bs \
locale-xdg-desktop-portal-pantheon-ca \
locale-xdg-desktop-portal-pantheon-ca@valencia \
locale-xdg-desktop-portal-pantheon-cs \
locale-xdg-desktop-portal-pantheon-cy \
locale-xdg-desktop-portal-pantheon-da \
locale-xdg-desktop-portal-pantheon-de \
locale-xdg-desktop-portal-pantheon-dz \
locale-xdg-desktop-portal-pantheon-el \
locale-xdg-desktop-portal-pantheon-en-AU \
locale-xdg-desktop-portal-pantheon-en-CA \
locale-xdg-desktop-portal-pantheon-en-GB \
locale-xdg-desktop-portal-pantheon-eo \
locale-xdg-desktop-portal-pantheon-es \
locale-xdg-desktop-portal-pantheon-et \
locale-xdg-desktop-portal-pantheon-eu \
locale-xdg-desktop-portal-pantheon-fa \
locale-xdg-desktop-portal-pantheon-fi \
locale-xdg-desktop-portal-pantheon-fr \
locale-xdg-desktop-portal-pantheon-fr-CA \
locale-xdg-desktop-portal-pantheon-ga \
locale-xdg-desktop-portal-pantheon-gd \
locale-xdg-desktop-portal-pantheon-gl \
locale-xdg-desktop-portal-pantheon-gu \
locale-xdg-desktop-portal-pantheon-he \
locale-xdg-desktop-portal-pantheon-hi \
locale-xdg-desktop-portal-pantheon-hr \
locale-xdg-desktop-portal-pantheon-hu \
locale-xdg-desktop-portal-pantheon-ia \
locale-xdg-desktop-portal-pantheon-id \
locale-xdg-desktop-portal-pantheon-is \
locale-xdg-desktop-portal-pantheon-it \
locale-xdg-desktop-portal-pantheon-ja \
locale-xdg-desktop-portal-pantheon-ka \
locale-xdg-desktop-portal-pantheon-kk \
locale-xdg-desktop-portal-pantheon-km \
locale-xdg-desktop-portal-pantheon-kn \
locale-xdg-desktop-portal-pantheon-ko \
locale-xdg-desktop-portal-pantheon-lt \
locale-xdg-desktop-portal-pantheon-lv \
locale-xdg-desktop-portal-pantheon-mk \
locale-xdg-desktop-portal-pantheon-ml \
locale-xdg-desktop-portal-pantheon-mr \
locale-xdg-desktop-portal-pantheon-ms \
locale-xdg-desktop-portal-pantheon-nb \
locale-xdg-desktop-portal-pantheon-ne \
locale-xdg-desktop-portal-pantheon-nl \
locale-xdg-desktop-portal-pantheon-nn \
locale-xdg-desktop-portal-pantheon-oc \
locale-xdg-desktop-portal-pantheon-or \
locale-xdg-desktop-portal-pantheon-pa \
locale-xdg-desktop-portal-pantheon-pl \
locale-xdg-desktop-portal-pantheon-pt \
locale-xdg-desktop-portal-pantheon-pt-BR \
locale-xdg-desktop-portal-pantheon-ro \
locale-xdg-desktop-portal-pantheon-ru \
locale-xdg-desktop-portal-pantheon-si \
locale-xdg-desktop-portal-pantheon-sk \
locale-xdg-desktop-portal-pantheon-sl \
locale-xdg-desktop-portal-pantheon-sq \
locale-xdg-desktop-portal-pantheon-sr \
locale-xdg-desktop-portal-pantheon-sr@latin \
locale-xdg-desktop-portal-pantheon-sv \
locale-xdg-desktop-portal-pantheon-ta \
locale-xdg-desktop-portal-pantheon-te \
locale-xdg-desktop-portal-pantheon-th \
locale-xdg-desktop-portal-pantheon-tr \
locale-xdg-desktop-portal-pantheon-ug \
locale-xdg-desktop-portal-pantheon-uk \
locale-xdg-desktop-portal-pantheon-vi \
locale-xdg-desktop-portal-pantheon-wa \
locale-xdg-desktop-portal-pantheon-zh \
locale-xdg-desktop-portal-pantheon-zh-CN \
locale-xdg-desktop-portal-pantheon-zh-HK \
locale-xdg-desktop-portal-pantheon-zh-TW \
xdg-desktop-portal-pantheon-lang \
xdg-desktop-portal-pantheon-lang-all"

RDEPENDS:${PN} += "xdg-desktop-portal-pantheon"

inherit rpm
