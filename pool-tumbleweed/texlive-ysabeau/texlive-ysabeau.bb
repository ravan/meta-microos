SUMMARY = "Ysabeau fonts with LaTeX support for traditional TeX engines"
DESCRIPTION = "Ysabeau is a free type family. It combines the time-honored and \
supremely readable letterforms of the Garamond legacy with the \
clean crispness of a low-contrast sans serif, rendering it well \
suited for body copy as well as display. This package provides \
LaTeX font support for traditional TeX engines (pdfTeX, dvips, \
and so on). For XeTeX or LuaTeX users, OpenType and TrueType \
fonts are provided only to use with the fontspec package."
LICENSE = "OFL-1.1"

PV = "2026.226.1.6svn77682"

RPM_NAME = "texlive-ysabeau-2026.226.1.6svn77682-59.4.noarch.rpm"
RPM_HASH = "7d8e7ed174d1899a4084e1b6007e98686c222457a8930d1242854da5dde2644367e22424ce59970b615e261bc0f73e4dad20d55fa3c68d316173393383bd35c1"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-CSYsabeau-Dnom.fd \
tex-CSYsabeau-Inf.fd \
tex-CSYsabeau-LF.fd \
tex-CSYsabeau-Numr.fd \
tex-CSYsabeau-OsF.fd \
tex-CSYsabeau-Sup.fd \
tex-CSYsabeau-TLF.fd \
tex-CSYsabeau-TOsF.fd \
tex-L7XYsabeau-Dnom.fd \
tex-L7XYsabeau-Inf.fd \
tex-L7XYsabeau-LF.fd \
tex-L7XYsabeau-Numr.fd \
tex-L7XYsabeau-OsF.fd \
tex-L7XYsabeau-Sup.fd \
tex-L7XYsabeau-TLF.fd \
tex-L7XYsabeau-TOsF.fd \
tex-LGRYsabeau-Dnom.fd \
tex-LGRYsabeau-Inf.fd \
tex-LGRYsabeau-LF.fd \
tex-LGRYsabeau-Numr.fd \
tex-LGRYsabeau-OsF.fd \
tex-LGRYsabeau-Sup.fd \
tex-LGRYsabeau-TLF.fd \
tex-LGRYsabeau-TOsF.fd \
tex-LY1Ysabeau-Dnom.fd \
tex-LY1Ysabeau-Inf.fd \
tex-LY1Ysabeau-LF.fd \
tex-LY1Ysabeau-Numr.fd \
tex-LY1Ysabeau-OsF.fd \
tex-LY1Ysabeau-Sup.fd \
tex-LY1Ysabeau-TLF.fd \
tex-LY1Ysabeau-TOsF.fd \
tex-OT1Ysabeau-Dnom.fd \
tex-OT1Ysabeau-Inf.fd \
tex-OT1Ysabeau-LF.fd \
tex-OT1Ysabeau-Numr.fd \
tex-OT1Ysabeau-OsF.fd \
tex-OT1Ysabeau-Sup.fd \
tex-OT1Ysabeau-TLF.fd \
tex-OT1Ysabeau-TOsF.fd \
tex-QXYsabeau-Dnom.fd \
tex-QXYsabeau-Inf.fd \
tex-QXYsabeau-LF.fd \
tex-QXYsabeau-Numr.fd \
tex-QXYsabeau-OsF.fd \
tex-QXYsabeau-Sup.fd \
tex-QXYsabeau-TLF.fd \
tex-QXYsabeau-TOsF.fd \
tex-T1Ysabeau-Dnom.fd \
tex-T1Ysabeau-Inf.fd \
tex-T1Ysabeau-LF.fd \
tex-T1Ysabeau-Numr.fd \
tex-T1Ysabeau-OsF.fd \
tex-T1Ysabeau-Sup.fd \
tex-T1Ysabeau-TLF.fd \
tex-T1Ysabeau-TOsF.fd \
tex-T2AYsabeau-Dnom.fd \
tex-T2AYsabeau-Inf.fd \
tex-T2AYsabeau-LF.fd \
tex-T2AYsabeau-Numr.fd \
tex-T2AYsabeau-OsF.fd \
tex-T2AYsabeau-Sup.fd \
tex-T2AYsabeau-TLF.fd \
tex-T2AYsabeau-TOsF.fd \
tex-T2BYsabeau-Dnom.fd \
tex-T2BYsabeau-Inf.fd \
tex-T2BYsabeau-LF.fd \
tex-T2BYsabeau-Numr.fd \
tex-T2BYsabeau-OsF.fd \
tex-T2BYsabeau-Sup.fd \
tex-T2BYsabeau-TLF.fd \
tex-T2BYsabeau-TOsF.fd \
tex-T2CYsabeau-Dnom.fd \
tex-T2CYsabeau-Inf.fd \
tex-T2CYsabeau-LF.fd \
tex-T2CYsabeau-Numr.fd \
tex-T2CYsabeau-OsF.fd \
tex-T2CYsabeau-Sup.fd \
tex-T2CYsabeau-TLF.fd \
tex-T2CYsabeau-TOsF.fd \
tex-T3Ysabeau-Dnom.fd \
tex-T3Ysabeau-Inf.fd \
tex-T3Ysabeau-LF.fd \
tex-T3Ysabeau-Numr.fd \
tex-T3Ysabeau-OsF.fd \
tex-T3Ysabeau-Sup.fd \
tex-T3Ysabeau-TLF.fd \
tex-T3Ysabeau-TOsF.fd \
tex-T4Ysabeau-Dnom.fd \
tex-T4Ysabeau-Inf.fd \
tex-T4Ysabeau-LF.fd \
tex-T4Ysabeau-Numr.fd \
tex-T4Ysabeau-OsF.fd \
tex-T4Ysabeau-Sup.fd \
tex-T4Ysabeau-TLF.fd \
tex-T4Ysabeau-TOsF.fd \
tex-T5Ysabeau-Dnom.fd \
tex-T5Ysabeau-Inf.fd \
tex-T5Ysabeau-LF.fd \
tex-T5Ysabeau-Numr.fd \
tex-T5Ysabeau-OsF.fd \
tex-T5Ysabeau-Sup.fd \
tex-T5Ysabeau-TLF.fd \
tex-T5Ysabeau-TOsF.fd \
tex-TS1Ysabeau-LF.fd \
tex-TS1Ysabeau-OsF.fd \
tex-TS1Ysabeau-TLF.fd \
tex-TS1Ysabeau-TOsF.fd \
tex-TS3Ysabeau-Dnom.fd \
tex-TS3Ysabeau-Inf.fd \
tex-TS3Ysabeau-LF.fd \
tex-TS3Ysabeau-Numr.fd \
tex-TS3Ysabeau-OsF.fd \
tex-TS3Ysabeau-Sup.fd \
tex-TS3Ysabeau-TLF.fd \
tex-TS3Ysabeau-TOsF.fd \
tex-Ysabeau-Black-dnom-cs.tfm \
tex-Ysabeau-Black-dnom-l7x.tfm \
tex-Ysabeau-Black-dnom-lgr.tfm \
tex-Ysabeau-Black-dnom-ly1.tfm \
tex-Ysabeau-Black-dnom-ot1.tfm \
tex-Ysabeau-Black-dnom-qx--base.tfm \
tex-Ysabeau-Black-dnom-qx.tfm \
tex-Ysabeau-Black-dnom-qx.vf \
tex-Ysabeau-Black-dnom-t1--base.tfm \
tex-Ysabeau-Black-dnom-t1.tfm \
tex-Ysabeau-Black-dnom-t1.vf \
tex-Ysabeau-Black-dnom-t2a--base.tfm \
tex-Ysabeau-Black-dnom-t2a.tfm \
tex-Ysabeau-Black-dnom-t2a.vf \
tex-Ysabeau-Black-dnom-t2b--base.tfm \
tex-Ysabeau-Black-dnom-t2b.tfm \
tex-Ysabeau-Black-dnom-t2b.vf \
tex-Ysabeau-Black-dnom-t2c--base.tfm \
tex-Ysabeau-Black-dnom-t2c.tfm \
tex-Ysabeau-Black-dnom-t2c.vf \
tex-Ysabeau-Black-dnom-t3.tfm \
tex-Ysabeau-Black-dnom-t4--base.tfm \
tex-Ysabeau-Black-dnom-t4.tfm \
tex-Ysabeau-Black-dnom-t4.vf \
tex-Ysabeau-Black-dnom-t5--base.tfm \
tex-Ysabeau-Black-dnom-t5.tfm \
tex-Ysabeau-Black-dnom-t5.vf \
tex-Ysabeau-Black-dnom-ts3.tfm \
tex-Ysabeau-Black-inf-cs.tfm \
tex-Ysabeau-Black-inf-l7x.tfm \
tex-Ysabeau-Black-inf-lgr.tfm \
tex-Ysabeau-Black-inf-ly1.tfm \
tex-Ysabeau-Black-inf-ot1.tfm \
tex-Ysabeau-Black-inf-qx--base.tfm \
tex-Ysabeau-Black-inf-qx.tfm \
tex-Ysabeau-Black-inf-qx.vf \
tex-Ysabeau-Black-inf-t1--base.tfm \
tex-Ysabeau-Black-inf-t1.tfm \
tex-Ysabeau-Black-inf-t1.vf \
tex-Ysabeau-Black-inf-t2a--base.tfm \
tex-Ysabeau-Black-inf-t2a.tfm \
tex-Ysabeau-Black-inf-t2a.vf \
tex-Ysabeau-Black-inf-t2b--base.tfm \
tex-Ysabeau-Black-inf-t2b.tfm \
tex-Ysabeau-Black-inf-t2b.vf \
tex-Ysabeau-Black-inf-t2c--base.tfm \
tex-Ysabeau-Black-inf-t2c.tfm \
tex-Ysabeau-Black-inf-t2c.vf \
tex-Ysabeau-Black-inf-t3.tfm \
tex-Ysabeau-Black-inf-t4--base.tfm \
tex-Ysabeau-Black-inf-t4.tfm \
tex-Ysabeau-Black-inf-t4.vf \
tex-Ysabeau-Black-inf-t5--base.tfm \
tex-Ysabeau-Black-inf-t5.tfm \
tex-Ysabeau-Black-inf-t5.vf \
tex-Ysabeau-Black-inf-ts3.tfm \
tex-Ysabeau-Black-lf-cs.tfm \
tex-Ysabeau-Black-lf-l7x.tfm \
tex-Ysabeau-Black-lf-lgr.tfm \
tex-Ysabeau-Black-lf-ly1.tfm \
tex-Ysabeau-Black-lf-ot1.tfm \
tex-Ysabeau-Black-lf-qx--base.tfm \
tex-Ysabeau-Black-lf-qx.tfm \
tex-Ysabeau-Black-lf-qx.vf \
tex-Ysabeau-Black-lf-sc-cs--base.tfm \
tex-Ysabeau-Black-lf-sc-cs.tfm \
tex-Ysabeau-Black-lf-sc-cs.vf \
tex-Ysabeau-Black-lf-sc-l7x--base.tfm \
tex-Ysabeau-Black-lf-sc-l7x.tfm \
tex-Ysabeau-Black-lf-sc-l7x.vf \
tex-Ysabeau-Black-lf-sc-lgr.tfm \
tex-Ysabeau-Black-lf-sc-ly1--base.tfm \
tex-Ysabeau-Black-lf-sc-ly1.tfm \
tex-Ysabeau-Black-lf-sc-ly1.vf \
tex-Ysabeau-Black-lf-sc-ot1--base.tfm \
tex-Ysabeau-Black-lf-sc-ot1.tfm \
tex-Ysabeau-Black-lf-sc-ot1.vf \
tex-Ysabeau-Black-lf-sc-qx--base.tfm \
tex-Ysabeau-Black-lf-sc-qx.tfm \
tex-Ysabeau-Black-lf-sc-qx.vf \
tex-Ysabeau-Black-lf-sc-t1--base.tfm \
tex-Ysabeau-Black-lf-sc-t1.tfm \
tex-Ysabeau-Black-lf-sc-t1.vf \
tex-Ysabeau-Black-lf-sc-t2a--base.tfm \
tex-Ysabeau-Black-lf-sc-t2a.tfm \
tex-Ysabeau-Black-lf-sc-t2a.vf \
tex-Ysabeau-Black-lf-sc-t2b--base.tfm \
tex-Ysabeau-Black-lf-sc-t2b.tfm \
tex-Ysabeau-Black-lf-sc-t2b.vf \
tex-Ysabeau-Black-lf-sc-t2c--base.tfm \
tex-Ysabeau-Black-lf-sc-t2c.tfm \
tex-Ysabeau-Black-lf-sc-t2c.vf \
tex-Ysabeau-Black-lf-sc-t3.tfm \
tex-Ysabeau-Black-lf-sc-t4--base.tfm \
tex-Ysabeau-Black-lf-sc-t4.tfm \
tex-Ysabeau-Black-lf-sc-t4.vf \
tex-Ysabeau-Black-lf-sc-t5--base.tfm \
tex-Ysabeau-Black-lf-sc-t5.tfm \
tex-Ysabeau-Black-lf-sc-t5.vf \
tex-Ysabeau-Black-lf-sc-ts3--base.tfm \
tex-Ysabeau-Black-lf-sc-ts3.tfm \
tex-Ysabeau-Black-lf-sc-ts3.vf \
tex-Ysabeau-Black-lf-t1--base.tfm \
tex-Ysabeau-Black-lf-t1.tfm \
tex-Ysabeau-Black-lf-t1.vf \
tex-Ysabeau-Black-lf-t2a--base.tfm \
tex-Ysabeau-Black-lf-t2a.tfm \
tex-Ysabeau-Black-lf-t2a.vf \
tex-Ysabeau-Black-lf-t2b--base.tfm \
tex-Ysabeau-Black-lf-t2b.tfm \
tex-Ysabeau-Black-lf-t2b.vf \
tex-Ysabeau-Black-lf-t2c--base.tfm \
tex-Ysabeau-Black-lf-t2c.tfm \
tex-Ysabeau-Black-lf-t2c.vf \
tex-Ysabeau-Black-lf-t3.tfm \
tex-Ysabeau-Black-lf-t4--base.tfm \
tex-Ysabeau-Black-lf-t4.tfm \
tex-Ysabeau-Black-lf-t4.vf \
tex-Ysabeau-Black-lf-t5--base.tfm \
tex-Ysabeau-Black-lf-t5.tfm \
tex-Ysabeau-Black-lf-t5.vf \
tex-Ysabeau-Black-lf-ts1--base.tfm \
tex-Ysabeau-Black-lf-ts1.tfm \
tex-Ysabeau-Black-lf-ts1.vf \
tex-Ysabeau-Black-lf-ts3.tfm \
tex-Ysabeau-Black-numr-cs.tfm \
tex-Ysabeau-Black-numr-l7x.tfm \
tex-Ysabeau-Black-numr-lgr.tfm \
tex-Ysabeau-Black-numr-ly1.tfm \
tex-Ysabeau-Black-numr-ot1.tfm \
tex-Ysabeau-Black-numr-qx--base.tfm \
tex-Ysabeau-Black-numr-qx.tfm \
tex-Ysabeau-Black-numr-qx.vf \
tex-Ysabeau-Black-numr-t1--base.tfm \
tex-Ysabeau-Black-numr-t1.tfm \
tex-Ysabeau-Black-numr-t1.vf \
tex-Ysabeau-Black-numr-t2a--base.tfm \
tex-Ysabeau-Black-numr-t2a.tfm \
tex-Ysabeau-Black-numr-t2a.vf \
tex-Ysabeau-Black-numr-t2b--base.tfm \
tex-Ysabeau-Black-numr-t2b.tfm \
tex-Ysabeau-Black-numr-t2b.vf \
tex-Ysabeau-Black-numr-t2c--base.tfm \
tex-Ysabeau-Black-numr-t2c.tfm \
tex-Ysabeau-Black-numr-t2c.vf \
tex-Ysabeau-Black-numr-t3.tfm \
tex-Ysabeau-Black-numr-t4--base.tfm \
tex-Ysabeau-Black-numr-t4.tfm \
tex-Ysabeau-Black-numr-t4.vf \
tex-Ysabeau-Black-numr-t5--base.tfm \
tex-Ysabeau-Black-numr-t5.tfm \
tex-Ysabeau-Black-numr-t5.vf \
tex-Ysabeau-Black-numr-ts3.tfm \
tex-Ysabeau-Black-osf-cs.tfm \
tex-Ysabeau-Black-osf-l7x.tfm \
tex-Ysabeau-Black-osf-lgr.tfm \
tex-Ysabeau-Black-osf-ly1.tfm \
tex-Ysabeau-Black-osf-ot1.tfm \
tex-Ysabeau-Black-osf-qx--base.tfm \
tex-Ysabeau-Black-osf-qx.tfm \
tex-Ysabeau-Black-osf-qx.vf \
tex-Ysabeau-Black-osf-sc-cs--base.tfm \
tex-Ysabeau-Black-osf-sc-cs.tfm \
tex-Ysabeau-Black-osf-sc-cs.vf \
tex-Ysabeau-Black-osf-sc-l7x--base.tfm \
tex-Ysabeau-Black-osf-sc-l7x.tfm \
tex-Ysabeau-Black-osf-sc-l7x.vf \
tex-Ysabeau-Black-osf-sc-lgr.tfm \
tex-Ysabeau-Black-osf-sc-ly1--base.tfm \
tex-Ysabeau-Black-osf-sc-ly1.tfm \
tex-Ysabeau-Black-osf-sc-ly1.vf \
tex-Ysabeau-Black-osf-sc-ot1--base.tfm \
tex-Ysabeau-Black-osf-sc-ot1.tfm \
tex-Ysabeau-Black-osf-sc-ot1.vf \
tex-Ysabeau-Black-osf-sc-qx--base.tfm \
tex-Ysabeau-Black-osf-sc-qx.tfm \
tex-Ysabeau-Black-osf-sc-qx.vf \
tex-Ysabeau-Black-osf-sc-t1--base.tfm \
tex-Ysabeau-Black-osf-sc-t1.tfm \
tex-Ysabeau-Black-osf-sc-t1.vf \
tex-Ysabeau-Black-osf-sc-t2a--base.tfm \
tex-Ysabeau-Black-osf-sc-t2a.tfm \
tex-Ysabeau-Black-osf-sc-t2a.vf \
tex-Ysabeau-Black-osf-sc-t2b--base.tfm \
tex-Ysabeau-Black-osf-sc-t2b.tfm \
tex-Ysabeau-Black-osf-sc-t2b.vf \
tex-Ysabeau-Black-osf-sc-t2c--base.tfm \
tex-Ysabeau-Black-osf-sc-t2c.tfm \
tex-Ysabeau-Black-osf-sc-t2c.vf \
tex-Ysabeau-Black-osf-sc-t3.tfm \
tex-Ysabeau-Black-osf-sc-t4--base.tfm \
tex-Ysabeau-Black-osf-sc-t4.tfm \
tex-Ysabeau-Black-osf-sc-t4.vf \
tex-Ysabeau-Black-osf-sc-t5--base.tfm \
tex-Ysabeau-Black-osf-sc-t5.tfm \
tex-Ysabeau-Black-osf-sc-t5.vf \
tex-Ysabeau-Black-osf-sc-ts3--base.tfm \
tex-Ysabeau-Black-osf-sc-ts3.tfm \
tex-Ysabeau-Black-osf-sc-ts3.vf \
tex-Ysabeau-Black-osf-t1--base.tfm \
tex-Ysabeau-Black-osf-t1.tfm \
tex-Ysabeau-Black-osf-t1.vf \
tex-Ysabeau-Black-osf-t2a--base.tfm \
tex-Ysabeau-Black-osf-t2a.tfm \
tex-Ysabeau-Black-osf-t2a.vf \
tex-Ysabeau-Black-osf-t2b--base.tfm \
tex-Ysabeau-Black-osf-t2b.tfm \
tex-Ysabeau-Black-osf-t2b.vf \
tex-Ysabeau-Black-osf-t2c--base.tfm \
tex-Ysabeau-Black-osf-t2c.tfm \
tex-Ysabeau-Black-osf-t2c.vf \
tex-Ysabeau-Black-osf-t3.tfm \
tex-Ysabeau-Black-osf-t4--base.tfm \
tex-Ysabeau-Black-osf-t4.tfm \
tex-Ysabeau-Black-osf-t4.vf \
tex-Ysabeau-Black-osf-t5--base.tfm \
tex-Ysabeau-Black-osf-t5.tfm \
tex-Ysabeau-Black-osf-t5.vf \
tex-Ysabeau-Black-osf-ts1--base.tfm \
tex-Ysabeau-Black-osf-ts1.tfm \
tex-Ysabeau-Black-osf-ts1.vf \
tex-Ysabeau-Black-osf-ts3.tfm \
tex-Ysabeau-Black-sup-cs.tfm \
tex-Ysabeau-Black-sup-l7x.tfm \
tex-Ysabeau-Black-sup-lgr.tfm \
tex-Ysabeau-Black-sup-ly1.tfm \
tex-Ysabeau-Black-sup-ot1.tfm \
tex-Ysabeau-Black-sup-qx--base.tfm \
tex-Ysabeau-Black-sup-qx.tfm \
tex-Ysabeau-Black-sup-qx.vf \
tex-Ysabeau-Black-sup-t1--base.tfm \
tex-Ysabeau-Black-sup-t1.tfm \
tex-Ysabeau-Black-sup-t1.vf \
tex-Ysabeau-Black-sup-t2a--base.tfm \
tex-Ysabeau-Black-sup-t2a.tfm \
tex-Ysabeau-Black-sup-t2a.vf \
tex-Ysabeau-Black-sup-t2b--base.tfm \
tex-Ysabeau-Black-sup-t2b.tfm \
tex-Ysabeau-Black-sup-t2b.vf \
tex-Ysabeau-Black-sup-t2c--base.tfm \
tex-Ysabeau-Black-sup-t2c.tfm \
tex-Ysabeau-Black-sup-t2c.vf \
tex-Ysabeau-Black-sup-t3.tfm \
tex-Ysabeau-Black-sup-t4--base.tfm \
tex-Ysabeau-Black-sup-t4.tfm \
tex-Ysabeau-Black-sup-t4.vf \
tex-Ysabeau-Black-sup-t5--base.tfm \
tex-Ysabeau-Black-sup-t5.tfm \
tex-Ysabeau-Black-sup-t5.vf \
tex-Ysabeau-Black-sup-ts3.tfm \
tex-Ysabeau-Black-tlf-cs.tfm \
tex-Ysabeau-Black-tlf-l7x.tfm \
tex-Ysabeau-Black-tlf-lgr.tfm \
tex-Ysabeau-Black-tlf-ly1.tfm \
tex-Ysabeau-Black-tlf-ot1.tfm \
tex-Ysabeau-Black-tlf-qx--base.tfm \
tex-Ysabeau-Black-tlf-qx.tfm \
tex-Ysabeau-Black-tlf-qx.vf \
tex-Ysabeau-Black-tlf-sc-cs--base.tfm \
tex-Ysabeau-Black-tlf-sc-cs.tfm \
tex-Ysabeau-Black-tlf-sc-cs.vf \
tex-Ysabeau-Black-tlf-sc-l7x--base.tfm \
tex-Ysabeau-Black-tlf-sc-l7x.tfm \
tex-Ysabeau-Black-tlf-sc-l7x.vf \
tex-Ysabeau-Black-tlf-sc-lgr.tfm \
tex-Ysabeau-Black-tlf-sc-ly1--base.tfm \
tex-Ysabeau-Black-tlf-sc-ly1.tfm \
tex-Ysabeau-Black-tlf-sc-ly1.vf \
tex-Ysabeau-Black-tlf-sc-ot1--base.tfm \
tex-Ysabeau-Black-tlf-sc-ot1.tfm \
tex-Ysabeau-Black-tlf-sc-ot1.vf \
tex-Ysabeau-Black-tlf-sc-qx--base.tfm \
tex-Ysabeau-Black-tlf-sc-qx.tfm \
tex-Ysabeau-Black-tlf-sc-qx.vf \
tex-Ysabeau-Black-tlf-sc-t1--base.tfm \
tex-Ysabeau-Black-tlf-sc-t1.tfm \
tex-Ysabeau-Black-tlf-sc-t1.vf \
tex-Ysabeau-Black-tlf-sc-t2a--base.tfm \
tex-Ysabeau-Black-tlf-sc-t2a.tfm \
tex-Ysabeau-Black-tlf-sc-t2a.vf \
tex-Ysabeau-Black-tlf-sc-t2b--base.tfm \
tex-Ysabeau-Black-tlf-sc-t2b.tfm \
tex-Ysabeau-Black-tlf-sc-t2b.vf \
tex-Ysabeau-Black-tlf-sc-t2c--base.tfm \
tex-Ysabeau-Black-tlf-sc-t2c.tfm \
tex-Ysabeau-Black-tlf-sc-t2c.vf \
tex-Ysabeau-Black-tlf-sc-t3.tfm \
tex-Ysabeau-Black-tlf-sc-t4--base.tfm \
tex-Ysabeau-Black-tlf-sc-t4.tfm \
tex-Ysabeau-Black-tlf-sc-t4.vf \
tex-Ysabeau-Black-tlf-sc-t5--base.tfm \
tex-Ysabeau-Black-tlf-sc-t5.tfm \
tex-Ysabeau-Black-tlf-sc-t5.vf \
tex-Ysabeau-Black-tlf-sc-ts3--base.tfm \
tex-Ysabeau-Black-tlf-sc-ts3.tfm \
tex-Ysabeau-Black-tlf-sc-ts3.vf \
tex-Ysabeau-Black-tlf-t1--base.tfm \
tex-Ysabeau-Black-tlf-t1.tfm \
tex-Ysabeau-Black-tlf-t1.vf \
tex-Ysabeau-Black-tlf-t2a--base.tfm \
tex-Ysabeau-Black-tlf-t2a.tfm \
tex-Ysabeau-Black-tlf-t2a.vf \
tex-Ysabeau-Black-tlf-t2b--base.tfm \
tex-Ysabeau-Black-tlf-t2b.tfm \
tex-Ysabeau-Black-tlf-t2b.vf \
tex-Ysabeau-Black-tlf-t2c--base.tfm \
tex-Ysabeau-Black-tlf-t2c.tfm \
tex-Ysabeau-Black-tlf-t2c.vf \
tex-Ysabeau-Black-tlf-t3.tfm \
tex-Ysabeau-Black-tlf-t4--base.tfm \
tex-Ysabeau-Black-tlf-t4.tfm \
tex-Ysabeau-Black-tlf-t4.vf \
tex-Ysabeau-Black-tlf-t5--base.tfm \
tex-Ysabeau-Black-tlf-t5.tfm \
tex-Ysabeau-Black-tlf-t5.vf \
tex-Ysabeau-Black-tlf-ts1--base.tfm \
tex-Ysabeau-Black-tlf-ts1.tfm \
tex-Ysabeau-Black-tlf-ts1.vf \
tex-Ysabeau-Black-tlf-ts3.tfm \
tex-Ysabeau-Black-tosf-cs.tfm \
tex-Ysabeau-Black-tosf-l7x.tfm \
tex-Ysabeau-Black-tosf-lgr.tfm \
tex-Ysabeau-Black-tosf-ly1.tfm \
tex-Ysabeau-Black-tosf-ot1.tfm \
tex-Ysabeau-Black-tosf-qx--base.tfm \
tex-Ysabeau-Black-tosf-qx.tfm \
tex-Ysabeau-Black-tosf-qx.vf \
tex-Ysabeau-Black-tosf-sc-cs--base.tfm \
tex-Ysabeau-Black-tosf-sc-cs.tfm \
tex-Ysabeau-Black-tosf-sc-cs.vf \
tex-Ysabeau-Black-tosf-sc-l7x--base.tfm \
tex-Ysabeau-Black-tosf-sc-l7x.tfm \
tex-Ysabeau-Black-tosf-sc-l7x.vf \
tex-Ysabeau-Black-tosf-sc-lgr.tfm \
tex-Ysabeau-Black-tosf-sc-ly1--base.tfm \
tex-Ysabeau-Black-tosf-sc-ly1.tfm \
tex-Ysabeau-Black-tosf-sc-ly1.vf \
tex-Ysabeau-Black-tosf-sc-ot1--base.tfm \
tex-Ysabeau-Black-tosf-sc-ot1.tfm \
tex-Ysabeau-Black-tosf-sc-ot1.vf \
tex-Ysabeau-Black-tosf-sc-qx--base.tfm \
tex-Ysabeau-Black-tosf-sc-qx.tfm \
tex-Ysabeau-Black-tosf-sc-qx.vf \
tex-Ysabeau-Black-tosf-sc-t1--base.tfm \
tex-Ysabeau-Black-tosf-sc-t1.tfm \
tex-Ysabeau-Black-tosf-sc-t1.vf \
tex-Ysabeau-Black-tosf-sc-t2a--base.tfm \
tex-Ysabeau-Black-tosf-sc-t2a.tfm \
tex-Ysabeau-Black-tosf-sc-t2a.vf \
tex-Ysabeau-Black-tosf-sc-t2b--base.tfm \
tex-Ysabeau-Black-tosf-sc-t2b.tfm \
tex-Ysabeau-Black-tosf-sc-t2b.vf \
tex-Ysabeau-Black-tosf-sc-t2c--base.tfm \
tex-Ysabeau-Black-tosf-sc-t2c.tfm \
tex-Ysabeau-Black-tosf-sc-t2c.vf \
tex-Ysabeau-Black-tosf-sc-t3.tfm \
tex-Ysabeau-Black-tosf-sc-t4--base.tfm \
tex-Ysabeau-Black-tosf-sc-t4.tfm \
tex-Ysabeau-Black-tosf-sc-t4.vf \
tex-Ysabeau-Black-tosf-sc-t5--base.tfm \
tex-Ysabeau-Black-tosf-sc-t5.tfm \
tex-Ysabeau-Black-tosf-sc-t5.vf \
tex-Ysabeau-Black-tosf-sc-ts3--base.tfm \
tex-Ysabeau-Black-tosf-sc-ts3.tfm \
tex-Ysabeau-Black-tosf-sc-ts3.vf \
tex-Ysabeau-Black-tosf-t1--base.tfm \
tex-Ysabeau-Black-tosf-t1.tfm \
tex-Ysabeau-Black-tosf-t1.vf \
tex-Ysabeau-Black-tosf-t2a--base.tfm \
tex-Ysabeau-Black-tosf-t2a.tfm \
tex-Ysabeau-Black-tosf-t2a.vf \
tex-Ysabeau-Black-tosf-t2b--base.tfm \
tex-Ysabeau-Black-tosf-t2b.tfm \
tex-Ysabeau-Black-tosf-t2b.vf \
tex-Ysabeau-Black-tosf-t2c--base.tfm \
tex-Ysabeau-Black-tosf-t2c.tfm \
tex-Ysabeau-Black-tosf-t2c.vf \
tex-Ysabeau-Black-tosf-t3.tfm \
tex-Ysabeau-Black-tosf-t4--base.tfm \
tex-Ysabeau-Black-tosf-t4.tfm \
tex-Ysabeau-Black-tosf-t4.vf \
tex-Ysabeau-Black-tosf-t5--base.tfm \
tex-Ysabeau-Black-tosf-t5.tfm \
tex-Ysabeau-Black-tosf-t5.vf \
tex-Ysabeau-Black-tosf-ts1--base.tfm \
tex-Ysabeau-Black-tosf-ts1.tfm \
tex-Ysabeau-Black-tosf-ts1.vf \
tex-Ysabeau-Black-tosf-ts3.tfm \
tex-Ysabeau-BlackItalic-dnom-cs.tfm \
tex-Ysabeau-BlackItalic-dnom-l7x.tfm \
tex-Ysabeau-BlackItalic-dnom-lgr.tfm \
tex-Ysabeau-BlackItalic-dnom-ly1.tfm \
tex-Ysabeau-BlackItalic-dnom-ot1.tfm \
tex-Ysabeau-BlackItalic-dnom-qx--base.tfm \
tex-Ysabeau-BlackItalic-dnom-qx.tfm \
tex-Ysabeau-BlackItalic-dnom-qx.vf \
tex-Ysabeau-BlackItalic-dnom-t1--base.tfm \
tex-Ysabeau-BlackItalic-dnom-t1.tfm \
tex-Ysabeau-BlackItalic-dnom-t1.vf \
tex-Ysabeau-BlackItalic-dnom-t2a--base.tfm \
tex-Ysabeau-BlackItalic-dnom-t2a.tfm \
tex-Ysabeau-BlackItalic-dnom-t2a.vf \
tex-Ysabeau-BlackItalic-dnom-t2b--base.tfm \
tex-Ysabeau-BlackItalic-dnom-t2b.tfm \
tex-Ysabeau-BlackItalic-dnom-t2b.vf \
tex-Ysabeau-BlackItalic-dnom-t2c--base.tfm \
tex-Ysabeau-BlackItalic-dnom-t2c.tfm \
tex-Ysabeau-BlackItalic-dnom-t2c.vf \
tex-Ysabeau-BlackItalic-dnom-t3.tfm \
tex-Ysabeau-BlackItalic-dnom-t4--base.tfm \
tex-Ysabeau-BlackItalic-dnom-t4.tfm \
tex-Ysabeau-BlackItalic-dnom-t4.vf \
tex-Ysabeau-BlackItalic-dnom-t5--base.tfm \
tex-Ysabeau-BlackItalic-dnom-t5.tfm \
tex-Ysabeau-BlackItalic-dnom-t5.vf \
tex-Ysabeau-BlackItalic-dnom-ts3.tfm \
tex-Ysabeau-BlackItalic-inf-cs.tfm \
tex-Ysabeau-BlackItalic-inf-l7x.tfm \
tex-Ysabeau-BlackItalic-inf-lgr.tfm \
tex-Ysabeau-BlackItalic-inf-ly1.tfm \
tex-Ysabeau-BlackItalic-inf-ot1.tfm \
tex-Ysabeau-BlackItalic-inf-qx--base.tfm \
tex-Ysabeau-BlackItalic-inf-qx.tfm \
tex-Ysabeau-BlackItalic-inf-qx.vf \
tex-Ysabeau-BlackItalic-inf-t1--base.tfm \
tex-Ysabeau-BlackItalic-inf-t1.tfm \
tex-Ysabeau-BlackItalic-inf-t1.vf \
tex-Ysabeau-BlackItalic-inf-t2a--base.tfm \
tex-Ysabeau-BlackItalic-inf-t2a.tfm \
tex-Ysabeau-BlackItalic-inf-t2a.vf \
tex-Ysabeau-BlackItalic-inf-t2b--base.tfm \
tex-Ysabeau-BlackItalic-inf-t2b.tfm \
tex-Ysabeau-BlackItalic-inf-t2b.vf \
tex-Ysabeau-BlackItalic-inf-t2c--base.tfm \
tex-Ysabeau-BlackItalic-inf-t2c.tfm \
tex-Ysabeau-BlackItalic-inf-t2c.vf \
tex-Ysabeau-BlackItalic-inf-t3.tfm \
tex-Ysabeau-BlackItalic-inf-t4--base.tfm \
tex-Ysabeau-BlackItalic-inf-t4.tfm \
tex-Ysabeau-BlackItalic-inf-t4.vf \
tex-Ysabeau-BlackItalic-inf-t5--base.tfm \
tex-Ysabeau-BlackItalic-inf-t5.tfm \
tex-Ysabeau-BlackItalic-inf-t5.vf \
tex-Ysabeau-BlackItalic-inf-ts3.tfm \
tex-Ysabeau-BlackItalic-lf-cs.tfm \
tex-Ysabeau-BlackItalic-lf-l7x.tfm \
tex-Ysabeau-BlackItalic-lf-lgr.tfm \
tex-Ysabeau-BlackItalic-lf-ly1.tfm \
tex-Ysabeau-BlackItalic-lf-ot1.tfm \
tex-Ysabeau-BlackItalic-lf-qx--base.tfm \
tex-Ysabeau-BlackItalic-lf-qx.tfm \
tex-Ysabeau-BlackItalic-lf-qx.vf \
tex-Ysabeau-BlackItalic-lf-swash-cs.tfm \
tex-Ysabeau-BlackItalic-lf-swash-l7x.tfm \
tex-Ysabeau-BlackItalic-lf-swash-lgr.tfm \
tex-Ysabeau-BlackItalic-lf-swash-ly1.tfm \
tex-Ysabeau-BlackItalic-lf-swash-ot1.tfm \
tex-Ysabeau-BlackItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-BlackItalic-lf-swash-qx.tfm \
tex-Ysabeau-BlackItalic-lf-swash-qx.vf \
tex-Ysabeau-BlackItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t1.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t1.vf \
tex-Ysabeau-BlackItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t2a.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t2a.vf \
tex-Ysabeau-BlackItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t2b.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t2b.vf \
tex-Ysabeau-BlackItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t2c.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t2c.vf \
tex-Ysabeau-BlackItalic-lf-swash-t3.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t4.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t4.vf \
tex-Ysabeau-BlackItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t5.tfm \
tex-Ysabeau-BlackItalic-lf-swash-t5.vf \
tex-Ysabeau-BlackItalic-lf-swash-ts3.tfm \
tex-Ysabeau-BlackItalic-lf-t1--base.tfm \
tex-Ysabeau-BlackItalic-lf-t1.tfm \
tex-Ysabeau-BlackItalic-lf-t1.vf \
tex-Ysabeau-BlackItalic-lf-t2a--base.tfm \
tex-Ysabeau-BlackItalic-lf-t2a.tfm \
tex-Ysabeau-BlackItalic-lf-t2a.vf \
tex-Ysabeau-BlackItalic-lf-t2b--base.tfm \
tex-Ysabeau-BlackItalic-lf-t2b.tfm \
tex-Ysabeau-BlackItalic-lf-t2b.vf \
tex-Ysabeau-BlackItalic-lf-t2c--base.tfm \
tex-Ysabeau-BlackItalic-lf-t2c.tfm \
tex-Ysabeau-BlackItalic-lf-t2c.vf \
tex-Ysabeau-BlackItalic-lf-t3.tfm \
tex-Ysabeau-BlackItalic-lf-t4--base.tfm \
tex-Ysabeau-BlackItalic-lf-t4.tfm \
tex-Ysabeau-BlackItalic-lf-t4.vf \
tex-Ysabeau-BlackItalic-lf-t5--base.tfm \
tex-Ysabeau-BlackItalic-lf-t5.tfm \
tex-Ysabeau-BlackItalic-lf-t5.vf \
tex-Ysabeau-BlackItalic-lf-ts1--base.tfm \
tex-Ysabeau-BlackItalic-lf-ts1.tfm \
tex-Ysabeau-BlackItalic-lf-ts1.vf \
tex-Ysabeau-BlackItalic-lf-ts3.tfm \
tex-Ysabeau-BlackItalic-numr-cs.tfm \
tex-Ysabeau-BlackItalic-numr-l7x.tfm \
tex-Ysabeau-BlackItalic-numr-lgr.tfm \
tex-Ysabeau-BlackItalic-numr-ly1.tfm \
tex-Ysabeau-BlackItalic-numr-ot1.tfm \
tex-Ysabeau-BlackItalic-numr-qx--base.tfm \
tex-Ysabeau-BlackItalic-numr-qx.tfm \
tex-Ysabeau-BlackItalic-numr-qx.vf \
tex-Ysabeau-BlackItalic-numr-t1--base.tfm \
tex-Ysabeau-BlackItalic-numr-t1.tfm \
tex-Ysabeau-BlackItalic-numr-t1.vf \
tex-Ysabeau-BlackItalic-numr-t2a--base.tfm \
tex-Ysabeau-BlackItalic-numr-t2a.tfm \
tex-Ysabeau-BlackItalic-numr-t2a.vf \
tex-Ysabeau-BlackItalic-numr-t2b--base.tfm \
tex-Ysabeau-BlackItalic-numr-t2b.tfm \
tex-Ysabeau-BlackItalic-numr-t2b.vf \
tex-Ysabeau-BlackItalic-numr-t2c--base.tfm \
tex-Ysabeau-BlackItalic-numr-t2c.tfm \
tex-Ysabeau-BlackItalic-numr-t2c.vf \
tex-Ysabeau-BlackItalic-numr-t3.tfm \
tex-Ysabeau-BlackItalic-numr-t4--base.tfm \
tex-Ysabeau-BlackItalic-numr-t4.tfm \
tex-Ysabeau-BlackItalic-numr-t4.vf \
tex-Ysabeau-BlackItalic-numr-t5--base.tfm \
tex-Ysabeau-BlackItalic-numr-t5.tfm \
tex-Ysabeau-BlackItalic-numr-t5.vf \
tex-Ysabeau-BlackItalic-numr-ts3.tfm \
tex-Ysabeau-BlackItalic-osf-cs.tfm \
tex-Ysabeau-BlackItalic-osf-l7x.tfm \
tex-Ysabeau-BlackItalic-osf-lgr.tfm \
tex-Ysabeau-BlackItalic-osf-ly1.tfm \
tex-Ysabeau-BlackItalic-osf-ot1.tfm \
tex-Ysabeau-BlackItalic-osf-qx--base.tfm \
tex-Ysabeau-BlackItalic-osf-qx.tfm \
tex-Ysabeau-BlackItalic-osf-qx.vf \
tex-Ysabeau-BlackItalic-osf-swash-cs.tfm \
tex-Ysabeau-BlackItalic-osf-swash-l7x.tfm \
tex-Ysabeau-BlackItalic-osf-swash-lgr.tfm \
tex-Ysabeau-BlackItalic-osf-swash-ly1.tfm \
tex-Ysabeau-BlackItalic-osf-swash-ot1.tfm \
tex-Ysabeau-BlackItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-BlackItalic-osf-swash-qx.tfm \
tex-Ysabeau-BlackItalic-osf-swash-qx.vf \
tex-Ysabeau-BlackItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t1.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t1.vf \
tex-Ysabeau-BlackItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t2a.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t2a.vf \
tex-Ysabeau-BlackItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t2b.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t2b.vf \
tex-Ysabeau-BlackItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t2c.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t2c.vf \
tex-Ysabeau-BlackItalic-osf-swash-t3.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t4.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t4.vf \
tex-Ysabeau-BlackItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t5.tfm \
tex-Ysabeau-BlackItalic-osf-swash-t5.vf \
tex-Ysabeau-BlackItalic-osf-swash-ts3.tfm \
tex-Ysabeau-BlackItalic-osf-t1--base.tfm \
tex-Ysabeau-BlackItalic-osf-t1.tfm \
tex-Ysabeau-BlackItalic-osf-t1.vf \
tex-Ysabeau-BlackItalic-osf-t2a--base.tfm \
tex-Ysabeau-BlackItalic-osf-t2a.tfm \
tex-Ysabeau-BlackItalic-osf-t2a.vf \
tex-Ysabeau-BlackItalic-osf-t2b--base.tfm \
tex-Ysabeau-BlackItalic-osf-t2b.tfm \
tex-Ysabeau-BlackItalic-osf-t2b.vf \
tex-Ysabeau-BlackItalic-osf-t2c--base.tfm \
tex-Ysabeau-BlackItalic-osf-t2c.tfm \
tex-Ysabeau-BlackItalic-osf-t2c.vf \
tex-Ysabeau-BlackItalic-osf-t3.tfm \
tex-Ysabeau-BlackItalic-osf-t4--base.tfm \
tex-Ysabeau-BlackItalic-osf-t4.tfm \
tex-Ysabeau-BlackItalic-osf-t4.vf \
tex-Ysabeau-BlackItalic-osf-t5--base.tfm \
tex-Ysabeau-BlackItalic-osf-t5.tfm \
tex-Ysabeau-BlackItalic-osf-t5.vf \
tex-Ysabeau-BlackItalic-osf-ts1--base.tfm \
tex-Ysabeau-BlackItalic-osf-ts1.tfm \
tex-Ysabeau-BlackItalic-osf-ts1.vf \
tex-Ysabeau-BlackItalic-osf-ts3.tfm \
tex-Ysabeau-BlackItalic-sup-cs.tfm \
tex-Ysabeau-BlackItalic-sup-l7x.tfm \
tex-Ysabeau-BlackItalic-sup-lgr.tfm \
tex-Ysabeau-BlackItalic-sup-ly1.tfm \
tex-Ysabeau-BlackItalic-sup-ot1.tfm \
tex-Ysabeau-BlackItalic-sup-qx--base.tfm \
tex-Ysabeau-BlackItalic-sup-qx.tfm \
tex-Ysabeau-BlackItalic-sup-qx.vf \
tex-Ysabeau-BlackItalic-sup-t1--base.tfm \
tex-Ysabeau-BlackItalic-sup-t1.tfm \
tex-Ysabeau-BlackItalic-sup-t1.vf \
tex-Ysabeau-BlackItalic-sup-t2a--base.tfm \
tex-Ysabeau-BlackItalic-sup-t2a.tfm \
tex-Ysabeau-BlackItalic-sup-t2a.vf \
tex-Ysabeau-BlackItalic-sup-t2b--base.tfm \
tex-Ysabeau-BlackItalic-sup-t2b.tfm \
tex-Ysabeau-BlackItalic-sup-t2b.vf \
tex-Ysabeau-BlackItalic-sup-t2c--base.tfm \
tex-Ysabeau-BlackItalic-sup-t2c.tfm \
tex-Ysabeau-BlackItalic-sup-t2c.vf \
tex-Ysabeau-BlackItalic-sup-t3.tfm \
tex-Ysabeau-BlackItalic-sup-t4--base.tfm \
tex-Ysabeau-BlackItalic-sup-t4.tfm \
tex-Ysabeau-BlackItalic-sup-t4.vf \
tex-Ysabeau-BlackItalic-sup-t5--base.tfm \
tex-Ysabeau-BlackItalic-sup-t5.tfm \
tex-Ysabeau-BlackItalic-sup-t5.vf \
tex-Ysabeau-BlackItalic-sup-ts3.tfm \
tex-Ysabeau-BlackItalic-tlf-cs.tfm \
tex-Ysabeau-BlackItalic-tlf-l7x.tfm \
tex-Ysabeau-BlackItalic-tlf-lgr.tfm \
tex-Ysabeau-BlackItalic-tlf-ly1.tfm \
tex-Ysabeau-BlackItalic-tlf-ot1.tfm \
tex-Ysabeau-BlackItalic-tlf-qx--base.tfm \
tex-Ysabeau-BlackItalic-tlf-qx.tfm \
tex-Ysabeau-BlackItalic-tlf-qx.vf \
tex-Ysabeau-BlackItalic-tlf-swash-cs.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-qx.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-qx.vf \
tex-Ysabeau-BlackItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t1.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t1.vf \
tex-Ysabeau-BlackItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t2a.vf \
tex-Ysabeau-BlackItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t2b.vf \
tex-Ysabeau-BlackItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t2c.vf \
tex-Ysabeau-BlackItalic-tlf-swash-t3.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t4.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t4.vf \
tex-Ysabeau-BlackItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t5.tfm \
tex-Ysabeau-BlackItalic-tlf-swash-t5.vf \
tex-Ysabeau-BlackItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-BlackItalic-tlf-t1--base.tfm \
tex-Ysabeau-BlackItalic-tlf-t1.tfm \
tex-Ysabeau-BlackItalic-tlf-t1.vf \
tex-Ysabeau-BlackItalic-tlf-t2a--base.tfm \
tex-Ysabeau-BlackItalic-tlf-t2a.tfm \
tex-Ysabeau-BlackItalic-tlf-t2a.vf \
tex-Ysabeau-BlackItalic-tlf-t2b--base.tfm \
tex-Ysabeau-BlackItalic-tlf-t2b.tfm \
tex-Ysabeau-BlackItalic-tlf-t2b.vf \
tex-Ysabeau-BlackItalic-tlf-t2c--base.tfm \
tex-Ysabeau-BlackItalic-tlf-t2c.tfm \
tex-Ysabeau-BlackItalic-tlf-t2c.vf \
tex-Ysabeau-BlackItalic-tlf-t3.tfm \
tex-Ysabeau-BlackItalic-tlf-t4--base.tfm \
tex-Ysabeau-BlackItalic-tlf-t4.tfm \
tex-Ysabeau-BlackItalic-tlf-t4.vf \
tex-Ysabeau-BlackItalic-tlf-t5--base.tfm \
tex-Ysabeau-BlackItalic-tlf-t5.tfm \
tex-Ysabeau-BlackItalic-tlf-t5.vf \
tex-Ysabeau-BlackItalic-tlf-ts1--base.tfm \
tex-Ysabeau-BlackItalic-tlf-ts1.tfm \
tex-Ysabeau-BlackItalic-tlf-ts1.vf \
tex-Ysabeau-BlackItalic-tlf-ts3.tfm \
tex-Ysabeau-BlackItalic-tosf-cs.tfm \
tex-Ysabeau-BlackItalic-tosf-l7x.tfm \
tex-Ysabeau-BlackItalic-tosf-lgr.tfm \
tex-Ysabeau-BlackItalic-tosf-ly1.tfm \
tex-Ysabeau-BlackItalic-tosf-ot1.tfm \
tex-Ysabeau-BlackItalic-tosf-qx--base.tfm \
tex-Ysabeau-BlackItalic-tosf-qx.tfm \
tex-Ysabeau-BlackItalic-tosf-qx.vf \
tex-Ysabeau-BlackItalic-tosf-swash-cs.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-qx.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-qx.vf \
tex-Ysabeau-BlackItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t1.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t1.vf \
tex-Ysabeau-BlackItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t2a.vf \
tex-Ysabeau-BlackItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t2b.vf \
tex-Ysabeau-BlackItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t2c.vf \
tex-Ysabeau-BlackItalic-tosf-swash-t3.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t4.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t4.vf \
tex-Ysabeau-BlackItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t5.tfm \
tex-Ysabeau-BlackItalic-tosf-swash-t5.vf \
tex-Ysabeau-BlackItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-BlackItalic-tosf-t1--base.tfm \
tex-Ysabeau-BlackItalic-tosf-t1.tfm \
tex-Ysabeau-BlackItalic-tosf-t1.vf \
tex-Ysabeau-BlackItalic-tosf-t2a--base.tfm \
tex-Ysabeau-BlackItalic-tosf-t2a.tfm \
tex-Ysabeau-BlackItalic-tosf-t2a.vf \
tex-Ysabeau-BlackItalic-tosf-t2b--base.tfm \
tex-Ysabeau-BlackItalic-tosf-t2b.tfm \
tex-Ysabeau-BlackItalic-tosf-t2b.vf \
tex-Ysabeau-BlackItalic-tosf-t2c--base.tfm \
tex-Ysabeau-BlackItalic-tosf-t2c.tfm \
tex-Ysabeau-BlackItalic-tosf-t2c.vf \
tex-Ysabeau-BlackItalic-tosf-t3.tfm \
tex-Ysabeau-BlackItalic-tosf-t4--base.tfm \
tex-Ysabeau-BlackItalic-tosf-t4.tfm \
tex-Ysabeau-BlackItalic-tosf-t4.vf \
tex-Ysabeau-BlackItalic-tosf-t5--base.tfm \
tex-Ysabeau-BlackItalic-tosf-t5.tfm \
tex-Ysabeau-BlackItalic-tosf-t5.vf \
tex-Ysabeau-BlackItalic-tosf-ts1--base.tfm \
tex-Ysabeau-BlackItalic-tosf-ts1.tfm \
tex-Ysabeau-BlackItalic-tosf-ts1.vf \
tex-Ysabeau-BlackItalic-tosf-ts3.tfm \
tex-Ysabeau-Bold-dnom-cs.tfm \
tex-Ysabeau-Bold-dnom-l7x.tfm \
tex-Ysabeau-Bold-dnom-lgr.tfm \
tex-Ysabeau-Bold-dnom-ly1.tfm \
tex-Ysabeau-Bold-dnom-ot1.tfm \
tex-Ysabeau-Bold-dnom-qx--base.tfm \
tex-Ysabeau-Bold-dnom-qx.tfm \
tex-Ysabeau-Bold-dnom-qx.vf \
tex-Ysabeau-Bold-dnom-t1--base.tfm \
tex-Ysabeau-Bold-dnom-t1.tfm \
tex-Ysabeau-Bold-dnom-t1.vf \
tex-Ysabeau-Bold-dnom-t2a--base.tfm \
tex-Ysabeau-Bold-dnom-t2a.tfm \
tex-Ysabeau-Bold-dnom-t2a.vf \
tex-Ysabeau-Bold-dnom-t2b--base.tfm \
tex-Ysabeau-Bold-dnom-t2b.tfm \
tex-Ysabeau-Bold-dnom-t2b.vf \
tex-Ysabeau-Bold-dnom-t2c--base.tfm \
tex-Ysabeau-Bold-dnom-t2c.tfm \
tex-Ysabeau-Bold-dnom-t2c.vf \
tex-Ysabeau-Bold-dnom-t3.tfm \
tex-Ysabeau-Bold-dnom-t4--base.tfm \
tex-Ysabeau-Bold-dnom-t4.tfm \
tex-Ysabeau-Bold-dnom-t4.vf \
tex-Ysabeau-Bold-dnom-t5--base.tfm \
tex-Ysabeau-Bold-dnom-t5.tfm \
tex-Ysabeau-Bold-dnom-t5.vf \
tex-Ysabeau-Bold-dnom-ts3.tfm \
tex-Ysabeau-Bold-inf-cs.tfm \
tex-Ysabeau-Bold-inf-l7x.tfm \
tex-Ysabeau-Bold-inf-lgr.tfm \
tex-Ysabeau-Bold-inf-ly1.tfm \
tex-Ysabeau-Bold-inf-ot1.tfm \
tex-Ysabeau-Bold-inf-qx--base.tfm \
tex-Ysabeau-Bold-inf-qx.tfm \
tex-Ysabeau-Bold-inf-qx.vf \
tex-Ysabeau-Bold-inf-t1--base.tfm \
tex-Ysabeau-Bold-inf-t1.tfm \
tex-Ysabeau-Bold-inf-t1.vf \
tex-Ysabeau-Bold-inf-t2a--base.tfm \
tex-Ysabeau-Bold-inf-t2a.tfm \
tex-Ysabeau-Bold-inf-t2a.vf \
tex-Ysabeau-Bold-inf-t2b--base.tfm \
tex-Ysabeau-Bold-inf-t2b.tfm \
tex-Ysabeau-Bold-inf-t2b.vf \
tex-Ysabeau-Bold-inf-t2c--base.tfm \
tex-Ysabeau-Bold-inf-t2c.tfm \
tex-Ysabeau-Bold-inf-t2c.vf \
tex-Ysabeau-Bold-inf-t3.tfm \
tex-Ysabeau-Bold-inf-t4--base.tfm \
tex-Ysabeau-Bold-inf-t4.tfm \
tex-Ysabeau-Bold-inf-t4.vf \
tex-Ysabeau-Bold-inf-t5--base.tfm \
tex-Ysabeau-Bold-inf-t5.tfm \
tex-Ysabeau-Bold-inf-t5.vf \
tex-Ysabeau-Bold-inf-ts3.tfm \
tex-Ysabeau-Bold-lf-cs.tfm \
tex-Ysabeau-Bold-lf-l7x.tfm \
tex-Ysabeau-Bold-lf-lgr.tfm \
tex-Ysabeau-Bold-lf-ly1.tfm \
tex-Ysabeau-Bold-lf-ot1.tfm \
tex-Ysabeau-Bold-lf-qx--base.tfm \
tex-Ysabeau-Bold-lf-qx.tfm \
tex-Ysabeau-Bold-lf-qx.vf \
tex-Ysabeau-Bold-lf-sc-cs--base.tfm \
tex-Ysabeau-Bold-lf-sc-cs.tfm \
tex-Ysabeau-Bold-lf-sc-cs.vf \
tex-Ysabeau-Bold-lf-sc-l7x--base.tfm \
tex-Ysabeau-Bold-lf-sc-l7x.tfm \
tex-Ysabeau-Bold-lf-sc-l7x.vf \
tex-Ysabeau-Bold-lf-sc-lgr.tfm \
tex-Ysabeau-Bold-lf-sc-ly1--base.tfm \
tex-Ysabeau-Bold-lf-sc-ly1.tfm \
tex-Ysabeau-Bold-lf-sc-ly1.vf \
tex-Ysabeau-Bold-lf-sc-ot1--base.tfm \
tex-Ysabeau-Bold-lf-sc-ot1.tfm \
tex-Ysabeau-Bold-lf-sc-ot1.vf \
tex-Ysabeau-Bold-lf-sc-qx--base.tfm \
tex-Ysabeau-Bold-lf-sc-qx.tfm \
tex-Ysabeau-Bold-lf-sc-qx.vf \
tex-Ysabeau-Bold-lf-sc-t1--base.tfm \
tex-Ysabeau-Bold-lf-sc-t1.tfm \
tex-Ysabeau-Bold-lf-sc-t1.vf \
tex-Ysabeau-Bold-lf-sc-t2a--base.tfm \
tex-Ysabeau-Bold-lf-sc-t2a.tfm \
tex-Ysabeau-Bold-lf-sc-t2a.vf \
tex-Ysabeau-Bold-lf-sc-t2b--base.tfm \
tex-Ysabeau-Bold-lf-sc-t2b.tfm \
tex-Ysabeau-Bold-lf-sc-t2b.vf \
tex-Ysabeau-Bold-lf-sc-t2c--base.tfm \
tex-Ysabeau-Bold-lf-sc-t2c.tfm \
tex-Ysabeau-Bold-lf-sc-t2c.vf \
tex-Ysabeau-Bold-lf-sc-t3.tfm \
tex-Ysabeau-Bold-lf-sc-t4--base.tfm \
tex-Ysabeau-Bold-lf-sc-t4.tfm \
tex-Ysabeau-Bold-lf-sc-t4.vf \
tex-Ysabeau-Bold-lf-sc-t5--base.tfm \
tex-Ysabeau-Bold-lf-sc-t5.tfm \
tex-Ysabeau-Bold-lf-sc-t5.vf \
tex-Ysabeau-Bold-lf-sc-ts3--base.tfm \
tex-Ysabeau-Bold-lf-sc-ts3.tfm \
tex-Ysabeau-Bold-lf-sc-ts3.vf \
tex-Ysabeau-Bold-lf-t1--base.tfm \
tex-Ysabeau-Bold-lf-t1.tfm \
tex-Ysabeau-Bold-lf-t1.vf \
tex-Ysabeau-Bold-lf-t2a--base.tfm \
tex-Ysabeau-Bold-lf-t2a.tfm \
tex-Ysabeau-Bold-lf-t2a.vf \
tex-Ysabeau-Bold-lf-t2b--base.tfm \
tex-Ysabeau-Bold-lf-t2b.tfm \
tex-Ysabeau-Bold-lf-t2b.vf \
tex-Ysabeau-Bold-lf-t2c--base.tfm \
tex-Ysabeau-Bold-lf-t2c.tfm \
tex-Ysabeau-Bold-lf-t2c.vf \
tex-Ysabeau-Bold-lf-t3.tfm \
tex-Ysabeau-Bold-lf-t4--base.tfm \
tex-Ysabeau-Bold-lf-t4.tfm \
tex-Ysabeau-Bold-lf-t4.vf \
tex-Ysabeau-Bold-lf-t5--base.tfm \
tex-Ysabeau-Bold-lf-t5.tfm \
tex-Ysabeau-Bold-lf-t5.vf \
tex-Ysabeau-Bold-lf-ts1--base.tfm \
tex-Ysabeau-Bold-lf-ts1.tfm \
tex-Ysabeau-Bold-lf-ts1.vf \
tex-Ysabeau-Bold-lf-ts3.tfm \
tex-Ysabeau-Bold-numr-cs.tfm \
tex-Ysabeau-Bold-numr-l7x.tfm \
tex-Ysabeau-Bold-numr-lgr.tfm \
tex-Ysabeau-Bold-numr-ly1.tfm \
tex-Ysabeau-Bold-numr-ot1.tfm \
tex-Ysabeau-Bold-numr-qx--base.tfm \
tex-Ysabeau-Bold-numr-qx.tfm \
tex-Ysabeau-Bold-numr-qx.vf \
tex-Ysabeau-Bold-numr-t1--base.tfm \
tex-Ysabeau-Bold-numr-t1.tfm \
tex-Ysabeau-Bold-numr-t1.vf \
tex-Ysabeau-Bold-numr-t2a--base.tfm \
tex-Ysabeau-Bold-numr-t2a.tfm \
tex-Ysabeau-Bold-numr-t2a.vf \
tex-Ysabeau-Bold-numr-t2b--base.tfm \
tex-Ysabeau-Bold-numr-t2b.tfm \
tex-Ysabeau-Bold-numr-t2b.vf \
tex-Ysabeau-Bold-numr-t2c--base.tfm \
tex-Ysabeau-Bold-numr-t2c.tfm \
tex-Ysabeau-Bold-numr-t2c.vf \
tex-Ysabeau-Bold-numr-t3.tfm \
tex-Ysabeau-Bold-numr-t4--base.tfm \
tex-Ysabeau-Bold-numr-t4.tfm \
tex-Ysabeau-Bold-numr-t4.vf \
tex-Ysabeau-Bold-numr-t5--base.tfm \
tex-Ysabeau-Bold-numr-t5.tfm \
tex-Ysabeau-Bold-numr-t5.vf \
tex-Ysabeau-Bold-numr-ts3.tfm \
tex-Ysabeau-Bold-osf-cs.tfm \
tex-Ysabeau-Bold-osf-l7x.tfm \
tex-Ysabeau-Bold-osf-lgr.tfm \
tex-Ysabeau-Bold-osf-ly1.tfm \
tex-Ysabeau-Bold-osf-ot1.tfm \
tex-Ysabeau-Bold-osf-qx--base.tfm \
tex-Ysabeau-Bold-osf-qx.tfm \
tex-Ysabeau-Bold-osf-qx.vf \
tex-Ysabeau-Bold-osf-sc-cs--base.tfm \
tex-Ysabeau-Bold-osf-sc-cs.tfm \
tex-Ysabeau-Bold-osf-sc-cs.vf \
tex-Ysabeau-Bold-osf-sc-l7x--base.tfm \
tex-Ysabeau-Bold-osf-sc-l7x.tfm \
tex-Ysabeau-Bold-osf-sc-l7x.vf \
tex-Ysabeau-Bold-osf-sc-lgr.tfm \
tex-Ysabeau-Bold-osf-sc-ly1--base.tfm \
tex-Ysabeau-Bold-osf-sc-ly1.tfm \
tex-Ysabeau-Bold-osf-sc-ly1.vf \
tex-Ysabeau-Bold-osf-sc-ot1--base.tfm \
tex-Ysabeau-Bold-osf-sc-ot1.tfm \
tex-Ysabeau-Bold-osf-sc-ot1.vf \
tex-Ysabeau-Bold-osf-sc-qx--base.tfm \
tex-Ysabeau-Bold-osf-sc-qx.tfm \
tex-Ysabeau-Bold-osf-sc-qx.vf \
tex-Ysabeau-Bold-osf-sc-t1--base.tfm \
tex-Ysabeau-Bold-osf-sc-t1.tfm \
tex-Ysabeau-Bold-osf-sc-t1.vf \
tex-Ysabeau-Bold-osf-sc-t2a--base.tfm \
tex-Ysabeau-Bold-osf-sc-t2a.tfm \
tex-Ysabeau-Bold-osf-sc-t2a.vf \
tex-Ysabeau-Bold-osf-sc-t2b--base.tfm \
tex-Ysabeau-Bold-osf-sc-t2b.tfm \
tex-Ysabeau-Bold-osf-sc-t2b.vf \
tex-Ysabeau-Bold-osf-sc-t2c--base.tfm \
tex-Ysabeau-Bold-osf-sc-t2c.tfm \
tex-Ysabeau-Bold-osf-sc-t2c.vf \
tex-Ysabeau-Bold-osf-sc-t3.tfm \
tex-Ysabeau-Bold-osf-sc-t4--base.tfm \
tex-Ysabeau-Bold-osf-sc-t4.tfm \
tex-Ysabeau-Bold-osf-sc-t4.vf \
tex-Ysabeau-Bold-osf-sc-t5--base.tfm \
tex-Ysabeau-Bold-osf-sc-t5.tfm \
tex-Ysabeau-Bold-osf-sc-t5.vf \
tex-Ysabeau-Bold-osf-sc-ts3--base.tfm \
tex-Ysabeau-Bold-osf-sc-ts3.tfm \
tex-Ysabeau-Bold-osf-sc-ts3.vf \
tex-Ysabeau-Bold-osf-t1--base.tfm \
tex-Ysabeau-Bold-osf-t1.tfm \
tex-Ysabeau-Bold-osf-t1.vf \
tex-Ysabeau-Bold-osf-t2a--base.tfm \
tex-Ysabeau-Bold-osf-t2a.tfm \
tex-Ysabeau-Bold-osf-t2a.vf \
tex-Ysabeau-Bold-osf-t2b--base.tfm \
tex-Ysabeau-Bold-osf-t2b.tfm \
tex-Ysabeau-Bold-osf-t2b.vf \
tex-Ysabeau-Bold-osf-t2c--base.tfm \
tex-Ysabeau-Bold-osf-t2c.tfm \
tex-Ysabeau-Bold-osf-t2c.vf \
tex-Ysabeau-Bold-osf-t3.tfm \
tex-Ysabeau-Bold-osf-t4--base.tfm \
tex-Ysabeau-Bold-osf-t4.tfm \
tex-Ysabeau-Bold-osf-t4.vf \
tex-Ysabeau-Bold-osf-t5--base.tfm \
tex-Ysabeau-Bold-osf-t5.tfm \
tex-Ysabeau-Bold-osf-t5.vf \
tex-Ysabeau-Bold-osf-ts1--base.tfm \
tex-Ysabeau-Bold-osf-ts1.tfm \
tex-Ysabeau-Bold-osf-ts1.vf \
tex-Ysabeau-Bold-osf-ts3.tfm \
tex-Ysabeau-Bold-sup-cs.tfm \
tex-Ysabeau-Bold-sup-l7x.tfm \
tex-Ysabeau-Bold-sup-lgr.tfm \
tex-Ysabeau-Bold-sup-ly1.tfm \
tex-Ysabeau-Bold-sup-ot1.tfm \
tex-Ysabeau-Bold-sup-qx--base.tfm \
tex-Ysabeau-Bold-sup-qx.tfm \
tex-Ysabeau-Bold-sup-qx.vf \
tex-Ysabeau-Bold-sup-t1--base.tfm \
tex-Ysabeau-Bold-sup-t1.tfm \
tex-Ysabeau-Bold-sup-t1.vf \
tex-Ysabeau-Bold-sup-t2a--base.tfm \
tex-Ysabeau-Bold-sup-t2a.tfm \
tex-Ysabeau-Bold-sup-t2a.vf \
tex-Ysabeau-Bold-sup-t2b--base.tfm \
tex-Ysabeau-Bold-sup-t2b.tfm \
tex-Ysabeau-Bold-sup-t2b.vf \
tex-Ysabeau-Bold-sup-t2c--base.tfm \
tex-Ysabeau-Bold-sup-t2c.tfm \
tex-Ysabeau-Bold-sup-t2c.vf \
tex-Ysabeau-Bold-sup-t3.tfm \
tex-Ysabeau-Bold-sup-t4--base.tfm \
tex-Ysabeau-Bold-sup-t4.tfm \
tex-Ysabeau-Bold-sup-t4.vf \
tex-Ysabeau-Bold-sup-t5--base.tfm \
tex-Ysabeau-Bold-sup-t5.tfm \
tex-Ysabeau-Bold-sup-t5.vf \
tex-Ysabeau-Bold-sup-ts3.tfm \
tex-Ysabeau-Bold-tlf-cs.tfm \
tex-Ysabeau-Bold-tlf-l7x.tfm \
tex-Ysabeau-Bold-tlf-lgr.tfm \
tex-Ysabeau-Bold-tlf-ly1.tfm \
tex-Ysabeau-Bold-tlf-ot1.tfm \
tex-Ysabeau-Bold-tlf-qx--base.tfm \
tex-Ysabeau-Bold-tlf-qx.tfm \
tex-Ysabeau-Bold-tlf-qx.vf \
tex-Ysabeau-Bold-tlf-sc-cs--base.tfm \
tex-Ysabeau-Bold-tlf-sc-cs.tfm \
tex-Ysabeau-Bold-tlf-sc-cs.vf \
tex-Ysabeau-Bold-tlf-sc-l7x--base.tfm \
tex-Ysabeau-Bold-tlf-sc-l7x.tfm \
tex-Ysabeau-Bold-tlf-sc-l7x.vf \
tex-Ysabeau-Bold-tlf-sc-lgr.tfm \
tex-Ysabeau-Bold-tlf-sc-ly1--base.tfm \
tex-Ysabeau-Bold-tlf-sc-ly1.tfm \
tex-Ysabeau-Bold-tlf-sc-ly1.vf \
tex-Ysabeau-Bold-tlf-sc-ot1--base.tfm \
tex-Ysabeau-Bold-tlf-sc-ot1.tfm \
tex-Ysabeau-Bold-tlf-sc-ot1.vf \
tex-Ysabeau-Bold-tlf-sc-qx--base.tfm \
tex-Ysabeau-Bold-tlf-sc-qx.tfm \
tex-Ysabeau-Bold-tlf-sc-qx.vf \
tex-Ysabeau-Bold-tlf-sc-t1--base.tfm \
tex-Ysabeau-Bold-tlf-sc-t1.tfm \
tex-Ysabeau-Bold-tlf-sc-t1.vf \
tex-Ysabeau-Bold-tlf-sc-t2a--base.tfm \
tex-Ysabeau-Bold-tlf-sc-t2a.tfm \
tex-Ysabeau-Bold-tlf-sc-t2a.vf \
tex-Ysabeau-Bold-tlf-sc-t2b--base.tfm \
tex-Ysabeau-Bold-tlf-sc-t2b.tfm \
tex-Ysabeau-Bold-tlf-sc-t2b.vf \
tex-Ysabeau-Bold-tlf-sc-t2c--base.tfm \
tex-Ysabeau-Bold-tlf-sc-t2c.tfm \
tex-Ysabeau-Bold-tlf-sc-t2c.vf \
tex-Ysabeau-Bold-tlf-sc-t3.tfm \
tex-Ysabeau-Bold-tlf-sc-t4--base.tfm \
tex-Ysabeau-Bold-tlf-sc-t4.tfm \
tex-Ysabeau-Bold-tlf-sc-t4.vf \
tex-Ysabeau-Bold-tlf-sc-t5--base.tfm \
tex-Ysabeau-Bold-tlf-sc-t5.tfm \
tex-Ysabeau-Bold-tlf-sc-t5.vf \
tex-Ysabeau-Bold-tlf-sc-ts3--base.tfm \
tex-Ysabeau-Bold-tlf-sc-ts3.tfm \
tex-Ysabeau-Bold-tlf-sc-ts3.vf \
tex-Ysabeau-Bold-tlf-t1--base.tfm \
tex-Ysabeau-Bold-tlf-t1.tfm \
tex-Ysabeau-Bold-tlf-t1.vf \
tex-Ysabeau-Bold-tlf-t2a--base.tfm \
tex-Ysabeau-Bold-tlf-t2a.tfm \
tex-Ysabeau-Bold-tlf-t2a.vf \
tex-Ysabeau-Bold-tlf-t2b--base.tfm \
tex-Ysabeau-Bold-tlf-t2b.tfm \
tex-Ysabeau-Bold-tlf-t2b.vf \
tex-Ysabeau-Bold-tlf-t2c--base.tfm \
tex-Ysabeau-Bold-tlf-t2c.tfm \
tex-Ysabeau-Bold-tlf-t2c.vf \
tex-Ysabeau-Bold-tlf-t3.tfm \
tex-Ysabeau-Bold-tlf-t4--base.tfm \
tex-Ysabeau-Bold-tlf-t4.tfm \
tex-Ysabeau-Bold-tlf-t4.vf \
tex-Ysabeau-Bold-tlf-t5--base.tfm \
tex-Ysabeau-Bold-tlf-t5.tfm \
tex-Ysabeau-Bold-tlf-t5.vf \
tex-Ysabeau-Bold-tlf-ts1--base.tfm \
tex-Ysabeau-Bold-tlf-ts1.tfm \
tex-Ysabeau-Bold-tlf-ts1.vf \
tex-Ysabeau-Bold-tlf-ts3.tfm \
tex-Ysabeau-Bold-tosf-cs.tfm \
tex-Ysabeau-Bold-tosf-l7x.tfm \
tex-Ysabeau-Bold-tosf-lgr.tfm \
tex-Ysabeau-Bold-tosf-ly1.tfm \
tex-Ysabeau-Bold-tosf-ot1.tfm \
tex-Ysabeau-Bold-tosf-qx--base.tfm \
tex-Ysabeau-Bold-tosf-qx.tfm \
tex-Ysabeau-Bold-tosf-qx.vf \
tex-Ysabeau-Bold-tosf-sc-cs--base.tfm \
tex-Ysabeau-Bold-tosf-sc-cs.tfm \
tex-Ysabeau-Bold-tosf-sc-cs.vf \
tex-Ysabeau-Bold-tosf-sc-l7x--base.tfm \
tex-Ysabeau-Bold-tosf-sc-l7x.tfm \
tex-Ysabeau-Bold-tosf-sc-l7x.vf \
tex-Ysabeau-Bold-tosf-sc-lgr.tfm \
tex-Ysabeau-Bold-tosf-sc-ly1--base.tfm \
tex-Ysabeau-Bold-tosf-sc-ly1.tfm \
tex-Ysabeau-Bold-tosf-sc-ly1.vf \
tex-Ysabeau-Bold-tosf-sc-ot1--base.tfm \
tex-Ysabeau-Bold-tosf-sc-ot1.tfm \
tex-Ysabeau-Bold-tosf-sc-ot1.vf \
tex-Ysabeau-Bold-tosf-sc-qx--base.tfm \
tex-Ysabeau-Bold-tosf-sc-qx.tfm \
tex-Ysabeau-Bold-tosf-sc-qx.vf \
tex-Ysabeau-Bold-tosf-sc-t1--base.tfm \
tex-Ysabeau-Bold-tosf-sc-t1.tfm \
tex-Ysabeau-Bold-tosf-sc-t1.vf \
tex-Ysabeau-Bold-tosf-sc-t2a--base.tfm \
tex-Ysabeau-Bold-tosf-sc-t2a.tfm \
tex-Ysabeau-Bold-tosf-sc-t2a.vf \
tex-Ysabeau-Bold-tosf-sc-t2b--base.tfm \
tex-Ysabeau-Bold-tosf-sc-t2b.tfm \
tex-Ysabeau-Bold-tosf-sc-t2b.vf \
tex-Ysabeau-Bold-tosf-sc-t2c--base.tfm \
tex-Ysabeau-Bold-tosf-sc-t2c.tfm \
tex-Ysabeau-Bold-tosf-sc-t2c.vf \
tex-Ysabeau-Bold-tosf-sc-t3.tfm \
tex-Ysabeau-Bold-tosf-sc-t4--base.tfm \
tex-Ysabeau-Bold-tosf-sc-t4.tfm \
tex-Ysabeau-Bold-tosf-sc-t4.vf \
tex-Ysabeau-Bold-tosf-sc-t5--base.tfm \
tex-Ysabeau-Bold-tosf-sc-t5.tfm \
tex-Ysabeau-Bold-tosf-sc-t5.vf \
tex-Ysabeau-Bold-tosf-sc-ts3--base.tfm \
tex-Ysabeau-Bold-tosf-sc-ts3.tfm \
tex-Ysabeau-Bold-tosf-sc-ts3.vf \
tex-Ysabeau-Bold-tosf-t1--base.tfm \
tex-Ysabeau-Bold-tosf-t1.tfm \
tex-Ysabeau-Bold-tosf-t1.vf \
tex-Ysabeau-Bold-tosf-t2a--base.tfm \
tex-Ysabeau-Bold-tosf-t2a.tfm \
tex-Ysabeau-Bold-tosf-t2a.vf \
tex-Ysabeau-Bold-tosf-t2b--base.tfm \
tex-Ysabeau-Bold-tosf-t2b.tfm \
tex-Ysabeau-Bold-tosf-t2b.vf \
tex-Ysabeau-Bold-tosf-t2c--base.tfm \
tex-Ysabeau-Bold-tosf-t2c.tfm \
tex-Ysabeau-Bold-tosf-t2c.vf \
tex-Ysabeau-Bold-tosf-t3.tfm \
tex-Ysabeau-Bold-tosf-t4--base.tfm \
tex-Ysabeau-Bold-tosf-t4.tfm \
tex-Ysabeau-Bold-tosf-t4.vf \
tex-Ysabeau-Bold-tosf-t5--base.tfm \
tex-Ysabeau-Bold-tosf-t5.tfm \
tex-Ysabeau-Bold-tosf-t5.vf \
tex-Ysabeau-Bold-tosf-ts1--base.tfm \
tex-Ysabeau-Bold-tosf-ts1.tfm \
tex-Ysabeau-Bold-tosf-ts1.vf \
tex-Ysabeau-Bold-tosf-ts3.tfm \
tex-Ysabeau-BoldItalic-dnom-cs.tfm \
tex-Ysabeau-BoldItalic-dnom-l7x.tfm \
tex-Ysabeau-BoldItalic-dnom-lgr.tfm \
tex-Ysabeau-BoldItalic-dnom-ly1.tfm \
tex-Ysabeau-BoldItalic-dnom-ot1.tfm \
tex-Ysabeau-BoldItalic-dnom-qx--base.tfm \
tex-Ysabeau-BoldItalic-dnom-qx.tfm \
tex-Ysabeau-BoldItalic-dnom-qx.vf \
tex-Ysabeau-BoldItalic-dnom-t1--base.tfm \
tex-Ysabeau-BoldItalic-dnom-t1.tfm \
tex-Ysabeau-BoldItalic-dnom-t1.vf \
tex-Ysabeau-BoldItalic-dnom-t2a--base.tfm \
tex-Ysabeau-BoldItalic-dnom-t2a.tfm \
tex-Ysabeau-BoldItalic-dnom-t2a.vf \
tex-Ysabeau-BoldItalic-dnom-t2b--base.tfm \
tex-Ysabeau-BoldItalic-dnom-t2b.tfm \
tex-Ysabeau-BoldItalic-dnom-t2b.vf \
tex-Ysabeau-BoldItalic-dnom-t2c--base.tfm \
tex-Ysabeau-BoldItalic-dnom-t2c.tfm \
tex-Ysabeau-BoldItalic-dnom-t2c.vf \
tex-Ysabeau-BoldItalic-dnom-t3.tfm \
tex-Ysabeau-BoldItalic-dnom-t4--base.tfm \
tex-Ysabeau-BoldItalic-dnom-t4.tfm \
tex-Ysabeau-BoldItalic-dnom-t4.vf \
tex-Ysabeau-BoldItalic-dnom-t5--base.tfm \
tex-Ysabeau-BoldItalic-dnom-t5.tfm \
tex-Ysabeau-BoldItalic-dnom-t5.vf \
tex-Ysabeau-BoldItalic-dnom-ts3.tfm \
tex-Ysabeau-BoldItalic-inf-cs.tfm \
tex-Ysabeau-BoldItalic-inf-l7x.tfm \
tex-Ysabeau-BoldItalic-inf-lgr.tfm \
tex-Ysabeau-BoldItalic-inf-ly1.tfm \
tex-Ysabeau-BoldItalic-inf-ot1.tfm \
tex-Ysabeau-BoldItalic-inf-qx--base.tfm \
tex-Ysabeau-BoldItalic-inf-qx.tfm \
tex-Ysabeau-BoldItalic-inf-qx.vf \
tex-Ysabeau-BoldItalic-inf-t1--base.tfm \
tex-Ysabeau-BoldItalic-inf-t1.tfm \
tex-Ysabeau-BoldItalic-inf-t1.vf \
tex-Ysabeau-BoldItalic-inf-t2a--base.tfm \
tex-Ysabeau-BoldItalic-inf-t2a.tfm \
tex-Ysabeau-BoldItalic-inf-t2a.vf \
tex-Ysabeau-BoldItalic-inf-t2b--base.tfm \
tex-Ysabeau-BoldItalic-inf-t2b.tfm \
tex-Ysabeau-BoldItalic-inf-t2b.vf \
tex-Ysabeau-BoldItalic-inf-t2c--base.tfm \
tex-Ysabeau-BoldItalic-inf-t2c.tfm \
tex-Ysabeau-BoldItalic-inf-t2c.vf \
tex-Ysabeau-BoldItalic-inf-t3.tfm \
tex-Ysabeau-BoldItalic-inf-t4--base.tfm \
tex-Ysabeau-BoldItalic-inf-t4.tfm \
tex-Ysabeau-BoldItalic-inf-t4.vf \
tex-Ysabeau-BoldItalic-inf-t5--base.tfm \
tex-Ysabeau-BoldItalic-inf-t5.tfm \
tex-Ysabeau-BoldItalic-inf-t5.vf \
tex-Ysabeau-BoldItalic-inf-ts3.tfm \
tex-Ysabeau-BoldItalic-lf-cs.tfm \
tex-Ysabeau-BoldItalic-lf-l7x.tfm \
tex-Ysabeau-BoldItalic-lf-lgr.tfm \
tex-Ysabeau-BoldItalic-lf-ly1.tfm \
tex-Ysabeau-BoldItalic-lf-ot1.tfm \
tex-Ysabeau-BoldItalic-lf-qx--base.tfm \
tex-Ysabeau-BoldItalic-lf-qx.tfm \
tex-Ysabeau-BoldItalic-lf-qx.vf \
tex-Ysabeau-BoldItalic-lf-swash-cs.tfm \
tex-Ysabeau-BoldItalic-lf-swash-l7x.tfm \
tex-Ysabeau-BoldItalic-lf-swash-lgr.tfm \
tex-Ysabeau-BoldItalic-lf-swash-ly1.tfm \
tex-Ysabeau-BoldItalic-lf-swash-ot1.tfm \
tex-Ysabeau-BoldItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-BoldItalic-lf-swash-qx.tfm \
tex-Ysabeau-BoldItalic-lf-swash-qx.vf \
tex-Ysabeau-BoldItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t1.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t1.vf \
tex-Ysabeau-BoldItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t2a.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t2a.vf \
tex-Ysabeau-BoldItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t2b.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t2b.vf \
tex-Ysabeau-BoldItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t2c.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t2c.vf \
tex-Ysabeau-BoldItalic-lf-swash-t3.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t4.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t4.vf \
tex-Ysabeau-BoldItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t5.tfm \
tex-Ysabeau-BoldItalic-lf-swash-t5.vf \
tex-Ysabeau-BoldItalic-lf-swash-ts3.tfm \
tex-Ysabeau-BoldItalic-lf-t1--base.tfm \
tex-Ysabeau-BoldItalic-lf-t1.tfm \
tex-Ysabeau-BoldItalic-lf-t1.vf \
tex-Ysabeau-BoldItalic-lf-t2a--base.tfm \
tex-Ysabeau-BoldItalic-lf-t2a.tfm \
tex-Ysabeau-BoldItalic-lf-t2a.vf \
tex-Ysabeau-BoldItalic-lf-t2b--base.tfm \
tex-Ysabeau-BoldItalic-lf-t2b.tfm \
tex-Ysabeau-BoldItalic-lf-t2b.vf \
tex-Ysabeau-BoldItalic-lf-t2c--base.tfm \
tex-Ysabeau-BoldItalic-lf-t2c.tfm \
tex-Ysabeau-BoldItalic-lf-t2c.vf \
tex-Ysabeau-BoldItalic-lf-t3.tfm \
tex-Ysabeau-BoldItalic-lf-t4--base.tfm \
tex-Ysabeau-BoldItalic-lf-t4.tfm \
tex-Ysabeau-BoldItalic-lf-t4.vf \
tex-Ysabeau-BoldItalic-lf-t5--base.tfm \
tex-Ysabeau-BoldItalic-lf-t5.tfm \
tex-Ysabeau-BoldItalic-lf-t5.vf \
tex-Ysabeau-BoldItalic-lf-ts1--base.tfm \
tex-Ysabeau-BoldItalic-lf-ts1.tfm \
tex-Ysabeau-BoldItalic-lf-ts1.vf \
tex-Ysabeau-BoldItalic-lf-ts3.tfm \
tex-Ysabeau-BoldItalic-numr-cs.tfm \
tex-Ysabeau-BoldItalic-numr-l7x.tfm \
tex-Ysabeau-BoldItalic-numr-lgr.tfm \
tex-Ysabeau-BoldItalic-numr-ly1.tfm \
tex-Ysabeau-BoldItalic-numr-ot1.tfm \
tex-Ysabeau-BoldItalic-numr-qx--base.tfm \
tex-Ysabeau-BoldItalic-numr-qx.tfm \
tex-Ysabeau-BoldItalic-numr-qx.vf \
tex-Ysabeau-BoldItalic-numr-t1--base.tfm \
tex-Ysabeau-BoldItalic-numr-t1.tfm \
tex-Ysabeau-BoldItalic-numr-t1.vf \
tex-Ysabeau-BoldItalic-numr-t2a--base.tfm \
tex-Ysabeau-BoldItalic-numr-t2a.tfm \
tex-Ysabeau-BoldItalic-numr-t2a.vf \
tex-Ysabeau-BoldItalic-numr-t2b--base.tfm \
tex-Ysabeau-BoldItalic-numr-t2b.tfm \
tex-Ysabeau-BoldItalic-numr-t2b.vf \
tex-Ysabeau-BoldItalic-numr-t2c--base.tfm \
tex-Ysabeau-BoldItalic-numr-t2c.tfm \
tex-Ysabeau-BoldItalic-numr-t2c.vf \
tex-Ysabeau-BoldItalic-numr-t3.tfm \
tex-Ysabeau-BoldItalic-numr-t4--base.tfm \
tex-Ysabeau-BoldItalic-numr-t4.tfm \
tex-Ysabeau-BoldItalic-numr-t4.vf \
tex-Ysabeau-BoldItalic-numr-t5--base.tfm \
tex-Ysabeau-BoldItalic-numr-t5.tfm \
tex-Ysabeau-BoldItalic-numr-t5.vf \
tex-Ysabeau-BoldItalic-numr-ts3.tfm \
tex-Ysabeau-BoldItalic-osf-cs.tfm \
tex-Ysabeau-BoldItalic-osf-l7x.tfm \
tex-Ysabeau-BoldItalic-osf-lgr.tfm \
tex-Ysabeau-BoldItalic-osf-ly1.tfm \
tex-Ysabeau-BoldItalic-osf-ot1.tfm \
tex-Ysabeau-BoldItalic-osf-qx--base.tfm \
tex-Ysabeau-BoldItalic-osf-qx.tfm \
tex-Ysabeau-BoldItalic-osf-qx.vf \
tex-Ysabeau-BoldItalic-osf-swash-cs.tfm \
tex-Ysabeau-BoldItalic-osf-swash-l7x.tfm \
tex-Ysabeau-BoldItalic-osf-swash-lgr.tfm \
tex-Ysabeau-BoldItalic-osf-swash-ly1.tfm \
tex-Ysabeau-BoldItalic-osf-swash-ot1.tfm \
tex-Ysabeau-BoldItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-BoldItalic-osf-swash-qx.tfm \
tex-Ysabeau-BoldItalic-osf-swash-qx.vf \
tex-Ysabeau-BoldItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t1.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t1.vf \
tex-Ysabeau-BoldItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t2a.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t2a.vf \
tex-Ysabeau-BoldItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t2b.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t2b.vf \
tex-Ysabeau-BoldItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t2c.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t2c.vf \
tex-Ysabeau-BoldItalic-osf-swash-t3.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t4.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t4.vf \
tex-Ysabeau-BoldItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t5.tfm \
tex-Ysabeau-BoldItalic-osf-swash-t5.vf \
tex-Ysabeau-BoldItalic-osf-swash-ts3.tfm \
tex-Ysabeau-BoldItalic-osf-t1--base.tfm \
tex-Ysabeau-BoldItalic-osf-t1.tfm \
tex-Ysabeau-BoldItalic-osf-t1.vf \
tex-Ysabeau-BoldItalic-osf-t2a--base.tfm \
tex-Ysabeau-BoldItalic-osf-t2a.tfm \
tex-Ysabeau-BoldItalic-osf-t2a.vf \
tex-Ysabeau-BoldItalic-osf-t2b--base.tfm \
tex-Ysabeau-BoldItalic-osf-t2b.tfm \
tex-Ysabeau-BoldItalic-osf-t2b.vf \
tex-Ysabeau-BoldItalic-osf-t2c--base.tfm \
tex-Ysabeau-BoldItalic-osf-t2c.tfm \
tex-Ysabeau-BoldItalic-osf-t2c.vf \
tex-Ysabeau-BoldItalic-osf-t3.tfm \
tex-Ysabeau-BoldItalic-osf-t4--base.tfm \
tex-Ysabeau-BoldItalic-osf-t4.tfm \
tex-Ysabeau-BoldItalic-osf-t4.vf \
tex-Ysabeau-BoldItalic-osf-t5--base.tfm \
tex-Ysabeau-BoldItalic-osf-t5.tfm \
tex-Ysabeau-BoldItalic-osf-t5.vf \
tex-Ysabeau-BoldItalic-osf-ts1--base.tfm \
tex-Ysabeau-BoldItalic-osf-ts1.tfm \
tex-Ysabeau-BoldItalic-osf-ts1.vf \
tex-Ysabeau-BoldItalic-osf-ts3.tfm \
tex-Ysabeau-BoldItalic-sup-cs.tfm \
tex-Ysabeau-BoldItalic-sup-l7x.tfm \
tex-Ysabeau-BoldItalic-sup-lgr.tfm \
tex-Ysabeau-BoldItalic-sup-ly1.tfm \
tex-Ysabeau-BoldItalic-sup-ot1.tfm \
tex-Ysabeau-BoldItalic-sup-qx--base.tfm \
tex-Ysabeau-BoldItalic-sup-qx.tfm \
tex-Ysabeau-BoldItalic-sup-qx.vf \
tex-Ysabeau-BoldItalic-sup-t1--base.tfm \
tex-Ysabeau-BoldItalic-sup-t1.tfm \
tex-Ysabeau-BoldItalic-sup-t1.vf \
tex-Ysabeau-BoldItalic-sup-t2a--base.tfm \
tex-Ysabeau-BoldItalic-sup-t2a.tfm \
tex-Ysabeau-BoldItalic-sup-t2a.vf \
tex-Ysabeau-BoldItalic-sup-t2b--base.tfm \
tex-Ysabeau-BoldItalic-sup-t2b.tfm \
tex-Ysabeau-BoldItalic-sup-t2b.vf \
tex-Ysabeau-BoldItalic-sup-t2c--base.tfm \
tex-Ysabeau-BoldItalic-sup-t2c.tfm \
tex-Ysabeau-BoldItalic-sup-t2c.vf \
tex-Ysabeau-BoldItalic-sup-t3.tfm \
tex-Ysabeau-BoldItalic-sup-t4--base.tfm \
tex-Ysabeau-BoldItalic-sup-t4.tfm \
tex-Ysabeau-BoldItalic-sup-t4.vf \
tex-Ysabeau-BoldItalic-sup-t5--base.tfm \
tex-Ysabeau-BoldItalic-sup-t5.tfm \
tex-Ysabeau-BoldItalic-sup-t5.vf \
tex-Ysabeau-BoldItalic-sup-ts3.tfm \
tex-Ysabeau-BoldItalic-tlf-cs.tfm \
tex-Ysabeau-BoldItalic-tlf-l7x.tfm \
tex-Ysabeau-BoldItalic-tlf-lgr.tfm \
tex-Ysabeau-BoldItalic-tlf-ly1.tfm \
tex-Ysabeau-BoldItalic-tlf-ot1.tfm \
tex-Ysabeau-BoldItalic-tlf-qx--base.tfm \
tex-Ysabeau-BoldItalic-tlf-qx.tfm \
tex-Ysabeau-BoldItalic-tlf-qx.vf \
tex-Ysabeau-BoldItalic-tlf-swash-cs.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-qx.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-qx.vf \
tex-Ysabeau-BoldItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t1.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t1.vf \
tex-Ysabeau-BoldItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t2a.vf \
tex-Ysabeau-BoldItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t2b.vf \
tex-Ysabeau-BoldItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t2c.vf \
tex-Ysabeau-BoldItalic-tlf-swash-t3.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t4.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t4.vf \
tex-Ysabeau-BoldItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t5.tfm \
tex-Ysabeau-BoldItalic-tlf-swash-t5.vf \
tex-Ysabeau-BoldItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-BoldItalic-tlf-t1--base.tfm \
tex-Ysabeau-BoldItalic-tlf-t1.tfm \
tex-Ysabeau-BoldItalic-tlf-t1.vf \
tex-Ysabeau-BoldItalic-tlf-t2a--base.tfm \
tex-Ysabeau-BoldItalic-tlf-t2a.tfm \
tex-Ysabeau-BoldItalic-tlf-t2a.vf \
tex-Ysabeau-BoldItalic-tlf-t2b--base.tfm \
tex-Ysabeau-BoldItalic-tlf-t2b.tfm \
tex-Ysabeau-BoldItalic-tlf-t2b.vf \
tex-Ysabeau-BoldItalic-tlf-t2c--base.tfm \
tex-Ysabeau-BoldItalic-tlf-t2c.tfm \
tex-Ysabeau-BoldItalic-tlf-t2c.vf \
tex-Ysabeau-BoldItalic-tlf-t3.tfm \
tex-Ysabeau-BoldItalic-tlf-t4--base.tfm \
tex-Ysabeau-BoldItalic-tlf-t4.tfm \
tex-Ysabeau-BoldItalic-tlf-t4.vf \
tex-Ysabeau-BoldItalic-tlf-t5--base.tfm \
tex-Ysabeau-BoldItalic-tlf-t5.tfm \
tex-Ysabeau-BoldItalic-tlf-t5.vf \
tex-Ysabeau-BoldItalic-tlf-ts1--base.tfm \
tex-Ysabeau-BoldItalic-tlf-ts1.tfm \
tex-Ysabeau-BoldItalic-tlf-ts1.vf \
tex-Ysabeau-BoldItalic-tlf-ts3.tfm \
tex-Ysabeau-BoldItalic-tosf-cs.tfm \
tex-Ysabeau-BoldItalic-tosf-l7x.tfm \
tex-Ysabeau-BoldItalic-tosf-lgr.tfm \
tex-Ysabeau-BoldItalic-tosf-ly1.tfm \
tex-Ysabeau-BoldItalic-tosf-ot1.tfm \
tex-Ysabeau-BoldItalic-tosf-qx--base.tfm \
tex-Ysabeau-BoldItalic-tosf-qx.tfm \
tex-Ysabeau-BoldItalic-tosf-qx.vf \
tex-Ysabeau-BoldItalic-tosf-swash-cs.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-qx.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-qx.vf \
tex-Ysabeau-BoldItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t1.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t1.vf \
tex-Ysabeau-BoldItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t2a.vf \
tex-Ysabeau-BoldItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t2b.vf \
tex-Ysabeau-BoldItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t2c.vf \
tex-Ysabeau-BoldItalic-tosf-swash-t3.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t4.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t4.vf \
tex-Ysabeau-BoldItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t5.tfm \
tex-Ysabeau-BoldItalic-tosf-swash-t5.vf \
tex-Ysabeau-BoldItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-BoldItalic-tosf-t1--base.tfm \
tex-Ysabeau-BoldItalic-tosf-t1.tfm \
tex-Ysabeau-BoldItalic-tosf-t1.vf \
tex-Ysabeau-BoldItalic-tosf-t2a--base.tfm \
tex-Ysabeau-BoldItalic-tosf-t2a.tfm \
tex-Ysabeau-BoldItalic-tosf-t2a.vf \
tex-Ysabeau-BoldItalic-tosf-t2b--base.tfm \
tex-Ysabeau-BoldItalic-tosf-t2b.tfm \
tex-Ysabeau-BoldItalic-tosf-t2b.vf \
tex-Ysabeau-BoldItalic-tosf-t2c--base.tfm \
tex-Ysabeau-BoldItalic-tosf-t2c.tfm \
tex-Ysabeau-BoldItalic-tosf-t2c.vf \
tex-Ysabeau-BoldItalic-tosf-t3.tfm \
tex-Ysabeau-BoldItalic-tosf-t4--base.tfm \
tex-Ysabeau-BoldItalic-tosf-t4.tfm \
tex-Ysabeau-BoldItalic-tosf-t4.vf \
tex-Ysabeau-BoldItalic-tosf-t5--base.tfm \
tex-Ysabeau-BoldItalic-tosf-t5.tfm \
tex-Ysabeau-BoldItalic-tosf-t5.vf \
tex-Ysabeau-BoldItalic-tosf-ts1--base.tfm \
tex-Ysabeau-BoldItalic-tosf-ts1.tfm \
tex-Ysabeau-BoldItalic-tosf-ts1.vf \
tex-Ysabeau-BoldItalic-tosf-ts3.tfm \
tex-Ysabeau-ExtraBold-dnom-cs.tfm \
tex-Ysabeau-ExtraBold-dnom-l7x.tfm \
tex-Ysabeau-ExtraBold-dnom-lgr.tfm \
tex-Ysabeau-ExtraBold-dnom-ly1.tfm \
tex-Ysabeau-ExtraBold-dnom-ot1.tfm \
tex-Ysabeau-ExtraBold-dnom-qx--base.tfm \
tex-Ysabeau-ExtraBold-dnom-qx.tfm \
tex-Ysabeau-ExtraBold-dnom-qx.vf \
tex-Ysabeau-ExtraBold-dnom-t1--base.tfm \
tex-Ysabeau-ExtraBold-dnom-t1.tfm \
tex-Ysabeau-ExtraBold-dnom-t1.vf \
tex-Ysabeau-ExtraBold-dnom-t2a--base.tfm \
tex-Ysabeau-ExtraBold-dnom-t2a.tfm \
tex-Ysabeau-ExtraBold-dnom-t2a.vf \
tex-Ysabeau-ExtraBold-dnom-t2b--base.tfm \
tex-Ysabeau-ExtraBold-dnom-t2b.tfm \
tex-Ysabeau-ExtraBold-dnom-t2b.vf \
tex-Ysabeau-ExtraBold-dnom-t2c--base.tfm \
tex-Ysabeau-ExtraBold-dnom-t2c.tfm \
tex-Ysabeau-ExtraBold-dnom-t2c.vf \
tex-Ysabeau-ExtraBold-dnom-t3.tfm \
tex-Ysabeau-ExtraBold-dnom-t4--base.tfm \
tex-Ysabeau-ExtraBold-dnom-t4.tfm \
tex-Ysabeau-ExtraBold-dnom-t4.vf \
tex-Ysabeau-ExtraBold-dnom-t5--base.tfm \
tex-Ysabeau-ExtraBold-dnom-t5.tfm \
tex-Ysabeau-ExtraBold-dnom-t5.vf \
tex-Ysabeau-ExtraBold-dnom-ts3.tfm \
tex-Ysabeau-ExtraBold-inf-cs.tfm \
tex-Ysabeau-ExtraBold-inf-l7x.tfm \
tex-Ysabeau-ExtraBold-inf-lgr.tfm \
tex-Ysabeau-ExtraBold-inf-ly1.tfm \
tex-Ysabeau-ExtraBold-inf-ot1.tfm \
tex-Ysabeau-ExtraBold-inf-qx--base.tfm \
tex-Ysabeau-ExtraBold-inf-qx.tfm \
tex-Ysabeau-ExtraBold-inf-qx.vf \
tex-Ysabeau-ExtraBold-inf-t1--base.tfm \
tex-Ysabeau-ExtraBold-inf-t1.tfm \
tex-Ysabeau-ExtraBold-inf-t1.vf \
tex-Ysabeau-ExtraBold-inf-t2a--base.tfm \
tex-Ysabeau-ExtraBold-inf-t2a.tfm \
tex-Ysabeau-ExtraBold-inf-t2a.vf \
tex-Ysabeau-ExtraBold-inf-t2b--base.tfm \
tex-Ysabeau-ExtraBold-inf-t2b.tfm \
tex-Ysabeau-ExtraBold-inf-t2b.vf \
tex-Ysabeau-ExtraBold-inf-t2c--base.tfm \
tex-Ysabeau-ExtraBold-inf-t2c.tfm \
tex-Ysabeau-ExtraBold-inf-t2c.vf \
tex-Ysabeau-ExtraBold-inf-t3.tfm \
tex-Ysabeau-ExtraBold-inf-t4--base.tfm \
tex-Ysabeau-ExtraBold-inf-t4.tfm \
tex-Ysabeau-ExtraBold-inf-t4.vf \
tex-Ysabeau-ExtraBold-inf-t5--base.tfm \
tex-Ysabeau-ExtraBold-inf-t5.tfm \
tex-Ysabeau-ExtraBold-inf-t5.vf \
tex-Ysabeau-ExtraBold-inf-ts3.tfm \
tex-Ysabeau-ExtraBold-lf-cs.tfm \
tex-Ysabeau-ExtraBold-lf-l7x.tfm \
tex-Ysabeau-ExtraBold-lf-lgr.tfm \
tex-Ysabeau-ExtraBold-lf-ly1.tfm \
tex-Ysabeau-ExtraBold-lf-ot1.tfm \
tex-Ysabeau-ExtraBold-lf-qx--base.tfm \
tex-Ysabeau-ExtraBold-lf-qx.tfm \
tex-Ysabeau-ExtraBold-lf-qx.vf \
tex-Ysabeau-ExtraBold-lf-sc-cs--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-cs.tfm \
tex-Ysabeau-ExtraBold-lf-sc-cs.vf \
tex-Ysabeau-ExtraBold-lf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-l7x.tfm \
tex-Ysabeau-ExtraBold-lf-sc-l7x.vf \
tex-Ysabeau-ExtraBold-lf-sc-lgr.tfm \
tex-Ysabeau-ExtraBold-lf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-ly1.tfm \
tex-Ysabeau-ExtraBold-lf-sc-ly1.vf \
tex-Ysabeau-ExtraBold-lf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-ot1.tfm \
tex-Ysabeau-ExtraBold-lf-sc-ot1.vf \
tex-Ysabeau-ExtraBold-lf-sc-qx--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-qx.tfm \
tex-Ysabeau-ExtraBold-lf-sc-qx.vf \
tex-Ysabeau-ExtraBold-lf-sc-t1--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t1.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t1.vf \
tex-Ysabeau-ExtraBold-lf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t2a.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t2a.vf \
tex-Ysabeau-ExtraBold-lf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t2b.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t2b.vf \
tex-Ysabeau-ExtraBold-lf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t2c.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t2c.vf \
tex-Ysabeau-ExtraBold-lf-sc-t3.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t4--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t4.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t4.vf \
tex-Ysabeau-ExtraBold-lf-sc-t5--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t5.tfm \
tex-Ysabeau-ExtraBold-lf-sc-t5.vf \
tex-Ysabeau-ExtraBold-lf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraBold-lf-sc-ts3.tfm \
tex-Ysabeau-ExtraBold-lf-sc-ts3.vf \
tex-Ysabeau-ExtraBold-lf-t1--base.tfm \
tex-Ysabeau-ExtraBold-lf-t1.tfm \
tex-Ysabeau-ExtraBold-lf-t1.vf \
tex-Ysabeau-ExtraBold-lf-t2a--base.tfm \
tex-Ysabeau-ExtraBold-lf-t2a.tfm \
tex-Ysabeau-ExtraBold-lf-t2a.vf \
tex-Ysabeau-ExtraBold-lf-t2b--base.tfm \
tex-Ysabeau-ExtraBold-lf-t2b.tfm \
tex-Ysabeau-ExtraBold-lf-t2b.vf \
tex-Ysabeau-ExtraBold-lf-t2c--base.tfm \
tex-Ysabeau-ExtraBold-lf-t2c.tfm \
tex-Ysabeau-ExtraBold-lf-t2c.vf \
tex-Ysabeau-ExtraBold-lf-t3.tfm \
tex-Ysabeau-ExtraBold-lf-t4--base.tfm \
tex-Ysabeau-ExtraBold-lf-t4.tfm \
tex-Ysabeau-ExtraBold-lf-t4.vf \
tex-Ysabeau-ExtraBold-lf-t5--base.tfm \
tex-Ysabeau-ExtraBold-lf-t5.tfm \
tex-Ysabeau-ExtraBold-lf-t5.vf \
tex-Ysabeau-ExtraBold-lf-ts1--base.tfm \
tex-Ysabeau-ExtraBold-lf-ts1.tfm \
tex-Ysabeau-ExtraBold-lf-ts1.vf \
tex-Ysabeau-ExtraBold-lf-ts3.tfm \
tex-Ysabeau-ExtraBold-numr-cs.tfm \
tex-Ysabeau-ExtraBold-numr-l7x.tfm \
tex-Ysabeau-ExtraBold-numr-lgr.tfm \
tex-Ysabeau-ExtraBold-numr-ly1.tfm \
tex-Ysabeau-ExtraBold-numr-ot1.tfm \
tex-Ysabeau-ExtraBold-numr-qx--base.tfm \
tex-Ysabeau-ExtraBold-numr-qx.tfm \
tex-Ysabeau-ExtraBold-numr-qx.vf \
tex-Ysabeau-ExtraBold-numr-t1--base.tfm \
tex-Ysabeau-ExtraBold-numr-t1.tfm \
tex-Ysabeau-ExtraBold-numr-t1.vf \
tex-Ysabeau-ExtraBold-numr-t2a--base.tfm \
tex-Ysabeau-ExtraBold-numr-t2a.tfm \
tex-Ysabeau-ExtraBold-numr-t2a.vf \
tex-Ysabeau-ExtraBold-numr-t2b--base.tfm \
tex-Ysabeau-ExtraBold-numr-t2b.tfm \
tex-Ysabeau-ExtraBold-numr-t2b.vf \
tex-Ysabeau-ExtraBold-numr-t2c--base.tfm \
tex-Ysabeau-ExtraBold-numr-t2c.tfm \
tex-Ysabeau-ExtraBold-numr-t2c.vf \
tex-Ysabeau-ExtraBold-numr-t3.tfm \
tex-Ysabeau-ExtraBold-numr-t4--base.tfm \
tex-Ysabeau-ExtraBold-numr-t4.tfm \
tex-Ysabeau-ExtraBold-numr-t4.vf \
tex-Ysabeau-ExtraBold-numr-t5--base.tfm \
tex-Ysabeau-ExtraBold-numr-t5.tfm \
tex-Ysabeau-ExtraBold-numr-t5.vf \
tex-Ysabeau-ExtraBold-numr-ts3.tfm \
tex-Ysabeau-ExtraBold-osf-cs.tfm \
tex-Ysabeau-ExtraBold-osf-l7x.tfm \
tex-Ysabeau-ExtraBold-osf-lgr.tfm \
tex-Ysabeau-ExtraBold-osf-ly1.tfm \
tex-Ysabeau-ExtraBold-osf-ot1.tfm \
tex-Ysabeau-ExtraBold-osf-qx--base.tfm \
tex-Ysabeau-ExtraBold-osf-qx.tfm \
tex-Ysabeau-ExtraBold-osf-qx.vf \
tex-Ysabeau-ExtraBold-osf-sc-cs--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-cs.tfm \
tex-Ysabeau-ExtraBold-osf-sc-cs.vf \
tex-Ysabeau-ExtraBold-osf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-l7x.tfm \
tex-Ysabeau-ExtraBold-osf-sc-l7x.vf \
tex-Ysabeau-ExtraBold-osf-sc-lgr.tfm \
tex-Ysabeau-ExtraBold-osf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-ly1.tfm \
tex-Ysabeau-ExtraBold-osf-sc-ly1.vf \
tex-Ysabeau-ExtraBold-osf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-ot1.tfm \
tex-Ysabeau-ExtraBold-osf-sc-ot1.vf \
tex-Ysabeau-ExtraBold-osf-sc-qx--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-qx.tfm \
tex-Ysabeau-ExtraBold-osf-sc-qx.vf \
tex-Ysabeau-ExtraBold-osf-sc-t1--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t1.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t1.vf \
tex-Ysabeau-ExtraBold-osf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t2a.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t2a.vf \
tex-Ysabeau-ExtraBold-osf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t2b.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t2b.vf \
tex-Ysabeau-ExtraBold-osf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t2c.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t2c.vf \
tex-Ysabeau-ExtraBold-osf-sc-t3.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t4--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t4.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t4.vf \
tex-Ysabeau-ExtraBold-osf-sc-t5--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t5.tfm \
tex-Ysabeau-ExtraBold-osf-sc-t5.vf \
tex-Ysabeau-ExtraBold-osf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraBold-osf-sc-ts3.tfm \
tex-Ysabeau-ExtraBold-osf-sc-ts3.vf \
tex-Ysabeau-ExtraBold-osf-t1--base.tfm \
tex-Ysabeau-ExtraBold-osf-t1.tfm \
tex-Ysabeau-ExtraBold-osf-t1.vf \
tex-Ysabeau-ExtraBold-osf-t2a--base.tfm \
tex-Ysabeau-ExtraBold-osf-t2a.tfm \
tex-Ysabeau-ExtraBold-osf-t2a.vf \
tex-Ysabeau-ExtraBold-osf-t2b--base.tfm \
tex-Ysabeau-ExtraBold-osf-t2b.tfm \
tex-Ysabeau-ExtraBold-osf-t2b.vf \
tex-Ysabeau-ExtraBold-osf-t2c--base.tfm \
tex-Ysabeau-ExtraBold-osf-t2c.tfm \
tex-Ysabeau-ExtraBold-osf-t2c.vf \
tex-Ysabeau-ExtraBold-osf-t3.tfm \
tex-Ysabeau-ExtraBold-osf-t4--base.tfm \
tex-Ysabeau-ExtraBold-osf-t4.tfm \
tex-Ysabeau-ExtraBold-osf-t4.vf \
tex-Ysabeau-ExtraBold-osf-t5--base.tfm \
tex-Ysabeau-ExtraBold-osf-t5.tfm \
tex-Ysabeau-ExtraBold-osf-t5.vf \
tex-Ysabeau-ExtraBold-osf-ts1--base.tfm \
tex-Ysabeau-ExtraBold-osf-ts1.tfm \
tex-Ysabeau-ExtraBold-osf-ts1.vf \
tex-Ysabeau-ExtraBold-osf-ts3.tfm \
tex-Ysabeau-ExtraBold-sup-cs.tfm \
tex-Ysabeau-ExtraBold-sup-l7x.tfm \
tex-Ysabeau-ExtraBold-sup-lgr.tfm \
tex-Ysabeau-ExtraBold-sup-ly1.tfm \
tex-Ysabeau-ExtraBold-sup-ot1.tfm \
tex-Ysabeau-ExtraBold-sup-qx--base.tfm \
tex-Ysabeau-ExtraBold-sup-qx.tfm \
tex-Ysabeau-ExtraBold-sup-qx.vf \
tex-Ysabeau-ExtraBold-sup-t1--base.tfm \
tex-Ysabeau-ExtraBold-sup-t1.tfm \
tex-Ysabeau-ExtraBold-sup-t1.vf \
tex-Ysabeau-ExtraBold-sup-t2a--base.tfm \
tex-Ysabeau-ExtraBold-sup-t2a.tfm \
tex-Ysabeau-ExtraBold-sup-t2a.vf \
tex-Ysabeau-ExtraBold-sup-t2b--base.tfm \
tex-Ysabeau-ExtraBold-sup-t2b.tfm \
tex-Ysabeau-ExtraBold-sup-t2b.vf \
tex-Ysabeau-ExtraBold-sup-t2c--base.tfm \
tex-Ysabeau-ExtraBold-sup-t2c.tfm \
tex-Ysabeau-ExtraBold-sup-t2c.vf \
tex-Ysabeau-ExtraBold-sup-t3.tfm \
tex-Ysabeau-ExtraBold-sup-t4--base.tfm \
tex-Ysabeau-ExtraBold-sup-t4.tfm \
tex-Ysabeau-ExtraBold-sup-t4.vf \
tex-Ysabeau-ExtraBold-sup-t5--base.tfm \
tex-Ysabeau-ExtraBold-sup-t5.tfm \
tex-Ysabeau-ExtraBold-sup-t5.vf \
tex-Ysabeau-ExtraBold-sup-ts3.tfm \
tex-Ysabeau-ExtraBold-tlf-cs.tfm \
tex-Ysabeau-ExtraBold-tlf-l7x.tfm \
tex-Ysabeau-ExtraBold-tlf-lgr.tfm \
tex-Ysabeau-ExtraBold-tlf-ly1.tfm \
tex-Ysabeau-ExtraBold-tlf-ot1.tfm \
tex-Ysabeau-ExtraBold-tlf-qx--base.tfm \
tex-Ysabeau-ExtraBold-tlf-qx.tfm \
tex-Ysabeau-ExtraBold-tlf-qx.vf \
tex-Ysabeau-ExtraBold-tlf-sc-cs--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-cs.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-cs.vf \
tex-Ysabeau-ExtraBold-tlf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-l7x.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-l7x.vf \
tex-Ysabeau-ExtraBold-tlf-sc-lgr.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-ly1.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-ly1.vf \
tex-Ysabeau-ExtraBold-tlf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-ot1.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-ot1.vf \
tex-Ysabeau-ExtraBold-tlf-sc-qx--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-qx.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-qx.vf \
tex-Ysabeau-ExtraBold-tlf-sc-t1--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t1.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t1.vf \
tex-Ysabeau-ExtraBold-tlf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t2a.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t2a.vf \
tex-Ysabeau-ExtraBold-tlf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t2b.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t2b.vf \
tex-Ysabeau-ExtraBold-tlf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t2c.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t2c.vf \
tex-Ysabeau-ExtraBold-tlf-sc-t3.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t4--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t4.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t4.vf \
tex-Ysabeau-ExtraBold-tlf-sc-t5--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t5.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-t5.vf \
tex-Ysabeau-ExtraBold-tlf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-ts3.tfm \
tex-Ysabeau-ExtraBold-tlf-sc-ts3.vf \
tex-Ysabeau-ExtraBold-tlf-t1--base.tfm \
tex-Ysabeau-ExtraBold-tlf-t1.tfm \
tex-Ysabeau-ExtraBold-tlf-t1.vf \
tex-Ysabeau-ExtraBold-tlf-t2a--base.tfm \
tex-Ysabeau-ExtraBold-tlf-t2a.tfm \
tex-Ysabeau-ExtraBold-tlf-t2a.vf \
tex-Ysabeau-ExtraBold-tlf-t2b--base.tfm \
tex-Ysabeau-ExtraBold-tlf-t2b.tfm \
tex-Ysabeau-ExtraBold-tlf-t2b.vf \
tex-Ysabeau-ExtraBold-tlf-t2c--base.tfm \
tex-Ysabeau-ExtraBold-tlf-t2c.tfm \
tex-Ysabeau-ExtraBold-tlf-t2c.vf \
tex-Ysabeau-ExtraBold-tlf-t3.tfm \
tex-Ysabeau-ExtraBold-tlf-t4--base.tfm \
tex-Ysabeau-ExtraBold-tlf-t4.tfm \
tex-Ysabeau-ExtraBold-tlf-t4.vf \
tex-Ysabeau-ExtraBold-tlf-t5--base.tfm \
tex-Ysabeau-ExtraBold-tlf-t5.tfm \
tex-Ysabeau-ExtraBold-tlf-t5.vf \
tex-Ysabeau-ExtraBold-tlf-ts1--base.tfm \
tex-Ysabeau-ExtraBold-tlf-ts1.tfm \
tex-Ysabeau-ExtraBold-tlf-ts1.vf \
tex-Ysabeau-ExtraBold-tlf-ts3.tfm \
tex-Ysabeau-ExtraBold-tosf-cs.tfm \
tex-Ysabeau-ExtraBold-tosf-l7x.tfm \
tex-Ysabeau-ExtraBold-tosf-lgr.tfm \
tex-Ysabeau-ExtraBold-tosf-ly1.tfm \
tex-Ysabeau-ExtraBold-tosf-ot1.tfm \
tex-Ysabeau-ExtraBold-tosf-qx--base.tfm \
tex-Ysabeau-ExtraBold-tosf-qx.tfm \
tex-Ysabeau-ExtraBold-tosf-qx.vf \
tex-Ysabeau-ExtraBold-tosf-sc-cs--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-cs.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-cs.vf \
tex-Ysabeau-ExtraBold-tosf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-l7x.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-l7x.vf \
tex-Ysabeau-ExtraBold-tosf-sc-lgr.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-ly1.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-ly1.vf \
tex-Ysabeau-ExtraBold-tosf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-ot1.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-ot1.vf \
tex-Ysabeau-ExtraBold-tosf-sc-qx--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-qx.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-qx.vf \
tex-Ysabeau-ExtraBold-tosf-sc-t1--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t1.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t1.vf \
tex-Ysabeau-ExtraBold-tosf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t2a.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t2a.vf \
tex-Ysabeau-ExtraBold-tosf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t2b.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t2b.vf \
tex-Ysabeau-ExtraBold-tosf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t2c.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t2c.vf \
tex-Ysabeau-ExtraBold-tosf-sc-t3.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t4--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t4.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t4.vf \
tex-Ysabeau-ExtraBold-tosf-sc-t5--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t5.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-t5.vf \
tex-Ysabeau-ExtraBold-tosf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-ts3.tfm \
tex-Ysabeau-ExtraBold-tosf-sc-ts3.vf \
tex-Ysabeau-ExtraBold-tosf-t1--base.tfm \
tex-Ysabeau-ExtraBold-tosf-t1.tfm \
tex-Ysabeau-ExtraBold-tosf-t1.vf \
tex-Ysabeau-ExtraBold-tosf-t2a--base.tfm \
tex-Ysabeau-ExtraBold-tosf-t2a.tfm \
tex-Ysabeau-ExtraBold-tosf-t2a.vf \
tex-Ysabeau-ExtraBold-tosf-t2b--base.tfm \
tex-Ysabeau-ExtraBold-tosf-t2b.tfm \
tex-Ysabeau-ExtraBold-tosf-t2b.vf \
tex-Ysabeau-ExtraBold-tosf-t2c--base.tfm \
tex-Ysabeau-ExtraBold-tosf-t2c.tfm \
tex-Ysabeau-ExtraBold-tosf-t2c.vf \
tex-Ysabeau-ExtraBold-tosf-t3.tfm \
tex-Ysabeau-ExtraBold-tosf-t4--base.tfm \
tex-Ysabeau-ExtraBold-tosf-t4.tfm \
tex-Ysabeau-ExtraBold-tosf-t4.vf \
tex-Ysabeau-ExtraBold-tosf-t5--base.tfm \
tex-Ysabeau-ExtraBold-tosf-t5.tfm \
tex-Ysabeau-ExtraBold-tosf-t5.vf \
tex-Ysabeau-ExtraBold-tosf-ts1--base.tfm \
tex-Ysabeau-ExtraBold-tosf-ts1.tfm \
tex-Ysabeau-ExtraBold-tosf-ts1.vf \
tex-Ysabeau-ExtraBold-tosf-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-qx.vf \
tex-Ysabeau-ExtraBoldItalic-dnom-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t1.vf \
tex-Ysabeau-ExtraBoldItalic-dnom-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-dnom-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-dnom-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-dnom-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t4.vf \
tex-Ysabeau-ExtraBoldItalic-dnom-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-dnom-t5.vf \
tex-Ysabeau-ExtraBoldItalic-dnom-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-qx.vf \
tex-Ysabeau-ExtraBoldItalic-inf-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t1.vf \
tex-Ysabeau-ExtraBoldItalic-inf-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-inf-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-inf-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-inf-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t4.vf \
tex-Ysabeau-ExtraBoldItalic-inf-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-inf-t5.vf \
tex-Ysabeau-ExtraBoldItalic-inf-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-qx.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-qx.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t1.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t4.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-swash-t5.vf \
tex-Ysabeau-ExtraBoldItalic-lf-swash-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t1.vf \
tex-Ysabeau-ExtraBoldItalic-lf-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-lf-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-lf-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-lf-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t4.vf \
tex-Ysabeau-ExtraBoldItalic-lf-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-t5.vf \
tex-Ysabeau-ExtraBoldItalic-lf-ts1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-ts1.tfm \
tex-Ysabeau-ExtraBoldItalic-lf-ts1.vf \
tex-Ysabeau-ExtraBoldItalic-lf-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-qx.vf \
tex-Ysabeau-ExtraBoldItalic-numr-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t1.vf \
tex-Ysabeau-ExtraBoldItalic-numr-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-numr-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-numr-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-numr-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t4.vf \
tex-Ysabeau-ExtraBoldItalic-numr-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-numr-t5.vf \
tex-Ysabeau-ExtraBoldItalic-numr-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-qx.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-qx.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t1.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t4.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-swash-t5.vf \
tex-Ysabeau-ExtraBoldItalic-osf-swash-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t1.vf \
tex-Ysabeau-ExtraBoldItalic-osf-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-osf-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-osf-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-osf-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t4.vf \
tex-Ysabeau-ExtraBoldItalic-osf-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-t5.vf \
tex-Ysabeau-ExtraBoldItalic-osf-ts1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-ts1.tfm \
tex-Ysabeau-ExtraBoldItalic-osf-ts1.vf \
tex-Ysabeau-ExtraBoldItalic-osf-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-qx.vf \
tex-Ysabeau-ExtraBoldItalic-sup-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t1.vf \
tex-Ysabeau-ExtraBoldItalic-sup-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-sup-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-sup-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-sup-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t4.vf \
tex-Ysabeau-ExtraBoldItalic-sup-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-sup-t5.vf \
tex-Ysabeau-ExtraBoldItalic-sup-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-qx.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-qx.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t1.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t4.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-t5.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t1.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t4.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-t5.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-ts1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-ts1.tfm \
tex-Ysabeau-ExtraBoldItalic-tlf-ts1.vf \
tex-Ysabeau-ExtraBoldItalic-tlf-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-qx.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-cs.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-qx.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-qx.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t1.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t4.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-t5.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t1.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t1.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-t2a--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t2a.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t2a.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-t2b--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t2b.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t2b.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-t2c--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t2c.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t2c.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-t3.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t4--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t4.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t4.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-t5--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t5.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-t5.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-ts1--base.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-ts1.tfm \
tex-Ysabeau-ExtraBoldItalic-tosf-ts1.vf \
tex-Ysabeau-ExtraBoldItalic-tosf-ts3.tfm \
tex-Ysabeau-ExtraLight-dnom-cs.tfm \
tex-Ysabeau-ExtraLight-dnom-l7x.tfm \
tex-Ysabeau-ExtraLight-dnom-lgr.tfm \
tex-Ysabeau-ExtraLight-dnom-ly1.tfm \
tex-Ysabeau-ExtraLight-dnom-ot1.tfm \
tex-Ysabeau-ExtraLight-dnom-qx--base.tfm \
tex-Ysabeau-ExtraLight-dnom-qx.tfm \
tex-Ysabeau-ExtraLight-dnom-qx.vf \
tex-Ysabeau-ExtraLight-dnom-t1--base.tfm \
tex-Ysabeau-ExtraLight-dnom-t1.tfm \
tex-Ysabeau-ExtraLight-dnom-t1.vf \
tex-Ysabeau-ExtraLight-dnom-t2a--base.tfm \
tex-Ysabeau-ExtraLight-dnom-t2a.tfm \
tex-Ysabeau-ExtraLight-dnom-t2a.vf \
tex-Ysabeau-ExtraLight-dnom-t2b--base.tfm \
tex-Ysabeau-ExtraLight-dnom-t2b.tfm \
tex-Ysabeau-ExtraLight-dnom-t2b.vf \
tex-Ysabeau-ExtraLight-dnom-t2c--base.tfm \
tex-Ysabeau-ExtraLight-dnom-t2c.tfm \
tex-Ysabeau-ExtraLight-dnom-t2c.vf \
tex-Ysabeau-ExtraLight-dnom-t3.tfm \
tex-Ysabeau-ExtraLight-dnom-t4--base.tfm \
tex-Ysabeau-ExtraLight-dnom-t4.tfm \
tex-Ysabeau-ExtraLight-dnom-t4.vf \
tex-Ysabeau-ExtraLight-dnom-t5--base.tfm \
tex-Ysabeau-ExtraLight-dnom-t5.tfm \
tex-Ysabeau-ExtraLight-dnom-t5.vf \
tex-Ysabeau-ExtraLight-dnom-ts3.tfm \
tex-Ysabeau-ExtraLight-inf-cs.tfm \
tex-Ysabeau-ExtraLight-inf-l7x.tfm \
tex-Ysabeau-ExtraLight-inf-lgr.tfm \
tex-Ysabeau-ExtraLight-inf-ly1.tfm \
tex-Ysabeau-ExtraLight-inf-ot1.tfm \
tex-Ysabeau-ExtraLight-inf-qx--base.tfm \
tex-Ysabeau-ExtraLight-inf-qx.tfm \
tex-Ysabeau-ExtraLight-inf-qx.vf \
tex-Ysabeau-ExtraLight-inf-t1--base.tfm \
tex-Ysabeau-ExtraLight-inf-t1.tfm \
tex-Ysabeau-ExtraLight-inf-t1.vf \
tex-Ysabeau-ExtraLight-inf-t2a--base.tfm \
tex-Ysabeau-ExtraLight-inf-t2a.tfm \
tex-Ysabeau-ExtraLight-inf-t2a.vf \
tex-Ysabeau-ExtraLight-inf-t2b--base.tfm \
tex-Ysabeau-ExtraLight-inf-t2b.tfm \
tex-Ysabeau-ExtraLight-inf-t2b.vf \
tex-Ysabeau-ExtraLight-inf-t2c--base.tfm \
tex-Ysabeau-ExtraLight-inf-t2c.tfm \
tex-Ysabeau-ExtraLight-inf-t2c.vf \
tex-Ysabeau-ExtraLight-inf-t3.tfm \
tex-Ysabeau-ExtraLight-inf-t4--base.tfm \
tex-Ysabeau-ExtraLight-inf-t4.tfm \
tex-Ysabeau-ExtraLight-inf-t4.vf \
tex-Ysabeau-ExtraLight-inf-t5--base.tfm \
tex-Ysabeau-ExtraLight-inf-t5.tfm \
tex-Ysabeau-ExtraLight-inf-t5.vf \
tex-Ysabeau-ExtraLight-inf-ts3.tfm \
tex-Ysabeau-ExtraLight-lf-cs.tfm \
tex-Ysabeau-ExtraLight-lf-l7x.tfm \
tex-Ysabeau-ExtraLight-lf-lgr.tfm \
tex-Ysabeau-ExtraLight-lf-ly1.tfm \
tex-Ysabeau-ExtraLight-lf-ot1.tfm \
tex-Ysabeau-ExtraLight-lf-qx--base.tfm \
tex-Ysabeau-ExtraLight-lf-qx.tfm \
tex-Ysabeau-ExtraLight-lf-qx.vf \
tex-Ysabeau-ExtraLight-lf-sc-cs--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-cs.tfm \
tex-Ysabeau-ExtraLight-lf-sc-cs.vf \
tex-Ysabeau-ExtraLight-lf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-l7x.tfm \
tex-Ysabeau-ExtraLight-lf-sc-l7x.vf \
tex-Ysabeau-ExtraLight-lf-sc-lgr.tfm \
tex-Ysabeau-ExtraLight-lf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-ly1.tfm \
tex-Ysabeau-ExtraLight-lf-sc-ly1.vf \
tex-Ysabeau-ExtraLight-lf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-ot1.tfm \
tex-Ysabeau-ExtraLight-lf-sc-ot1.vf \
tex-Ysabeau-ExtraLight-lf-sc-qx--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-qx.tfm \
tex-Ysabeau-ExtraLight-lf-sc-qx.vf \
tex-Ysabeau-ExtraLight-lf-sc-t1--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t1.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t1.vf \
tex-Ysabeau-ExtraLight-lf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t2a.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t2a.vf \
tex-Ysabeau-ExtraLight-lf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t2b.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t2b.vf \
tex-Ysabeau-ExtraLight-lf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t2c.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t2c.vf \
tex-Ysabeau-ExtraLight-lf-sc-t3.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t4--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t4.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t4.vf \
tex-Ysabeau-ExtraLight-lf-sc-t5--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t5.tfm \
tex-Ysabeau-ExtraLight-lf-sc-t5.vf \
tex-Ysabeau-ExtraLight-lf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraLight-lf-sc-ts3.tfm \
tex-Ysabeau-ExtraLight-lf-sc-ts3.vf \
tex-Ysabeau-ExtraLight-lf-t1--base.tfm \
tex-Ysabeau-ExtraLight-lf-t1.tfm \
tex-Ysabeau-ExtraLight-lf-t1.vf \
tex-Ysabeau-ExtraLight-lf-t2a--base.tfm \
tex-Ysabeau-ExtraLight-lf-t2a.tfm \
tex-Ysabeau-ExtraLight-lf-t2a.vf \
tex-Ysabeau-ExtraLight-lf-t2b--base.tfm \
tex-Ysabeau-ExtraLight-lf-t2b.tfm \
tex-Ysabeau-ExtraLight-lf-t2b.vf \
tex-Ysabeau-ExtraLight-lf-t2c--base.tfm \
tex-Ysabeau-ExtraLight-lf-t2c.tfm \
tex-Ysabeau-ExtraLight-lf-t2c.vf \
tex-Ysabeau-ExtraLight-lf-t3.tfm \
tex-Ysabeau-ExtraLight-lf-t4--base.tfm \
tex-Ysabeau-ExtraLight-lf-t4.tfm \
tex-Ysabeau-ExtraLight-lf-t4.vf \
tex-Ysabeau-ExtraLight-lf-t5--base.tfm \
tex-Ysabeau-ExtraLight-lf-t5.tfm \
tex-Ysabeau-ExtraLight-lf-t5.vf \
tex-Ysabeau-ExtraLight-lf-ts1--base.tfm \
tex-Ysabeau-ExtraLight-lf-ts1.tfm \
tex-Ysabeau-ExtraLight-lf-ts1.vf \
tex-Ysabeau-ExtraLight-lf-ts3.tfm \
tex-Ysabeau-ExtraLight-numr-cs.tfm \
tex-Ysabeau-ExtraLight-numr-l7x.tfm \
tex-Ysabeau-ExtraLight-numr-lgr.tfm \
tex-Ysabeau-ExtraLight-numr-ly1.tfm \
tex-Ysabeau-ExtraLight-numr-ot1.tfm \
tex-Ysabeau-ExtraLight-numr-qx--base.tfm \
tex-Ysabeau-ExtraLight-numr-qx.tfm \
tex-Ysabeau-ExtraLight-numr-qx.vf \
tex-Ysabeau-ExtraLight-numr-t1--base.tfm \
tex-Ysabeau-ExtraLight-numr-t1.tfm \
tex-Ysabeau-ExtraLight-numr-t1.vf \
tex-Ysabeau-ExtraLight-numr-t2a--base.tfm \
tex-Ysabeau-ExtraLight-numr-t2a.tfm \
tex-Ysabeau-ExtraLight-numr-t2a.vf \
tex-Ysabeau-ExtraLight-numr-t2b--base.tfm \
tex-Ysabeau-ExtraLight-numr-t2b.tfm \
tex-Ysabeau-ExtraLight-numr-t2b.vf \
tex-Ysabeau-ExtraLight-numr-t2c--base.tfm \
tex-Ysabeau-ExtraLight-numr-t2c.tfm \
tex-Ysabeau-ExtraLight-numr-t2c.vf \
tex-Ysabeau-ExtraLight-numr-t3.tfm \
tex-Ysabeau-ExtraLight-numr-t4--base.tfm \
tex-Ysabeau-ExtraLight-numr-t4.tfm \
tex-Ysabeau-ExtraLight-numr-t4.vf \
tex-Ysabeau-ExtraLight-numr-t5--base.tfm \
tex-Ysabeau-ExtraLight-numr-t5.tfm \
tex-Ysabeau-ExtraLight-numr-t5.vf \
tex-Ysabeau-ExtraLight-numr-ts3.tfm \
tex-Ysabeau-ExtraLight-osf-cs.tfm \
tex-Ysabeau-ExtraLight-osf-l7x.tfm \
tex-Ysabeau-ExtraLight-osf-lgr.tfm \
tex-Ysabeau-ExtraLight-osf-ly1.tfm \
tex-Ysabeau-ExtraLight-osf-ot1.tfm \
tex-Ysabeau-ExtraLight-osf-qx--base.tfm \
tex-Ysabeau-ExtraLight-osf-qx.tfm \
tex-Ysabeau-ExtraLight-osf-qx.vf \
tex-Ysabeau-ExtraLight-osf-sc-cs--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-cs.tfm \
tex-Ysabeau-ExtraLight-osf-sc-cs.vf \
tex-Ysabeau-ExtraLight-osf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-l7x.tfm \
tex-Ysabeau-ExtraLight-osf-sc-l7x.vf \
tex-Ysabeau-ExtraLight-osf-sc-lgr.tfm \
tex-Ysabeau-ExtraLight-osf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-ly1.tfm \
tex-Ysabeau-ExtraLight-osf-sc-ly1.vf \
tex-Ysabeau-ExtraLight-osf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-ot1.tfm \
tex-Ysabeau-ExtraLight-osf-sc-ot1.vf \
tex-Ysabeau-ExtraLight-osf-sc-qx--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-qx.tfm \
tex-Ysabeau-ExtraLight-osf-sc-qx.vf \
tex-Ysabeau-ExtraLight-osf-sc-t1--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t1.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t1.vf \
tex-Ysabeau-ExtraLight-osf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t2a.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t2a.vf \
tex-Ysabeau-ExtraLight-osf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t2b.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t2b.vf \
tex-Ysabeau-ExtraLight-osf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t2c.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t2c.vf \
tex-Ysabeau-ExtraLight-osf-sc-t3.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t4--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t4.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t4.vf \
tex-Ysabeau-ExtraLight-osf-sc-t5--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t5.tfm \
tex-Ysabeau-ExtraLight-osf-sc-t5.vf \
tex-Ysabeau-ExtraLight-osf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraLight-osf-sc-ts3.tfm \
tex-Ysabeau-ExtraLight-osf-sc-ts3.vf \
tex-Ysabeau-ExtraLight-osf-t1--base.tfm \
tex-Ysabeau-ExtraLight-osf-t1.tfm \
tex-Ysabeau-ExtraLight-osf-t1.vf \
tex-Ysabeau-ExtraLight-osf-t2a--base.tfm \
tex-Ysabeau-ExtraLight-osf-t2a.tfm \
tex-Ysabeau-ExtraLight-osf-t2a.vf \
tex-Ysabeau-ExtraLight-osf-t2b--base.tfm \
tex-Ysabeau-ExtraLight-osf-t2b.tfm \
tex-Ysabeau-ExtraLight-osf-t2b.vf \
tex-Ysabeau-ExtraLight-osf-t2c--base.tfm \
tex-Ysabeau-ExtraLight-osf-t2c.tfm \
tex-Ysabeau-ExtraLight-osf-t2c.vf \
tex-Ysabeau-ExtraLight-osf-t3.tfm \
tex-Ysabeau-ExtraLight-osf-t4--base.tfm \
tex-Ysabeau-ExtraLight-osf-t4.tfm \
tex-Ysabeau-ExtraLight-osf-t4.vf \
tex-Ysabeau-ExtraLight-osf-t5--base.tfm \
tex-Ysabeau-ExtraLight-osf-t5.tfm \
tex-Ysabeau-ExtraLight-osf-t5.vf \
tex-Ysabeau-ExtraLight-osf-ts1--base.tfm \
tex-Ysabeau-ExtraLight-osf-ts1.tfm \
tex-Ysabeau-ExtraLight-osf-ts1.vf \
tex-Ysabeau-ExtraLight-osf-ts3.tfm \
tex-Ysabeau-ExtraLight-sup-cs.tfm \
tex-Ysabeau-ExtraLight-sup-l7x.tfm \
tex-Ysabeau-ExtraLight-sup-lgr.tfm \
tex-Ysabeau-ExtraLight-sup-ly1.tfm \
tex-Ysabeau-ExtraLight-sup-ot1.tfm \
tex-Ysabeau-ExtraLight-sup-qx--base.tfm \
tex-Ysabeau-ExtraLight-sup-qx.tfm \
tex-Ysabeau-ExtraLight-sup-qx.vf \
tex-Ysabeau-ExtraLight-sup-t1--base.tfm \
tex-Ysabeau-ExtraLight-sup-t1.tfm \
tex-Ysabeau-ExtraLight-sup-t1.vf \
tex-Ysabeau-ExtraLight-sup-t2a--base.tfm \
tex-Ysabeau-ExtraLight-sup-t2a.tfm \
tex-Ysabeau-ExtraLight-sup-t2a.vf \
tex-Ysabeau-ExtraLight-sup-t2b--base.tfm \
tex-Ysabeau-ExtraLight-sup-t2b.tfm \
tex-Ysabeau-ExtraLight-sup-t2b.vf \
tex-Ysabeau-ExtraLight-sup-t2c--base.tfm \
tex-Ysabeau-ExtraLight-sup-t2c.tfm \
tex-Ysabeau-ExtraLight-sup-t2c.vf \
tex-Ysabeau-ExtraLight-sup-t3.tfm \
tex-Ysabeau-ExtraLight-sup-t4--base.tfm \
tex-Ysabeau-ExtraLight-sup-t4.tfm \
tex-Ysabeau-ExtraLight-sup-t4.vf \
tex-Ysabeau-ExtraLight-sup-t5--base.tfm \
tex-Ysabeau-ExtraLight-sup-t5.tfm \
tex-Ysabeau-ExtraLight-sup-t5.vf \
tex-Ysabeau-ExtraLight-sup-ts3.tfm \
tex-Ysabeau-ExtraLight-tlf-cs.tfm \
tex-Ysabeau-ExtraLight-tlf-l7x.tfm \
tex-Ysabeau-ExtraLight-tlf-lgr.tfm \
tex-Ysabeau-ExtraLight-tlf-ly1.tfm \
tex-Ysabeau-ExtraLight-tlf-ot1.tfm \
tex-Ysabeau-ExtraLight-tlf-qx--base.tfm \
tex-Ysabeau-ExtraLight-tlf-qx.tfm \
tex-Ysabeau-ExtraLight-tlf-qx.vf \
tex-Ysabeau-ExtraLight-tlf-sc-cs--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-cs.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-cs.vf \
tex-Ysabeau-ExtraLight-tlf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-l7x.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-l7x.vf \
tex-Ysabeau-ExtraLight-tlf-sc-lgr.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-ly1.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-ly1.vf \
tex-Ysabeau-ExtraLight-tlf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-ot1.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-ot1.vf \
tex-Ysabeau-ExtraLight-tlf-sc-qx--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-qx.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-qx.vf \
tex-Ysabeau-ExtraLight-tlf-sc-t1--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t1.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t1.vf \
tex-Ysabeau-ExtraLight-tlf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t2a.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t2a.vf \
tex-Ysabeau-ExtraLight-tlf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t2b.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t2b.vf \
tex-Ysabeau-ExtraLight-tlf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t2c.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t2c.vf \
tex-Ysabeau-ExtraLight-tlf-sc-t3.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t4--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t4.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t4.vf \
tex-Ysabeau-ExtraLight-tlf-sc-t5--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t5.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-t5.vf \
tex-Ysabeau-ExtraLight-tlf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-ts3.tfm \
tex-Ysabeau-ExtraLight-tlf-sc-ts3.vf \
tex-Ysabeau-ExtraLight-tlf-t1--base.tfm \
tex-Ysabeau-ExtraLight-tlf-t1.tfm \
tex-Ysabeau-ExtraLight-tlf-t1.vf \
tex-Ysabeau-ExtraLight-tlf-t2a--base.tfm \
tex-Ysabeau-ExtraLight-tlf-t2a.tfm \
tex-Ysabeau-ExtraLight-tlf-t2a.vf \
tex-Ysabeau-ExtraLight-tlf-t2b--base.tfm \
tex-Ysabeau-ExtraLight-tlf-t2b.tfm \
tex-Ysabeau-ExtraLight-tlf-t2b.vf \
tex-Ysabeau-ExtraLight-tlf-t2c--base.tfm \
tex-Ysabeau-ExtraLight-tlf-t2c.tfm \
tex-Ysabeau-ExtraLight-tlf-t2c.vf \
tex-Ysabeau-ExtraLight-tlf-t3.tfm \
tex-Ysabeau-ExtraLight-tlf-t4--base.tfm \
tex-Ysabeau-ExtraLight-tlf-t4.tfm \
tex-Ysabeau-ExtraLight-tlf-t4.vf \
tex-Ysabeau-ExtraLight-tlf-t5--base.tfm \
tex-Ysabeau-ExtraLight-tlf-t5.tfm \
tex-Ysabeau-ExtraLight-tlf-t5.vf \
tex-Ysabeau-ExtraLight-tlf-ts1--base.tfm \
tex-Ysabeau-ExtraLight-tlf-ts1.tfm \
tex-Ysabeau-ExtraLight-tlf-ts1.vf \
tex-Ysabeau-ExtraLight-tlf-ts3.tfm \
tex-Ysabeau-ExtraLight-tosf-cs.tfm \
tex-Ysabeau-ExtraLight-tosf-l7x.tfm \
tex-Ysabeau-ExtraLight-tosf-lgr.tfm \
tex-Ysabeau-ExtraLight-tosf-ly1.tfm \
tex-Ysabeau-ExtraLight-tosf-ot1.tfm \
tex-Ysabeau-ExtraLight-tosf-qx--base.tfm \
tex-Ysabeau-ExtraLight-tosf-qx.tfm \
tex-Ysabeau-ExtraLight-tosf-qx.vf \
tex-Ysabeau-ExtraLight-tosf-sc-cs--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-cs.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-cs.vf \
tex-Ysabeau-ExtraLight-tosf-sc-l7x--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-l7x.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-l7x.vf \
tex-Ysabeau-ExtraLight-tosf-sc-lgr.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-ly1--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-ly1.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-ly1.vf \
tex-Ysabeau-ExtraLight-tosf-sc-ot1--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-ot1.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-ot1.vf \
tex-Ysabeau-ExtraLight-tosf-sc-qx--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-qx.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-qx.vf \
tex-Ysabeau-ExtraLight-tosf-sc-t1--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t1.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t1.vf \
tex-Ysabeau-ExtraLight-tosf-sc-t2a--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t2a.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t2a.vf \
tex-Ysabeau-ExtraLight-tosf-sc-t2b--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t2b.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t2b.vf \
tex-Ysabeau-ExtraLight-tosf-sc-t2c--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t2c.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t2c.vf \
tex-Ysabeau-ExtraLight-tosf-sc-t3.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t4--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t4.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t4.vf \
tex-Ysabeau-ExtraLight-tosf-sc-t5--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t5.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-t5.vf \
tex-Ysabeau-ExtraLight-tosf-sc-ts3--base.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-ts3.tfm \
tex-Ysabeau-ExtraLight-tosf-sc-ts3.vf \
tex-Ysabeau-ExtraLight-tosf-t1--base.tfm \
tex-Ysabeau-ExtraLight-tosf-t1.tfm \
tex-Ysabeau-ExtraLight-tosf-t1.vf \
tex-Ysabeau-ExtraLight-tosf-t2a--base.tfm \
tex-Ysabeau-ExtraLight-tosf-t2a.tfm \
tex-Ysabeau-ExtraLight-tosf-t2a.vf \
tex-Ysabeau-ExtraLight-tosf-t2b--base.tfm \
tex-Ysabeau-ExtraLight-tosf-t2b.tfm \
tex-Ysabeau-ExtraLight-tosf-t2b.vf \
tex-Ysabeau-ExtraLight-tosf-t2c--base.tfm \
tex-Ysabeau-ExtraLight-tosf-t2c.tfm \
tex-Ysabeau-ExtraLight-tosf-t2c.vf \
tex-Ysabeau-ExtraLight-tosf-t3.tfm \
tex-Ysabeau-ExtraLight-tosf-t4--base.tfm \
tex-Ysabeau-ExtraLight-tosf-t4.tfm \
tex-Ysabeau-ExtraLight-tosf-t4.vf \
tex-Ysabeau-ExtraLight-tosf-t5--base.tfm \
tex-Ysabeau-ExtraLight-tosf-t5.tfm \
tex-Ysabeau-ExtraLight-tosf-t5.vf \
tex-Ysabeau-ExtraLight-tosf-ts1--base.tfm \
tex-Ysabeau-ExtraLight-tosf-ts1.tfm \
tex-Ysabeau-ExtraLight-tosf-ts1.vf \
tex-Ysabeau-ExtraLight-tosf-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-cs.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-qx.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-qx.vf \
tex-Ysabeau-ExtraLightItalic-dnom-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t1.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t1.vf \
tex-Ysabeau-ExtraLightItalic-dnom-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t2a.vf \
tex-Ysabeau-ExtraLightItalic-dnom-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t2b.vf \
tex-Ysabeau-ExtraLightItalic-dnom-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t2c.vf \
tex-Ysabeau-ExtraLightItalic-dnom-t3.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t4.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t4.vf \
tex-Ysabeau-ExtraLightItalic-dnom-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t5.tfm \
tex-Ysabeau-ExtraLightItalic-dnom-t5.vf \
tex-Ysabeau-ExtraLightItalic-dnom-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-inf-cs.tfm \
tex-Ysabeau-ExtraLightItalic-inf-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-inf-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-inf-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-inf-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-inf-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-inf-qx.tfm \
tex-Ysabeau-ExtraLightItalic-inf-qx.vf \
tex-Ysabeau-ExtraLightItalic-inf-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t1.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t1.vf \
tex-Ysabeau-ExtraLightItalic-inf-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t2a.vf \
tex-Ysabeau-ExtraLightItalic-inf-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t2b.vf \
tex-Ysabeau-ExtraLightItalic-inf-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t2c.vf \
tex-Ysabeau-ExtraLightItalic-inf-t3.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t4.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t4.vf \
tex-Ysabeau-ExtraLightItalic-inf-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t5.tfm \
tex-Ysabeau-ExtraLightItalic-inf-t5.vf \
tex-Ysabeau-ExtraLightItalic-inf-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-lf-cs.tfm \
tex-Ysabeau-ExtraLightItalic-lf-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-lf-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-lf-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-lf-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-lf-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-qx.tfm \
tex-Ysabeau-ExtraLightItalic-lf-qx.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-cs.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-qx.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-qx.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t1.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t1.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2a.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2b.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t2c.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-t3.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t4.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t4.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t5.tfm \
tex-Ysabeau-ExtraLightItalic-lf-swash-t5.vf \
tex-Ysabeau-ExtraLightItalic-lf-swash-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t1.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t1.vf \
tex-Ysabeau-ExtraLightItalic-lf-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t2a.vf \
tex-Ysabeau-ExtraLightItalic-lf-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t2b.vf \
tex-Ysabeau-ExtraLightItalic-lf-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t2c.vf \
tex-Ysabeau-ExtraLightItalic-lf-t3.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t4.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t4.vf \
tex-Ysabeau-ExtraLightItalic-lf-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t5.tfm \
tex-Ysabeau-ExtraLightItalic-lf-t5.vf \
tex-Ysabeau-ExtraLightItalic-lf-ts1--base.tfm \
tex-Ysabeau-ExtraLightItalic-lf-ts1.tfm \
tex-Ysabeau-ExtraLightItalic-lf-ts1.vf \
tex-Ysabeau-ExtraLightItalic-lf-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-numr-cs.tfm \
tex-Ysabeau-ExtraLightItalic-numr-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-numr-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-numr-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-numr-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-numr-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-numr-qx.tfm \
tex-Ysabeau-ExtraLightItalic-numr-qx.vf \
tex-Ysabeau-ExtraLightItalic-numr-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t1.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t1.vf \
tex-Ysabeau-ExtraLightItalic-numr-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t2a.vf \
tex-Ysabeau-ExtraLightItalic-numr-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t2b.vf \
tex-Ysabeau-ExtraLightItalic-numr-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t2c.vf \
tex-Ysabeau-ExtraLightItalic-numr-t3.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t4.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t4.vf \
tex-Ysabeau-ExtraLightItalic-numr-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t5.tfm \
tex-Ysabeau-ExtraLightItalic-numr-t5.vf \
tex-Ysabeau-ExtraLightItalic-numr-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-osf-cs.tfm \
tex-Ysabeau-ExtraLightItalic-osf-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-osf-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-osf-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-osf-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-osf-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-qx.tfm \
tex-Ysabeau-ExtraLightItalic-osf-qx.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-cs.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-qx.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-qx.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t1.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t1.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2a.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2b.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t2c.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-t3.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t4.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t4.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t5.tfm \
tex-Ysabeau-ExtraLightItalic-osf-swash-t5.vf \
tex-Ysabeau-ExtraLightItalic-osf-swash-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t1.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t1.vf \
tex-Ysabeau-ExtraLightItalic-osf-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t2a.vf \
tex-Ysabeau-ExtraLightItalic-osf-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t2b.vf \
tex-Ysabeau-ExtraLightItalic-osf-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t2c.vf \
tex-Ysabeau-ExtraLightItalic-osf-t3.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t4.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t4.vf \
tex-Ysabeau-ExtraLightItalic-osf-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t5.tfm \
tex-Ysabeau-ExtraLightItalic-osf-t5.vf \
tex-Ysabeau-ExtraLightItalic-osf-ts1--base.tfm \
tex-Ysabeau-ExtraLightItalic-osf-ts1.tfm \
tex-Ysabeau-ExtraLightItalic-osf-ts1.vf \
tex-Ysabeau-ExtraLightItalic-osf-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-sup-cs.tfm \
tex-Ysabeau-ExtraLightItalic-sup-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-sup-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-sup-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-sup-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-sup-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-sup-qx.tfm \
tex-Ysabeau-ExtraLightItalic-sup-qx.vf \
tex-Ysabeau-ExtraLightItalic-sup-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t1.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t1.vf \
tex-Ysabeau-ExtraLightItalic-sup-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t2a.vf \
tex-Ysabeau-ExtraLightItalic-sup-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t2b.vf \
tex-Ysabeau-ExtraLightItalic-sup-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t2c.vf \
tex-Ysabeau-ExtraLightItalic-sup-t3.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t4.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t4.vf \
tex-Ysabeau-ExtraLightItalic-sup-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t5.tfm \
tex-Ysabeau-ExtraLightItalic-sup-t5.vf \
tex-Ysabeau-ExtraLightItalic-sup-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-cs.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-qx.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-qx.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-cs.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-qx.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-qx.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t1.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t1.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2a.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2b.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t2c.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t3.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t4.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t4.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t5.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-swash-t5.vf \
tex-Ysabeau-ExtraLightItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t1.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t1.vf \
tex-Ysabeau-ExtraLightItalic-tlf-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t2a.vf \
tex-Ysabeau-ExtraLightItalic-tlf-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t2b.vf \
tex-Ysabeau-ExtraLightItalic-tlf-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t2c.vf \
tex-Ysabeau-ExtraLightItalic-tlf-t3.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t4.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t4.vf \
tex-Ysabeau-ExtraLightItalic-tlf-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t5.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-t5.vf \
tex-Ysabeau-ExtraLightItalic-tlf-ts1--base.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-ts1.tfm \
tex-Ysabeau-ExtraLightItalic-tlf-ts1.vf \
tex-Ysabeau-ExtraLightItalic-tlf-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-cs.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-qx.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-qx.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-cs.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-qx.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-qx.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t1.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t1.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2a.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2b.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t2c.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t3.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t4.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t4.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t5.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-swash-t5.vf \
tex-Ysabeau-ExtraLightItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t1--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t1.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t1.vf \
tex-Ysabeau-ExtraLightItalic-tosf-t2a--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t2a.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t2a.vf \
tex-Ysabeau-ExtraLightItalic-tosf-t2b--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t2b.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t2b.vf \
tex-Ysabeau-ExtraLightItalic-tosf-t2c--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t2c.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t2c.vf \
tex-Ysabeau-ExtraLightItalic-tosf-t3.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t4--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t4.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t4.vf \
tex-Ysabeau-ExtraLightItalic-tosf-t5--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t5.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-t5.vf \
tex-Ysabeau-ExtraLightItalic-tosf-ts1--base.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-ts1.tfm \
tex-Ysabeau-ExtraLightItalic-tosf-ts1.vf \
tex-Ysabeau-ExtraLightItalic-tosf-ts3.tfm \
tex-Ysabeau-Hairline-dnom-cs.tfm \
tex-Ysabeau-Hairline-dnom-l7x.tfm \
tex-Ysabeau-Hairline-dnom-lgr.tfm \
tex-Ysabeau-Hairline-dnom-ly1.tfm \
tex-Ysabeau-Hairline-dnom-ot1.tfm \
tex-Ysabeau-Hairline-dnom-qx--base.tfm \
tex-Ysabeau-Hairline-dnom-qx.tfm \
tex-Ysabeau-Hairline-dnom-qx.vf \
tex-Ysabeau-Hairline-dnom-t1--base.tfm \
tex-Ysabeau-Hairline-dnom-t1.tfm \
tex-Ysabeau-Hairline-dnom-t1.vf \
tex-Ysabeau-Hairline-dnom-t2a--base.tfm \
tex-Ysabeau-Hairline-dnom-t2a.tfm \
tex-Ysabeau-Hairline-dnom-t2a.vf \
tex-Ysabeau-Hairline-dnom-t2b--base.tfm \
tex-Ysabeau-Hairline-dnom-t2b.tfm \
tex-Ysabeau-Hairline-dnom-t2b.vf \
tex-Ysabeau-Hairline-dnom-t2c--base.tfm \
tex-Ysabeau-Hairline-dnom-t2c.tfm \
tex-Ysabeau-Hairline-dnom-t2c.vf \
tex-Ysabeau-Hairline-dnom-t3.tfm \
tex-Ysabeau-Hairline-dnom-t4--base.tfm \
tex-Ysabeau-Hairline-dnom-t4.tfm \
tex-Ysabeau-Hairline-dnom-t4.vf \
tex-Ysabeau-Hairline-dnom-t5--base.tfm \
tex-Ysabeau-Hairline-dnom-t5.tfm \
tex-Ysabeau-Hairline-dnom-t5.vf \
tex-Ysabeau-Hairline-dnom-ts3.tfm \
tex-Ysabeau-Hairline-inf-cs.tfm \
tex-Ysabeau-Hairline-inf-l7x.tfm \
tex-Ysabeau-Hairline-inf-lgr.tfm \
tex-Ysabeau-Hairline-inf-ly1.tfm \
tex-Ysabeau-Hairline-inf-ot1.tfm \
tex-Ysabeau-Hairline-inf-qx--base.tfm \
tex-Ysabeau-Hairline-inf-qx.tfm \
tex-Ysabeau-Hairline-inf-qx.vf \
tex-Ysabeau-Hairline-inf-t1--base.tfm \
tex-Ysabeau-Hairline-inf-t1.tfm \
tex-Ysabeau-Hairline-inf-t1.vf \
tex-Ysabeau-Hairline-inf-t2a--base.tfm \
tex-Ysabeau-Hairline-inf-t2a.tfm \
tex-Ysabeau-Hairline-inf-t2a.vf \
tex-Ysabeau-Hairline-inf-t2b--base.tfm \
tex-Ysabeau-Hairline-inf-t2b.tfm \
tex-Ysabeau-Hairline-inf-t2b.vf \
tex-Ysabeau-Hairline-inf-t2c--base.tfm \
tex-Ysabeau-Hairline-inf-t2c.tfm \
tex-Ysabeau-Hairline-inf-t2c.vf \
tex-Ysabeau-Hairline-inf-t3.tfm \
tex-Ysabeau-Hairline-inf-t4--base.tfm \
tex-Ysabeau-Hairline-inf-t4.tfm \
tex-Ysabeau-Hairline-inf-t4.vf \
tex-Ysabeau-Hairline-inf-t5--base.tfm \
tex-Ysabeau-Hairline-inf-t5.tfm \
tex-Ysabeau-Hairline-inf-t5.vf \
tex-Ysabeau-Hairline-inf-ts3.tfm \
tex-Ysabeau-Hairline-lf-cs.tfm \
tex-Ysabeau-Hairline-lf-l7x.tfm \
tex-Ysabeau-Hairline-lf-lgr.tfm \
tex-Ysabeau-Hairline-lf-ly1.tfm \
tex-Ysabeau-Hairline-lf-ot1.tfm \
tex-Ysabeau-Hairline-lf-qx--base.tfm \
tex-Ysabeau-Hairline-lf-qx.tfm \
tex-Ysabeau-Hairline-lf-qx.vf \
tex-Ysabeau-Hairline-lf-sc-cs--base.tfm \
tex-Ysabeau-Hairline-lf-sc-cs.tfm \
tex-Ysabeau-Hairline-lf-sc-cs.vf \
tex-Ysabeau-Hairline-lf-sc-l7x--base.tfm \
tex-Ysabeau-Hairline-lf-sc-l7x.tfm \
tex-Ysabeau-Hairline-lf-sc-l7x.vf \
tex-Ysabeau-Hairline-lf-sc-lgr.tfm \
tex-Ysabeau-Hairline-lf-sc-ly1--base.tfm \
tex-Ysabeau-Hairline-lf-sc-ly1.tfm \
tex-Ysabeau-Hairline-lf-sc-ly1.vf \
tex-Ysabeau-Hairline-lf-sc-ot1--base.tfm \
tex-Ysabeau-Hairline-lf-sc-ot1.tfm \
tex-Ysabeau-Hairline-lf-sc-ot1.vf \
tex-Ysabeau-Hairline-lf-sc-qx--base.tfm \
tex-Ysabeau-Hairline-lf-sc-qx.tfm \
tex-Ysabeau-Hairline-lf-sc-qx.vf \
tex-Ysabeau-Hairline-lf-sc-t1--base.tfm \
tex-Ysabeau-Hairline-lf-sc-t1.tfm \
tex-Ysabeau-Hairline-lf-sc-t1.vf \
tex-Ysabeau-Hairline-lf-sc-t2a--base.tfm \
tex-Ysabeau-Hairline-lf-sc-t2a.tfm \
tex-Ysabeau-Hairline-lf-sc-t2a.vf \
tex-Ysabeau-Hairline-lf-sc-t2b--base.tfm \
tex-Ysabeau-Hairline-lf-sc-t2b.tfm \
tex-Ysabeau-Hairline-lf-sc-t2b.vf \
tex-Ysabeau-Hairline-lf-sc-t2c--base.tfm \
tex-Ysabeau-Hairline-lf-sc-t2c.tfm \
tex-Ysabeau-Hairline-lf-sc-t2c.vf \
tex-Ysabeau-Hairline-lf-sc-t3.tfm \
tex-Ysabeau-Hairline-lf-sc-t4--base.tfm \
tex-Ysabeau-Hairline-lf-sc-t4.tfm \
tex-Ysabeau-Hairline-lf-sc-t4.vf \
tex-Ysabeau-Hairline-lf-sc-t5--base.tfm \
tex-Ysabeau-Hairline-lf-sc-t5.tfm \
tex-Ysabeau-Hairline-lf-sc-t5.vf \
tex-Ysabeau-Hairline-lf-sc-ts3--base.tfm \
tex-Ysabeau-Hairline-lf-sc-ts3.tfm \
tex-Ysabeau-Hairline-lf-sc-ts3.vf \
tex-Ysabeau-Hairline-lf-t1--base.tfm \
tex-Ysabeau-Hairline-lf-t1.tfm \
tex-Ysabeau-Hairline-lf-t1.vf \
tex-Ysabeau-Hairline-lf-t2a--base.tfm \
tex-Ysabeau-Hairline-lf-t2a.tfm \
tex-Ysabeau-Hairline-lf-t2a.vf \
tex-Ysabeau-Hairline-lf-t2b--base.tfm \
tex-Ysabeau-Hairline-lf-t2b.tfm \
tex-Ysabeau-Hairline-lf-t2b.vf \
tex-Ysabeau-Hairline-lf-t2c--base.tfm \
tex-Ysabeau-Hairline-lf-t2c.tfm \
tex-Ysabeau-Hairline-lf-t2c.vf \
tex-Ysabeau-Hairline-lf-t3.tfm \
tex-Ysabeau-Hairline-lf-t4--base.tfm \
tex-Ysabeau-Hairline-lf-t4.tfm \
tex-Ysabeau-Hairline-lf-t4.vf \
tex-Ysabeau-Hairline-lf-t5--base.tfm \
tex-Ysabeau-Hairline-lf-t5.tfm \
tex-Ysabeau-Hairline-lf-t5.vf \
tex-Ysabeau-Hairline-lf-ts1--base.tfm \
tex-Ysabeau-Hairline-lf-ts1.tfm \
tex-Ysabeau-Hairline-lf-ts1.vf \
tex-Ysabeau-Hairline-lf-ts3.tfm \
tex-Ysabeau-Hairline-numr-cs.tfm \
tex-Ysabeau-Hairline-numr-l7x.tfm \
tex-Ysabeau-Hairline-numr-lgr.tfm \
tex-Ysabeau-Hairline-numr-ly1.tfm \
tex-Ysabeau-Hairline-numr-ot1.tfm \
tex-Ysabeau-Hairline-numr-qx--base.tfm \
tex-Ysabeau-Hairline-numr-qx.tfm \
tex-Ysabeau-Hairline-numr-qx.vf \
tex-Ysabeau-Hairline-numr-t1--base.tfm \
tex-Ysabeau-Hairline-numr-t1.tfm \
tex-Ysabeau-Hairline-numr-t1.vf \
tex-Ysabeau-Hairline-numr-t2a--base.tfm \
tex-Ysabeau-Hairline-numr-t2a.tfm \
tex-Ysabeau-Hairline-numr-t2a.vf \
tex-Ysabeau-Hairline-numr-t2b--base.tfm \
tex-Ysabeau-Hairline-numr-t2b.tfm \
tex-Ysabeau-Hairline-numr-t2b.vf \
tex-Ysabeau-Hairline-numr-t2c--base.tfm \
tex-Ysabeau-Hairline-numr-t2c.tfm \
tex-Ysabeau-Hairline-numr-t2c.vf \
tex-Ysabeau-Hairline-numr-t3.tfm \
tex-Ysabeau-Hairline-numr-t4--base.tfm \
tex-Ysabeau-Hairline-numr-t4.tfm \
tex-Ysabeau-Hairline-numr-t4.vf \
tex-Ysabeau-Hairline-numr-t5--base.tfm \
tex-Ysabeau-Hairline-numr-t5.tfm \
tex-Ysabeau-Hairline-numr-t5.vf \
tex-Ysabeau-Hairline-numr-ts3.tfm \
tex-Ysabeau-Hairline-osf-cs.tfm \
tex-Ysabeau-Hairline-osf-l7x.tfm \
tex-Ysabeau-Hairline-osf-lgr.tfm \
tex-Ysabeau-Hairline-osf-ly1.tfm \
tex-Ysabeau-Hairline-osf-ot1.tfm \
tex-Ysabeau-Hairline-osf-qx--base.tfm \
tex-Ysabeau-Hairline-osf-qx.tfm \
tex-Ysabeau-Hairline-osf-qx.vf \
tex-Ysabeau-Hairline-osf-sc-cs--base.tfm \
tex-Ysabeau-Hairline-osf-sc-cs.tfm \
tex-Ysabeau-Hairline-osf-sc-cs.vf \
tex-Ysabeau-Hairline-osf-sc-l7x--base.tfm \
tex-Ysabeau-Hairline-osf-sc-l7x.tfm \
tex-Ysabeau-Hairline-osf-sc-l7x.vf \
tex-Ysabeau-Hairline-osf-sc-lgr.tfm \
tex-Ysabeau-Hairline-osf-sc-ly1--base.tfm \
tex-Ysabeau-Hairline-osf-sc-ly1.tfm \
tex-Ysabeau-Hairline-osf-sc-ly1.vf \
tex-Ysabeau-Hairline-osf-sc-ot1--base.tfm \
tex-Ysabeau-Hairline-osf-sc-ot1.tfm \
tex-Ysabeau-Hairline-osf-sc-ot1.vf \
tex-Ysabeau-Hairline-osf-sc-qx--base.tfm \
tex-Ysabeau-Hairline-osf-sc-qx.tfm \
tex-Ysabeau-Hairline-osf-sc-qx.vf \
tex-Ysabeau-Hairline-osf-sc-t1--base.tfm \
tex-Ysabeau-Hairline-osf-sc-t1.tfm \
tex-Ysabeau-Hairline-osf-sc-t1.vf \
tex-Ysabeau-Hairline-osf-sc-t2a--base.tfm \
tex-Ysabeau-Hairline-osf-sc-t2a.tfm \
tex-Ysabeau-Hairline-osf-sc-t2a.vf \
tex-Ysabeau-Hairline-osf-sc-t2b--base.tfm \
tex-Ysabeau-Hairline-osf-sc-t2b.tfm \
tex-Ysabeau-Hairline-osf-sc-t2b.vf \
tex-Ysabeau-Hairline-osf-sc-t2c--base.tfm \
tex-Ysabeau-Hairline-osf-sc-t2c.tfm \
tex-Ysabeau-Hairline-osf-sc-t2c.vf \
tex-Ysabeau-Hairline-osf-sc-t3.tfm \
tex-Ysabeau-Hairline-osf-sc-t4--base.tfm \
tex-Ysabeau-Hairline-osf-sc-t4.tfm \
tex-Ysabeau-Hairline-osf-sc-t4.vf \
tex-Ysabeau-Hairline-osf-sc-t5--base.tfm \
tex-Ysabeau-Hairline-osf-sc-t5.tfm \
tex-Ysabeau-Hairline-osf-sc-t5.vf \
tex-Ysabeau-Hairline-osf-sc-ts3--base.tfm \
tex-Ysabeau-Hairline-osf-sc-ts3.tfm \
tex-Ysabeau-Hairline-osf-sc-ts3.vf \
tex-Ysabeau-Hairline-osf-t1--base.tfm \
tex-Ysabeau-Hairline-osf-t1.tfm \
tex-Ysabeau-Hairline-osf-t1.vf \
tex-Ysabeau-Hairline-osf-t2a--base.tfm \
tex-Ysabeau-Hairline-osf-t2a.tfm \
tex-Ysabeau-Hairline-osf-t2a.vf \
tex-Ysabeau-Hairline-osf-t2b--base.tfm \
tex-Ysabeau-Hairline-osf-t2b.tfm \
tex-Ysabeau-Hairline-osf-t2b.vf \
tex-Ysabeau-Hairline-osf-t2c--base.tfm \
tex-Ysabeau-Hairline-osf-t2c.tfm \
tex-Ysabeau-Hairline-osf-t2c.vf \
tex-Ysabeau-Hairline-osf-t3.tfm \
tex-Ysabeau-Hairline-osf-t4--base.tfm \
tex-Ysabeau-Hairline-osf-t4.tfm \
tex-Ysabeau-Hairline-osf-t4.vf \
tex-Ysabeau-Hairline-osf-t5--base.tfm \
tex-Ysabeau-Hairline-osf-t5.tfm \
tex-Ysabeau-Hairline-osf-t5.vf \
tex-Ysabeau-Hairline-osf-ts1--base.tfm \
tex-Ysabeau-Hairline-osf-ts1.tfm \
tex-Ysabeau-Hairline-osf-ts1.vf \
tex-Ysabeau-Hairline-osf-ts3.tfm \
tex-Ysabeau-Hairline-sup-cs.tfm \
tex-Ysabeau-Hairline-sup-l7x.tfm \
tex-Ysabeau-Hairline-sup-lgr.tfm \
tex-Ysabeau-Hairline-sup-ly1.tfm \
tex-Ysabeau-Hairline-sup-ot1.tfm \
tex-Ysabeau-Hairline-sup-qx--base.tfm \
tex-Ysabeau-Hairline-sup-qx.tfm \
tex-Ysabeau-Hairline-sup-qx.vf \
tex-Ysabeau-Hairline-sup-t1--base.tfm \
tex-Ysabeau-Hairline-sup-t1.tfm \
tex-Ysabeau-Hairline-sup-t1.vf \
tex-Ysabeau-Hairline-sup-t2a--base.tfm \
tex-Ysabeau-Hairline-sup-t2a.tfm \
tex-Ysabeau-Hairline-sup-t2a.vf \
tex-Ysabeau-Hairline-sup-t2b--base.tfm \
tex-Ysabeau-Hairline-sup-t2b.tfm \
tex-Ysabeau-Hairline-sup-t2b.vf \
tex-Ysabeau-Hairline-sup-t2c--base.tfm \
tex-Ysabeau-Hairline-sup-t2c.tfm \
tex-Ysabeau-Hairline-sup-t2c.vf \
tex-Ysabeau-Hairline-sup-t3.tfm \
tex-Ysabeau-Hairline-sup-t4--base.tfm \
tex-Ysabeau-Hairline-sup-t4.tfm \
tex-Ysabeau-Hairline-sup-t4.vf \
tex-Ysabeau-Hairline-sup-t5--base.tfm \
tex-Ysabeau-Hairline-sup-t5.tfm \
tex-Ysabeau-Hairline-sup-t5.vf \
tex-Ysabeau-Hairline-sup-ts3.tfm \
tex-Ysabeau-Hairline-tlf-cs.tfm \
tex-Ysabeau-Hairline-tlf-l7x.tfm \
tex-Ysabeau-Hairline-tlf-lgr.tfm \
tex-Ysabeau-Hairline-tlf-ly1.tfm \
tex-Ysabeau-Hairline-tlf-ot1.tfm \
tex-Ysabeau-Hairline-tlf-qx--base.tfm \
tex-Ysabeau-Hairline-tlf-qx.tfm \
tex-Ysabeau-Hairline-tlf-qx.vf \
tex-Ysabeau-Hairline-tlf-sc-cs--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-cs.tfm \
tex-Ysabeau-Hairline-tlf-sc-cs.vf \
tex-Ysabeau-Hairline-tlf-sc-l7x--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-l7x.tfm \
tex-Ysabeau-Hairline-tlf-sc-l7x.vf \
tex-Ysabeau-Hairline-tlf-sc-lgr.tfm \
tex-Ysabeau-Hairline-tlf-sc-ly1--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-ly1.tfm \
tex-Ysabeau-Hairline-tlf-sc-ly1.vf \
tex-Ysabeau-Hairline-tlf-sc-ot1--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-ot1.tfm \
tex-Ysabeau-Hairline-tlf-sc-ot1.vf \
tex-Ysabeau-Hairline-tlf-sc-qx--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-qx.tfm \
tex-Ysabeau-Hairline-tlf-sc-qx.vf \
tex-Ysabeau-Hairline-tlf-sc-t1--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-t1.tfm \
tex-Ysabeau-Hairline-tlf-sc-t1.vf \
tex-Ysabeau-Hairline-tlf-sc-t2a--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-t2a.tfm \
tex-Ysabeau-Hairline-tlf-sc-t2a.vf \
tex-Ysabeau-Hairline-tlf-sc-t2b--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-t2b.tfm \
tex-Ysabeau-Hairline-tlf-sc-t2b.vf \
tex-Ysabeau-Hairline-tlf-sc-t2c--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-t2c.tfm \
tex-Ysabeau-Hairline-tlf-sc-t2c.vf \
tex-Ysabeau-Hairline-tlf-sc-t3.tfm \
tex-Ysabeau-Hairline-tlf-sc-t4--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-t4.tfm \
tex-Ysabeau-Hairline-tlf-sc-t4.vf \
tex-Ysabeau-Hairline-tlf-sc-t5--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-t5.tfm \
tex-Ysabeau-Hairline-tlf-sc-t5.vf \
tex-Ysabeau-Hairline-tlf-sc-ts3--base.tfm \
tex-Ysabeau-Hairline-tlf-sc-ts3.tfm \
tex-Ysabeau-Hairline-tlf-sc-ts3.vf \
tex-Ysabeau-Hairline-tlf-t1--base.tfm \
tex-Ysabeau-Hairline-tlf-t1.tfm \
tex-Ysabeau-Hairline-tlf-t1.vf \
tex-Ysabeau-Hairline-tlf-t2a--base.tfm \
tex-Ysabeau-Hairline-tlf-t2a.tfm \
tex-Ysabeau-Hairline-tlf-t2a.vf \
tex-Ysabeau-Hairline-tlf-t2b--base.tfm \
tex-Ysabeau-Hairline-tlf-t2b.tfm \
tex-Ysabeau-Hairline-tlf-t2b.vf \
tex-Ysabeau-Hairline-tlf-t2c--base.tfm \
tex-Ysabeau-Hairline-tlf-t2c.tfm \
tex-Ysabeau-Hairline-tlf-t2c.vf \
tex-Ysabeau-Hairline-tlf-t3.tfm \
tex-Ysabeau-Hairline-tlf-t4--base.tfm \
tex-Ysabeau-Hairline-tlf-t4.tfm \
tex-Ysabeau-Hairline-tlf-t4.vf \
tex-Ysabeau-Hairline-tlf-t5--base.tfm \
tex-Ysabeau-Hairline-tlf-t5.tfm \
tex-Ysabeau-Hairline-tlf-t5.vf \
tex-Ysabeau-Hairline-tlf-ts1--base.tfm \
tex-Ysabeau-Hairline-tlf-ts1.tfm \
tex-Ysabeau-Hairline-tlf-ts1.vf \
tex-Ysabeau-Hairline-tlf-ts3.tfm \
tex-Ysabeau-Hairline-tosf-cs.tfm \
tex-Ysabeau-Hairline-tosf-l7x.tfm \
tex-Ysabeau-Hairline-tosf-lgr.tfm \
tex-Ysabeau-Hairline-tosf-ly1.tfm \
tex-Ysabeau-Hairline-tosf-ot1.tfm \
tex-Ysabeau-Hairline-tosf-qx--base.tfm \
tex-Ysabeau-Hairline-tosf-qx.tfm \
tex-Ysabeau-Hairline-tosf-qx.vf \
tex-Ysabeau-Hairline-tosf-sc-cs--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-cs.tfm \
tex-Ysabeau-Hairline-tosf-sc-cs.vf \
tex-Ysabeau-Hairline-tosf-sc-l7x--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-l7x.tfm \
tex-Ysabeau-Hairline-tosf-sc-l7x.vf \
tex-Ysabeau-Hairline-tosf-sc-lgr.tfm \
tex-Ysabeau-Hairline-tosf-sc-ly1--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-ly1.tfm \
tex-Ysabeau-Hairline-tosf-sc-ly1.vf \
tex-Ysabeau-Hairline-tosf-sc-ot1--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-ot1.tfm \
tex-Ysabeau-Hairline-tosf-sc-ot1.vf \
tex-Ysabeau-Hairline-tosf-sc-qx--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-qx.tfm \
tex-Ysabeau-Hairline-tosf-sc-qx.vf \
tex-Ysabeau-Hairline-tosf-sc-t1--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-t1.tfm \
tex-Ysabeau-Hairline-tosf-sc-t1.vf \
tex-Ysabeau-Hairline-tosf-sc-t2a--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-t2a.tfm \
tex-Ysabeau-Hairline-tosf-sc-t2a.vf \
tex-Ysabeau-Hairline-tosf-sc-t2b--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-t2b.tfm \
tex-Ysabeau-Hairline-tosf-sc-t2b.vf \
tex-Ysabeau-Hairline-tosf-sc-t2c--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-t2c.tfm \
tex-Ysabeau-Hairline-tosf-sc-t2c.vf \
tex-Ysabeau-Hairline-tosf-sc-t3.tfm \
tex-Ysabeau-Hairline-tosf-sc-t4--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-t4.tfm \
tex-Ysabeau-Hairline-tosf-sc-t4.vf \
tex-Ysabeau-Hairline-tosf-sc-t5--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-t5.tfm \
tex-Ysabeau-Hairline-tosf-sc-t5.vf \
tex-Ysabeau-Hairline-tosf-sc-ts3--base.tfm \
tex-Ysabeau-Hairline-tosf-sc-ts3.tfm \
tex-Ysabeau-Hairline-tosf-sc-ts3.vf \
tex-Ysabeau-Hairline-tosf-t1--base.tfm \
tex-Ysabeau-Hairline-tosf-t1.tfm \
tex-Ysabeau-Hairline-tosf-t1.vf \
tex-Ysabeau-Hairline-tosf-t2a--base.tfm \
tex-Ysabeau-Hairline-tosf-t2a.tfm \
tex-Ysabeau-Hairline-tosf-t2a.vf \
tex-Ysabeau-Hairline-tosf-t2b--base.tfm \
tex-Ysabeau-Hairline-tosf-t2b.tfm \
tex-Ysabeau-Hairline-tosf-t2b.vf \
tex-Ysabeau-Hairline-tosf-t2c--base.tfm \
tex-Ysabeau-Hairline-tosf-t2c.tfm \
tex-Ysabeau-Hairline-tosf-t2c.vf \
tex-Ysabeau-Hairline-tosf-t3.tfm \
tex-Ysabeau-Hairline-tosf-t4--base.tfm \
tex-Ysabeau-Hairline-tosf-t4.tfm \
tex-Ysabeau-Hairline-tosf-t4.vf \
tex-Ysabeau-Hairline-tosf-t5--base.tfm \
tex-Ysabeau-Hairline-tosf-t5.tfm \
tex-Ysabeau-Hairline-tosf-t5.vf \
tex-Ysabeau-Hairline-tosf-ts1--base.tfm \
tex-Ysabeau-Hairline-tosf-ts1.tfm \
tex-Ysabeau-Hairline-tosf-ts1.vf \
tex-Ysabeau-Hairline-tosf-ts3.tfm \
tex-Ysabeau-HairlineItalic-dnom-cs.tfm \
tex-Ysabeau-HairlineItalic-dnom-l7x.tfm \
tex-Ysabeau-HairlineItalic-dnom-lgr.tfm \
tex-Ysabeau-HairlineItalic-dnom-ly1.tfm \
tex-Ysabeau-HairlineItalic-dnom-ot1.tfm \
tex-Ysabeau-HairlineItalic-dnom-qx--base.tfm \
tex-Ysabeau-HairlineItalic-dnom-qx.tfm \
tex-Ysabeau-HairlineItalic-dnom-qx.vf \
tex-Ysabeau-HairlineItalic-dnom-t1--base.tfm \
tex-Ysabeau-HairlineItalic-dnom-t1.tfm \
tex-Ysabeau-HairlineItalic-dnom-t1.vf \
tex-Ysabeau-HairlineItalic-dnom-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-dnom-t2a.tfm \
tex-Ysabeau-HairlineItalic-dnom-t2a.vf \
tex-Ysabeau-HairlineItalic-dnom-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-dnom-t2b.tfm \
tex-Ysabeau-HairlineItalic-dnom-t2b.vf \
tex-Ysabeau-HairlineItalic-dnom-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-dnom-t2c.tfm \
tex-Ysabeau-HairlineItalic-dnom-t2c.vf \
tex-Ysabeau-HairlineItalic-dnom-t3.tfm \
tex-Ysabeau-HairlineItalic-dnom-t4--base.tfm \
tex-Ysabeau-HairlineItalic-dnom-t4.tfm \
tex-Ysabeau-HairlineItalic-dnom-t4.vf \
tex-Ysabeau-HairlineItalic-dnom-t5--base.tfm \
tex-Ysabeau-HairlineItalic-dnom-t5.tfm \
tex-Ysabeau-HairlineItalic-dnom-t5.vf \
tex-Ysabeau-HairlineItalic-dnom-ts3.tfm \
tex-Ysabeau-HairlineItalic-inf-cs.tfm \
tex-Ysabeau-HairlineItalic-inf-l7x.tfm \
tex-Ysabeau-HairlineItalic-inf-lgr.tfm \
tex-Ysabeau-HairlineItalic-inf-ly1.tfm \
tex-Ysabeau-HairlineItalic-inf-ot1.tfm \
tex-Ysabeau-HairlineItalic-inf-qx--base.tfm \
tex-Ysabeau-HairlineItalic-inf-qx.tfm \
tex-Ysabeau-HairlineItalic-inf-qx.vf \
tex-Ysabeau-HairlineItalic-inf-t1--base.tfm \
tex-Ysabeau-HairlineItalic-inf-t1.tfm \
tex-Ysabeau-HairlineItalic-inf-t1.vf \
tex-Ysabeau-HairlineItalic-inf-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-inf-t2a.tfm \
tex-Ysabeau-HairlineItalic-inf-t2a.vf \
tex-Ysabeau-HairlineItalic-inf-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-inf-t2b.tfm \
tex-Ysabeau-HairlineItalic-inf-t2b.vf \
tex-Ysabeau-HairlineItalic-inf-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-inf-t2c.tfm \
tex-Ysabeau-HairlineItalic-inf-t2c.vf \
tex-Ysabeau-HairlineItalic-inf-t3.tfm \
tex-Ysabeau-HairlineItalic-inf-t4--base.tfm \
tex-Ysabeau-HairlineItalic-inf-t4.tfm \
tex-Ysabeau-HairlineItalic-inf-t4.vf \
tex-Ysabeau-HairlineItalic-inf-t5--base.tfm \
tex-Ysabeau-HairlineItalic-inf-t5.tfm \
tex-Ysabeau-HairlineItalic-inf-t5.vf \
tex-Ysabeau-HairlineItalic-inf-ts3.tfm \
tex-Ysabeau-HairlineItalic-lf-cs.tfm \
tex-Ysabeau-HairlineItalic-lf-l7x.tfm \
tex-Ysabeau-HairlineItalic-lf-lgr.tfm \
tex-Ysabeau-HairlineItalic-lf-ly1.tfm \
tex-Ysabeau-HairlineItalic-lf-ot1.tfm \
tex-Ysabeau-HairlineItalic-lf-qx--base.tfm \
tex-Ysabeau-HairlineItalic-lf-qx.tfm \
tex-Ysabeau-HairlineItalic-lf-qx.vf \
tex-Ysabeau-HairlineItalic-lf-swash-cs.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-l7x.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-lgr.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-ly1.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-ot1.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-qx.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-qx.vf \
tex-Ysabeau-HairlineItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t1.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t1.vf \
tex-Ysabeau-HairlineItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t2a.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t2a.vf \
tex-Ysabeau-HairlineItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t2b.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t2b.vf \
tex-Ysabeau-HairlineItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t2c.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t2c.vf \
tex-Ysabeau-HairlineItalic-lf-swash-t3.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t4.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t4.vf \
tex-Ysabeau-HairlineItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t5.tfm \
tex-Ysabeau-HairlineItalic-lf-swash-t5.vf \
tex-Ysabeau-HairlineItalic-lf-swash-ts3.tfm \
tex-Ysabeau-HairlineItalic-lf-t1--base.tfm \
tex-Ysabeau-HairlineItalic-lf-t1.tfm \
tex-Ysabeau-HairlineItalic-lf-t1.vf \
tex-Ysabeau-HairlineItalic-lf-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-lf-t2a.tfm \
tex-Ysabeau-HairlineItalic-lf-t2a.vf \
tex-Ysabeau-HairlineItalic-lf-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-lf-t2b.tfm \
tex-Ysabeau-HairlineItalic-lf-t2b.vf \
tex-Ysabeau-HairlineItalic-lf-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-lf-t2c.tfm \
tex-Ysabeau-HairlineItalic-lf-t2c.vf \
tex-Ysabeau-HairlineItalic-lf-t3.tfm \
tex-Ysabeau-HairlineItalic-lf-t4--base.tfm \
tex-Ysabeau-HairlineItalic-lf-t4.tfm \
tex-Ysabeau-HairlineItalic-lf-t4.vf \
tex-Ysabeau-HairlineItalic-lf-t5--base.tfm \
tex-Ysabeau-HairlineItalic-lf-t5.tfm \
tex-Ysabeau-HairlineItalic-lf-t5.vf \
tex-Ysabeau-HairlineItalic-lf-ts1--base.tfm \
tex-Ysabeau-HairlineItalic-lf-ts1.tfm \
tex-Ysabeau-HairlineItalic-lf-ts1.vf \
tex-Ysabeau-HairlineItalic-lf-ts3.tfm \
tex-Ysabeau-HairlineItalic-numr-cs.tfm \
tex-Ysabeau-HairlineItalic-numr-l7x.tfm \
tex-Ysabeau-HairlineItalic-numr-lgr.tfm \
tex-Ysabeau-HairlineItalic-numr-ly1.tfm \
tex-Ysabeau-HairlineItalic-numr-ot1.tfm \
tex-Ysabeau-HairlineItalic-numr-qx--base.tfm \
tex-Ysabeau-HairlineItalic-numr-qx.tfm \
tex-Ysabeau-HairlineItalic-numr-qx.vf \
tex-Ysabeau-HairlineItalic-numr-t1--base.tfm \
tex-Ysabeau-HairlineItalic-numr-t1.tfm \
tex-Ysabeau-HairlineItalic-numr-t1.vf \
tex-Ysabeau-HairlineItalic-numr-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-numr-t2a.tfm \
tex-Ysabeau-HairlineItalic-numr-t2a.vf \
tex-Ysabeau-HairlineItalic-numr-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-numr-t2b.tfm \
tex-Ysabeau-HairlineItalic-numr-t2b.vf \
tex-Ysabeau-HairlineItalic-numr-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-numr-t2c.tfm \
tex-Ysabeau-HairlineItalic-numr-t2c.vf \
tex-Ysabeau-HairlineItalic-numr-t3.tfm \
tex-Ysabeau-HairlineItalic-numr-t4--base.tfm \
tex-Ysabeau-HairlineItalic-numr-t4.tfm \
tex-Ysabeau-HairlineItalic-numr-t4.vf \
tex-Ysabeau-HairlineItalic-numr-t5--base.tfm \
tex-Ysabeau-HairlineItalic-numr-t5.tfm \
tex-Ysabeau-HairlineItalic-numr-t5.vf \
tex-Ysabeau-HairlineItalic-numr-ts3.tfm \
tex-Ysabeau-HairlineItalic-osf-cs.tfm \
tex-Ysabeau-HairlineItalic-osf-l7x.tfm \
tex-Ysabeau-HairlineItalic-osf-lgr.tfm \
tex-Ysabeau-HairlineItalic-osf-ly1.tfm \
tex-Ysabeau-HairlineItalic-osf-ot1.tfm \
tex-Ysabeau-HairlineItalic-osf-qx--base.tfm \
tex-Ysabeau-HairlineItalic-osf-qx.tfm \
tex-Ysabeau-HairlineItalic-osf-qx.vf \
tex-Ysabeau-HairlineItalic-osf-swash-cs.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-l7x.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-lgr.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-ly1.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-ot1.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-qx.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-qx.vf \
tex-Ysabeau-HairlineItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t1.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t1.vf \
tex-Ysabeau-HairlineItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t2a.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t2a.vf \
tex-Ysabeau-HairlineItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t2b.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t2b.vf \
tex-Ysabeau-HairlineItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t2c.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t2c.vf \
tex-Ysabeau-HairlineItalic-osf-swash-t3.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t4.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t4.vf \
tex-Ysabeau-HairlineItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t5.tfm \
tex-Ysabeau-HairlineItalic-osf-swash-t5.vf \
tex-Ysabeau-HairlineItalic-osf-swash-ts3.tfm \
tex-Ysabeau-HairlineItalic-osf-t1--base.tfm \
tex-Ysabeau-HairlineItalic-osf-t1.tfm \
tex-Ysabeau-HairlineItalic-osf-t1.vf \
tex-Ysabeau-HairlineItalic-osf-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-osf-t2a.tfm \
tex-Ysabeau-HairlineItalic-osf-t2a.vf \
tex-Ysabeau-HairlineItalic-osf-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-osf-t2b.tfm \
tex-Ysabeau-HairlineItalic-osf-t2b.vf \
tex-Ysabeau-HairlineItalic-osf-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-osf-t2c.tfm \
tex-Ysabeau-HairlineItalic-osf-t2c.vf \
tex-Ysabeau-HairlineItalic-osf-t3.tfm \
tex-Ysabeau-HairlineItalic-osf-t4--base.tfm \
tex-Ysabeau-HairlineItalic-osf-t4.tfm \
tex-Ysabeau-HairlineItalic-osf-t4.vf \
tex-Ysabeau-HairlineItalic-osf-t5--base.tfm \
tex-Ysabeau-HairlineItalic-osf-t5.tfm \
tex-Ysabeau-HairlineItalic-osf-t5.vf \
tex-Ysabeau-HairlineItalic-osf-ts1--base.tfm \
tex-Ysabeau-HairlineItalic-osf-ts1.tfm \
tex-Ysabeau-HairlineItalic-osf-ts1.vf \
tex-Ysabeau-HairlineItalic-osf-ts3.tfm \
tex-Ysabeau-HairlineItalic-sup-cs.tfm \
tex-Ysabeau-HairlineItalic-sup-l7x.tfm \
tex-Ysabeau-HairlineItalic-sup-lgr.tfm \
tex-Ysabeau-HairlineItalic-sup-ly1.tfm \
tex-Ysabeau-HairlineItalic-sup-ot1.tfm \
tex-Ysabeau-HairlineItalic-sup-qx--base.tfm \
tex-Ysabeau-HairlineItalic-sup-qx.tfm \
tex-Ysabeau-HairlineItalic-sup-qx.vf \
tex-Ysabeau-HairlineItalic-sup-t1--base.tfm \
tex-Ysabeau-HairlineItalic-sup-t1.tfm \
tex-Ysabeau-HairlineItalic-sup-t1.vf \
tex-Ysabeau-HairlineItalic-sup-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-sup-t2a.tfm \
tex-Ysabeau-HairlineItalic-sup-t2a.vf \
tex-Ysabeau-HairlineItalic-sup-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-sup-t2b.tfm \
tex-Ysabeau-HairlineItalic-sup-t2b.vf \
tex-Ysabeau-HairlineItalic-sup-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-sup-t2c.tfm \
tex-Ysabeau-HairlineItalic-sup-t2c.vf \
tex-Ysabeau-HairlineItalic-sup-t3.tfm \
tex-Ysabeau-HairlineItalic-sup-t4--base.tfm \
tex-Ysabeau-HairlineItalic-sup-t4.tfm \
tex-Ysabeau-HairlineItalic-sup-t4.vf \
tex-Ysabeau-HairlineItalic-sup-t5--base.tfm \
tex-Ysabeau-HairlineItalic-sup-t5.tfm \
tex-Ysabeau-HairlineItalic-sup-t5.vf \
tex-Ysabeau-HairlineItalic-sup-ts3.tfm \
tex-Ysabeau-HairlineItalic-tlf-cs.tfm \
tex-Ysabeau-HairlineItalic-tlf-l7x.tfm \
tex-Ysabeau-HairlineItalic-tlf-lgr.tfm \
tex-Ysabeau-HairlineItalic-tlf-ly1.tfm \
tex-Ysabeau-HairlineItalic-tlf-ot1.tfm \
tex-Ysabeau-HairlineItalic-tlf-qx--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-qx.tfm \
tex-Ysabeau-HairlineItalic-tlf-qx.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-cs.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-qx.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-qx.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t1.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t1.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t2a.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t2b.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t2c.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-t3.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t4.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t4.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t5.tfm \
tex-Ysabeau-HairlineItalic-tlf-swash-t5.vf \
tex-Ysabeau-HairlineItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-HairlineItalic-tlf-t1--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-t1.tfm \
tex-Ysabeau-HairlineItalic-tlf-t1.vf \
tex-Ysabeau-HairlineItalic-tlf-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-t2a.tfm \
tex-Ysabeau-HairlineItalic-tlf-t2a.vf \
tex-Ysabeau-HairlineItalic-tlf-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-t2b.tfm \
tex-Ysabeau-HairlineItalic-tlf-t2b.vf \
tex-Ysabeau-HairlineItalic-tlf-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-t2c.tfm \
tex-Ysabeau-HairlineItalic-tlf-t2c.vf \
tex-Ysabeau-HairlineItalic-tlf-t3.tfm \
tex-Ysabeau-HairlineItalic-tlf-t4--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-t4.tfm \
tex-Ysabeau-HairlineItalic-tlf-t4.vf \
tex-Ysabeau-HairlineItalic-tlf-t5--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-t5.tfm \
tex-Ysabeau-HairlineItalic-tlf-t5.vf \
tex-Ysabeau-HairlineItalic-tlf-ts1--base.tfm \
tex-Ysabeau-HairlineItalic-tlf-ts1.tfm \
tex-Ysabeau-HairlineItalic-tlf-ts1.vf \
tex-Ysabeau-HairlineItalic-tlf-ts3.tfm \
tex-Ysabeau-HairlineItalic-tosf-cs.tfm \
tex-Ysabeau-HairlineItalic-tosf-l7x.tfm \
tex-Ysabeau-HairlineItalic-tosf-lgr.tfm \
tex-Ysabeau-HairlineItalic-tosf-ly1.tfm \
tex-Ysabeau-HairlineItalic-tosf-ot1.tfm \
tex-Ysabeau-HairlineItalic-tosf-qx--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-qx.tfm \
tex-Ysabeau-HairlineItalic-tosf-qx.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-cs.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-qx.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-qx.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t1.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t1.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t2a.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t2b.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t2c.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-t3.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t4.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t4.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t5.tfm \
tex-Ysabeau-HairlineItalic-tosf-swash-t5.vf \
tex-Ysabeau-HairlineItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-HairlineItalic-tosf-t1--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-t1.tfm \
tex-Ysabeau-HairlineItalic-tosf-t1.vf \
tex-Ysabeau-HairlineItalic-tosf-t2a--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-t2a.tfm \
tex-Ysabeau-HairlineItalic-tosf-t2a.vf \
tex-Ysabeau-HairlineItalic-tosf-t2b--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-t2b.tfm \
tex-Ysabeau-HairlineItalic-tosf-t2b.vf \
tex-Ysabeau-HairlineItalic-tosf-t2c--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-t2c.tfm \
tex-Ysabeau-HairlineItalic-tosf-t2c.vf \
tex-Ysabeau-HairlineItalic-tosf-t3.tfm \
tex-Ysabeau-HairlineItalic-tosf-t4--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-t4.tfm \
tex-Ysabeau-HairlineItalic-tosf-t4.vf \
tex-Ysabeau-HairlineItalic-tosf-t5--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-t5.tfm \
tex-Ysabeau-HairlineItalic-tosf-t5.vf \
tex-Ysabeau-HairlineItalic-tosf-ts1--base.tfm \
tex-Ysabeau-HairlineItalic-tosf-ts1.tfm \
tex-Ysabeau-HairlineItalic-tosf-ts1.vf \
tex-Ysabeau-HairlineItalic-tosf-ts3.tfm \
tex-Ysabeau-Italic-dnom-cs.tfm \
tex-Ysabeau-Italic-dnom-l7x.tfm \
tex-Ysabeau-Italic-dnom-lgr.tfm \
tex-Ysabeau-Italic-dnom-ly1.tfm \
tex-Ysabeau-Italic-dnom-ot1.tfm \
tex-Ysabeau-Italic-dnom-qx--base.tfm \
tex-Ysabeau-Italic-dnom-qx.tfm \
tex-Ysabeau-Italic-dnom-qx.vf \
tex-Ysabeau-Italic-dnom-t1--base.tfm \
tex-Ysabeau-Italic-dnom-t1.tfm \
tex-Ysabeau-Italic-dnom-t1.vf \
tex-Ysabeau-Italic-dnom-t2a--base.tfm \
tex-Ysabeau-Italic-dnom-t2a.tfm \
tex-Ysabeau-Italic-dnom-t2a.vf \
tex-Ysabeau-Italic-dnom-t2b--base.tfm \
tex-Ysabeau-Italic-dnom-t2b.tfm \
tex-Ysabeau-Italic-dnom-t2b.vf \
tex-Ysabeau-Italic-dnom-t2c--base.tfm \
tex-Ysabeau-Italic-dnom-t2c.tfm \
tex-Ysabeau-Italic-dnom-t2c.vf \
tex-Ysabeau-Italic-dnom-t3.tfm \
tex-Ysabeau-Italic-dnom-t4--base.tfm \
tex-Ysabeau-Italic-dnom-t4.tfm \
tex-Ysabeau-Italic-dnom-t4.vf \
tex-Ysabeau-Italic-dnom-t5--base.tfm \
tex-Ysabeau-Italic-dnom-t5.tfm \
tex-Ysabeau-Italic-dnom-t5.vf \
tex-Ysabeau-Italic-dnom-ts3.tfm \
tex-Ysabeau-Italic-inf-cs.tfm \
tex-Ysabeau-Italic-inf-l7x.tfm \
tex-Ysabeau-Italic-inf-lgr.tfm \
tex-Ysabeau-Italic-inf-ly1.tfm \
tex-Ysabeau-Italic-inf-ot1.tfm \
tex-Ysabeau-Italic-inf-qx--base.tfm \
tex-Ysabeau-Italic-inf-qx.tfm \
tex-Ysabeau-Italic-inf-qx.vf \
tex-Ysabeau-Italic-inf-t1--base.tfm \
tex-Ysabeau-Italic-inf-t1.tfm \
tex-Ysabeau-Italic-inf-t1.vf \
tex-Ysabeau-Italic-inf-t2a--base.tfm \
tex-Ysabeau-Italic-inf-t2a.tfm \
tex-Ysabeau-Italic-inf-t2a.vf \
tex-Ysabeau-Italic-inf-t2b--base.tfm \
tex-Ysabeau-Italic-inf-t2b.tfm \
tex-Ysabeau-Italic-inf-t2b.vf \
tex-Ysabeau-Italic-inf-t2c--base.tfm \
tex-Ysabeau-Italic-inf-t2c.tfm \
tex-Ysabeau-Italic-inf-t2c.vf \
tex-Ysabeau-Italic-inf-t3.tfm \
tex-Ysabeau-Italic-inf-t4--base.tfm \
tex-Ysabeau-Italic-inf-t4.tfm \
tex-Ysabeau-Italic-inf-t4.vf \
tex-Ysabeau-Italic-inf-t5--base.tfm \
tex-Ysabeau-Italic-inf-t5.tfm \
tex-Ysabeau-Italic-inf-t5.vf \
tex-Ysabeau-Italic-inf-ts3.tfm \
tex-Ysabeau-Italic-lf-cs.tfm \
tex-Ysabeau-Italic-lf-l7x.tfm \
tex-Ysabeau-Italic-lf-lgr.tfm \
tex-Ysabeau-Italic-lf-ly1.tfm \
tex-Ysabeau-Italic-lf-ot1.tfm \
tex-Ysabeau-Italic-lf-qx--base.tfm \
tex-Ysabeau-Italic-lf-qx.tfm \
tex-Ysabeau-Italic-lf-qx.vf \
tex-Ysabeau-Italic-lf-swash-cs.tfm \
tex-Ysabeau-Italic-lf-swash-l7x.tfm \
tex-Ysabeau-Italic-lf-swash-lgr.tfm \
tex-Ysabeau-Italic-lf-swash-ly1.tfm \
tex-Ysabeau-Italic-lf-swash-ot1.tfm \
tex-Ysabeau-Italic-lf-swash-qx--base.tfm \
tex-Ysabeau-Italic-lf-swash-qx.tfm \
tex-Ysabeau-Italic-lf-swash-qx.vf \
tex-Ysabeau-Italic-lf-swash-t1--base.tfm \
tex-Ysabeau-Italic-lf-swash-t1.tfm \
tex-Ysabeau-Italic-lf-swash-t1.vf \
tex-Ysabeau-Italic-lf-swash-t2a--base.tfm \
tex-Ysabeau-Italic-lf-swash-t2a.tfm \
tex-Ysabeau-Italic-lf-swash-t2a.vf \
tex-Ysabeau-Italic-lf-swash-t2b--base.tfm \
tex-Ysabeau-Italic-lf-swash-t2b.tfm \
tex-Ysabeau-Italic-lf-swash-t2b.vf \
tex-Ysabeau-Italic-lf-swash-t2c--base.tfm \
tex-Ysabeau-Italic-lf-swash-t2c.tfm \
tex-Ysabeau-Italic-lf-swash-t2c.vf \
tex-Ysabeau-Italic-lf-swash-t3.tfm \
tex-Ysabeau-Italic-lf-swash-t4--base.tfm \
tex-Ysabeau-Italic-lf-swash-t4.tfm \
tex-Ysabeau-Italic-lf-swash-t4.vf \
tex-Ysabeau-Italic-lf-swash-t5--base.tfm \
tex-Ysabeau-Italic-lf-swash-t5.tfm \
tex-Ysabeau-Italic-lf-swash-t5.vf \
tex-Ysabeau-Italic-lf-swash-ts3.tfm \
tex-Ysabeau-Italic-lf-t1--base.tfm \
tex-Ysabeau-Italic-lf-t1.tfm \
tex-Ysabeau-Italic-lf-t1.vf \
tex-Ysabeau-Italic-lf-t2a--base.tfm \
tex-Ysabeau-Italic-lf-t2a.tfm \
tex-Ysabeau-Italic-lf-t2a.vf \
tex-Ysabeau-Italic-lf-t2b--base.tfm \
tex-Ysabeau-Italic-lf-t2b.tfm \
tex-Ysabeau-Italic-lf-t2b.vf \
tex-Ysabeau-Italic-lf-t2c--base.tfm \
tex-Ysabeau-Italic-lf-t2c.tfm \
tex-Ysabeau-Italic-lf-t2c.vf \
tex-Ysabeau-Italic-lf-t3.tfm \
tex-Ysabeau-Italic-lf-t4--base.tfm \
tex-Ysabeau-Italic-lf-t4.tfm \
tex-Ysabeau-Italic-lf-t4.vf \
tex-Ysabeau-Italic-lf-t5--base.tfm \
tex-Ysabeau-Italic-lf-t5.tfm \
tex-Ysabeau-Italic-lf-t5.vf \
tex-Ysabeau-Italic-lf-ts1--base.tfm \
tex-Ysabeau-Italic-lf-ts1.tfm \
tex-Ysabeau-Italic-lf-ts1.vf \
tex-Ysabeau-Italic-lf-ts3.tfm \
tex-Ysabeau-Italic-numr-cs.tfm \
tex-Ysabeau-Italic-numr-l7x.tfm \
tex-Ysabeau-Italic-numr-lgr.tfm \
tex-Ysabeau-Italic-numr-ly1.tfm \
tex-Ysabeau-Italic-numr-ot1.tfm \
tex-Ysabeau-Italic-numr-qx--base.tfm \
tex-Ysabeau-Italic-numr-qx.tfm \
tex-Ysabeau-Italic-numr-qx.vf \
tex-Ysabeau-Italic-numr-t1--base.tfm \
tex-Ysabeau-Italic-numr-t1.tfm \
tex-Ysabeau-Italic-numr-t1.vf \
tex-Ysabeau-Italic-numr-t2a--base.tfm \
tex-Ysabeau-Italic-numr-t2a.tfm \
tex-Ysabeau-Italic-numr-t2a.vf \
tex-Ysabeau-Italic-numr-t2b--base.tfm \
tex-Ysabeau-Italic-numr-t2b.tfm \
tex-Ysabeau-Italic-numr-t2b.vf \
tex-Ysabeau-Italic-numr-t2c--base.tfm \
tex-Ysabeau-Italic-numr-t2c.tfm \
tex-Ysabeau-Italic-numr-t2c.vf \
tex-Ysabeau-Italic-numr-t3.tfm \
tex-Ysabeau-Italic-numr-t4--base.tfm \
tex-Ysabeau-Italic-numr-t4.tfm \
tex-Ysabeau-Italic-numr-t4.vf \
tex-Ysabeau-Italic-numr-t5--base.tfm \
tex-Ysabeau-Italic-numr-t5.tfm \
tex-Ysabeau-Italic-numr-t5.vf \
tex-Ysabeau-Italic-numr-ts3.tfm \
tex-Ysabeau-Italic-osf-cs.tfm \
tex-Ysabeau-Italic-osf-l7x.tfm \
tex-Ysabeau-Italic-osf-lgr.tfm \
tex-Ysabeau-Italic-osf-ly1.tfm \
tex-Ysabeau-Italic-osf-ot1.tfm \
tex-Ysabeau-Italic-osf-qx--base.tfm \
tex-Ysabeau-Italic-osf-qx.tfm \
tex-Ysabeau-Italic-osf-qx.vf \
tex-Ysabeau-Italic-osf-swash-cs.tfm \
tex-Ysabeau-Italic-osf-swash-l7x.tfm \
tex-Ysabeau-Italic-osf-swash-lgr.tfm \
tex-Ysabeau-Italic-osf-swash-ly1.tfm \
tex-Ysabeau-Italic-osf-swash-ot1.tfm \
tex-Ysabeau-Italic-osf-swash-qx--base.tfm \
tex-Ysabeau-Italic-osf-swash-qx.tfm \
tex-Ysabeau-Italic-osf-swash-qx.vf \
tex-Ysabeau-Italic-osf-swash-t1--base.tfm \
tex-Ysabeau-Italic-osf-swash-t1.tfm \
tex-Ysabeau-Italic-osf-swash-t1.vf \
tex-Ysabeau-Italic-osf-swash-t2a--base.tfm \
tex-Ysabeau-Italic-osf-swash-t2a.tfm \
tex-Ysabeau-Italic-osf-swash-t2a.vf \
tex-Ysabeau-Italic-osf-swash-t2b--base.tfm \
tex-Ysabeau-Italic-osf-swash-t2b.tfm \
tex-Ysabeau-Italic-osf-swash-t2b.vf \
tex-Ysabeau-Italic-osf-swash-t2c--base.tfm \
tex-Ysabeau-Italic-osf-swash-t2c.tfm \
tex-Ysabeau-Italic-osf-swash-t2c.vf \
tex-Ysabeau-Italic-osf-swash-t3.tfm \
tex-Ysabeau-Italic-osf-swash-t4--base.tfm \
tex-Ysabeau-Italic-osf-swash-t4.tfm \
tex-Ysabeau-Italic-osf-swash-t4.vf \
tex-Ysabeau-Italic-osf-swash-t5--base.tfm \
tex-Ysabeau-Italic-osf-swash-t5.tfm \
tex-Ysabeau-Italic-osf-swash-t5.vf \
tex-Ysabeau-Italic-osf-swash-ts3.tfm \
tex-Ysabeau-Italic-osf-t1--base.tfm \
tex-Ysabeau-Italic-osf-t1.tfm \
tex-Ysabeau-Italic-osf-t1.vf \
tex-Ysabeau-Italic-osf-t2a--base.tfm \
tex-Ysabeau-Italic-osf-t2a.tfm \
tex-Ysabeau-Italic-osf-t2a.vf \
tex-Ysabeau-Italic-osf-t2b--base.tfm \
tex-Ysabeau-Italic-osf-t2b.tfm \
tex-Ysabeau-Italic-osf-t2b.vf \
tex-Ysabeau-Italic-osf-t2c--base.tfm \
tex-Ysabeau-Italic-osf-t2c.tfm \
tex-Ysabeau-Italic-osf-t2c.vf \
tex-Ysabeau-Italic-osf-t3.tfm \
tex-Ysabeau-Italic-osf-t4--base.tfm \
tex-Ysabeau-Italic-osf-t4.tfm \
tex-Ysabeau-Italic-osf-t4.vf \
tex-Ysabeau-Italic-osf-t5--base.tfm \
tex-Ysabeau-Italic-osf-t5.tfm \
tex-Ysabeau-Italic-osf-t5.vf \
tex-Ysabeau-Italic-osf-ts1--base.tfm \
tex-Ysabeau-Italic-osf-ts1.tfm \
tex-Ysabeau-Italic-osf-ts1.vf \
tex-Ysabeau-Italic-osf-ts3.tfm \
tex-Ysabeau-Italic-sup-cs.tfm \
tex-Ysabeau-Italic-sup-l7x.tfm \
tex-Ysabeau-Italic-sup-lgr.tfm \
tex-Ysabeau-Italic-sup-ly1.tfm \
tex-Ysabeau-Italic-sup-ot1.tfm \
tex-Ysabeau-Italic-sup-qx--base.tfm \
tex-Ysabeau-Italic-sup-qx.tfm \
tex-Ysabeau-Italic-sup-qx.vf \
tex-Ysabeau-Italic-sup-t1--base.tfm \
tex-Ysabeau-Italic-sup-t1.tfm \
tex-Ysabeau-Italic-sup-t1.vf \
tex-Ysabeau-Italic-sup-t2a--base.tfm \
tex-Ysabeau-Italic-sup-t2a.tfm \
tex-Ysabeau-Italic-sup-t2a.vf \
tex-Ysabeau-Italic-sup-t2b--base.tfm \
tex-Ysabeau-Italic-sup-t2b.tfm \
tex-Ysabeau-Italic-sup-t2b.vf \
tex-Ysabeau-Italic-sup-t2c--base.tfm \
tex-Ysabeau-Italic-sup-t2c.tfm \
tex-Ysabeau-Italic-sup-t2c.vf \
tex-Ysabeau-Italic-sup-t3.tfm \
tex-Ysabeau-Italic-sup-t4--base.tfm \
tex-Ysabeau-Italic-sup-t4.tfm \
tex-Ysabeau-Italic-sup-t4.vf \
tex-Ysabeau-Italic-sup-t5--base.tfm \
tex-Ysabeau-Italic-sup-t5.tfm \
tex-Ysabeau-Italic-sup-t5.vf \
tex-Ysabeau-Italic-sup-ts3.tfm \
tex-Ysabeau-Italic-tlf-cs.tfm \
tex-Ysabeau-Italic-tlf-l7x.tfm \
tex-Ysabeau-Italic-tlf-lgr.tfm \
tex-Ysabeau-Italic-tlf-ly1.tfm \
tex-Ysabeau-Italic-tlf-ot1.tfm \
tex-Ysabeau-Italic-tlf-qx--base.tfm \
tex-Ysabeau-Italic-tlf-qx.tfm \
tex-Ysabeau-Italic-tlf-qx.vf \
tex-Ysabeau-Italic-tlf-swash-cs.tfm \
tex-Ysabeau-Italic-tlf-swash-l7x.tfm \
tex-Ysabeau-Italic-tlf-swash-lgr.tfm \
tex-Ysabeau-Italic-tlf-swash-ly1.tfm \
tex-Ysabeau-Italic-tlf-swash-ot1.tfm \
tex-Ysabeau-Italic-tlf-swash-qx--base.tfm \
tex-Ysabeau-Italic-tlf-swash-qx.tfm \
tex-Ysabeau-Italic-tlf-swash-qx.vf \
tex-Ysabeau-Italic-tlf-swash-t1--base.tfm \
tex-Ysabeau-Italic-tlf-swash-t1.tfm \
tex-Ysabeau-Italic-tlf-swash-t1.vf \
tex-Ysabeau-Italic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-Italic-tlf-swash-t2a.tfm \
tex-Ysabeau-Italic-tlf-swash-t2a.vf \
tex-Ysabeau-Italic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-Italic-tlf-swash-t2b.tfm \
tex-Ysabeau-Italic-tlf-swash-t2b.vf \
tex-Ysabeau-Italic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-Italic-tlf-swash-t2c.tfm \
tex-Ysabeau-Italic-tlf-swash-t2c.vf \
tex-Ysabeau-Italic-tlf-swash-t3.tfm \
tex-Ysabeau-Italic-tlf-swash-t4--base.tfm \
tex-Ysabeau-Italic-tlf-swash-t4.tfm \
tex-Ysabeau-Italic-tlf-swash-t4.vf \
tex-Ysabeau-Italic-tlf-swash-t5--base.tfm \
tex-Ysabeau-Italic-tlf-swash-t5.tfm \
tex-Ysabeau-Italic-tlf-swash-t5.vf \
tex-Ysabeau-Italic-tlf-swash-ts3.tfm \
tex-Ysabeau-Italic-tlf-t1--base.tfm \
tex-Ysabeau-Italic-tlf-t1.tfm \
tex-Ysabeau-Italic-tlf-t1.vf \
tex-Ysabeau-Italic-tlf-t2a--base.tfm \
tex-Ysabeau-Italic-tlf-t2a.tfm \
tex-Ysabeau-Italic-tlf-t2a.vf \
tex-Ysabeau-Italic-tlf-t2b--base.tfm \
tex-Ysabeau-Italic-tlf-t2b.tfm \
tex-Ysabeau-Italic-tlf-t2b.vf \
tex-Ysabeau-Italic-tlf-t2c--base.tfm \
tex-Ysabeau-Italic-tlf-t2c.tfm \
tex-Ysabeau-Italic-tlf-t2c.vf \
tex-Ysabeau-Italic-tlf-t3.tfm \
tex-Ysabeau-Italic-tlf-t4--base.tfm \
tex-Ysabeau-Italic-tlf-t4.tfm \
tex-Ysabeau-Italic-tlf-t4.vf \
tex-Ysabeau-Italic-tlf-t5--base.tfm \
tex-Ysabeau-Italic-tlf-t5.tfm \
tex-Ysabeau-Italic-tlf-t5.vf \
tex-Ysabeau-Italic-tlf-ts1--base.tfm \
tex-Ysabeau-Italic-tlf-ts1.tfm \
tex-Ysabeau-Italic-tlf-ts1.vf \
tex-Ysabeau-Italic-tlf-ts3.tfm \
tex-Ysabeau-Italic-tosf-cs.tfm \
tex-Ysabeau-Italic-tosf-l7x.tfm \
tex-Ysabeau-Italic-tosf-lgr.tfm \
tex-Ysabeau-Italic-tosf-ly1.tfm \
tex-Ysabeau-Italic-tosf-ot1.tfm \
tex-Ysabeau-Italic-tosf-qx--base.tfm \
tex-Ysabeau-Italic-tosf-qx.tfm \
tex-Ysabeau-Italic-tosf-qx.vf \
tex-Ysabeau-Italic-tosf-swash-cs.tfm \
tex-Ysabeau-Italic-tosf-swash-l7x.tfm \
tex-Ysabeau-Italic-tosf-swash-lgr.tfm \
tex-Ysabeau-Italic-tosf-swash-ly1.tfm \
tex-Ysabeau-Italic-tosf-swash-ot1.tfm \
tex-Ysabeau-Italic-tosf-swash-qx--base.tfm \
tex-Ysabeau-Italic-tosf-swash-qx.tfm \
tex-Ysabeau-Italic-tosf-swash-qx.vf \
tex-Ysabeau-Italic-tosf-swash-t1--base.tfm \
tex-Ysabeau-Italic-tosf-swash-t1.tfm \
tex-Ysabeau-Italic-tosf-swash-t1.vf \
tex-Ysabeau-Italic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-Italic-tosf-swash-t2a.tfm \
tex-Ysabeau-Italic-tosf-swash-t2a.vf \
tex-Ysabeau-Italic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-Italic-tosf-swash-t2b.tfm \
tex-Ysabeau-Italic-tosf-swash-t2b.vf \
tex-Ysabeau-Italic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-Italic-tosf-swash-t2c.tfm \
tex-Ysabeau-Italic-tosf-swash-t2c.vf \
tex-Ysabeau-Italic-tosf-swash-t3.tfm \
tex-Ysabeau-Italic-tosf-swash-t4--base.tfm \
tex-Ysabeau-Italic-tosf-swash-t4.tfm \
tex-Ysabeau-Italic-tosf-swash-t4.vf \
tex-Ysabeau-Italic-tosf-swash-t5--base.tfm \
tex-Ysabeau-Italic-tosf-swash-t5.tfm \
tex-Ysabeau-Italic-tosf-swash-t5.vf \
tex-Ysabeau-Italic-tosf-swash-ts3.tfm \
tex-Ysabeau-Italic-tosf-t1--base.tfm \
tex-Ysabeau-Italic-tosf-t1.tfm \
tex-Ysabeau-Italic-tosf-t1.vf \
tex-Ysabeau-Italic-tosf-t2a--base.tfm \
tex-Ysabeau-Italic-tosf-t2a.tfm \
tex-Ysabeau-Italic-tosf-t2a.vf \
tex-Ysabeau-Italic-tosf-t2b--base.tfm \
tex-Ysabeau-Italic-tosf-t2b.tfm \
tex-Ysabeau-Italic-tosf-t2b.vf \
tex-Ysabeau-Italic-tosf-t2c--base.tfm \
tex-Ysabeau-Italic-tosf-t2c.tfm \
tex-Ysabeau-Italic-tosf-t2c.vf \
tex-Ysabeau-Italic-tosf-t3.tfm \
tex-Ysabeau-Italic-tosf-t4--base.tfm \
tex-Ysabeau-Italic-tosf-t4.tfm \
tex-Ysabeau-Italic-tosf-t4.vf \
tex-Ysabeau-Italic-tosf-t5--base.tfm \
tex-Ysabeau-Italic-tosf-t5.tfm \
tex-Ysabeau-Italic-tosf-t5.vf \
tex-Ysabeau-Italic-tosf-ts1--base.tfm \
tex-Ysabeau-Italic-tosf-ts1.tfm \
tex-Ysabeau-Italic-tosf-ts1.vf \
tex-Ysabeau-Italic-tosf-ts3.tfm \
tex-Ysabeau-Light-dnom-cs.tfm \
tex-Ysabeau-Light-dnom-l7x.tfm \
tex-Ysabeau-Light-dnom-lgr.tfm \
tex-Ysabeau-Light-dnom-ly1.tfm \
tex-Ysabeau-Light-dnom-ot1.tfm \
tex-Ysabeau-Light-dnom-qx--base.tfm \
tex-Ysabeau-Light-dnom-qx.tfm \
tex-Ysabeau-Light-dnom-qx.vf \
tex-Ysabeau-Light-dnom-t1--base.tfm \
tex-Ysabeau-Light-dnom-t1.tfm \
tex-Ysabeau-Light-dnom-t1.vf \
tex-Ysabeau-Light-dnom-t2a--base.tfm \
tex-Ysabeau-Light-dnom-t2a.tfm \
tex-Ysabeau-Light-dnom-t2a.vf \
tex-Ysabeau-Light-dnom-t2b--base.tfm \
tex-Ysabeau-Light-dnom-t2b.tfm \
tex-Ysabeau-Light-dnom-t2b.vf \
tex-Ysabeau-Light-dnom-t2c--base.tfm \
tex-Ysabeau-Light-dnom-t2c.tfm \
tex-Ysabeau-Light-dnom-t2c.vf \
tex-Ysabeau-Light-dnom-t3.tfm \
tex-Ysabeau-Light-dnom-t4--base.tfm \
tex-Ysabeau-Light-dnom-t4.tfm \
tex-Ysabeau-Light-dnom-t4.vf \
tex-Ysabeau-Light-dnom-t5--base.tfm \
tex-Ysabeau-Light-dnom-t5.tfm \
tex-Ysabeau-Light-dnom-t5.vf \
tex-Ysabeau-Light-dnom-ts3.tfm \
tex-Ysabeau-Light-inf-cs.tfm \
tex-Ysabeau-Light-inf-l7x.tfm \
tex-Ysabeau-Light-inf-lgr.tfm \
tex-Ysabeau-Light-inf-ly1.tfm \
tex-Ysabeau-Light-inf-ot1.tfm \
tex-Ysabeau-Light-inf-qx--base.tfm \
tex-Ysabeau-Light-inf-qx.tfm \
tex-Ysabeau-Light-inf-qx.vf \
tex-Ysabeau-Light-inf-t1--base.tfm \
tex-Ysabeau-Light-inf-t1.tfm \
tex-Ysabeau-Light-inf-t1.vf \
tex-Ysabeau-Light-inf-t2a--base.tfm \
tex-Ysabeau-Light-inf-t2a.tfm \
tex-Ysabeau-Light-inf-t2a.vf \
tex-Ysabeau-Light-inf-t2b--base.tfm \
tex-Ysabeau-Light-inf-t2b.tfm \
tex-Ysabeau-Light-inf-t2b.vf \
tex-Ysabeau-Light-inf-t2c--base.tfm \
tex-Ysabeau-Light-inf-t2c.tfm \
tex-Ysabeau-Light-inf-t2c.vf \
tex-Ysabeau-Light-inf-t3.tfm \
tex-Ysabeau-Light-inf-t4--base.tfm \
tex-Ysabeau-Light-inf-t4.tfm \
tex-Ysabeau-Light-inf-t4.vf \
tex-Ysabeau-Light-inf-t5--base.tfm \
tex-Ysabeau-Light-inf-t5.tfm \
tex-Ysabeau-Light-inf-t5.vf \
tex-Ysabeau-Light-inf-ts3.tfm \
tex-Ysabeau-Light-lf-cs.tfm \
tex-Ysabeau-Light-lf-l7x.tfm \
tex-Ysabeau-Light-lf-lgr.tfm \
tex-Ysabeau-Light-lf-ly1.tfm \
tex-Ysabeau-Light-lf-ot1.tfm \
tex-Ysabeau-Light-lf-qx--base.tfm \
tex-Ysabeau-Light-lf-qx.tfm \
tex-Ysabeau-Light-lf-qx.vf \
tex-Ysabeau-Light-lf-sc-cs--base.tfm \
tex-Ysabeau-Light-lf-sc-cs.tfm \
tex-Ysabeau-Light-lf-sc-cs.vf \
tex-Ysabeau-Light-lf-sc-l7x--base.tfm \
tex-Ysabeau-Light-lf-sc-l7x.tfm \
tex-Ysabeau-Light-lf-sc-l7x.vf \
tex-Ysabeau-Light-lf-sc-lgr.tfm \
tex-Ysabeau-Light-lf-sc-ly1--base.tfm \
tex-Ysabeau-Light-lf-sc-ly1.tfm \
tex-Ysabeau-Light-lf-sc-ly1.vf \
tex-Ysabeau-Light-lf-sc-ot1--base.tfm \
tex-Ysabeau-Light-lf-sc-ot1.tfm \
tex-Ysabeau-Light-lf-sc-ot1.vf \
tex-Ysabeau-Light-lf-sc-qx--base.tfm \
tex-Ysabeau-Light-lf-sc-qx.tfm \
tex-Ysabeau-Light-lf-sc-qx.vf \
tex-Ysabeau-Light-lf-sc-t1--base.tfm \
tex-Ysabeau-Light-lf-sc-t1.tfm \
tex-Ysabeau-Light-lf-sc-t1.vf \
tex-Ysabeau-Light-lf-sc-t2a--base.tfm \
tex-Ysabeau-Light-lf-sc-t2a.tfm \
tex-Ysabeau-Light-lf-sc-t2a.vf \
tex-Ysabeau-Light-lf-sc-t2b--base.tfm \
tex-Ysabeau-Light-lf-sc-t2b.tfm \
tex-Ysabeau-Light-lf-sc-t2b.vf \
tex-Ysabeau-Light-lf-sc-t2c--base.tfm \
tex-Ysabeau-Light-lf-sc-t2c.tfm \
tex-Ysabeau-Light-lf-sc-t2c.vf \
tex-Ysabeau-Light-lf-sc-t3.tfm \
tex-Ysabeau-Light-lf-sc-t4--base.tfm \
tex-Ysabeau-Light-lf-sc-t4.tfm \
tex-Ysabeau-Light-lf-sc-t4.vf \
tex-Ysabeau-Light-lf-sc-t5--base.tfm \
tex-Ysabeau-Light-lf-sc-t5.tfm \
tex-Ysabeau-Light-lf-sc-t5.vf \
tex-Ysabeau-Light-lf-sc-ts3--base.tfm \
tex-Ysabeau-Light-lf-sc-ts3.tfm \
tex-Ysabeau-Light-lf-sc-ts3.vf \
tex-Ysabeau-Light-lf-t1--base.tfm \
tex-Ysabeau-Light-lf-t1.tfm \
tex-Ysabeau-Light-lf-t1.vf \
tex-Ysabeau-Light-lf-t2a--base.tfm \
tex-Ysabeau-Light-lf-t2a.tfm \
tex-Ysabeau-Light-lf-t2a.vf \
tex-Ysabeau-Light-lf-t2b--base.tfm \
tex-Ysabeau-Light-lf-t2b.tfm \
tex-Ysabeau-Light-lf-t2b.vf \
tex-Ysabeau-Light-lf-t2c--base.tfm \
tex-Ysabeau-Light-lf-t2c.tfm \
tex-Ysabeau-Light-lf-t2c.vf \
tex-Ysabeau-Light-lf-t3.tfm \
tex-Ysabeau-Light-lf-t4--base.tfm \
tex-Ysabeau-Light-lf-t4.tfm \
tex-Ysabeau-Light-lf-t4.vf \
tex-Ysabeau-Light-lf-t5--base.tfm \
tex-Ysabeau-Light-lf-t5.tfm \
tex-Ysabeau-Light-lf-t5.vf \
tex-Ysabeau-Light-lf-ts1--base.tfm \
tex-Ysabeau-Light-lf-ts1.tfm \
tex-Ysabeau-Light-lf-ts1.vf \
tex-Ysabeau-Light-lf-ts3.tfm \
tex-Ysabeau-Light-numr-cs.tfm \
tex-Ysabeau-Light-numr-l7x.tfm \
tex-Ysabeau-Light-numr-lgr.tfm \
tex-Ysabeau-Light-numr-ly1.tfm \
tex-Ysabeau-Light-numr-ot1.tfm \
tex-Ysabeau-Light-numr-qx--base.tfm \
tex-Ysabeau-Light-numr-qx.tfm \
tex-Ysabeau-Light-numr-qx.vf \
tex-Ysabeau-Light-numr-t1--base.tfm \
tex-Ysabeau-Light-numr-t1.tfm \
tex-Ysabeau-Light-numr-t1.vf \
tex-Ysabeau-Light-numr-t2a--base.tfm \
tex-Ysabeau-Light-numr-t2a.tfm \
tex-Ysabeau-Light-numr-t2a.vf \
tex-Ysabeau-Light-numr-t2b--base.tfm \
tex-Ysabeau-Light-numr-t2b.tfm \
tex-Ysabeau-Light-numr-t2b.vf \
tex-Ysabeau-Light-numr-t2c--base.tfm \
tex-Ysabeau-Light-numr-t2c.tfm \
tex-Ysabeau-Light-numr-t2c.vf \
tex-Ysabeau-Light-numr-t3.tfm \
tex-Ysabeau-Light-numr-t4--base.tfm \
tex-Ysabeau-Light-numr-t4.tfm \
tex-Ysabeau-Light-numr-t4.vf \
tex-Ysabeau-Light-numr-t5--base.tfm \
tex-Ysabeau-Light-numr-t5.tfm \
tex-Ysabeau-Light-numr-t5.vf \
tex-Ysabeau-Light-numr-ts3.tfm \
tex-Ysabeau-Light-osf-cs.tfm \
tex-Ysabeau-Light-osf-l7x.tfm \
tex-Ysabeau-Light-osf-lgr.tfm \
tex-Ysabeau-Light-osf-ly1.tfm \
tex-Ysabeau-Light-osf-ot1.tfm \
tex-Ysabeau-Light-osf-qx--base.tfm \
tex-Ysabeau-Light-osf-qx.tfm \
tex-Ysabeau-Light-osf-qx.vf \
tex-Ysabeau-Light-osf-sc-cs--base.tfm \
tex-Ysabeau-Light-osf-sc-cs.tfm \
tex-Ysabeau-Light-osf-sc-cs.vf \
tex-Ysabeau-Light-osf-sc-l7x--base.tfm \
tex-Ysabeau-Light-osf-sc-l7x.tfm \
tex-Ysabeau-Light-osf-sc-l7x.vf \
tex-Ysabeau-Light-osf-sc-lgr.tfm \
tex-Ysabeau-Light-osf-sc-ly1--base.tfm \
tex-Ysabeau-Light-osf-sc-ly1.tfm \
tex-Ysabeau-Light-osf-sc-ly1.vf \
tex-Ysabeau-Light-osf-sc-ot1--base.tfm \
tex-Ysabeau-Light-osf-sc-ot1.tfm \
tex-Ysabeau-Light-osf-sc-ot1.vf \
tex-Ysabeau-Light-osf-sc-qx--base.tfm \
tex-Ysabeau-Light-osf-sc-qx.tfm \
tex-Ysabeau-Light-osf-sc-qx.vf \
tex-Ysabeau-Light-osf-sc-t1--base.tfm \
tex-Ysabeau-Light-osf-sc-t1.tfm \
tex-Ysabeau-Light-osf-sc-t1.vf \
tex-Ysabeau-Light-osf-sc-t2a--base.tfm \
tex-Ysabeau-Light-osf-sc-t2a.tfm \
tex-Ysabeau-Light-osf-sc-t2a.vf \
tex-Ysabeau-Light-osf-sc-t2b--base.tfm \
tex-Ysabeau-Light-osf-sc-t2b.tfm \
tex-Ysabeau-Light-osf-sc-t2b.vf \
tex-Ysabeau-Light-osf-sc-t2c--base.tfm \
tex-Ysabeau-Light-osf-sc-t2c.tfm \
tex-Ysabeau-Light-osf-sc-t2c.vf \
tex-Ysabeau-Light-osf-sc-t3.tfm \
tex-Ysabeau-Light-osf-sc-t4--base.tfm \
tex-Ysabeau-Light-osf-sc-t4.tfm \
tex-Ysabeau-Light-osf-sc-t4.vf \
tex-Ysabeau-Light-osf-sc-t5--base.tfm \
tex-Ysabeau-Light-osf-sc-t5.tfm \
tex-Ysabeau-Light-osf-sc-t5.vf \
tex-Ysabeau-Light-osf-sc-ts3--base.tfm \
tex-Ysabeau-Light-osf-sc-ts3.tfm \
tex-Ysabeau-Light-osf-sc-ts3.vf \
tex-Ysabeau-Light-osf-t1--base.tfm \
tex-Ysabeau-Light-osf-t1.tfm \
tex-Ysabeau-Light-osf-t1.vf \
tex-Ysabeau-Light-osf-t2a--base.tfm \
tex-Ysabeau-Light-osf-t2a.tfm \
tex-Ysabeau-Light-osf-t2a.vf \
tex-Ysabeau-Light-osf-t2b--base.tfm \
tex-Ysabeau-Light-osf-t2b.tfm \
tex-Ysabeau-Light-osf-t2b.vf \
tex-Ysabeau-Light-osf-t2c--base.tfm \
tex-Ysabeau-Light-osf-t2c.tfm \
tex-Ysabeau-Light-osf-t2c.vf \
tex-Ysabeau-Light-osf-t3.tfm \
tex-Ysabeau-Light-osf-t4--base.tfm \
tex-Ysabeau-Light-osf-t4.tfm \
tex-Ysabeau-Light-osf-t4.vf \
tex-Ysabeau-Light-osf-t5--base.tfm \
tex-Ysabeau-Light-osf-t5.tfm \
tex-Ysabeau-Light-osf-t5.vf \
tex-Ysabeau-Light-osf-ts1--base.tfm \
tex-Ysabeau-Light-osf-ts1.tfm \
tex-Ysabeau-Light-osf-ts1.vf \
tex-Ysabeau-Light-osf-ts3.tfm \
tex-Ysabeau-Light-sup-cs.tfm \
tex-Ysabeau-Light-sup-l7x.tfm \
tex-Ysabeau-Light-sup-lgr.tfm \
tex-Ysabeau-Light-sup-ly1.tfm \
tex-Ysabeau-Light-sup-ot1.tfm \
tex-Ysabeau-Light-sup-qx--base.tfm \
tex-Ysabeau-Light-sup-qx.tfm \
tex-Ysabeau-Light-sup-qx.vf \
tex-Ysabeau-Light-sup-t1--base.tfm \
tex-Ysabeau-Light-sup-t1.tfm \
tex-Ysabeau-Light-sup-t1.vf \
tex-Ysabeau-Light-sup-t2a--base.tfm \
tex-Ysabeau-Light-sup-t2a.tfm \
tex-Ysabeau-Light-sup-t2a.vf \
tex-Ysabeau-Light-sup-t2b--base.tfm \
tex-Ysabeau-Light-sup-t2b.tfm \
tex-Ysabeau-Light-sup-t2b.vf \
tex-Ysabeau-Light-sup-t2c--base.tfm \
tex-Ysabeau-Light-sup-t2c.tfm \
tex-Ysabeau-Light-sup-t2c.vf \
tex-Ysabeau-Light-sup-t3.tfm \
tex-Ysabeau-Light-sup-t4--base.tfm \
tex-Ysabeau-Light-sup-t4.tfm \
tex-Ysabeau-Light-sup-t4.vf \
tex-Ysabeau-Light-sup-t5--base.tfm \
tex-Ysabeau-Light-sup-t5.tfm \
tex-Ysabeau-Light-sup-t5.vf \
tex-Ysabeau-Light-sup-ts3.tfm \
tex-Ysabeau-Light-tlf-cs.tfm \
tex-Ysabeau-Light-tlf-l7x.tfm \
tex-Ysabeau-Light-tlf-lgr.tfm \
tex-Ysabeau-Light-tlf-ly1.tfm \
tex-Ysabeau-Light-tlf-ot1.tfm \
tex-Ysabeau-Light-tlf-qx--base.tfm \
tex-Ysabeau-Light-tlf-qx.tfm \
tex-Ysabeau-Light-tlf-qx.vf \
tex-Ysabeau-Light-tlf-sc-cs--base.tfm \
tex-Ysabeau-Light-tlf-sc-cs.tfm \
tex-Ysabeau-Light-tlf-sc-cs.vf \
tex-Ysabeau-Light-tlf-sc-l7x--base.tfm \
tex-Ysabeau-Light-tlf-sc-l7x.tfm \
tex-Ysabeau-Light-tlf-sc-l7x.vf \
tex-Ysabeau-Light-tlf-sc-lgr.tfm \
tex-Ysabeau-Light-tlf-sc-ly1--base.tfm \
tex-Ysabeau-Light-tlf-sc-ly1.tfm \
tex-Ysabeau-Light-tlf-sc-ly1.vf \
tex-Ysabeau-Light-tlf-sc-ot1--base.tfm \
tex-Ysabeau-Light-tlf-sc-ot1.tfm \
tex-Ysabeau-Light-tlf-sc-ot1.vf \
tex-Ysabeau-Light-tlf-sc-qx--base.tfm \
tex-Ysabeau-Light-tlf-sc-qx.tfm \
tex-Ysabeau-Light-tlf-sc-qx.vf \
tex-Ysabeau-Light-tlf-sc-t1--base.tfm \
tex-Ysabeau-Light-tlf-sc-t1.tfm \
tex-Ysabeau-Light-tlf-sc-t1.vf \
tex-Ysabeau-Light-tlf-sc-t2a--base.tfm \
tex-Ysabeau-Light-tlf-sc-t2a.tfm \
tex-Ysabeau-Light-tlf-sc-t2a.vf \
tex-Ysabeau-Light-tlf-sc-t2b--base.tfm \
tex-Ysabeau-Light-tlf-sc-t2b.tfm \
tex-Ysabeau-Light-tlf-sc-t2b.vf \
tex-Ysabeau-Light-tlf-sc-t2c--base.tfm \
tex-Ysabeau-Light-tlf-sc-t2c.tfm \
tex-Ysabeau-Light-tlf-sc-t2c.vf \
tex-Ysabeau-Light-tlf-sc-t3.tfm \
tex-Ysabeau-Light-tlf-sc-t4--base.tfm \
tex-Ysabeau-Light-tlf-sc-t4.tfm \
tex-Ysabeau-Light-tlf-sc-t4.vf \
tex-Ysabeau-Light-tlf-sc-t5--base.tfm \
tex-Ysabeau-Light-tlf-sc-t5.tfm \
tex-Ysabeau-Light-tlf-sc-t5.vf \
tex-Ysabeau-Light-tlf-sc-ts3--base.tfm \
tex-Ysabeau-Light-tlf-sc-ts3.tfm \
tex-Ysabeau-Light-tlf-sc-ts3.vf \
tex-Ysabeau-Light-tlf-t1--base.tfm \
tex-Ysabeau-Light-tlf-t1.tfm \
tex-Ysabeau-Light-tlf-t1.vf \
tex-Ysabeau-Light-tlf-t2a--base.tfm \
tex-Ysabeau-Light-tlf-t2a.tfm \
tex-Ysabeau-Light-tlf-t2a.vf \
tex-Ysabeau-Light-tlf-t2b--base.tfm \
tex-Ysabeau-Light-tlf-t2b.tfm \
tex-Ysabeau-Light-tlf-t2b.vf \
tex-Ysabeau-Light-tlf-t2c--base.tfm \
tex-Ysabeau-Light-tlf-t2c.tfm \
tex-Ysabeau-Light-tlf-t2c.vf \
tex-Ysabeau-Light-tlf-t3.tfm \
tex-Ysabeau-Light-tlf-t4--base.tfm \
tex-Ysabeau-Light-tlf-t4.tfm \
tex-Ysabeau-Light-tlf-t4.vf \
tex-Ysabeau-Light-tlf-t5--base.tfm \
tex-Ysabeau-Light-tlf-t5.tfm \
tex-Ysabeau-Light-tlf-t5.vf \
tex-Ysabeau-Light-tlf-ts1--base.tfm \
tex-Ysabeau-Light-tlf-ts1.tfm \
tex-Ysabeau-Light-tlf-ts1.vf \
tex-Ysabeau-Light-tlf-ts3.tfm \
tex-Ysabeau-Light-tosf-cs.tfm \
tex-Ysabeau-Light-tosf-l7x.tfm \
tex-Ysabeau-Light-tosf-lgr.tfm \
tex-Ysabeau-Light-tosf-ly1.tfm \
tex-Ysabeau-Light-tosf-ot1.tfm \
tex-Ysabeau-Light-tosf-qx--base.tfm \
tex-Ysabeau-Light-tosf-qx.tfm \
tex-Ysabeau-Light-tosf-qx.vf \
tex-Ysabeau-Light-tosf-sc-cs--base.tfm \
tex-Ysabeau-Light-tosf-sc-cs.tfm \
tex-Ysabeau-Light-tosf-sc-cs.vf \
tex-Ysabeau-Light-tosf-sc-l7x--base.tfm \
tex-Ysabeau-Light-tosf-sc-l7x.tfm \
tex-Ysabeau-Light-tosf-sc-l7x.vf \
tex-Ysabeau-Light-tosf-sc-lgr.tfm \
tex-Ysabeau-Light-tosf-sc-ly1--base.tfm \
tex-Ysabeau-Light-tosf-sc-ly1.tfm \
tex-Ysabeau-Light-tosf-sc-ly1.vf \
tex-Ysabeau-Light-tosf-sc-ot1--base.tfm \
tex-Ysabeau-Light-tosf-sc-ot1.tfm \
tex-Ysabeau-Light-tosf-sc-ot1.vf \
tex-Ysabeau-Light-tosf-sc-qx--base.tfm \
tex-Ysabeau-Light-tosf-sc-qx.tfm \
tex-Ysabeau-Light-tosf-sc-qx.vf \
tex-Ysabeau-Light-tosf-sc-t1--base.tfm \
tex-Ysabeau-Light-tosf-sc-t1.tfm \
tex-Ysabeau-Light-tosf-sc-t1.vf \
tex-Ysabeau-Light-tosf-sc-t2a--base.tfm \
tex-Ysabeau-Light-tosf-sc-t2a.tfm \
tex-Ysabeau-Light-tosf-sc-t2a.vf \
tex-Ysabeau-Light-tosf-sc-t2b--base.tfm \
tex-Ysabeau-Light-tosf-sc-t2b.tfm \
tex-Ysabeau-Light-tosf-sc-t2b.vf \
tex-Ysabeau-Light-tosf-sc-t2c--base.tfm \
tex-Ysabeau-Light-tosf-sc-t2c.tfm \
tex-Ysabeau-Light-tosf-sc-t2c.vf \
tex-Ysabeau-Light-tosf-sc-t3.tfm \
tex-Ysabeau-Light-tosf-sc-t4--base.tfm \
tex-Ysabeau-Light-tosf-sc-t4.tfm \
tex-Ysabeau-Light-tosf-sc-t4.vf \
tex-Ysabeau-Light-tosf-sc-t5--base.tfm \
tex-Ysabeau-Light-tosf-sc-t5.tfm \
tex-Ysabeau-Light-tosf-sc-t5.vf \
tex-Ysabeau-Light-tosf-sc-ts3--base.tfm \
tex-Ysabeau-Light-tosf-sc-ts3.tfm \
tex-Ysabeau-Light-tosf-sc-ts3.vf \
tex-Ysabeau-Light-tosf-t1--base.tfm \
tex-Ysabeau-Light-tosf-t1.tfm \
tex-Ysabeau-Light-tosf-t1.vf \
tex-Ysabeau-Light-tosf-t2a--base.tfm \
tex-Ysabeau-Light-tosf-t2a.tfm \
tex-Ysabeau-Light-tosf-t2a.vf \
tex-Ysabeau-Light-tosf-t2b--base.tfm \
tex-Ysabeau-Light-tosf-t2b.tfm \
tex-Ysabeau-Light-tosf-t2b.vf \
tex-Ysabeau-Light-tosf-t2c--base.tfm \
tex-Ysabeau-Light-tosf-t2c.tfm \
tex-Ysabeau-Light-tosf-t2c.vf \
tex-Ysabeau-Light-tosf-t3.tfm \
tex-Ysabeau-Light-tosf-t4--base.tfm \
tex-Ysabeau-Light-tosf-t4.tfm \
tex-Ysabeau-Light-tosf-t4.vf \
tex-Ysabeau-Light-tosf-t5--base.tfm \
tex-Ysabeau-Light-tosf-t5.tfm \
tex-Ysabeau-Light-tosf-t5.vf \
tex-Ysabeau-Light-tosf-ts1--base.tfm \
tex-Ysabeau-Light-tosf-ts1.tfm \
tex-Ysabeau-Light-tosf-ts1.vf \
tex-Ysabeau-Light-tosf-ts3.tfm \
tex-Ysabeau-LightItalic-dnom-cs.tfm \
tex-Ysabeau-LightItalic-dnom-l7x.tfm \
tex-Ysabeau-LightItalic-dnom-lgr.tfm \
tex-Ysabeau-LightItalic-dnom-ly1.tfm \
tex-Ysabeau-LightItalic-dnom-ot1.tfm \
tex-Ysabeau-LightItalic-dnom-qx--base.tfm \
tex-Ysabeau-LightItalic-dnom-qx.tfm \
tex-Ysabeau-LightItalic-dnom-qx.vf \
tex-Ysabeau-LightItalic-dnom-t1--base.tfm \
tex-Ysabeau-LightItalic-dnom-t1.tfm \
tex-Ysabeau-LightItalic-dnom-t1.vf \
tex-Ysabeau-LightItalic-dnom-t2a--base.tfm \
tex-Ysabeau-LightItalic-dnom-t2a.tfm \
tex-Ysabeau-LightItalic-dnom-t2a.vf \
tex-Ysabeau-LightItalic-dnom-t2b--base.tfm \
tex-Ysabeau-LightItalic-dnom-t2b.tfm \
tex-Ysabeau-LightItalic-dnom-t2b.vf \
tex-Ysabeau-LightItalic-dnom-t2c--base.tfm \
tex-Ysabeau-LightItalic-dnom-t2c.tfm \
tex-Ysabeau-LightItalic-dnom-t2c.vf \
tex-Ysabeau-LightItalic-dnom-t3.tfm \
tex-Ysabeau-LightItalic-dnom-t4--base.tfm \
tex-Ysabeau-LightItalic-dnom-t4.tfm \
tex-Ysabeau-LightItalic-dnom-t4.vf \
tex-Ysabeau-LightItalic-dnom-t5--base.tfm \
tex-Ysabeau-LightItalic-dnom-t5.tfm \
tex-Ysabeau-LightItalic-dnom-t5.vf \
tex-Ysabeau-LightItalic-dnom-ts3.tfm \
tex-Ysabeau-LightItalic-inf-cs.tfm \
tex-Ysabeau-LightItalic-inf-l7x.tfm \
tex-Ysabeau-LightItalic-inf-lgr.tfm \
tex-Ysabeau-LightItalic-inf-ly1.tfm \
tex-Ysabeau-LightItalic-inf-ot1.tfm \
tex-Ysabeau-LightItalic-inf-qx--base.tfm \
tex-Ysabeau-LightItalic-inf-qx.tfm \
tex-Ysabeau-LightItalic-inf-qx.vf \
tex-Ysabeau-LightItalic-inf-t1--base.tfm \
tex-Ysabeau-LightItalic-inf-t1.tfm \
tex-Ysabeau-LightItalic-inf-t1.vf \
tex-Ysabeau-LightItalic-inf-t2a--base.tfm \
tex-Ysabeau-LightItalic-inf-t2a.tfm \
tex-Ysabeau-LightItalic-inf-t2a.vf \
tex-Ysabeau-LightItalic-inf-t2b--base.tfm \
tex-Ysabeau-LightItalic-inf-t2b.tfm \
tex-Ysabeau-LightItalic-inf-t2b.vf \
tex-Ysabeau-LightItalic-inf-t2c--base.tfm \
tex-Ysabeau-LightItalic-inf-t2c.tfm \
tex-Ysabeau-LightItalic-inf-t2c.vf \
tex-Ysabeau-LightItalic-inf-t3.tfm \
tex-Ysabeau-LightItalic-inf-t4--base.tfm \
tex-Ysabeau-LightItalic-inf-t4.tfm \
tex-Ysabeau-LightItalic-inf-t4.vf \
tex-Ysabeau-LightItalic-inf-t5--base.tfm \
tex-Ysabeau-LightItalic-inf-t5.tfm \
tex-Ysabeau-LightItalic-inf-t5.vf \
tex-Ysabeau-LightItalic-inf-ts3.tfm \
tex-Ysabeau-LightItalic-lf-cs.tfm \
tex-Ysabeau-LightItalic-lf-l7x.tfm \
tex-Ysabeau-LightItalic-lf-lgr.tfm \
tex-Ysabeau-LightItalic-lf-ly1.tfm \
tex-Ysabeau-LightItalic-lf-ot1.tfm \
tex-Ysabeau-LightItalic-lf-qx--base.tfm \
tex-Ysabeau-LightItalic-lf-qx.tfm \
tex-Ysabeau-LightItalic-lf-qx.vf \
tex-Ysabeau-LightItalic-lf-swash-cs.tfm \
tex-Ysabeau-LightItalic-lf-swash-l7x.tfm \
tex-Ysabeau-LightItalic-lf-swash-lgr.tfm \
tex-Ysabeau-LightItalic-lf-swash-ly1.tfm \
tex-Ysabeau-LightItalic-lf-swash-ot1.tfm \
tex-Ysabeau-LightItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-LightItalic-lf-swash-qx.tfm \
tex-Ysabeau-LightItalic-lf-swash-qx.vf \
tex-Ysabeau-LightItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-LightItalic-lf-swash-t1.tfm \
tex-Ysabeau-LightItalic-lf-swash-t1.vf \
tex-Ysabeau-LightItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-LightItalic-lf-swash-t2a.tfm \
tex-Ysabeau-LightItalic-lf-swash-t2a.vf \
tex-Ysabeau-LightItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-LightItalic-lf-swash-t2b.tfm \
tex-Ysabeau-LightItalic-lf-swash-t2b.vf \
tex-Ysabeau-LightItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-LightItalic-lf-swash-t2c.tfm \
tex-Ysabeau-LightItalic-lf-swash-t2c.vf \
tex-Ysabeau-LightItalic-lf-swash-t3.tfm \
tex-Ysabeau-LightItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-LightItalic-lf-swash-t4.tfm \
tex-Ysabeau-LightItalic-lf-swash-t4.vf \
tex-Ysabeau-LightItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-LightItalic-lf-swash-t5.tfm \
tex-Ysabeau-LightItalic-lf-swash-t5.vf \
tex-Ysabeau-LightItalic-lf-swash-ts3.tfm \
tex-Ysabeau-LightItalic-lf-t1--base.tfm \
tex-Ysabeau-LightItalic-lf-t1.tfm \
tex-Ysabeau-LightItalic-lf-t1.vf \
tex-Ysabeau-LightItalic-lf-t2a--base.tfm \
tex-Ysabeau-LightItalic-lf-t2a.tfm \
tex-Ysabeau-LightItalic-lf-t2a.vf \
tex-Ysabeau-LightItalic-lf-t2b--base.tfm \
tex-Ysabeau-LightItalic-lf-t2b.tfm \
tex-Ysabeau-LightItalic-lf-t2b.vf \
tex-Ysabeau-LightItalic-lf-t2c--base.tfm \
tex-Ysabeau-LightItalic-lf-t2c.tfm \
tex-Ysabeau-LightItalic-lf-t2c.vf \
tex-Ysabeau-LightItalic-lf-t3.tfm \
tex-Ysabeau-LightItalic-lf-t4--base.tfm \
tex-Ysabeau-LightItalic-lf-t4.tfm \
tex-Ysabeau-LightItalic-lf-t4.vf \
tex-Ysabeau-LightItalic-lf-t5--base.tfm \
tex-Ysabeau-LightItalic-lf-t5.tfm \
tex-Ysabeau-LightItalic-lf-t5.vf \
tex-Ysabeau-LightItalic-lf-ts1--base.tfm \
tex-Ysabeau-LightItalic-lf-ts1.tfm \
tex-Ysabeau-LightItalic-lf-ts1.vf \
tex-Ysabeau-LightItalic-lf-ts3.tfm \
tex-Ysabeau-LightItalic-numr-cs.tfm \
tex-Ysabeau-LightItalic-numr-l7x.tfm \
tex-Ysabeau-LightItalic-numr-lgr.tfm \
tex-Ysabeau-LightItalic-numr-ly1.tfm \
tex-Ysabeau-LightItalic-numr-ot1.tfm \
tex-Ysabeau-LightItalic-numr-qx--base.tfm \
tex-Ysabeau-LightItalic-numr-qx.tfm \
tex-Ysabeau-LightItalic-numr-qx.vf \
tex-Ysabeau-LightItalic-numr-t1--base.tfm \
tex-Ysabeau-LightItalic-numr-t1.tfm \
tex-Ysabeau-LightItalic-numr-t1.vf \
tex-Ysabeau-LightItalic-numr-t2a--base.tfm \
tex-Ysabeau-LightItalic-numr-t2a.tfm \
tex-Ysabeau-LightItalic-numr-t2a.vf \
tex-Ysabeau-LightItalic-numr-t2b--base.tfm \
tex-Ysabeau-LightItalic-numr-t2b.tfm \
tex-Ysabeau-LightItalic-numr-t2b.vf \
tex-Ysabeau-LightItalic-numr-t2c--base.tfm \
tex-Ysabeau-LightItalic-numr-t2c.tfm \
tex-Ysabeau-LightItalic-numr-t2c.vf \
tex-Ysabeau-LightItalic-numr-t3.tfm \
tex-Ysabeau-LightItalic-numr-t4--base.tfm \
tex-Ysabeau-LightItalic-numr-t4.tfm \
tex-Ysabeau-LightItalic-numr-t4.vf \
tex-Ysabeau-LightItalic-numr-t5--base.tfm \
tex-Ysabeau-LightItalic-numr-t5.tfm \
tex-Ysabeau-LightItalic-numr-t5.vf \
tex-Ysabeau-LightItalic-numr-ts3.tfm \
tex-Ysabeau-LightItalic-osf-cs.tfm \
tex-Ysabeau-LightItalic-osf-l7x.tfm \
tex-Ysabeau-LightItalic-osf-lgr.tfm \
tex-Ysabeau-LightItalic-osf-ly1.tfm \
tex-Ysabeau-LightItalic-osf-ot1.tfm \
tex-Ysabeau-LightItalic-osf-qx--base.tfm \
tex-Ysabeau-LightItalic-osf-qx.tfm \
tex-Ysabeau-LightItalic-osf-qx.vf \
tex-Ysabeau-LightItalic-osf-swash-cs.tfm \
tex-Ysabeau-LightItalic-osf-swash-l7x.tfm \
tex-Ysabeau-LightItalic-osf-swash-lgr.tfm \
tex-Ysabeau-LightItalic-osf-swash-ly1.tfm \
tex-Ysabeau-LightItalic-osf-swash-ot1.tfm \
tex-Ysabeau-LightItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-LightItalic-osf-swash-qx.tfm \
tex-Ysabeau-LightItalic-osf-swash-qx.vf \
tex-Ysabeau-LightItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-LightItalic-osf-swash-t1.tfm \
tex-Ysabeau-LightItalic-osf-swash-t1.vf \
tex-Ysabeau-LightItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-LightItalic-osf-swash-t2a.tfm \
tex-Ysabeau-LightItalic-osf-swash-t2a.vf \
tex-Ysabeau-LightItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-LightItalic-osf-swash-t2b.tfm \
tex-Ysabeau-LightItalic-osf-swash-t2b.vf \
tex-Ysabeau-LightItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-LightItalic-osf-swash-t2c.tfm \
tex-Ysabeau-LightItalic-osf-swash-t2c.vf \
tex-Ysabeau-LightItalic-osf-swash-t3.tfm \
tex-Ysabeau-LightItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-LightItalic-osf-swash-t4.tfm \
tex-Ysabeau-LightItalic-osf-swash-t4.vf \
tex-Ysabeau-LightItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-LightItalic-osf-swash-t5.tfm \
tex-Ysabeau-LightItalic-osf-swash-t5.vf \
tex-Ysabeau-LightItalic-osf-swash-ts3.tfm \
tex-Ysabeau-LightItalic-osf-t1--base.tfm \
tex-Ysabeau-LightItalic-osf-t1.tfm \
tex-Ysabeau-LightItalic-osf-t1.vf \
tex-Ysabeau-LightItalic-osf-t2a--base.tfm \
tex-Ysabeau-LightItalic-osf-t2a.tfm \
tex-Ysabeau-LightItalic-osf-t2a.vf \
tex-Ysabeau-LightItalic-osf-t2b--base.tfm \
tex-Ysabeau-LightItalic-osf-t2b.tfm \
tex-Ysabeau-LightItalic-osf-t2b.vf \
tex-Ysabeau-LightItalic-osf-t2c--base.tfm \
tex-Ysabeau-LightItalic-osf-t2c.tfm \
tex-Ysabeau-LightItalic-osf-t2c.vf \
tex-Ysabeau-LightItalic-osf-t3.tfm \
tex-Ysabeau-LightItalic-osf-t4--base.tfm \
tex-Ysabeau-LightItalic-osf-t4.tfm \
tex-Ysabeau-LightItalic-osf-t4.vf \
tex-Ysabeau-LightItalic-osf-t5--base.tfm \
tex-Ysabeau-LightItalic-osf-t5.tfm \
tex-Ysabeau-LightItalic-osf-t5.vf \
tex-Ysabeau-LightItalic-osf-ts1--base.tfm \
tex-Ysabeau-LightItalic-osf-ts1.tfm \
tex-Ysabeau-LightItalic-osf-ts1.vf \
tex-Ysabeau-LightItalic-osf-ts3.tfm \
tex-Ysabeau-LightItalic-sup-cs.tfm \
tex-Ysabeau-LightItalic-sup-l7x.tfm \
tex-Ysabeau-LightItalic-sup-lgr.tfm \
tex-Ysabeau-LightItalic-sup-ly1.tfm \
tex-Ysabeau-LightItalic-sup-ot1.tfm \
tex-Ysabeau-LightItalic-sup-qx--base.tfm \
tex-Ysabeau-LightItalic-sup-qx.tfm \
tex-Ysabeau-LightItalic-sup-qx.vf \
tex-Ysabeau-LightItalic-sup-t1--base.tfm \
tex-Ysabeau-LightItalic-sup-t1.tfm \
tex-Ysabeau-LightItalic-sup-t1.vf \
tex-Ysabeau-LightItalic-sup-t2a--base.tfm \
tex-Ysabeau-LightItalic-sup-t2a.tfm \
tex-Ysabeau-LightItalic-sup-t2a.vf \
tex-Ysabeau-LightItalic-sup-t2b--base.tfm \
tex-Ysabeau-LightItalic-sup-t2b.tfm \
tex-Ysabeau-LightItalic-sup-t2b.vf \
tex-Ysabeau-LightItalic-sup-t2c--base.tfm \
tex-Ysabeau-LightItalic-sup-t2c.tfm \
tex-Ysabeau-LightItalic-sup-t2c.vf \
tex-Ysabeau-LightItalic-sup-t3.tfm \
tex-Ysabeau-LightItalic-sup-t4--base.tfm \
tex-Ysabeau-LightItalic-sup-t4.tfm \
tex-Ysabeau-LightItalic-sup-t4.vf \
tex-Ysabeau-LightItalic-sup-t5--base.tfm \
tex-Ysabeau-LightItalic-sup-t5.tfm \
tex-Ysabeau-LightItalic-sup-t5.vf \
tex-Ysabeau-LightItalic-sup-ts3.tfm \
tex-Ysabeau-LightItalic-tlf-cs.tfm \
tex-Ysabeau-LightItalic-tlf-l7x.tfm \
tex-Ysabeau-LightItalic-tlf-lgr.tfm \
tex-Ysabeau-LightItalic-tlf-ly1.tfm \
tex-Ysabeau-LightItalic-tlf-ot1.tfm \
tex-Ysabeau-LightItalic-tlf-qx--base.tfm \
tex-Ysabeau-LightItalic-tlf-qx.tfm \
tex-Ysabeau-LightItalic-tlf-qx.vf \
tex-Ysabeau-LightItalic-tlf-swash-cs.tfm \
tex-Ysabeau-LightItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-LightItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-LightItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-LightItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-LightItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-LightItalic-tlf-swash-qx.tfm \
tex-Ysabeau-LightItalic-tlf-swash-qx.vf \
tex-Ysabeau-LightItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t1.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t1.vf \
tex-Ysabeau-LightItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t2a.vf \
tex-Ysabeau-LightItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t2b.vf \
tex-Ysabeau-LightItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t2c.vf \
tex-Ysabeau-LightItalic-tlf-swash-t3.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t4.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t4.vf \
tex-Ysabeau-LightItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t5.tfm \
tex-Ysabeau-LightItalic-tlf-swash-t5.vf \
tex-Ysabeau-LightItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-LightItalic-tlf-t1--base.tfm \
tex-Ysabeau-LightItalic-tlf-t1.tfm \
tex-Ysabeau-LightItalic-tlf-t1.vf \
tex-Ysabeau-LightItalic-tlf-t2a--base.tfm \
tex-Ysabeau-LightItalic-tlf-t2a.tfm \
tex-Ysabeau-LightItalic-tlf-t2a.vf \
tex-Ysabeau-LightItalic-tlf-t2b--base.tfm \
tex-Ysabeau-LightItalic-tlf-t2b.tfm \
tex-Ysabeau-LightItalic-tlf-t2b.vf \
tex-Ysabeau-LightItalic-tlf-t2c--base.tfm \
tex-Ysabeau-LightItalic-tlf-t2c.tfm \
tex-Ysabeau-LightItalic-tlf-t2c.vf \
tex-Ysabeau-LightItalic-tlf-t3.tfm \
tex-Ysabeau-LightItalic-tlf-t4--base.tfm \
tex-Ysabeau-LightItalic-tlf-t4.tfm \
tex-Ysabeau-LightItalic-tlf-t4.vf \
tex-Ysabeau-LightItalic-tlf-t5--base.tfm \
tex-Ysabeau-LightItalic-tlf-t5.tfm \
tex-Ysabeau-LightItalic-tlf-t5.vf \
tex-Ysabeau-LightItalic-tlf-ts1--base.tfm \
tex-Ysabeau-LightItalic-tlf-ts1.tfm \
tex-Ysabeau-LightItalic-tlf-ts1.vf \
tex-Ysabeau-LightItalic-tlf-ts3.tfm \
tex-Ysabeau-LightItalic-tosf-cs.tfm \
tex-Ysabeau-LightItalic-tosf-l7x.tfm \
tex-Ysabeau-LightItalic-tosf-lgr.tfm \
tex-Ysabeau-LightItalic-tosf-ly1.tfm \
tex-Ysabeau-LightItalic-tosf-ot1.tfm \
tex-Ysabeau-LightItalic-tosf-qx--base.tfm \
tex-Ysabeau-LightItalic-tosf-qx.tfm \
tex-Ysabeau-LightItalic-tosf-qx.vf \
tex-Ysabeau-LightItalic-tosf-swash-cs.tfm \
tex-Ysabeau-LightItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-LightItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-LightItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-LightItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-LightItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-LightItalic-tosf-swash-qx.tfm \
tex-Ysabeau-LightItalic-tosf-swash-qx.vf \
tex-Ysabeau-LightItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t1.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t1.vf \
tex-Ysabeau-LightItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t2a.vf \
tex-Ysabeau-LightItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t2b.vf \
tex-Ysabeau-LightItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t2c.vf \
tex-Ysabeau-LightItalic-tosf-swash-t3.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t4.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t4.vf \
tex-Ysabeau-LightItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t5.tfm \
tex-Ysabeau-LightItalic-tosf-swash-t5.vf \
tex-Ysabeau-LightItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-LightItalic-tosf-t1--base.tfm \
tex-Ysabeau-LightItalic-tosf-t1.tfm \
tex-Ysabeau-LightItalic-tosf-t1.vf \
tex-Ysabeau-LightItalic-tosf-t2a--base.tfm \
tex-Ysabeau-LightItalic-tosf-t2a.tfm \
tex-Ysabeau-LightItalic-tosf-t2a.vf \
tex-Ysabeau-LightItalic-tosf-t2b--base.tfm \
tex-Ysabeau-LightItalic-tosf-t2b.tfm \
tex-Ysabeau-LightItalic-tosf-t2b.vf \
tex-Ysabeau-LightItalic-tosf-t2c--base.tfm \
tex-Ysabeau-LightItalic-tosf-t2c.tfm \
tex-Ysabeau-LightItalic-tosf-t2c.vf \
tex-Ysabeau-LightItalic-tosf-t3.tfm \
tex-Ysabeau-LightItalic-tosf-t4--base.tfm \
tex-Ysabeau-LightItalic-tosf-t4.tfm \
tex-Ysabeau-LightItalic-tosf-t4.vf \
tex-Ysabeau-LightItalic-tosf-t5--base.tfm \
tex-Ysabeau-LightItalic-tosf-t5.tfm \
tex-Ysabeau-LightItalic-tosf-t5.vf \
tex-Ysabeau-LightItalic-tosf-ts1--base.tfm \
tex-Ysabeau-LightItalic-tosf-ts1.tfm \
tex-Ysabeau-LightItalic-tosf-ts1.vf \
tex-Ysabeau-LightItalic-tosf-ts3.tfm \
tex-Ysabeau-Medium-dnom-cs.tfm \
tex-Ysabeau-Medium-dnom-l7x.tfm \
tex-Ysabeau-Medium-dnom-lgr.tfm \
tex-Ysabeau-Medium-dnom-ly1.tfm \
tex-Ysabeau-Medium-dnom-ot1.tfm \
tex-Ysabeau-Medium-dnom-qx--base.tfm \
tex-Ysabeau-Medium-dnom-qx.tfm \
tex-Ysabeau-Medium-dnom-qx.vf \
tex-Ysabeau-Medium-dnom-t1--base.tfm \
tex-Ysabeau-Medium-dnom-t1.tfm \
tex-Ysabeau-Medium-dnom-t1.vf \
tex-Ysabeau-Medium-dnom-t2a--base.tfm \
tex-Ysabeau-Medium-dnom-t2a.tfm \
tex-Ysabeau-Medium-dnom-t2a.vf \
tex-Ysabeau-Medium-dnom-t2b--base.tfm \
tex-Ysabeau-Medium-dnom-t2b.tfm \
tex-Ysabeau-Medium-dnom-t2b.vf \
tex-Ysabeau-Medium-dnom-t2c--base.tfm \
tex-Ysabeau-Medium-dnom-t2c.tfm \
tex-Ysabeau-Medium-dnom-t2c.vf \
tex-Ysabeau-Medium-dnom-t3.tfm \
tex-Ysabeau-Medium-dnom-t4--base.tfm \
tex-Ysabeau-Medium-dnom-t4.tfm \
tex-Ysabeau-Medium-dnom-t4.vf \
tex-Ysabeau-Medium-dnom-t5--base.tfm \
tex-Ysabeau-Medium-dnom-t5.tfm \
tex-Ysabeau-Medium-dnom-t5.vf \
tex-Ysabeau-Medium-dnom-ts3.tfm \
tex-Ysabeau-Medium-inf-cs.tfm \
tex-Ysabeau-Medium-inf-l7x.tfm \
tex-Ysabeau-Medium-inf-lgr.tfm \
tex-Ysabeau-Medium-inf-ly1.tfm \
tex-Ysabeau-Medium-inf-ot1.tfm \
tex-Ysabeau-Medium-inf-qx--base.tfm \
tex-Ysabeau-Medium-inf-qx.tfm \
tex-Ysabeau-Medium-inf-qx.vf \
tex-Ysabeau-Medium-inf-t1--base.tfm \
tex-Ysabeau-Medium-inf-t1.tfm \
tex-Ysabeau-Medium-inf-t1.vf \
tex-Ysabeau-Medium-inf-t2a--base.tfm \
tex-Ysabeau-Medium-inf-t2a.tfm \
tex-Ysabeau-Medium-inf-t2a.vf \
tex-Ysabeau-Medium-inf-t2b--base.tfm \
tex-Ysabeau-Medium-inf-t2b.tfm \
tex-Ysabeau-Medium-inf-t2b.vf \
tex-Ysabeau-Medium-inf-t2c--base.tfm \
tex-Ysabeau-Medium-inf-t2c.tfm \
tex-Ysabeau-Medium-inf-t2c.vf \
tex-Ysabeau-Medium-inf-t3.tfm \
tex-Ysabeau-Medium-inf-t4--base.tfm \
tex-Ysabeau-Medium-inf-t4.tfm \
tex-Ysabeau-Medium-inf-t4.vf \
tex-Ysabeau-Medium-inf-t5--base.tfm \
tex-Ysabeau-Medium-inf-t5.tfm \
tex-Ysabeau-Medium-inf-t5.vf \
tex-Ysabeau-Medium-inf-ts3.tfm \
tex-Ysabeau-Medium-lf-cs.tfm \
tex-Ysabeau-Medium-lf-l7x.tfm \
tex-Ysabeau-Medium-lf-lgr.tfm \
tex-Ysabeau-Medium-lf-ly1.tfm \
tex-Ysabeau-Medium-lf-ot1.tfm \
tex-Ysabeau-Medium-lf-qx--base.tfm \
tex-Ysabeau-Medium-lf-qx.tfm \
tex-Ysabeau-Medium-lf-qx.vf \
tex-Ysabeau-Medium-lf-sc-cs--base.tfm \
tex-Ysabeau-Medium-lf-sc-cs.tfm \
tex-Ysabeau-Medium-lf-sc-cs.vf \
tex-Ysabeau-Medium-lf-sc-l7x--base.tfm \
tex-Ysabeau-Medium-lf-sc-l7x.tfm \
tex-Ysabeau-Medium-lf-sc-l7x.vf \
tex-Ysabeau-Medium-lf-sc-lgr.tfm \
tex-Ysabeau-Medium-lf-sc-ly1--base.tfm \
tex-Ysabeau-Medium-lf-sc-ly1.tfm \
tex-Ysabeau-Medium-lf-sc-ly1.vf \
tex-Ysabeau-Medium-lf-sc-ot1--base.tfm \
tex-Ysabeau-Medium-lf-sc-ot1.tfm \
tex-Ysabeau-Medium-lf-sc-ot1.vf \
tex-Ysabeau-Medium-lf-sc-qx--base.tfm \
tex-Ysabeau-Medium-lf-sc-qx.tfm \
tex-Ysabeau-Medium-lf-sc-qx.vf \
tex-Ysabeau-Medium-lf-sc-t1--base.tfm \
tex-Ysabeau-Medium-lf-sc-t1.tfm \
tex-Ysabeau-Medium-lf-sc-t1.vf \
tex-Ysabeau-Medium-lf-sc-t2a--base.tfm \
tex-Ysabeau-Medium-lf-sc-t2a.tfm \
tex-Ysabeau-Medium-lf-sc-t2a.vf \
tex-Ysabeau-Medium-lf-sc-t2b--base.tfm \
tex-Ysabeau-Medium-lf-sc-t2b.tfm \
tex-Ysabeau-Medium-lf-sc-t2b.vf \
tex-Ysabeau-Medium-lf-sc-t2c--base.tfm \
tex-Ysabeau-Medium-lf-sc-t2c.tfm \
tex-Ysabeau-Medium-lf-sc-t2c.vf \
tex-Ysabeau-Medium-lf-sc-t3.tfm \
tex-Ysabeau-Medium-lf-sc-t4--base.tfm \
tex-Ysabeau-Medium-lf-sc-t4.tfm \
tex-Ysabeau-Medium-lf-sc-t4.vf \
tex-Ysabeau-Medium-lf-sc-t5--base.tfm \
tex-Ysabeau-Medium-lf-sc-t5.tfm \
tex-Ysabeau-Medium-lf-sc-t5.vf \
tex-Ysabeau-Medium-lf-sc-ts3--base.tfm \
tex-Ysabeau-Medium-lf-sc-ts3.tfm \
tex-Ysabeau-Medium-lf-sc-ts3.vf \
tex-Ysabeau-Medium-lf-t1--base.tfm \
tex-Ysabeau-Medium-lf-t1.tfm \
tex-Ysabeau-Medium-lf-t1.vf \
tex-Ysabeau-Medium-lf-t2a--base.tfm \
tex-Ysabeau-Medium-lf-t2a.tfm \
tex-Ysabeau-Medium-lf-t2a.vf \
tex-Ysabeau-Medium-lf-t2b--base.tfm \
tex-Ysabeau-Medium-lf-t2b.tfm \
tex-Ysabeau-Medium-lf-t2b.vf \
tex-Ysabeau-Medium-lf-t2c--base.tfm \
tex-Ysabeau-Medium-lf-t2c.tfm \
tex-Ysabeau-Medium-lf-t2c.vf \
tex-Ysabeau-Medium-lf-t3.tfm \
tex-Ysabeau-Medium-lf-t4--base.tfm \
tex-Ysabeau-Medium-lf-t4.tfm \
tex-Ysabeau-Medium-lf-t4.vf \
tex-Ysabeau-Medium-lf-t5--base.tfm \
tex-Ysabeau-Medium-lf-t5.tfm \
tex-Ysabeau-Medium-lf-t5.vf \
tex-Ysabeau-Medium-lf-ts1--base.tfm \
tex-Ysabeau-Medium-lf-ts1.tfm \
tex-Ysabeau-Medium-lf-ts1.vf \
tex-Ysabeau-Medium-lf-ts3.tfm \
tex-Ysabeau-Medium-numr-cs.tfm \
tex-Ysabeau-Medium-numr-l7x.tfm \
tex-Ysabeau-Medium-numr-lgr.tfm \
tex-Ysabeau-Medium-numr-ly1.tfm \
tex-Ysabeau-Medium-numr-ot1.tfm \
tex-Ysabeau-Medium-numr-qx--base.tfm \
tex-Ysabeau-Medium-numr-qx.tfm \
tex-Ysabeau-Medium-numr-qx.vf \
tex-Ysabeau-Medium-numr-t1--base.tfm \
tex-Ysabeau-Medium-numr-t1.tfm \
tex-Ysabeau-Medium-numr-t1.vf \
tex-Ysabeau-Medium-numr-t2a--base.tfm \
tex-Ysabeau-Medium-numr-t2a.tfm \
tex-Ysabeau-Medium-numr-t2a.vf \
tex-Ysabeau-Medium-numr-t2b--base.tfm \
tex-Ysabeau-Medium-numr-t2b.tfm \
tex-Ysabeau-Medium-numr-t2b.vf \
tex-Ysabeau-Medium-numr-t2c--base.tfm \
tex-Ysabeau-Medium-numr-t2c.tfm \
tex-Ysabeau-Medium-numr-t2c.vf \
tex-Ysabeau-Medium-numr-t3.tfm \
tex-Ysabeau-Medium-numr-t4--base.tfm \
tex-Ysabeau-Medium-numr-t4.tfm \
tex-Ysabeau-Medium-numr-t4.vf \
tex-Ysabeau-Medium-numr-t5--base.tfm \
tex-Ysabeau-Medium-numr-t5.tfm \
tex-Ysabeau-Medium-numr-t5.vf \
tex-Ysabeau-Medium-numr-ts3.tfm \
tex-Ysabeau-Medium-osf-cs.tfm \
tex-Ysabeau-Medium-osf-l7x.tfm \
tex-Ysabeau-Medium-osf-lgr.tfm \
tex-Ysabeau-Medium-osf-ly1.tfm \
tex-Ysabeau-Medium-osf-ot1.tfm \
tex-Ysabeau-Medium-osf-qx--base.tfm \
tex-Ysabeau-Medium-osf-qx.tfm \
tex-Ysabeau-Medium-osf-qx.vf \
tex-Ysabeau-Medium-osf-sc-cs--base.tfm \
tex-Ysabeau-Medium-osf-sc-cs.tfm \
tex-Ysabeau-Medium-osf-sc-cs.vf \
tex-Ysabeau-Medium-osf-sc-l7x--base.tfm \
tex-Ysabeau-Medium-osf-sc-l7x.tfm \
tex-Ysabeau-Medium-osf-sc-l7x.vf \
tex-Ysabeau-Medium-osf-sc-lgr.tfm \
tex-Ysabeau-Medium-osf-sc-ly1--base.tfm \
tex-Ysabeau-Medium-osf-sc-ly1.tfm \
tex-Ysabeau-Medium-osf-sc-ly1.vf \
tex-Ysabeau-Medium-osf-sc-ot1--base.tfm \
tex-Ysabeau-Medium-osf-sc-ot1.tfm \
tex-Ysabeau-Medium-osf-sc-ot1.vf \
tex-Ysabeau-Medium-osf-sc-qx--base.tfm \
tex-Ysabeau-Medium-osf-sc-qx.tfm \
tex-Ysabeau-Medium-osf-sc-qx.vf \
tex-Ysabeau-Medium-osf-sc-t1--base.tfm \
tex-Ysabeau-Medium-osf-sc-t1.tfm \
tex-Ysabeau-Medium-osf-sc-t1.vf \
tex-Ysabeau-Medium-osf-sc-t2a--base.tfm \
tex-Ysabeau-Medium-osf-sc-t2a.tfm \
tex-Ysabeau-Medium-osf-sc-t2a.vf \
tex-Ysabeau-Medium-osf-sc-t2b--base.tfm \
tex-Ysabeau-Medium-osf-sc-t2b.tfm \
tex-Ysabeau-Medium-osf-sc-t2b.vf \
tex-Ysabeau-Medium-osf-sc-t2c--base.tfm \
tex-Ysabeau-Medium-osf-sc-t2c.tfm \
tex-Ysabeau-Medium-osf-sc-t2c.vf \
tex-Ysabeau-Medium-osf-sc-t3.tfm \
tex-Ysabeau-Medium-osf-sc-t4--base.tfm \
tex-Ysabeau-Medium-osf-sc-t4.tfm \
tex-Ysabeau-Medium-osf-sc-t4.vf \
tex-Ysabeau-Medium-osf-sc-t5--base.tfm \
tex-Ysabeau-Medium-osf-sc-t5.tfm \
tex-Ysabeau-Medium-osf-sc-t5.vf \
tex-Ysabeau-Medium-osf-sc-ts3--base.tfm \
tex-Ysabeau-Medium-osf-sc-ts3.tfm \
tex-Ysabeau-Medium-osf-sc-ts3.vf \
tex-Ysabeau-Medium-osf-t1--base.tfm \
tex-Ysabeau-Medium-osf-t1.tfm \
tex-Ysabeau-Medium-osf-t1.vf \
tex-Ysabeau-Medium-osf-t2a--base.tfm \
tex-Ysabeau-Medium-osf-t2a.tfm \
tex-Ysabeau-Medium-osf-t2a.vf \
tex-Ysabeau-Medium-osf-t2b--base.tfm \
tex-Ysabeau-Medium-osf-t2b.tfm \
tex-Ysabeau-Medium-osf-t2b.vf \
tex-Ysabeau-Medium-osf-t2c--base.tfm \
tex-Ysabeau-Medium-osf-t2c.tfm \
tex-Ysabeau-Medium-osf-t2c.vf \
tex-Ysabeau-Medium-osf-t3.tfm \
tex-Ysabeau-Medium-osf-t4--base.tfm \
tex-Ysabeau-Medium-osf-t4.tfm \
tex-Ysabeau-Medium-osf-t4.vf \
tex-Ysabeau-Medium-osf-t5--base.tfm \
tex-Ysabeau-Medium-osf-t5.tfm \
tex-Ysabeau-Medium-osf-t5.vf \
tex-Ysabeau-Medium-osf-ts1--base.tfm \
tex-Ysabeau-Medium-osf-ts1.tfm \
tex-Ysabeau-Medium-osf-ts1.vf \
tex-Ysabeau-Medium-osf-ts3.tfm \
tex-Ysabeau-Medium-sup-cs.tfm \
tex-Ysabeau-Medium-sup-l7x.tfm \
tex-Ysabeau-Medium-sup-lgr.tfm \
tex-Ysabeau-Medium-sup-ly1.tfm \
tex-Ysabeau-Medium-sup-ot1.tfm \
tex-Ysabeau-Medium-sup-qx--base.tfm \
tex-Ysabeau-Medium-sup-qx.tfm \
tex-Ysabeau-Medium-sup-qx.vf \
tex-Ysabeau-Medium-sup-t1--base.tfm \
tex-Ysabeau-Medium-sup-t1.tfm \
tex-Ysabeau-Medium-sup-t1.vf \
tex-Ysabeau-Medium-sup-t2a--base.tfm \
tex-Ysabeau-Medium-sup-t2a.tfm \
tex-Ysabeau-Medium-sup-t2a.vf \
tex-Ysabeau-Medium-sup-t2b--base.tfm \
tex-Ysabeau-Medium-sup-t2b.tfm \
tex-Ysabeau-Medium-sup-t2b.vf \
tex-Ysabeau-Medium-sup-t2c--base.tfm \
tex-Ysabeau-Medium-sup-t2c.tfm \
tex-Ysabeau-Medium-sup-t2c.vf \
tex-Ysabeau-Medium-sup-t3.tfm \
tex-Ysabeau-Medium-sup-t4--base.tfm \
tex-Ysabeau-Medium-sup-t4.tfm \
tex-Ysabeau-Medium-sup-t4.vf \
tex-Ysabeau-Medium-sup-t5--base.tfm \
tex-Ysabeau-Medium-sup-t5.tfm \
tex-Ysabeau-Medium-sup-t5.vf \
tex-Ysabeau-Medium-sup-ts3.tfm \
tex-Ysabeau-Medium-tlf-cs.tfm \
tex-Ysabeau-Medium-tlf-l7x.tfm \
tex-Ysabeau-Medium-tlf-lgr.tfm \
tex-Ysabeau-Medium-tlf-ly1.tfm \
tex-Ysabeau-Medium-tlf-ot1.tfm \
tex-Ysabeau-Medium-tlf-qx--base.tfm \
tex-Ysabeau-Medium-tlf-qx.tfm \
tex-Ysabeau-Medium-tlf-qx.vf \
tex-Ysabeau-Medium-tlf-sc-cs--base.tfm \
tex-Ysabeau-Medium-tlf-sc-cs.tfm \
tex-Ysabeau-Medium-tlf-sc-cs.vf \
tex-Ysabeau-Medium-tlf-sc-l7x--base.tfm \
tex-Ysabeau-Medium-tlf-sc-l7x.tfm \
tex-Ysabeau-Medium-tlf-sc-l7x.vf \
tex-Ysabeau-Medium-tlf-sc-lgr.tfm \
tex-Ysabeau-Medium-tlf-sc-ly1--base.tfm \
tex-Ysabeau-Medium-tlf-sc-ly1.tfm \
tex-Ysabeau-Medium-tlf-sc-ly1.vf \
tex-Ysabeau-Medium-tlf-sc-ot1--base.tfm \
tex-Ysabeau-Medium-tlf-sc-ot1.tfm \
tex-Ysabeau-Medium-tlf-sc-ot1.vf \
tex-Ysabeau-Medium-tlf-sc-qx--base.tfm \
tex-Ysabeau-Medium-tlf-sc-qx.tfm \
tex-Ysabeau-Medium-tlf-sc-qx.vf \
tex-Ysabeau-Medium-tlf-sc-t1--base.tfm \
tex-Ysabeau-Medium-tlf-sc-t1.tfm \
tex-Ysabeau-Medium-tlf-sc-t1.vf \
tex-Ysabeau-Medium-tlf-sc-t2a--base.tfm \
tex-Ysabeau-Medium-tlf-sc-t2a.tfm \
tex-Ysabeau-Medium-tlf-sc-t2a.vf \
tex-Ysabeau-Medium-tlf-sc-t2b--base.tfm \
tex-Ysabeau-Medium-tlf-sc-t2b.tfm \
tex-Ysabeau-Medium-tlf-sc-t2b.vf \
tex-Ysabeau-Medium-tlf-sc-t2c--base.tfm \
tex-Ysabeau-Medium-tlf-sc-t2c.tfm \
tex-Ysabeau-Medium-tlf-sc-t2c.vf \
tex-Ysabeau-Medium-tlf-sc-t3.tfm \
tex-Ysabeau-Medium-tlf-sc-t4--base.tfm \
tex-Ysabeau-Medium-tlf-sc-t4.tfm \
tex-Ysabeau-Medium-tlf-sc-t4.vf \
tex-Ysabeau-Medium-tlf-sc-t5--base.tfm \
tex-Ysabeau-Medium-tlf-sc-t5.tfm \
tex-Ysabeau-Medium-tlf-sc-t5.vf \
tex-Ysabeau-Medium-tlf-sc-ts3--base.tfm \
tex-Ysabeau-Medium-tlf-sc-ts3.tfm \
tex-Ysabeau-Medium-tlf-sc-ts3.vf \
tex-Ysabeau-Medium-tlf-t1--base.tfm \
tex-Ysabeau-Medium-tlf-t1.tfm \
tex-Ysabeau-Medium-tlf-t1.vf \
tex-Ysabeau-Medium-tlf-t2a--base.tfm \
tex-Ysabeau-Medium-tlf-t2a.tfm \
tex-Ysabeau-Medium-tlf-t2a.vf \
tex-Ysabeau-Medium-tlf-t2b--base.tfm \
tex-Ysabeau-Medium-tlf-t2b.tfm \
tex-Ysabeau-Medium-tlf-t2b.vf \
tex-Ysabeau-Medium-tlf-t2c--base.tfm \
tex-Ysabeau-Medium-tlf-t2c.tfm \
tex-Ysabeau-Medium-tlf-t2c.vf \
tex-Ysabeau-Medium-tlf-t3.tfm \
tex-Ysabeau-Medium-tlf-t4--base.tfm \
tex-Ysabeau-Medium-tlf-t4.tfm \
tex-Ysabeau-Medium-tlf-t4.vf \
tex-Ysabeau-Medium-tlf-t5--base.tfm \
tex-Ysabeau-Medium-tlf-t5.tfm \
tex-Ysabeau-Medium-tlf-t5.vf \
tex-Ysabeau-Medium-tlf-ts1--base.tfm \
tex-Ysabeau-Medium-tlf-ts1.tfm \
tex-Ysabeau-Medium-tlf-ts1.vf \
tex-Ysabeau-Medium-tlf-ts3.tfm \
tex-Ysabeau-Medium-tosf-cs.tfm \
tex-Ysabeau-Medium-tosf-l7x.tfm \
tex-Ysabeau-Medium-tosf-lgr.tfm \
tex-Ysabeau-Medium-tosf-ly1.tfm \
tex-Ysabeau-Medium-tosf-ot1.tfm \
tex-Ysabeau-Medium-tosf-qx--base.tfm \
tex-Ysabeau-Medium-tosf-qx.tfm \
tex-Ysabeau-Medium-tosf-qx.vf \
tex-Ysabeau-Medium-tosf-sc-cs--base.tfm \
tex-Ysabeau-Medium-tosf-sc-cs.tfm \
tex-Ysabeau-Medium-tosf-sc-cs.vf \
tex-Ysabeau-Medium-tosf-sc-l7x--base.tfm \
tex-Ysabeau-Medium-tosf-sc-l7x.tfm \
tex-Ysabeau-Medium-tosf-sc-l7x.vf \
tex-Ysabeau-Medium-tosf-sc-lgr.tfm \
tex-Ysabeau-Medium-tosf-sc-ly1--base.tfm \
tex-Ysabeau-Medium-tosf-sc-ly1.tfm \
tex-Ysabeau-Medium-tosf-sc-ly1.vf \
tex-Ysabeau-Medium-tosf-sc-ot1--base.tfm \
tex-Ysabeau-Medium-tosf-sc-ot1.tfm \
tex-Ysabeau-Medium-tosf-sc-ot1.vf \
tex-Ysabeau-Medium-tosf-sc-qx--base.tfm \
tex-Ysabeau-Medium-tosf-sc-qx.tfm \
tex-Ysabeau-Medium-tosf-sc-qx.vf \
tex-Ysabeau-Medium-tosf-sc-t1--base.tfm \
tex-Ysabeau-Medium-tosf-sc-t1.tfm \
tex-Ysabeau-Medium-tosf-sc-t1.vf \
tex-Ysabeau-Medium-tosf-sc-t2a--base.tfm \
tex-Ysabeau-Medium-tosf-sc-t2a.tfm \
tex-Ysabeau-Medium-tosf-sc-t2a.vf \
tex-Ysabeau-Medium-tosf-sc-t2b--base.tfm \
tex-Ysabeau-Medium-tosf-sc-t2b.tfm \
tex-Ysabeau-Medium-tosf-sc-t2b.vf \
tex-Ysabeau-Medium-tosf-sc-t2c--base.tfm \
tex-Ysabeau-Medium-tosf-sc-t2c.tfm \
tex-Ysabeau-Medium-tosf-sc-t2c.vf \
tex-Ysabeau-Medium-tosf-sc-t3.tfm \
tex-Ysabeau-Medium-tosf-sc-t4--base.tfm \
tex-Ysabeau-Medium-tosf-sc-t4.tfm \
tex-Ysabeau-Medium-tosf-sc-t4.vf \
tex-Ysabeau-Medium-tosf-sc-t5--base.tfm \
tex-Ysabeau-Medium-tosf-sc-t5.tfm \
tex-Ysabeau-Medium-tosf-sc-t5.vf \
tex-Ysabeau-Medium-tosf-sc-ts3--base.tfm \
tex-Ysabeau-Medium-tosf-sc-ts3.tfm \
tex-Ysabeau-Medium-tosf-sc-ts3.vf \
tex-Ysabeau-Medium-tosf-t1--base.tfm \
tex-Ysabeau-Medium-tosf-t1.tfm \
tex-Ysabeau-Medium-tosf-t1.vf \
tex-Ysabeau-Medium-tosf-t2a--base.tfm \
tex-Ysabeau-Medium-tosf-t2a.tfm \
tex-Ysabeau-Medium-tosf-t2a.vf \
tex-Ysabeau-Medium-tosf-t2b--base.tfm \
tex-Ysabeau-Medium-tosf-t2b.tfm \
tex-Ysabeau-Medium-tosf-t2b.vf \
tex-Ysabeau-Medium-tosf-t2c--base.tfm \
tex-Ysabeau-Medium-tosf-t2c.tfm \
tex-Ysabeau-Medium-tosf-t2c.vf \
tex-Ysabeau-Medium-tosf-t3.tfm \
tex-Ysabeau-Medium-tosf-t4--base.tfm \
tex-Ysabeau-Medium-tosf-t4.tfm \
tex-Ysabeau-Medium-tosf-t4.vf \
tex-Ysabeau-Medium-tosf-t5--base.tfm \
tex-Ysabeau-Medium-tosf-t5.tfm \
tex-Ysabeau-Medium-tosf-t5.vf \
tex-Ysabeau-Medium-tosf-ts1--base.tfm \
tex-Ysabeau-Medium-tosf-ts1.tfm \
tex-Ysabeau-Medium-tosf-ts1.vf \
tex-Ysabeau-Medium-tosf-ts3.tfm \
tex-Ysabeau-MediumItalic-dnom-cs.tfm \
tex-Ysabeau-MediumItalic-dnom-l7x.tfm \
tex-Ysabeau-MediumItalic-dnom-lgr.tfm \
tex-Ysabeau-MediumItalic-dnom-ly1.tfm \
tex-Ysabeau-MediumItalic-dnom-ot1.tfm \
tex-Ysabeau-MediumItalic-dnom-qx--base.tfm \
tex-Ysabeau-MediumItalic-dnom-qx.tfm \
tex-Ysabeau-MediumItalic-dnom-qx.vf \
tex-Ysabeau-MediumItalic-dnom-t1--base.tfm \
tex-Ysabeau-MediumItalic-dnom-t1.tfm \
tex-Ysabeau-MediumItalic-dnom-t1.vf \
tex-Ysabeau-MediumItalic-dnom-t2a--base.tfm \
tex-Ysabeau-MediumItalic-dnom-t2a.tfm \
tex-Ysabeau-MediumItalic-dnom-t2a.vf \
tex-Ysabeau-MediumItalic-dnom-t2b--base.tfm \
tex-Ysabeau-MediumItalic-dnom-t2b.tfm \
tex-Ysabeau-MediumItalic-dnom-t2b.vf \
tex-Ysabeau-MediumItalic-dnom-t2c--base.tfm \
tex-Ysabeau-MediumItalic-dnom-t2c.tfm \
tex-Ysabeau-MediumItalic-dnom-t2c.vf \
tex-Ysabeau-MediumItalic-dnom-t3.tfm \
tex-Ysabeau-MediumItalic-dnom-t4--base.tfm \
tex-Ysabeau-MediumItalic-dnom-t4.tfm \
tex-Ysabeau-MediumItalic-dnom-t4.vf \
tex-Ysabeau-MediumItalic-dnom-t5--base.tfm \
tex-Ysabeau-MediumItalic-dnom-t5.tfm \
tex-Ysabeau-MediumItalic-dnom-t5.vf \
tex-Ysabeau-MediumItalic-dnom-ts3.tfm \
tex-Ysabeau-MediumItalic-inf-cs.tfm \
tex-Ysabeau-MediumItalic-inf-l7x.tfm \
tex-Ysabeau-MediumItalic-inf-lgr.tfm \
tex-Ysabeau-MediumItalic-inf-ly1.tfm \
tex-Ysabeau-MediumItalic-inf-ot1.tfm \
tex-Ysabeau-MediumItalic-inf-qx--base.tfm \
tex-Ysabeau-MediumItalic-inf-qx.tfm \
tex-Ysabeau-MediumItalic-inf-qx.vf \
tex-Ysabeau-MediumItalic-inf-t1--base.tfm \
tex-Ysabeau-MediumItalic-inf-t1.tfm \
tex-Ysabeau-MediumItalic-inf-t1.vf \
tex-Ysabeau-MediumItalic-inf-t2a--base.tfm \
tex-Ysabeau-MediumItalic-inf-t2a.tfm \
tex-Ysabeau-MediumItalic-inf-t2a.vf \
tex-Ysabeau-MediumItalic-inf-t2b--base.tfm \
tex-Ysabeau-MediumItalic-inf-t2b.tfm \
tex-Ysabeau-MediumItalic-inf-t2b.vf \
tex-Ysabeau-MediumItalic-inf-t2c--base.tfm \
tex-Ysabeau-MediumItalic-inf-t2c.tfm \
tex-Ysabeau-MediumItalic-inf-t2c.vf \
tex-Ysabeau-MediumItalic-inf-t3.tfm \
tex-Ysabeau-MediumItalic-inf-t4--base.tfm \
tex-Ysabeau-MediumItalic-inf-t4.tfm \
tex-Ysabeau-MediumItalic-inf-t4.vf \
tex-Ysabeau-MediumItalic-inf-t5--base.tfm \
tex-Ysabeau-MediumItalic-inf-t5.tfm \
tex-Ysabeau-MediumItalic-inf-t5.vf \
tex-Ysabeau-MediumItalic-inf-ts3.tfm \
tex-Ysabeau-MediumItalic-lf-cs.tfm \
tex-Ysabeau-MediumItalic-lf-l7x.tfm \
tex-Ysabeau-MediumItalic-lf-lgr.tfm \
tex-Ysabeau-MediumItalic-lf-ly1.tfm \
tex-Ysabeau-MediumItalic-lf-ot1.tfm \
tex-Ysabeau-MediumItalic-lf-qx--base.tfm \
tex-Ysabeau-MediumItalic-lf-qx.tfm \
tex-Ysabeau-MediumItalic-lf-qx.vf \
tex-Ysabeau-MediumItalic-lf-swash-cs.tfm \
tex-Ysabeau-MediumItalic-lf-swash-l7x.tfm \
tex-Ysabeau-MediumItalic-lf-swash-lgr.tfm \
tex-Ysabeau-MediumItalic-lf-swash-ly1.tfm \
tex-Ysabeau-MediumItalic-lf-swash-ot1.tfm \
tex-Ysabeau-MediumItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-MediumItalic-lf-swash-qx.tfm \
tex-Ysabeau-MediumItalic-lf-swash-qx.vf \
tex-Ysabeau-MediumItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t1.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t1.vf \
tex-Ysabeau-MediumItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t2a.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t2a.vf \
tex-Ysabeau-MediumItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t2b.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t2b.vf \
tex-Ysabeau-MediumItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t2c.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t2c.vf \
tex-Ysabeau-MediumItalic-lf-swash-t3.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t4.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t4.vf \
tex-Ysabeau-MediumItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t5.tfm \
tex-Ysabeau-MediumItalic-lf-swash-t5.vf \
tex-Ysabeau-MediumItalic-lf-swash-ts3.tfm \
tex-Ysabeau-MediumItalic-lf-t1--base.tfm \
tex-Ysabeau-MediumItalic-lf-t1.tfm \
tex-Ysabeau-MediumItalic-lf-t1.vf \
tex-Ysabeau-MediumItalic-lf-t2a--base.tfm \
tex-Ysabeau-MediumItalic-lf-t2a.tfm \
tex-Ysabeau-MediumItalic-lf-t2a.vf \
tex-Ysabeau-MediumItalic-lf-t2b--base.tfm \
tex-Ysabeau-MediumItalic-lf-t2b.tfm \
tex-Ysabeau-MediumItalic-lf-t2b.vf \
tex-Ysabeau-MediumItalic-lf-t2c--base.tfm \
tex-Ysabeau-MediumItalic-lf-t2c.tfm \
tex-Ysabeau-MediumItalic-lf-t2c.vf \
tex-Ysabeau-MediumItalic-lf-t3.tfm \
tex-Ysabeau-MediumItalic-lf-t4--base.tfm \
tex-Ysabeau-MediumItalic-lf-t4.tfm \
tex-Ysabeau-MediumItalic-lf-t4.vf \
tex-Ysabeau-MediumItalic-lf-t5--base.tfm \
tex-Ysabeau-MediumItalic-lf-t5.tfm \
tex-Ysabeau-MediumItalic-lf-t5.vf \
tex-Ysabeau-MediumItalic-lf-ts1--base.tfm \
tex-Ysabeau-MediumItalic-lf-ts1.tfm \
tex-Ysabeau-MediumItalic-lf-ts1.vf \
tex-Ysabeau-MediumItalic-lf-ts3.tfm \
tex-Ysabeau-MediumItalic-numr-cs.tfm \
tex-Ysabeau-MediumItalic-numr-l7x.tfm \
tex-Ysabeau-MediumItalic-numr-lgr.tfm \
tex-Ysabeau-MediumItalic-numr-ly1.tfm \
tex-Ysabeau-MediumItalic-numr-ot1.tfm \
tex-Ysabeau-MediumItalic-numr-qx--base.tfm \
tex-Ysabeau-MediumItalic-numr-qx.tfm \
tex-Ysabeau-MediumItalic-numr-qx.vf \
tex-Ysabeau-MediumItalic-numr-t1--base.tfm \
tex-Ysabeau-MediumItalic-numr-t1.tfm \
tex-Ysabeau-MediumItalic-numr-t1.vf \
tex-Ysabeau-MediumItalic-numr-t2a--base.tfm \
tex-Ysabeau-MediumItalic-numr-t2a.tfm \
tex-Ysabeau-MediumItalic-numr-t2a.vf \
tex-Ysabeau-MediumItalic-numr-t2b--base.tfm \
tex-Ysabeau-MediumItalic-numr-t2b.tfm \
tex-Ysabeau-MediumItalic-numr-t2b.vf \
tex-Ysabeau-MediumItalic-numr-t2c--base.tfm \
tex-Ysabeau-MediumItalic-numr-t2c.tfm \
tex-Ysabeau-MediumItalic-numr-t2c.vf \
tex-Ysabeau-MediumItalic-numr-t3.tfm \
tex-Ysabeau-MediumItalic-numr-t4--base.tfm \
tex-Ysabeau-MediumItalic-numr-t4.tfm \
tex-Ysabeau-MediumItalic-numr-t4.vf \
tex-Ysabeau-MediumItalic-numr-t5--base.tfm \
tex-Ysabeau-MediumItalic-numr-t5.tfm \
tex-Ysabeau-MediumItalic-numr-t5.vf \
tex-Ysabeau-MediumItalic-numr-ts3.tfm \
tex-Ysabeau-MediumItalic-osf-cs.tfm \
tex-Ysabeau-MediumItalic-osf-l7x.tfm \
tex-Ysabeau-MediumItalic-osf-lgr.tfm \
tex-Ysabeau-MediumItalic-osf-ly1.tfm \
tex-Ysabeau-MediumItalic-osf-ot1.tfm \
tex-Ysabeau-MediumItalic-osf-qx--base.tfm \
tex-Ysabeau-MediumItalic-osf-qx.tfm \
tex-Ysabeau-MediumItalic-osf-qx.vf \
tex-Ysabeau-MediumItalic-osf-swash-cs.tfm \
tex-Ysabeau-MediumItalic-osf-swash-l7x.tfm \
tex-Ysabeau-MediumItalic-osf-swash-lgr.tfm \
tex-Ysabeau-MediumItalic-osf-swash-ly1.tfm \
tex-Ysabeau-MediumItalic-osf-swash-ot1.tfm \
tex-Ysabeau-MediumItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-MediumItalic-osf-swash-qx.tfm \
tex-Ysabeau-MediumItalic-osf-swash-qx.vf \
tex-Ysabeau-MediumItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t1.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t1.vf \
tex-Ysabeau-MediumItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t2a.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t2a.vf \
tex-Ysabeau-MediumItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t2b.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t2b.vf \
tex-Ysabeau-MediumItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t2c.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t2c.vf \
tex-Ysabeau-MediumItalic-osf-swash-t3.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t4.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t4.vf \
tex-Ysabeau-MediumItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t5.tfm \
tex-Ysabeau-MediumItalic-osf-swash-t5.vf \
tex-Ysabeau-MediumItalic-osf-swash-ts3.tfm \
tex-Ysabeau-MediumItalic-osf-t1--base.tfm \
tex-Ysabeau-MediumItalic-osf-t1.tfm \
tex-Ysabeau-MediumItalic-osf-t1.vf \
tex-Ysabeau-MediumItalic-osf-t2a--base.tfm \
tex-Ysabeau-MediumItalic-osf-t2a.tfm \
tex-Ysabeau-MediumItalic-osf-t2a.vf \
tex-Ysabeau-MediumItalic-osf-t2b--base.tfm \
tex-Ysabeau-MediumItalic-osf-t2b.tfm \
tex-Ysabeau-MediumItalic-osf-t2b.vf \
tex-Ysabeau-MediumItalic-osf-t2c--base.tfm \
tex-Ysabeau-MediumItalic-osf-t2c.tfm \
tex-Ysabeau-MediumItalic-osf-t2c.vf \
tex-Ysabeau-MediumItalic-osf-t3.tfm \
tex-Ysabeau-MediumItalic-osf-t4--base.tfm \
tex-Ysabeau-MediumItalic-osf-t4.tfm \
tex-Ysabeau-MediumItalic-osf-t4.vf \
tex-Ysabeau-MediumItalic-osf-t5--base.tfm \
tex-Ysabeau-MediumItalic-osf-t5.tfm \
tex-Ysabeau-MediumItalic-osf-t5.vf \
tex-Ysabeau-MediumItalic-osf-ts1--base.tfm \
tex-Ysabeau-MediumItalic-osf-ts1.tfm \
tex-Ysabeau-MediumItalic-osf-ts1.vf \
tex-Ysabeau-MediumItalic-osf-ts3.tfm \
tex-Ysabeau-MediumItalic-sup-cs.tfm \
tex-Ysabeau-MediumItalic-sup-l7x.tfm \
tex-Ysabeau-MediumItalic-sup-lgr.tfm \
tex-Ysabeau-MediumItalic-sup-ly1.tfm \
tex-Ysabeau-MediumItalic-sup-ot1.tfm \
tex-Ysabeau-MediumItalic-sup-qx--base.tfm \
tex-Ysabeau-MediumItalic-sup-qx.tfm \
tex-Ysabeau-MediumItalic-sup-qx.vf \
tex-Ysabeau-MediumItalic-sup-t1--base.tfm \
tex-Ysabeau-MediumItalic-sup-t1.tfm \
tex-Ysabeau-MediumItalic-sup-t1.vf \
tex-Ysabeau-MediumItalic-sup-t2a--base.tfm \
tex-Ysabeau-MediumItalic-sup-t2a.tfm \
tex-Ysabeau-MediumItalic-sup-t2a.vf \
tex-Ysabeau-MediumItalic-sup-t2b--base.tfm \
tex-Ysabeau-MediumItalic-sup-t2b.tfm \
tex-Ysabeau-MediumItalic-sup-t2b.vf \
tex-Ysabeau-MediumItalic-sup-t2c--base.tfm \
tex-Ysabeau-MediumItalic-sup-t2c.tfm \
tex-Ysabeau-MediumItalic-sup-t2c.vf \
tex-Ysabeau-MediumItalic-sup-t3.tfm \
tex-Ysabeau-MediumItalic-sup-t4--base.tfm \
tex-Ysabeau-MediumItalic-sup-t4.tfm \
tex-Ysabeau-MediumItalic-sup-t4.vf \
tex-Ysabeau-MediumItalic-sup-t5--base.tfm \
tex-Ysabeau-MediumItalic-sup-t5.tfm \
tex-Ysabeau-MediumItalic-sup-t5.vf \
tex-Ysabeau-MediumItalic-sup-ts3.tfm \
tex-Ysabeau-MediumItalic-tlf-cs.tfm \
tex-Ysabeau-MediumItalic-tlf-l7x.tfm \
tex-Ysabeau-MediumItalic-tlf-lgr.tfm \
tex-Ysabeau-MediumItalic-tlf-ly1.tfm \
tex-Ysabeau-MediumItalic-tlf-ot1.tfm \
tex-Ysabeau-MediumItalic-tlf-qx--base.tfm \
tex-Ysabeau-MediumItalic-tlf-qx.tfm \
tex-Ysabeau-MediumItalic-tlf-qx.vf \
tex-Ysabeau-MediumItalic-tlf-swash-cs.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-qx.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-qx.vf \
tex-Ysabeau-MediumItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t1.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t1.vf \
tex-Ysabeau-MediumItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t2a.vf \
tex-Ysabeau-MediumItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t2b.vf \
tex-Ysabeau-MediumItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t2c.vf \
tex-Ysabeau-MediumItalic-tlf-swash-t3.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t4.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t4.vf \
tex-Ysabeau-MediumItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t5.tfm \
tex-Ysabeau-MediumItalic-tlf-swash-t5.vf \
tex-Ysabeau-MediumItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-MediumItalic-tlf-t1--base.tfm \
tex-Ysabeau-MediumItalic-tlf-t1.tfm \
tex-Ysabeau-MediumItalic-tlf-t1.vf \
tex-Ysabeau-MediumItalic-tlf-t2a--base.tfm \
tex-Ysabeau-MediumItalic-tlf-t2a.tfm \
tex-Ysabeau-MediumItalic-tlf-t2a.vf \
tex-Ysabeau-MediumItalic-tlf-t2b--base.tfm \
tex-Ysabeau-MediumItalic-tlf-t2b.tfm \
tex-Ysabeau-MediumItalic-tlf-t2b.vf \
tex-Ysabeau-MediumItalic-tlf-t2c--base.tfm \
tex-Ysabeau-MediumItalic-tlf-t2c.tfm \
tex-Ysabeau-MediumItalic-tlf-t2c.vf \
tex-Ysabeau-MediumItalic-tlf-t3.tfm \
tex-Ysabeau-MediumItalic-tlf-t4--base.tfm \
tex-Ysabeau-MediumItalic-tlf-t4.tfm \
tex-Ysabeau-MediumItalic-tlf-t4.vf \
tex-Ysabeau-MediumItalic-tlf-t5--base.tfm \
tex-Ysabeau-MediumItalic-tlf-t5.tfm \
tex-Ysabeau-MediumItalic-tlf-t5.vf \
tex-Ysabeau-MediumItalic-tlf-ts1--base.tfm \
tex-Ysabeau-MediumItalic-tlf-ts1.tfm \
tex-Ysabeau-MediumItalic-tlf-ts1.vf \
tex-Ysabeau-MediumItalic-tlf-ts3.tfm \
tex-Ysabeau-MediumItalic-tosf-cs.tfm \
tex-Ysabeau-MediumItalic-tosf-l7x.tfm \
tex-Ysabeau-MediumItalic-tosf-lgr.tfm \
tex-Ysabeau-MediumItalic-tosf-ly1.tfm \
tex-Ysabeau-MediumItalic-tosf-ot1.tfm \
tex-Ysabeau-MediumItalic-tosf-qx--base.tfm \
tex-Ysabeau-MediumItalic-tosf-qx.tfm \
tex-Ysabeau-MediumItalic-tosf-qx.vf \
tex-Ysabeau-MediumItalic-tosf-swash-cs.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-qx.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-qx.vf \
tex-Ysabeau-MediumItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t1.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t1.vf \
tex-Ysabeau-MediumItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t2a.vf \
tex-Ysabeau-MediumItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t2b.vf \
tex-Ysabeau-MediumItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t2c.vf \
tex-Ysabeau-MediumItalic-tosf-swash-t3.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t4.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t4.vf \
tex-Ysabeau-MediumItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t5.tfm \
tex-Ysabeau-MediumItalic-tosf-swash-t5.vf \
tex-Ysabeau-MediumItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-MediumItalic-tosf-t1--base.tfm \
tex-Ysabeau-MediumItalic-tosf-t1.tfm \
tex-Ysabeau-MediumItalic-tosf-t1.vf \
tex-Ysabeau-MediumItalic-tosf-t2a--base.tfm \
tex-Ysabeau-MediumItalic-tosf-t2a.tfm \
tex-Ysabeau-MediumItalic-tosf-t2a.vf \
tex-Ysabeau-MediumItalic-tosf-t2b--base.tfm \
tex-Ysabeau-MediumItalic-tosf-t2b.tfm \
tex-Ysabeau-MediumItalic-tosf-t2b.vf \
tex-Ysabeau-MediumItalic-tosf-t2c--base.tfm \
tex-Ysabeau-MediumItalic-tosf-t2c.tfm \
tex-Ysabeau-MediumItalic-tosf-t2c.vf \
tex-Ysabeau-MediumItalic-tosf-t3.tfm \
tex-Ysabeau-MediumItalic-tosf-t4--base.tfm \
tex-Ysabeau-MediumItalic-tosf-t4.tfm \
tex-Ysabeau-MediumItalic-tosf-t4.vf \
tex-Ysabeau-MediumItalic-tosf-t5--base.tfm \
tex-Ysabeau-MediumItalic-tosf-t5.tfm \
tex-Ysabeau-MediumItalic-tosf-t5.vf \
tex-Ysabeau-MediumItalic-tosf-ts1--base.tfm \
tex-Ysabeau-MediumItalic-tosf-ts1.tfm \
tex-Ysabeau-MediumItalic-tosf-ts1.vf \
tex-Ysabeau-MediumItalic-tosf-ts3.tfm \
tex-Ysabeau-Regular-dnom-cs.tfm \
tex-Ysabeau-Regular-dnom-l7x.tfm \
tex-Ysabeau-Regular-dnom-lgr.tfm \
tex-Ysabeau-Regular-dnom-ly1.tfm \
tex-Ysabeau-Regular-dnom-ot1.tfm \
tex-Ysabeau-Regular-dnom-qx--base.tfm \
tex-Ysabeau-Regular-dnom-qx.tfm \
tex-Ysabeau-Regular-dnom-qx.vf \
tex-Ysabeau-Regular-dnom-t1--base.tfm \
tex-Ysabeau-Regular-dnom-t1.tfm \
tex-Ysabeau-Regular-dnom-t1.vf \
tex-Ysabeau-Regular-dnom-t2a--base.tfm \
tex-Ysabeau-Regular-dnom-t2a.tfm \
tex-Ysabeau-Regular-dnom-t2a.vf \
tex-Ysabeau-Regular-dnom-t2b--base.tfm \
tex-Ysabeau-Regular-dnom-t2b.tfm \
tex-Ysabeau-Regular-dnom-t2b.vf \
tex-Ysabeau-Regular-dnom-t2c--base.tfm \
tex-Ysabeau-Regular-dnom-t2c.tfm \
tex-Ysabeau-Regular-dnom-t2c.vf \
tex-Ysabeau-Regular-dnom-t3.tfm \
tex-Ysabeau-Regular-dnom-t4--base.tfm \
tex-Ysabeau-Regular-dnom-t4.tfm \
tex-Ysabeau-Regular-dnom-t4.vf \
tex-Ysabeau-Regular-dnom-t5--base.tfm \
tex-Ysabeau-Regular-dnom-t5.tfm \
tex-Ysabeau-Regular-dnom-t5.vf \
tex-Ysabeau-Regular-dnom-ts3.tfm \
tex-Ysabeau-Regular-inf-cs.tfm \
tex-Ysabeau-Regular-inf-l7x.tfm \
tex-Ysabeau-Regular-inf-lgr.tfm \
tex-Ysabeau-Regular-inf-ly1.tfm \
tex-Ysabeau-Regular-inf-ot1.tfm \
tex-Ysabeau-Regular-inf-qx--base.tfm \
tex-Ysabeau-Regular-inf-qx.tfm \
tex-Ysabeau-Regular-inf-qx.vf \
tex-Ysabeau-Regular-inf-t1--base.tfm \
tex-Ysabeau-Regular-inf-t1.tfm \
tex-Ysabeau-Regular-inf-t1.vf \
tex-Ysabeau-Regular-inf-t2a--base.tfm \
tex-Ysabeau-Regular-inf-t2a.tfm \
tex-Ysabeau-Regular-inf-t2a.vf \
tex-Ysabeau-Regular-inf-t2b--base.tfm \
tex-Ysabeau-Regular-inf-t2b.tfm \
tex-Ysabeau-Regular-inf-t2b.vf \
tex-Ysabeau-Regular-inf-t2c--base.tfm \
tex-Ysabeau-Regular-inf-t2c.tfm \
tex-Ysabeau-Regular-inf-t2c.vf \
tex-Ysabeau-Regular-inf-t3.tfm \
tex-Ysabeau-Regular-inf-t4--base.tfm \
tex-Ysabeau-Regular-inf-t4.tfm \
tex-Ysabeau-Regular-inf-t4.vf \
tex-Ysabeau-Regular-inf-t5--base.tfm \
tex-Ysabeau-Regular-inf-t5.tfm \
tex-Ysabeau-Regular-inf-t5.vf \
tex-Ysabeau-Regular-inf-ts3.tfm \
tex-Ysabeau-Regular-lf-cs.tfm \
tex-Ysabeau-Regular-lf-l7x.tfm \
tex-Ysabeau-Regular-lf-lgr.tfm \
tex-Ysabeau-Regular-lf-ly1.tfm \
tex-Ysabeau-Regular-lf-ot1.tfm \
tex-Ysabeau-Regular-lf-qx--base.tfm \
tex-Ysabeau-Regular-lf-qx.tfm \
tex-Ysabeau-Regular-lf-qx.vf \
tex-Ysabeau-Regular-lf-sc-cs--base.tfm \
tex-Ysabeau-Regular-lf-sc-cs.tfm \
tex-Ysabeau-Regular-lf-sc-cs.vf \
tex-Ysabeau-Regular-lf-sc-l7x--base.tfm \
tex-Ysabeau-Regular-lf-sc-l7x.tfm \
tex-Ysabeau-Regular-lf-sc-l7x.vf \
tex-Ysabeau-Regular-lf-sc-lgr.tfm \
tex-Ysabeau-Regular-lf-sc-ly1--base.tfm \
tex-Ysabeau-Regular-lf-sc-ly1.tfm \
tex-Ysabeau-Regular-lf-sc-ly1.vf \
tex-Ysabeau-Regular-lf-sc-ot1--base.tfm \
tex-Ysabeau-Regular-lf-sc-ot1.tfm \
tex-Ysabeau-Regular-lf-sc-ot1.vf \
tex-Ysabeau-Regular-lf-sc-qx--base.tfm \
tex-Ysabeau-Regular-lf-sc-qx.tfm \
tex-Ysabeau-Regular-lf-sc-qx.vf \
tex-Ysabeau-Regular-lf-sc-t1--base.tfm \
tex-Ysabeau-Regular-lf-sc-t1.tfm \
tex-Ysabeau-Regular-lf-sc-t1.vf \
tex-Ysabeau-Regular-lf-sc-t2a--base.tfm \
tex-Ysabeau-Regular-lf-sc-t2a.tfm \
tex-Ysabeau-Regular-lf-sc-t2a.vf \
tex-Ysabeau-Regular-lf-sc-t2b--base.tfm \
tex-Ysabeau-Regular-lf-sc-t2b.tfm \
tex-Ysabeau-Regular-lf-sc-t2b.vf \
tex-Ysabeau-Regular-lf-sc-t2c--base.tfm \
tex-Ysabeau-Regular-lf-sc-t2c.tfm \
tex-Ysabeau-Regular-lf-sc-t2c.vf \
tex-Ysabeau-Regular-lf-sc-t3.tfm \
tex-Ysabeau-Regular-lf-sc-t4--base.tfm \
tex-Ysabeau-Regular-lf-sc-t4.tfm \
tex-Ysabeau-Regular-lf-sc-t4.vf \
tex-Ysabeau-Regular-lf-sc-t5--base.tfm \
tex-Ysabeau-Regular-lf-sc-t5.tfm \
tex-Ysabeau-Regular-lf-sc-t5.vf \
tex-Ysabeau-Regular-lf-sc-ts3--base.tfm \
tex-Ysabeau-Regular-lf-sc-ts3.tfm \
tex-Ysabeau-Regular-lf-sc-ts3.vf \
tex-Ysabeau-Regular-lf-t1--base.tfm \
tex-Ysabeau-Regular-lf-t1.tfm \
tex-Ysabeau-Regular-lf-t1.vf \
tex-Ysabeau-Regular-lf-t2a--base.tfm \
tex-Ysabeau-Regular-lf-t2a.tfm \
tex-Ysabeau-Regular-lf-t2a.vf \
tex-Ysabeau-Regular-lf-t2b--base.tfm \
tex-Ysabeau-Regular-lf-t2b.tfm \
tex-Ysabeau-Regular-lf-t2b.vf \
tex-Ysabeau-Regular-lf-t2c--base.tfm \
tex-Ysabeau-Regular-lf-t2c.tfm \
tex-Ysabeau-Regular-lf-t2c.vf \
tex-Ysabeau-Regular-lf-t3.tfm \
tex-Ysabeau-Regular-lf-t4--base.tfm \
tex-Ysabeau-Regular-lf-t4.tfm \
tex-Ysabeau-Regular-lf-t4.vf \
tex-Ysabeau-Regular-lf-t5--base.tfm \
tex-Ysabeau-Regular-lf-t5.tfm \
tex-Ysabeau-Regular-lf-t5.vf \
tex-Ysabeau-Regular-lf-ts1--base.tfm \
tex-Ysabeau-Regular-lf-ts1.tfm \
tex-Ysabeau-Regular-lf-ts1.vf \
tex-Ysabeau-Regular-lf-ts3.tfm \
tex-Ysabeau-Regular-numr-cs.tfm \
tex-Ysabeau-Regular-numr-l7x.tfm \
tex-Ysabeau-Regular-numr-lgr.tfm \
tex-Ysabeau-Regular-numr-ly1.tfm \
tex-Ysabeau-Regular-numr-ot1.tfm \
tex-Ysabeau-Regular-numr-qx--base.tfm \
tex-Ysabeau-Regular-numr-qx.tfm \
tex-Ysabeau-Regular-numr-qx.vf \
tex-Ysabeau-Regular-numr-t1--base.tfm \
tex-Ysabeau-Regular-numr-t1.tfm \
tex-Ysabeau-Regular-numr-t1.vf \
tex-Ysabeau-Regular-numr-t2a--base.tfm \
tex-Ysabeau-Regular-numr-t2a.tfm \
tex-Ysabeau-Regular-numr-t2a.vf \
tex-Ysabeau-Regular-numr-t2b--base.tfm \
tex-Ysabeau-Regular-numr-t2b.tfm \
tex-Ysabeau-Regular-numr-t2b.vf \
tex-Ysabeau-Regular-numr-t2c--base.tfm \
tex-Ysabeau-Regular-numr-t2c.tfm \
tex-Ysabeau-Regular-numr-t2c.vf \
tex-Ysabeau-Regular-numr-t3.tfm \
tex-Ysabeau-Regular-numr-t4--base.tfm \
tex-Ysabeau-Regular-numr-t4.tfm \
tex-Ysabeau-Regular-numr-t4.vf \
tex-Ysabeau-Regular-numr-t5--base.tfm \
tex-Ysabeau-Regular-numr-t5.tfm \
tex-Ysabeau-Regular-numr-t5.vf \
tex-Ysabeau-Regular-numr-ts3.tfm \
tex-Ysabeau-Regular-osf-cs.tfm \
tex-Ysabeau-Regular-osf-l7x.tfm \
tex-Ysabeau-Regular-osf-lgr.tfm \
tex-Ysabeau-Regular-osf-ly1.tfm \
tex-Ysabeau-Regular-osf-ot1.tfm \
tex-Ysabeau-Regular-osf-qx--base.tfm \
tex-Ysabeau-Regular-osf-qx.tfm \
tex-Ysabeau-Regular-osf-qx.vf \
tex-Ysabeau-Regular-osf-sc-cs--base.tfm \
tex-Ysabeau-Regular-osf-sc-cs.tfm \
tex-Ysabeau-Regular-osf-sc-cs.vf \
tex-Ysabeau-Regular-osf-sc-l7x--base.tfm \
tex-Ysabeau-Regular-osf-sc-l7x.tfm \
tex-Ysabeau-Regular-osf-sc-l7x.vf \
tex-Ysabeau-Regular-osf-sc-lgr.tfm \
tex-Ysabeau-Regular-osf-sc-ly1--base.tfm \
tex-Ysabeau-Regular-osf-sc-ly1.tfm \
tex-Ysabeau-Regular-osf-sc-ly1.vf \
tex-Ysabeau-Regular-osf-sc-ot1--base.tfm \
tex-Ysabeau-Regular-osf-sc-ot1.tfm \
tex-Ysabeau-Regular-osf-sc-ot1.vf \
tex-Ysabeau-Regular-osf-sc-qx--base.tfm \
tex-Ysabeau-Regular-osf-sc-qx.tfm \
tex-Ysabeau-Regular-osf-sc-qx.vf \
tex-Ysabeau-Regular-osf-sc-t1--base.tfm \
tex-Ysabeau-Regular-osf-sc-t1.tfm \
tex-Ysabeau-Regular-osf-sc-t1.vf \
tex-Ysabeau-Regular-osf-sc-t2a--base.tfm \
tex-Ysabeau-Regular-osf-sc-t2a.tfm \
tex-Ysabeau-Regular-osf-sc-t2a.vf \
tex-Ysabeau-Regular-osf-sc-t2b--base.tfm \
tex-Ysabeau-Regular-osf-sc-t2b.tfm \
tex-Ysabeau-Regular-osf-sc-t2b.vf \
tex-Ysabeau-Regular-osf-sc-t2c--base.tfm \
tex-Ysabeau-Regular-osf-sc-t2c.tfm \
tex-Ysabeau-Regular-osf-sc-t2c.vf \
tex-Ysabeau-Regular-osf-sc-t3.tfm \
tex-Ysabeau-Regular-osf-sc-t4--base.tfm \
tex-Ysabeau-Regular-osf-sc-t4.tfm \
tex-Ysabeau-Regular-osf-sc-t4.vf \
tex-Ysabeau-Regular-osf-sc-t5--base.tfm \
tex-Ysabeau-Regular-osf-sc-t5.tfm \
tex-Ysabeau-Regular-osf-sc-t5.vf \
tex-Ysabeau-Regular-osf-sc-ts3--base.tfm \
tex-Ysabeau-Regular-osf-sc-ts3.tfm \
tex-Ysabeau-Regular-osf-sc-ts3.vf \
tex-Ysabeau-Regular-osf-t1--base.tfm \
tex-Ysabeau-Regular-osf-t1.tfm \
tex-Ysabeau-Regular-osf-t1.vf \
tex-Ysabeau-Regular-osf-t2a--base.tfm \
tex-Ysabeau-Regular-osf-t2a.tfm \
tex-Ysabeau-Regular-osf-t2a.vf \
tex-Ysabeau-Regular-osf-t2b--base.tfm \
tex-Ysabeau-Regular-osf-t2b.tfm \
tex-Ysabeau-Regular-osf-t2b.vf \
tex-Ysabeau-Regular-osf-t2c--base.tfm \
tex-Ysabeau-Regular-osf-t2c.tfm \
tex-Ysabeau-Regular-osf-t2c.vf \
tex-Ysabeau-Regular-osf-t3.tfm \
tex-Ysabeau-Regular-osf-t4--base.tfm \
tex-Ysabeau-Regular-osf-t4.tfm \
tex-Ysabeau-Regular-osf-t4.vf \
tex-Ysabeau-Regular-osf-t5--base.tfm \
tex-Ysabeau-Regular-osf-t5.tfm \
tex-Ysabeau-Regular-osf-t5.vf \
tex-Ysabeau-Regular-osf-ts1--base.tfm \
tex-Ysabeau-Regular-osf-ts1.tfm \
tex-Ysabeau-Regular-osf-ts1.vf \
tex-Ysabeau-Regular-osf-ts3.tfm \
tex-Ysabeau-Regular-sup-cs.tfm \
tex-Ysabeau-Regular-sup-l7x.tfm \
tex-Ysabeau-Regular-sup-lgr.tfm \
tex-Ysabeau-Regular-sup-ly1.tfm \
tex-Ysabeau-Regular-sup-ot1.tfm \
tex-Ysabeau-Regular-sup-qx--base.tfm \
tex-Ysabeau-Regular-sup-qx.tfm \
tex-Ysabeau-Regular-sup-qx.vf \
tex-Ysabeau-Regular-sup-t1--base.tfm \
tex-Ysabeau-Regular-sup-t1.tfm \
tex-Ysabeau-Regular-sup-t1.vf \
tex-Ysabeau-Regular-sup-t2a--base.tfm \
tex-Ysabeau-Regular-sup-t2a.tfm \
tex-Ysabeau-Regular-sup-t2a.vf \
tex-Ysabeau-Regular-sup-t2b--base.tfm \
tex-Ysabeau-Regular-sup-t2b.tfm \
tex-Ysabeau-Regular-sup-t2b.vf \
tex-Ysabeau-Regular-sup-t2c--base.tfm \
tex-Ysabeau-Regular-sup-t2c.tfm \
tex-Ysabeau-Regular-sup-t2c.vf \
tex-Ysabeau-Regular-sup-t3.tfm \
tex-Ysabeau-Regular-sup-t4--base.tfm \
tex-Ysabeau-Regular-sup-t4.tfm \
tex-Ysabeau-Regular-sup-t4.vf \
tex-Ysabeau-Regular-sup-t5--base.tfm \
tex-Ysabeau-Regular-sup-t5.tfm \
tex-Ysabeau-Regular-sup-t5.vf \
tex-Ysabeau-Regular-sup-ts3.tfm \
tex-Ysabeau-Regular-tlf-cs.tfm \
tex-Ysabeau-Regular-tlf-l7x.tfm \
tex-Ysabeau-Regular-tlf-lgr.tfm \
tex-Ysabeau-Regular-tlf-ly1.tfm \
tex-Ysabeau-Regular-tlf-ot1.tfm \
tex-Ysabeau-Regular-tlf-qx--base.tfm \
tex-Ysabeau-Regular-tlf-qx.tfm \
tex-Ysabeau-Regular-tlf-qx.vf \
tex-Ysabeau-Regular-tlf-sc-cs--base.tfm \
tex-Ysabeau-Regular-tlf-sc-cs.tfm \
tex-Ysabeau-Regular-tlf-sc-cs.vf \
tex-Ysabeau-Regular-tlf-sc-l7x--base.tfm \
tex-Ysabeau-Regular-tlf-sc-l7x.tfm \
tex-Ysabeau-Regular-tlf-sc-l7x.vf \
tex-Ysabeau-Regular-tlf-sc-lgr.tfm \
tex-Ysabeau-Regular-tlf-sc-ly1--base.tfm \
tex-Ysabeau-Regular-tlf-sc-ly1.tfm \
tex-Ysabeau-Regular-tlf-sc-ly1.vf \
tex-Ysabeau-Regular-tlf-sc-ot1--base.tfm \
tex-Ysabeau-Regular-tlf-sc-ot1.tfm \
tex-Ysabeau-Regular-tlf-sc-ot1.vf \
tex-Ysabeau-Regular-tlf-sc-qx--base.tfm \
tex-Ysabeau-Regular-tlf-sc-qx.tfm \
tex-Ysabeau-Regular-tlf-sc-qx.vf \
tex-Ysabeau-Regular-tlf-sc-t1--base.tfm \
tex-Ysabeau-Regular-tlf-sc-t1.tfm \
tex-Ysabeau-Regular-tlf-sc-t1.vf \
tex-Ysabeau-Regular-tlf-sc-t2a--base.tfm \
tex-Ysabeau-Regular-tlf-sc-t2a.tfm \
tex-Ysabeau-Regular-tlf-sc-t2a.vf \
tex-Ysabeau-Regular-tlf-sc-t2b--base.tfm \
tex-Ysabeau-Regular-tlf-sc-t2b.tfm \
tex-Ysabeau-Regular-tlf-sc-t2b.vf \
tex-Ysabeau-Regular-tlf-sc-t2c--base.tfm \
tex-Ysabeau-Regular-tlf-sc-t2c.tfm \
tex-Ysabeau-Regular-tlf-sc-t2c.vf \
tex-Ysabeau-Regular-tlf-sc-t3.tfm \
tex-Ysabeau-Regular-tlf-sc-t4--base.tfm \
tex-Ysabeau-Regular-tlf-sc-t4.tfm \
tex-Ysabeau-Regular-tlf-sc-t4.vf \
tex-Ysabeau-Regular-tlf-sc-t5--base.tfm \
tex-Ysabeau-Regular-tlf-sc-t5.tfm \
tex-Ysabeau-Regular-tlf-sc-t5.vf \
tex-Ysabeau-Regular-tlf-sc-ts3--base.tfm \
tex-Ysabeau-Regular-tlf-sc-ts3.tfm \
tex-Ysabeau-Regular-tlf-sc-ts3.vf \
tex-Ysabeau-Regular-tlf-t1--base.tfm \
tex-Ysabeau-Regular-tlf-t1.tfm \
tex-Ysabeau-Regular-tlf-t1.vf \
tex-Ysabeau-Regular-tlf-t2a--base.tfm \
tex-Ysabeau-Regular-tlf-t2a.tfm \
tex-Ysabeau-Regular-tlf-t2a.vf \
tex-Ysabeau-Regular-tlf-t2b--base.tfm \
tex-Ysabeau-Regular-tlf-t2b.tfm \
tex-Ysabeau-Regular-tlf-t2b.vf \
tex-Ysabeau-Regular-tlf-t2c--base.tfm \
tex-Ysabeau-Regular-tlf-t2c.tfm \
tex-Ysabeau-Regular-tlf-t2c.vf \
tex-Ysabeau-Regular-tlf-t3.tfm \
tex-Ysabeau-Regular-tlf-t4--base.tfm \
tex-Ysabeau-Regular-tlf-t4.tfm \
tex-Ysabeau-Regular-tlf-t4.vf \
tex-Ysabeau-Regular-tlf-t5--base.tfm \
tex-Ysabeau-Regular-tlf-t5.tfm \
tex-Ysabeau-Regular-tlf-t5.vf \
tex-Ysabeau-Regular-tlf-ts1--base.tfm \
tex-Ysabeau-Regular-tlf-ts1.tfm \
tex-Ysabeau-Regular-tlf-ts1.vf \
tex-Ysabeau-Regular-tlf-ts3.tfm \
tex-Ysabeau-Regular-tosf-cs.tfm \
tex-Ysabeau-Regular-tosf-l7x.tfm \
tex-Ysabeau-Regular-tosf-lgr.tfm \
tex-Ysabeau-Regular-tosf-ly1.tfm \
tex-Ysabeau-Regular-tosf-ot1.tfm \
tex-Ysabeau-Regular-tosf-qx--base.tfm \
tex-Ysabeau-Regular-tosf-qx.tfm \
tex-Ysabeau-Regular-tosf-qx.vf \
tex-Ysabeau-Regular-tosf-sc-cs--base.tfm \
tex-Ysabeau-Regular-tosf-sc-cs.tfm \
tex-Ysabeau-Regular-tosf-sc-cs.vf \
tex-Ysabeau-Regular-tosf-sc-l7x--base.tfm \
tex-Ysabeau-Regular-tosf-sc-l7x.tfm \
tex-Ysabeau-Regular-tosf-sc-l7x.vf \
tex-Ysabeau-Regular-tosf-sc-lgr.tfm \
tex-Ysabeau-Regular-tosf-sc-ly1--base.tfm \
tex-Ysabeau-Regular-tosf-sc-ly1.tfm \
tex-Ysabeau-Regular-tosf-sc-ly1.vf \
tex-Ysabeau-Regular-tosf-sc-ot1--base.tfm \
tex-Ysabeau-Regular-tosf-sc-ot1.tfm \
tex-Ysabeau-Regular-tosf-sc-ot1.vf \
tex-Ysabeau-Regular-tosf-sc-qx--base.tfm \
tex-Ysabeau-Regular-tosf-sc-qx.tfm \
tex-Ysabeau-Regular-tosf-sc-qx.vf \
tex-Ysabeau-Regular-tosf-sc-t1--base.tfm \
tex-Ysabeau-Regular-tosf-sc-t1.tfm \
tex-Ysabeau-Regular-tosf-sc-t1.vf \
tex-Ysabeau-Regular-tosf-sc-t2a--base.tfm \
tex-Ysabeau-Regular-tosf-sc-t2a.tfm \
tex-Ysabeau-Regular-tosf-sc-t2a.vf \
tex-Ysabeau-Regular-tosf-sc-t2b--base.tfm \
tex-Ysabeau-Regular-tosf-sc-t2b.tfm \
tex-Ysabeau-Regular-tosf-sc-t2b.vf \
tex-Ysabeau-Regular-tosf-sc-t2c--base.tfm \
tex-Ysabeau-Regular-tosf-sc-t2c.tfm \
tex-Ysabeau-Regular-tosf-sc-t2c.vf \
tex-Ysabeau-Regular-tosf-sc-t3.tfm \
tex-Ysabeau-Regular-tosf-sc-t4--base.tfm \
tex-Ysabeau-Regular-tosf-sc-t4.tfm \
tex-Ysabeau-Regular-tosf-sc-t4.vf \
tex-Ysabeau-Regular-tosf-sc-t5--base.tfm \
tex-Ysabeau-Regular-tosf-sc-t5.tfm \
tex-Ysabeau-Regular-tosf-sc-t5.vf \
tex-Ysabeau-Regular-tosf-sc-ts3--base.tfm \
tex-Ysabeau-Regular-tosf-sc-ts3.tfm \
tex-Ysabeau-Regular-tosf-sc-ts3.vf \
tex-Ysabeau-Regular-tosf-t1--base.tfm \
tex-Ysabeau-Regular-tosf-t1.tfm \
tex-Ysabeau-Regular-tosf-t1.vf \
tex-Ysabeau-Regular-tosf-t2a--base.tfm \
tex-Ysabeau-Regular-tosf-t2a.tfm \
tex-Ysabeau-Regular-tosf-t2a.vf \
tex-Ysabeau-Regular-tosf-t2b--base.tfm \
tex-Ysabeau-Regular-tosf-t2b.tfm \
tex-Ysabeau-Regular-tosf-t2b.vf \
tex-Ysabeau-Regular-tosf-t2c--base.tfm \
tex-Ysabeau-Regular-tosf-t2c.tfm \
tex-Ysabeau-Regular-tosf-t2c.vf \
tex-Ysabeau-Regular-tosf-t3.tfm \
tex-Ysabeau-Regular-tosf-t4--base.tfm \
tex-Ysabeau-Regular-tosf-t4.tfm \
tex-Ysabeau-Regular-tosf-t4.vf \
tex-Ysabeau-Regular-tosf-t5--base.tfm \
tex-Ysabeau-Regular-tosf-t5.tfm \
tex-Ysabeau-Regular-tosf-t5.vf \
tex-Ysabeau-Regular-tosf-ts1--base.tfm \
tex-Ysabeau-Regular-tosf-ts1.tfm \
tex-Ysabeau-Regular-tosf-ts1.vf \
tex-Ysabeau-Regular-tosf-ts3.tfm \
tex-Ysabeau-SemiBold-dnom-cs.tfm \
tex-Ysabeau-SemiBold-dnom-l7x.tfm \
tex-Ysabeau-SemiBold-dnom-lgr.tfm \
tex-Ysabeau-SemiBold-dnom-ly1.tfm \
tex-Ysabeau-SemiBold-dnom-ot1.tfm \
tex-Ysabeau-SemiBold-dnom-qx--base.tfm \
tex-Ysabeau-SemiBold-dnom-qx.tfm \
tex-Ysabeau-SemiBold-dnom-qx.vf \
tex-Ysabeau-SemiBold-dnom-t1--base.tfm \
tex-Ysabeau-SemiBold-dnom-t1.tfm \
tex-Ysabeau-SemiBold-dnom-t1.vf \
tex-Ysabeau-SemiBold-dnom-t2a--base.tfm \
tex-Ysabeau-SemiBold-dnom-t2a.tfm \
tex-Ysabeau-SemiBold-dnom-t2a.vf \
tex-Ysabeau-SemiBold-dnom-t2b--base.tfm \
tex-Ysabeau-SemiBold-dnom-t2b.tfm \
tex-Ysabeau-SemiBold-dnom-t2b.vf \
tex-Ysabeau-SemiBold-dnom-t2c--base.tfm \
tex-Ysabeau-SemiBold-dnom-t2c.tfm \
tex-Ysabeau-SemiBold-dnom-t2c.vf \
tex-Ysabeau-SemiBold-dnom-t3.tfm \
tex-Ysabeau-SemiBold-dnom-t4--base.tfm \
tex-Ysabeau-SemiBold-dnom-t4.tfm \
tex-Ysabeau-SemiBold-dnom-t4.vf \
tex-Ysabeau-SemiBold-dnom-t5--base.tfm \
tex-Ysabeau-SemiBold-dnom-t5.tfm \
tex-Ysabeau-SemiBold-dnom-t5.vf \
tex-Ysabeau-SemiBold-dnom-ts3.tfm \
tex-Ysabeau-SemiBold-inf-cs.tfm \
tex-Ysabeau-SemiBold-inf-l7x.tfm \
tex-Ysabeau-SemiBold-inf-lgr.tfm \
tex-Ysabeau-SemiBold-inf-ly1.tfm \
tex-Ysabeau-SemiBold-inf-ot1.tfm \
tex-Ysabeau-SemiBold-inf-qx--base.tfm \
tex-Ysabeau-SemiBold-inf-qx.tfm \
tex-Ysabeau-SemiBold-inf-qx.vf \
tex-Ysabeau-SemiBold-inf-t1--base.tfm \
tex-Ysabeau-SemiBold-inf-t1.tfm \
tex-Ysabeau-SemiBold-inf-t1.vf \
tex-Ysabeau-SemiBold-inf-t2a--base.tfm \
tex-Ysabeau-SemiBold-inf-t2a.tfm \
tex-Ysabeau-SemiBold-inf-t2a.vf \
tex-Ysabeau-SemiBold-inf-t2b--base.tfm \
tex-Ysabeau-SemiBold-inf-t2b.tfm \
tex-Ysabeau-SemiBold-inf-t2b.vf \
tex-Ysabeau-SemiBold-inf-t2c--base.tfm \
tex-Ysabeau-SemiBold-inf-t2c.tfm \
tex-Ysabeau-SemiBold-inf-t2c.vf \
tex-Ysabeau-SemiBold-inf-t3.tfm \
tex-Ysabeau-SemiBold-inf-t4--base.tfm \
tex-Ysabeau-SemiBold-inf-t4.tfm \
tex-Ysabeau-SemiBold-inf-t4.vf \
tex-Ysabeau-SemiBold-inf-t5--base.tfm \
tex-Ysabeau-SemiBold-inf-t5.tfm \
tex-Ysabeau-SemiBold-inf-t5.vf \
tex-Ysabeau-SemiBold-inf-ts3.tfm \
tex-Ysabeau-SemiBold-lf-cs.tfm \
tex-Ysabeau-SemiBold-lf-l7x.tfm \
tex-Ysabeau-SemiBold-lf-lgr.tfm \
tex-Ysabeau-SemiBold-lf-ly1.tfm \
tex-Ysabeau-SemiBold-lf-ot1.tfm \
tex-Ysabeau-SemiBold-lf-qx--base.tfm \
tex-Ysabeau-SemiBold-lf-qx.tfm \
tex-Ysabeau-SemiBold-lf-qx.vf \
tex-Ysabeau-SemiBold-lf-sc-cs--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-cs.tfm \
tex-Ysabeau-SemiBold-lf-sc-cs.vf \
tex-Ysabeau-SemiBold-lf-sc-l7x--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-l7x.tfm \
tex-Ysabeau-SemiBold-lf-sc-l7x.vf \
tex-Ysabeau-SemiBold-lf-sc-lgr.tfm \
tex-Ysabeau-SemiBold-lf-sc-ly1--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-ly1.tfm \
tex-Ysabeau-SemiBold-lf-sc-ly1.vf \
tex-Ysabeau-SemiBold-lf-sc-ot1--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-ot1.tfm \
tex-Ysabeau-SemiBold-lf-sc-ot1.vf \
tex-Ysabeau-SemiBold-lf-sc-qx--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-qx.tfm \
tex-Ysabeau-SemiBold-lf-sc-qx.vf \
tex-Ysabeau-SemiBold-lf-sc-t1--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-t1.tfm \
tex-Ysabeau-SemiBold-lf-sc-t1.vf \
tex-Ysabeau-SemiBold-lf-sc-t2a--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-t2a.tfm \
tex-Ysabeau-SemiBold-lf-sc-t2a.vf \
tex-Ysabeau-SemiBold-lf-sc-t2b--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-t2b.tfm \
tex-Ysabeau-SemiBold-lf-sc-t2b.vf \
tex-Ysabeau-SemiBold-lf-sc-t2c--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-t2c.tfm \
tex-Ysabeau-SemiBold-lf-sc-t2c.vf \
tex-Ysabeau-SemiBold-lf-sc-t3.tfm \
tex-Ysabeau-SemiBold-lf-sc-t4--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-t4.tfm \
tex-Ysabeau-SemiBold-lf-sc-t4.vf \
tex-Ysabeau-SemiBold-lf-sc-t5--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-t5.tfm \
tex-Ysabeau-SemiBold-lf-sc-t5.vf \
tex-Ysabeau-SemiBold-lf-sc-ts3--base.tfm \
tex-Ysabeau-SemiBold-lf-sc-ts3.tfm \
tex-Ysabeau-SemiBold-lf-sc-ts3.vf \
tex-Ysabeau-SemiBold-lf-t1--base.tfm \
tex-Ysabeau-SemiBold-lf-t1.tfm \
tex-Ysabeau-SemiBold-lf-t1.vf \
tex-Ysabeau-SemiBold-lf-t2a--base.tfm \
tex-Ysabeau-SemiBold-lf-t2a.tfm \
tex-Ysabeau-SemiBold-lf-t2a.vf \
tex-Ysabeau-SemiBold-lf-t2b--base.tfm \
tex-Ysabeau-SemiBold-lf-t2b.tfm \
tex-Ysabeau-SemiBold-lf-t2b.vf \
tex-Ysabeau-SemiBold-lf-t2c--base.tfm \
tex-Ysabeau-SemiBold-lf-t2c.tfm \
tex-Ysabeau-SemiBold-lf-t2c.vf \
tex-Ysabeau-SemiBold-lf-t3.tfm \
tex-Ysabeau-SemiBold-lf-t4--base.tfm \
tex-Ysabeau-SemiBold-lf-t4.tfm \
tex-Ysabeau-SemiBold-lf-t4.vf \
tex-Ysabeau-SemiBold-lf-t5--base.tfm \
tex-Ysabeau-SemiBold-lf-t5.tfm \
tex-Ysabeau-SemiBold-lf-t5.vf \
tex-Ysabeau-SemiBold-lf-ts1--base.tfm \
tex-Ysabeau-SemiBold-lf-ts1.tfm \
tex-Ysabeau-SemiBold-lf-ts1.vf \
tex-Ysabeau-SemiBold-lf-ts3.tfm \
tex-Ysabeau-SemiBold-numr-cs.tfm \
tex-Ysabeau-SemiBold-numr-l7x.tfm \
tex-Ysabeau-SemiBold-numr-lgr.tfm \
tex-Ysabeau-SemiBold-numr-ly1.tfm \
tex-Ysabeau-SemiBold-numr-ot1.tfm \
tex-Ysabeau-SemiBold-numr-qx--base.tfm \
tex-Ysabeau-SemiBold-numr-qx.tfm \
tex-Ysabeau-SemiBold-numr-qx.vf \
tex-Ysabeau-SemiBold-numr-t1--base.tfm \
tex-Ysabeau-SemiBold-numr-t1.tfm \
tex-Ysabeau-SemiBold-numr-t1.vf \
tex-Ysabeau-SemiBold-numr-t2a--base.tfm \
tex-Ysabeau-SemiBold-numr-t2a.tfm \
tex-Ysabeau-SemiBold-numr-t2a.vf \
tex-Ysabeau-SemiBold-numr-t2b--base.tfm \
tex-Ysabeau-SemiBold-numr-t2b.tfm \
tex-Ysabeau-SemiBold-numr-t2b.vf \
tex-Ysabeau-SemiBold-numr-t2c--base.tfm \
tex-Ysabeau-SemiBold-numr-t2c.tfm \
tex-Ysabeau-SemiBold-numr-t2c.vf \
tex-Ysabeau-SemiBold-numr-t3.tfm \
tex-Ysabeau-SemiBold-numr-t4--base.tfm \
tex-Ysabeau-SemiBold-numr-t4.tfm \
tex-Ysabeau-SemiBold-numr-t4.vf \
tex-Ysabeau-SemiBold-numr-t5--base.tfm \
tex-Ysabeau-SemiBold-numr-t5.tfm \
tex-Ysabeau-SemiBold-numr-t5.vf \
tex-Ysabeau-SemiBold-numr-ts3.tfm \
tex-Ysabeau-SemiBold-osf-cs.tfm \
tex-Ysabeau-SemiBold-osf-l7x.tfm \
tex-Ysabeau-SemiBold-osf-lgr.tfm \
tex-Ysabeau-SemiBold-osf-ly1.tfm \
tex-Ysabeau-SemiBold-osf-ot1.tfm \
tex-Ysabeau-SemiBold-osf-qx--base.tfm \
tex-Ysabeau-SemiBold-osf-qx.tfm \
tex-Ysabeau-SemiBold-osf-qx.vf \
tex-Ysabeau-SemiBold-osf-sc-cs--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-cs.tfm \
tex-Ysabeau-SemiBold-osf-sc-cs.vf \
tex-Ysabeau-SemiBold-osf-sc-l7x--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-l7x.tfm \
tex-Ysabeau-SemiBold-osf-sc-l7x.vf \
tex-Ysabeau-SemiBold-osf-sc-lgr.tfm \
tex-Ysabeau-SemiBold-osf-sc-ly1--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-ly1.tfm \
tex-Ysabeau-SemiBold-osf-sc-ly1.vf \
tex-Ysabeau-SemiBold-osf-sc-ot1--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-ot1.tfm \
tex-Ysabeau-SemiBold-osf-sc-ot1.vf \
tex-Ysabeau-SemiBold-osf-sc-qx--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-qx.tfm \
tex-Ysabeau-SemiBold-osf-sc-qx.vf \
tex-Ysabeau-SemiBold-osf-sc-t1--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-t1.tfm \
tex-Ysabeau-SemiBold-osf-sc-t1.vf \
tex-Ysabeau-SemiBold-osf-sc-t2a--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-t2a.tfm \
tex-Ysabeau-SemiBold-osf-sc-t2a.vf \
tex-Ysabeau-SemiBold-osf-sc-t2b--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-t2b.tfm \
tex-Ysabeau-SemiBold-osf-sc-t2b.vf \
tex-Ysabeau-SemiBold-osf-sc-t2c--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-t2c.tfm \
tex-Ysabeau-SemiBold-osf-sc-t2c.vf \
tex-Ysabeau-SemiBold-osf-sc-t3.tfm \
tex-Ysabeau-SemiBold-osf-sc-t4--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-t4.tfm \
tex-Ysabeau-SemiBold-osf-sc-t4.vf \
tex-Ysabeau-SemiBold-osf-sc-t5--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-t5.tfm \
tex-Ysabeau-SemiBold-osf-sc-t5.vf \
tex-Ysabeau-SemiBold-osf-sc-ts3--base.tfm \
tex-Ysabeau-SemiBold-osf-sc-ts3.tfm \
tex-Ysabeau-SemiBold-osf-sc-ts3.vf \
tex-Ysabeau-SemiBold-osf-t1--base.tfm \
tex-Ysabeau-SemiBold-osf-t1.tfm \
tex-Ysabeau-SemiBold-osf-t1.vf \
tex-Ysabeau-SemiBold-osf-t2a--base.tfm \
tex-Ysabeau-SemiBold-osf-t2a.tfm \
tex-Ysabeau-SemiBold-osf-t2a.vf \
tex-Ysabeau-SemiBold-osf-t2b--base.tfm \
tex-Ysabeau-SemiBold-osf-t2b.tfm \
tex-Ysabeau-SemiBold-osf-t2b.vf \
tex-Ysabeau-SemiBold-osf-t2c--base.tfm \
tex-Ysabeau-SemiBold-osf-t2c.tfm \
tex-Ysabeau-SemiBold-osf-t2c.vf \
tex-Ysabeau-SemiBold-osf-t3.tfm \
tex-Ysabeau-SemiBold-osf-t4--base.tfm \
tex-Ysabeau-SemiBold-osf-t4.tfm \
tex-Ysabeau-SemiBold-osf-t4.vf \
tex-Ysabeau-SemiBold-osf-t5--base.tfm \
tex-Ysabeau-SemiBold-osf-t5.tfm \
tex-Ysabeau-SemiBold-osf-t5.vf \
tex-Ysabeau-SemiBold-osf-ts1--base.tfm \
tex-Ysabeau-SemiBold-osf-ts1.tfm \
tex-Ysabeau-SemiBold-osf-ts1.vf \
tex-Ysabeau-SemiBold-osf-ts3.tfm \
tex-Ysabeau-SemiBold-sup-cs.tfm \
tex-Ysabeau-SemiBold-sup-l7x.tfm \
tex-Ysabeau-SemiBold-sup-lgr.tfm \
tex-Ysabeau-SemiBold-sup-ly1.tfm \
tex-Ysabeau-SemiBold-sup-ot1.tfm \
tex-Ysabeau-SemiBold-sup-qx--base.tfm \
tex-Ysabeau-SemiBold-sup-qx.tfm \
tex-Ysabeau-SemiBold-sup-qx.vf \
tex-Ysabeau-SemiBold-sup-t1--base.tfm \
tex-Ysabeau-SemiBold-sup-t1.tfm \
tex-Ysabeau-SemiBold-sup-t1.vf \
tex-Ysabeau-SemiBold-sup-t2a--base.tfm \
tex-Ysabeau-SemiBold-sup-t2a.tfm \
tex-Ysabeau-SemiBold-sup-t2a.vf \
tex-Ysabeau-SemiBold-sup-t2b--base.tfm \
tex-Ysabeau-SemiBold-sup-t2b.tfm \
tex-Ysabeau-SemiBold-sup-t2b.vf \
tex-Ysabeau-SemiBold-sup-t2c--base.tfm \
tex-Ysabeau-SemiBold-sup-t2c.tfm \
tex-Ysabeau-SemiBold-sup-t2c.vf \
tex-Ysabeau-SemiBold-sup-t3.tfm \
tex-Ysabeau-SemiBold-sup-t4--base.tfm \
tex-Ysabeau-SemiBold-sup-t4.tfm \
tex-Ysabeau-SemiBold-sup-t4.vf \
tex-Ysabeau-SemiBold-sup-t5--base.tfm \
tex-Ysabeau-SemiBold-sup-t5.tfm \
tex-Ysabeau-SemiBold-sup-t5.vf \
tex-Ysabeau-SemiBold-sup-ts3.tfm \
tex-Ysabeau-SemiBold-tlf-cs.tfm \
tex-Ysabeau-SemiBold-tlf-l7x.tfm \
tex-Ysabeau-SemiBold-tlf-lgr.tfm \
tex-Ysabeau-SemiBold-tlf-ly1.tfm \
tex-Ysabeau-SemiBold-tlf-ot1.tfm \
tex-Ysabeau-SemiBold-tlf-qx--base.tfm \
tex-Ysabeau-SemiBold-tlf-qx.tfm \
tex-Ysabeau-SemiBold-tlf-qx.vf \
tex-Ysabeau-SemiBold-tlf-sc-cs--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-cs.tfm \
tex-Ysabeau-SemiBold-tlf-sc-cs.vf \
tex-Ysabeau-SemiBold-tlf-sc-l7x--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-l7x.tfm \
tex-Ysabeau-SemiBold-tlf-sc-l7x.vf \
tex-Ysabeau-SemiBold-tlf-sc-lgr.tfm \
tex-Ysabeau-SemiBold-tlf-sc-ly1--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-ly1.tfm \
tex-Ysabeau-SemiBold-tlf-sc-ly1.vf \
tex-Ysabeau-SemiBold-tlf-sc-ot1--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-ot1.tfm \
tex-Ysabeau-SemiBold-tlf-sc-ot1.vf \
tex-Ysabeau-SemiBold-tlf-sc-qx--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-qx.tfm \
tex-Ysabeau-SemiBold-tlf-sc-qx.vf \
tex-Ysabeau-SemiBold-tlf-sc-t1--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t1.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t1.vf \
tex-Ysabeau-SemiBold-tlf-sc-t2a--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t2a.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t2a.vf \
tex-Ysabeau-SemiBold-tlf-sc-t2b--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t2b.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t2b.vf \
tex-Ysabeau-SemiBold-tlf-sc-t2c--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t2c.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t2c.vf \
tex-Ysabeau-SemiBold-tlf-sc-t3.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t4--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t4.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t4.vf \
tex-Ysabeau-SemiBold-tlf-sc-t5--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t5.tfm \
tex-Ysabeau-SemiBold-tlf-sc-t5.vf \
tex-Ysabeau-SemiBold-tlf-sc-ts3--base.tfm \
tex-Ysabeau-SemiBold-tlf-sc-ts3.tfm \
tex-Ysabeau-SemiBold-tlf-sc-ts3.vf \
tex-Ysabeau-SemiBold-tlf-t1--base.tfm \
tex-Ysabeau-SemiBold-tlf-t1.tfm \
tex-Ysabeau-SemiBold-tlf-t1.vf \
tex-Ysabeau-SemiBold-tlf-t2a--base.tfm \
tex-Ysabeau-SemiBold-tlf-t2a.tfm \
tex-Ysabeau-SemiBold-tlf-t2a.vf \
tex-Ysabeau-SemiBold-tlf-t2b--base.tfm \
tex-Ysabeau-SemiBold-tlf-t2b.tfm \
tex-Ysabeau-SemiBold-tlf-t2b.vf \
tex-Ysabeau-SemiBold-tlf-t2c--base.tfm \
tex-Ysabeau-SemiBold-tlf-t2c.tfm \
tex-Ysabeau-SemiBold-tlf-t2c.vf \
tex-Ysabeau-SemiBold-tlf-t3.tfm \
tex-Ysabeau-SemiBold-tlf-t4--base.tfm \
tex-Ysabeau-SemiBold-tlf-t4.tfm \
tex-Ysabeau-SemiBold-tlf-t4.vf \
tex-Ysabeau-SemiBold-tlf-t5--base.tfm \
tex-Ysabeau-SemiBold-tlf-t5.tfm \
tex-Ysabeau-SemiBold-tlf-t5.vf \
tex-Ysabeau-SemiBold-tlf-ts1--base.tfm \
tex-Ysabeau-SemiBold-tlf-ts1.tfm \
tex-Ysabeau-SemiBold-tlf-ts1.vf \
tex-Ysabeau-SemiBold-tlf-ts3.tfm \
tex-Ysabeau-SemiBold-tosf-cs.tfm \
tex-Ysabeau-SemiBold-tosf-l7x.tfm \
tex-Ysabeau-SemiBold-tosf-lgr.tfm \
tex-Ysabeau-SemiBold-tosf-ly1.tfm \
tex-Ysabeau-SemiBold-tosf-ot1.tfm \
tex-Ysabeau-SemiBold-tosf-qx--base.tfm \
tex-Ysabeau-SemiBold-tosf-qx.tfm \
tex-Ysabeau-SemiBold-tosf-qx.vf \
tex-Ysabeau-SemiBold-tosf-sc-cs--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-cs.tfm \
tex-Ysabeau-SemiBold-tosf-sc-cs.vf \
tex-Ysabeau-SemiBold-tosf-sc-l7x--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-l7x.tfm \
tex-Ysabeau-SemiBold-tosf-sc-l7x.vf \
tex-Ysabeau-SemiBold-tosf-sc-lgr.tfm \
tex-Ysabeau-SemiBold-tosf-sc-ly1--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-ly1.tfm \
tex-Ysabeau-SemiBold-tosf-sc-ly1.vf \
tex-Ysabeau-SemiBold-tosf-sc-ot1--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-ot1.tfm \
tex-Ysabeau-SemiBold-tosf-sc-ot1.vf \
tex-Ysabeau-SemiBold-tosf-sc-qx--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-qx.tfm \
tex-Ysabeau-SemiBold-tosf-sc-qx.vf \
tex-Ysabeau-SemiBold-tosf-sc-t1--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t1.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t1.vf \
tex-Ysabeau-SemiBold-tosf-sc-t2a--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t2a.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t2a.vf \
tex-Ysabeau-SemiBold-tosf-sc-t2b--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t2b.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t2b.vf \
tex-Ysabeau-SemiBold-tosf-sc-t2c--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t2c.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t2c.vf \
tex-Ysabeau-SemiBold-tosf-sc-t3.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t4--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t4.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t4.vf \
tex-Ysabeau-SemiBold-tosf-sc-t5--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t5.tfm \
tex-Ysabeau-SemiBold-tosf-sc-t5.vf \
tex-Ysabeau-SemiBold-tosf-sc-ts3--base.tfm \
tex-Ysabeau-SemiBold-tosf-sc-ts3.tfm \
tex-Ysabeau-SemiBold-tosf-sc-ts3.vf \
tex-Ysabeau-SemiBold-tosf-t1--base.tfm \
tex-Ysabeau-SemiBold-tosf-t1.tfm \
tex-Ysabeau-SemiBold-tosf-t1.vf \
tex-Ysabeau-SemiBold-tosf-t2a--base.tfm \
tex-Ysabeau-SemiBold-tosf-t2a.tfm \
tex-Ysabeau-SemiBold-tosf-t2a.vf \
tex-Ysabeau-SemiBold-tosf-t2b--base.tfm \
tex-Ysabeau-SemiBold-tosf-t2b.tfm \
tex-Ysabeau-SemiBold-tosf-t2b.vf \
tex-Ysabeau-SemiBold-tosf-t2c--base.tfm \
tex-Ysabeau-SemiBold-tosf-t2c.tfm \
tex-Ysabeau-SemiBold-tosf-t2c.vf \
tex-Ysabeau-SemiBold-tosf-t3.tfm \
tex-Ysabeau-SemiBold-tosf-t4--base.tfm \
tex-Ysabeau-SemiBold-tosf-t4.tfm \
tex-Ysabeau-SemiBold-tosf-t4.vf \
tex-Ysabeau-SemiBold-tosf-t5--base.tfm \
tex-Ysabeau-SemiBold-tosf-t5.tfm \
tex-Ysabeau-SemiBold-tosf-t5.vf \
tex-Ysabeau-SemiBold-tosf-ts1--base.tfm \
tex-Ysabeau-SemiBold-tosf-ts1.tfm \
tex-Ysabeau-SemiBold-tosf-ts1.vf \
tex-Ysabeau-SemiBold-tosf-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-cs.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-qx.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-qx.vf \
tex-Ysabeau-SemiBoldItalic-dnom-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t1.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t1.vf \
tex-Ysabeau-SemiBoldItalic-dnom-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t2a.vf \
tex-Ysabeau-SemiBoldItalic-dnom-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t2b.vf \
tex-Ysabeau-SemiBoldItalic-dnom-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t2c.vf \
tex-Ysabeau-SemiBoldItalic-dnom-t3.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t4.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t4.vf \
tex-Ysabeau-SemiBoldItalic-dnom-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t5.tfm \
tex-Ysabeau-SemiBoldItalic-dnom-t5.vf \
tex-Ysabeau-SemiBoldItalic-dnom-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-inf-cs.tfm \
tex-Ysabeau-SemiBoldItalic-inf-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-inf-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-inf-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-inf-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-inf-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-inf-qx.tfm \
tex-Ysabeau-SemiBoldItalic-inf-qx.vf \
tex-Ysabeau-SemiBoldItalic-inf-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t1.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t1.vf \
tex-Ysabeau-SemiBoldItalic-inf-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t2a.vf \
tex-Ysabeau-SemiBoldItalic-inf-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t2b.vf \
tex-Ysabeau-SemiBoldItalic-inf-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t2c.vf \
tex-Ysabeau-SemiBoldItalic-inf-t3.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t4.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t4.vf \
tex-Ysabeau-SemiBoldItalic-inf-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t5.tfm \
tex-Ysabeau-SemiBoldItalic-inf-t5.vf \
tex-Ysabeau-SemiBoldItalic-inf-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-lf-cs.tfm \
tex-Ysabeau-SemiBoldItalic-lf-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-lf-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-lf-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-lf-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-lf-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-qx.tfm \
tex-Ysabeau-SemiBoldItalic-lf-qx.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-cs.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-qx.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-qx.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t1.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t1.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2a.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2b.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t2c.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-t3.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t4.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t4.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t5.tfm \
tex-Ysabeau-SemiBoldItalic-lf-swash-t5.vf \
tex-Ysabeau-SemiBoldItalic-lf-swash-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t1.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t1.vf \
tex-Ysabeau-SemiBoldItalic-lf-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t2a.vf \
tex-Ysabeau-SemiBoldItalic-lf-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t2b.vf \
tex-Ysabeau-SemiBoldItalic-lf-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t2c.vf \
tex-Ysabeau-SemiBoldItalic-lf-t3.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t4.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t4.vf \
tex-Ysabeau-SemiBoldItalic-lf-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t5.tfm \
tex-Ysabeau-SemiBoldItalic-lf-t5.vf \
tex-Ysabeau-SemiBoldItalic-lf-ts1--base.tfm \
tex-Ysabeau-SemiBoldItalic-lf-ts1.tfm \
tex-Ysabeau-SemiBoldItalic-lf-ts1.vf \
tex-Ysabeau-SemiBoldItalic-lf-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-numr-cs.tfm \
tex-Ysabeau-SemiBoldItalic-numr-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-numr-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-numr-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-numr-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-numr-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-numr-qx.tfm \
tex-Ysabeau-SemiBoldItalic-numr-qx.vf \
tex-Ysabeau-SemiBoldItalic-numr-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t1.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t1.vf \
tex-Ysabeau-SemiBoldItalic-numr-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t2a.vf \
tex-Ysabeau-SemiBoldItalic-numr-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t2b.vf \
tex-Ysabeau-SemiBoldItalic-numr-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t2c.vf \
tex-Ysabeau-SemiBoldItalic-numr-t3.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t4.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t4.vf \
tex-Ysabeau-SemiBoldItalic-numr-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t5.tfm \
tex-Ysabeau-SemiBoldItalic-numr-t5.vf \
tex-Ysabeau-SemiBoldItalic-numr-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-osf-cs.tfm \
tex-Ysabeau-SemiBoldItalic-osf-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-osf-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-osf-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-osf-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-osf-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-qx.tfm \
tex-Ysabeau-SemiBoldItalic-osf-qx.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-cs.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-qx.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-qx.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t1.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t1.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2a.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2b.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t2c.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-t3.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t4.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t4.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t5.tfm \
tex-Ysabeau-SemiBoldItalic-osf-swash-t5.vf \
tex-Ysabeau-SemiBoldItalic-osf-swash-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t1.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t1.vf \
tex-Ysabeau-SemiBoldItalic-osf-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t2a.vf \
tex-Ysabeau-SemiBoldItalic-osf-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t2b.vf \
tex-Ysabeau-SemiBoldItalic-osf-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t2c.vf \
tex-Ysabeau-SemiBoldItalic-osf-t3.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t4.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t4.vf \
tex-Ysabeau-SemiBoldItalic-osf-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t5.tfm \
tex-Ysabeau-SemiBoldItalic-osf-t5.vf \
tex-Ysabeau-SemiBoldItalic-osf-ts1--base.tfm \
tex-Ysabeau-SemiBoldItalic-osf-ts1.tfm \
tex-Ysabeau-SemiBoldItalic-osf-ts1.vf \
tex-Ysabeau-SemiBoldItalic-osf-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-sup-cs.tfm \
tex-Ysabeau-SemiBoldItalic-sup-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-sup-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-sup-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-sup-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-sup-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-sup-qx.tfm \
tex-Ysabeau-SemiBoldItalic-sup-qx.vf \
tex-Ysabeau-SemiBoldItalic-sup-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t1.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t1.vf \
tex-Ysabeau-SemiBoldItalic-sup-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t2a.vf \
tex-Ysabeau-SemiBoldItalic-sup-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t2b.vf \
tex-Ysabeau-SemiBoldItalic-sup-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t2c.vf \
tex-Ysabeau-SemiBoldItalic-sup-t3.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t4.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t4.vf \
tex-Ysabeau-SemiBoldItalic-sup-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t5.tfm \
tex-Ysabeau-SemiBoldItalic-sup-t5.vf \
tex-Ysabeau-SemiBoldItalic-sup-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-cs.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-qx.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-qx.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-cs.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-qx.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-qx.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t1.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t1.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2a.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2b.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t2c.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t3.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t4.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t4.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t5.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-swash-t5.vf \
tex-Ysabeau-SemiBoldItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t1.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t1.vf \
tex-Ysabeau-SemiBoldItalic-tlf-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t2a.vf \
tex-Ysabeau-SemiBoldItalic-tlf-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t2b.vf \
tex-Ysabeau-SemiBoldItalic-tlf-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t2c.vf \
tex-Ysabeau-SemiBoldItalic-tlf-t3.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t4.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t4.vf \
tex-Ysabeau-SemiBoldItalic-tlf-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t5.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-t5.vf \
tex-Ysabeau-SemiBoldItalic-tlf-ts1--base.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-ts1.tfm \
tex-Ysabeau-SemiBoldItalic-tlf-ts1.vf \
tex-Ysabeau-SemiBoldItalic-tlf-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-cs.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-qx.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-qx.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-cs.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-qx.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-qx.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t1.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t1.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2a.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2b.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t2c.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t3.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t4.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t4.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t5.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-swash-t5.vf \
tex-Ysabeau-SemiBoldItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t1--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t1.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t1.vf \
tex-Ysabeau-SemiBoldItalic-tosf-t2a--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t2a.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t2a.vf \
tex-Ysabeau-SemiBoldItalic-tosf-t2b--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t2b.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t2b.vf \
tex-Ysabeau-SemiBoldItalic-tosf-t2c--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t2c.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t2c.vf \
tex-Ysabeau-SemiBoldItalic-tosf-t3.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t4--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t4.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t4.vf \
tex-Ysabeau-SemiBoldItalic-tosf-t5--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t5.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-t5.vf \
tex-Ysabeau-SemiBoldItalic-tosf-ts1--base.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-ts1.tfm \
tex-Ysabeau-SemiBoldItalic-tosf-ts1.vf \
tex-Ysabeau-SemiBoldItalic-tosf-ts3.tfm \
tex-Ysabeau-Thin-dnom-cs.tfm \
tex-Ysabeau-Thin-dnom-l7x.tfm \
tex-Ysabeau-Thin-dnom-lgr.tfm \
tex-Ysabeau-Thin-dnom-ly1.tfm \
tex-Ysabeau-Thin-dnom-ot1.tfm \
tex-Ysabeau-Thin-dnom-qx--base.tfm \
tex-Ysabeau-Thin-dnom-qx.tfm \
tex-Ysabeau-Thin-dnom-qx.vf \
tex-Ysabeau-Thin-dnom-t1--base.tfm \
tex-Ysabeau-Thin-dnom-t1.tfm \
tex-Ysabeau-Thin-dnom-t1.vf \
tex-Ysabeau-Thin-dnom-t2a--base.tfm \
tex-Ysabeau-Thin-dnom-t2a.tfm \
tex-Ysabeau-Thin-dnom-t2a.vf \
tex-Ysabeau-Thin-dnom-t2b--base.tfm \
tex-Ysabeau-Thin-dnom-t2b.tfm \
tex-Ysabeau-Thin-dnom-t2b.vf \
tex-Ysabeau-Thin-dnom-t2c--base.tfm \
tex-Ysabeau-Thin-dnom-t2c.tfm \
tex-Ysabeau-Thin-dnom-t2c.vf \
tex-Ysabeau-Thin-dnom-t3.tfm \
tex-Ysabeau-Thin-dnom-t4--base.tfm \
tex-Ysabeau-Thin-dnom-t4.tfm \
tex-Ysabeau-Thin-dnom-t4.vf \
tex-Ysabeau-Thin-dnom-t5--base.tfm \
tex-Ysabeau-Thin-dnom-t5.tfm \
tex-Ysabeau-Thin-dnom-t5.vf \
tex-Ysabeau-Thin-dnom-ts3.tfm \
tex-Ysabeau-Thin-inf-cs.tfm \
tex-Ysabeau-Thin-inf-l7x.tfm \
tex-Ysabeau-Thin-inf-lgr.tfm \
tex-Ysabeau-Thin-inf-ly1.tfm \
tex-Ysabeau-Thin-inf-ot1.tfm \
tex-Ysabeau-Thin-inf-qx--base.tfm \
tex-Ysabeau-Thin-inf-qx.tfm \
tex-Ysabeau-Thin-inf-qx.vf \
tex-Ysabeau-Thin-inf-t1--base.tfm \
tex-Ysabeau-Thin-inf-t1.tfm \
tex-Ysabeau-Thin-inf-t1.vf \
tex-Ysabeau-Thin-inf-t2a--base.tfm \
tex-Ysabeau-Thin-inf-t2a.tfm \
tex-Ysabeau-Thin-inf-t2a.vf \
tex-Ysabeau-Thin-inf-t2b--base.tfm \
tex-Ysabeau-Thin-inf-t2b.tfm \
tex-Ysabeau-Thin-inf-t2b.vf \
tex-Ysabeau-Thin-inf-t2c--base.tfm \
tex-Ysabeau-Thin-inf-t2c.tfm \
tex-Ysabeau-Thin-inf-t2c.vf \
tex-Ysabeau-Thin-inf-t3.tfm \
tex-Ysabeau-Thin-inf-t4--base.tfm \
tex-Ysabeau-Thin-inf-t4.tfm \
tex-Ysabeau-Thin-inf-t4.vf \
tex-Ysabeau-Thin-inf-t5--base.tfm \
tex-Ysabeau-Thin-inf-t5.tfm \
tex-Ysabeau-Thin-inf-t5.vf \
tex-Ysabeau-Thin-inf-ts3.tfm \
tex-Ysabeau-Thin-lf-cs.tfm \
tex-Ysabeau-Thin-lf-l7x.tfm \
tex-Ysabeau-Thin-lf-lgr.tfm \
tex-Ysabeau-Thin-lf-ly1.tfm \
tex-Ysabeau-Thin-lf-ot1.tfm \
tex-Ysabeau-Thin-lf-qx--base.tfm \
tex-Ysabeau-Thin-lf-qx.tfm \
tex-Ysabeau-Thin-lf-qx.vf \
tex-Ysabeau-Thin-lf-sc-cs--base.tfm \
tex-Ysabeau-Thin-lf-sc-cs.tfm \
tex-Ysabeau-Thin-lf-sc-cs.vf \
tex-Ysabeau-Thin-lf-sc-l7x--base.tfm \
tex-Ysabeau-Thin-lf-sc-l7x.tfm \
tex-Ysabeau-Thin-lf-sc-l7x.vf \
tex-Ysabeau-Thin-lf-sc-lgr.tfm \
tex-Ysabeau-Thin-lf-sc-ly1--base.tfm \
tex-Ysabeau-Thin-lf-sc-ly1.tfm \
tex-Ysabeau-Thin-lf-sc-ly1.vf \
tex-Ysabeau-Thin-lf-sc-ot1--base.tfm \
tex-Ysabeau-Thin-lf-sc-ot1.tfm \
tex-Ysabeau-Thin-lf-sc-ot1.vf \
tex-Ysabeau-Thin-lf-sc-qx--base.tfm \
tex-Ysabeau-Thin-lf-sc-qx.tfm \
tex-Ysabeau-Thin-lf-sc-qx.vf \
tex-Ysabeau-Thin-lf-sc-t1--base.tfm \
tex-Ysabeau-Thin-lf-sc-t1.tfm \
tex-Ysabeau-Thin-lf-sc-t1.vf \
tex-Ysabeau-Thin-lf-sc-t2a--base.tfm \
tex-Ysabeau-Thin-lf-sc-t2a.tfm \
tex-Ysabeau-Thin-lf-sc-t2a.vf \
tex-Ysabeau-Thin-lf-sc-t2b--base.tfm \
tex-Ysabeau-Thin-lf-sc-t2b.tfm \
tex-Ysabeau-Thin-lf-sc-t2b.vf \
tex-Ysabeau-Thin-lf-sc-t2c--base.tfm \
tex-Ysabeau-Thin-lf-sc-t2c.tfm \
tex-Ysabeau-Thin-lf-sc-t2c.vf \
tex-Ysabeau-Thin-lf-sc-t3.tfm \
tex-Ysabeau-Thin-lf-sc-t4--base.tfm \
tex-Ysabeau-Thin-lf-sc-t4.tfm \
tex-Ysabeau-Thin-lf-sc-t4.vf \
tex-Ysabeau-Thin-lf-sc-t5--base.tfm \
tex-Ysabeau-Thin-lf-sc-t5.tfm \
tex-Ysabeau-Thin-lf-sc-t5.vf \
tex-Ysabeau-Thin-lf-sc-ts3--base.tfm \
tex-Ysabeau-Thin-lf-sc-ts3.tfm \
tex-Ysabeau-Thin-lf-sc-ts3.vf \
tex-Ysabeau-Thin-lf-t1--base.tfm \
tex-Ysabeau-Thin-lf-t1.tfm \
tex-Ysabeau-Thin-lf-t1.vf \
tex-Ysabeau-Thin-lf-t2a--base.tfm \
tex-Ysabeau-Thin-lf-t2a.tfm \
tex-Ysabeau-Thin-lf-t2a.vf \
tex-Ysabeau-Thin-lf-t2b--base.tfm \
tex-Ysabeau-Thin-lf-t2b.tfm \
tex-Ysabeau-Thin-lf-t2b.vf \
tex-Ysabeau-Thin-lf-t2c--base.tfm \
tex-Ysabeau-Thin-lf-t2c.tfm \
tex-Ysabeau-Thin-lf-t2c.vf \
tex-Ysabeau-Thin-lf-t3.tfm \
tex-Ysabeau-Thin-lf-t4--base.tfm \
tex-Ysabeau-Thin-lf-t4.tfm \
tex-Ysabeau-Thin-lf-t4.vf \
tex-Ysabeau-Thin-lf-t5--base.tfm \
tex-Ysabeau-Thin-lf-t5.tfm \
tex-Ysabeau-Thin-lf-t5.vf \
tex-Ysabeau-Thin-lf-ts1--base.tfm \
tex-Ysabeau-Thin-lf-ts1.tfm \
tex-Ysabeau-Thin-lf-ts1.vf \
tex-Ysabeau-Thin-lf-ts3.tfm \
tex-Ysabeau-Thin-numr-cs.tfm \
tex-Ysabeau-Thin-numr-l7x.tfm \
tex-Ysabeau-Thin-numr-lgr.tfm \
tex-Ysabeau-Thin-numr-ly1.tfm \
tex-Ysabeau-Thin-numr-ot1.tfm \
tex-Ysabeau-Thin-numr-qx--base.tfm \
tex-Ysabeau-Thin-numr-qx.tfm \
tex-Ysabeau-Thin-numr-qx.vf \
tex-Ysabeau-Thin-numr-t1--base.tfm \
tex-Ysabeau-Thin-numr-t1.tfm \
tex-Ysabeau-Thin-numr-t1.vf \
tex-Ysabeau-Thin-numr-t2a--base.tfm \
tex-Ysabeau-Thin-numr-t2a.tfm \
tex-Ysabeau-Thin-numr-t2a.vf \
tex-Ysabeau-Thin-numr-t2b--base.tfm \
tex-Ysabeau-Thin-numr-t2b.tfm \
tex-Ysabeau-Thin-numr-t2b.vf \
tex-Ysabeau-Thin-numr-t2c--base.tfm \
tex-Ysabeau-Thin-numr-t2c.tfm \
tex-Ysabeau-Thin-numr-t2c.vf \
tex-Ysabeau-Thin-numr-t3.tfm \
tex-Ysabeau-Thin-numr-t4--base.tfm \
tex-Ysabeau-Thin-numr-t4.tfm \
tex-Ysabeau-Thin-numr-t4.vf \
tex-Ysabeau-Thin-numr-t5--base.tfm \
tex-Ysabeau-Thin-numr-t5.tfm \
tex-Ysabeau-Thin-numr-t5.vf \
tex-Ysabeau-Thin-numr-ts3.tfm \
tex-Ysabeau-Thin-osf-cs.tfm \
tex-Ysabeau-Thin-osf-l7x.tfm \
tex-Ysabeau-Thin-osf-lgr.tfm \
tex-Ysabeau-Thin-osf-ly1.tfm \
tex-Ysabeau-Thin-osf-ot1.tfm \
tex-Ysabeau-Thin-osf-qx--base.tfm \
tex-Ysabeau-Thin-osf-qx.tfm \
tex-Ysabeau-Thin-osf-qx.vf \
tex-Ysabeau-Thin-osf-sc-cs--base.tfm \
tex-Ysabeau-Thin-osf-sc-cs.tfm \
tex-Ysabeau-Thin-osf-sc-cs.vf \
tex-Ysabeau-Thin-osf-sc-l7x--base.tfm \
tex-Ysabeau-Thin-osf-sc-l7x.tfm \
tex-Ysabeau-Thin-osf-sc-l7x.vf \
tex-Ysabeau-Thin-osf-sc-lgr.tfm \
tex-Ysabeau-Thin-osf-sc-ly1--base.tfm \
tex-Ysabeau-Thin-osf-sc-ly1.tfm \
tex-Ysabeau-Thin-osf-sc-ly1.vf \
tex-Ysabeau-Thin-osf-sc-ot1--base.tfm \
tex-Ysabeau-Thin-osf-sc-ot1.tfm \
tex-Ysabeau-Thin-osf-sc-ot1.vf \
tex-Ysabeau-Thin-osf-sc-qx--base.tfm \
tex-Ysabeau-Thin-osf-sc-qx.tfm \
tex-Ysabeau-Thin-osf-sc-qx.vf \
tex-Ysabeau-Thin-osf-sc-t1--base.tfm \
tex-Ysabeau-Thin-osf-sc-t1.tfm \
tex-Ysabeau-Thin-osf-sc-t1.vf \
tex-Ysabeau-Thin-osf-sc-t2a--base.tfm \
tex-Ysabeau-Thin-osf-sc-t2a.tfm \
tex-Ysabeau-Thin-osf-sc-t2a.vf \
tex-Ysabeau-Thin-osf-sc-t2b--base.tfm \
tex-Ysabeau-Thin-osf-sc-t2b.tfm \
tex-Ysabeau-Thin-osf-sc-t2b.vf \
tex-Ysabeau-Thin-osf-sc-t2c--base.tfm \
tex-Ysabeau-Thin-osf-sc-t2c.tfm \
tex-Ysabeau-Thin-osf-sc-t2c.vf \
tex-Ysabeau-Thin-osf-sc-t3.tfm \
tex-Ysabeau-Thin-osf-sc-t4--base.tfm \
tex-Ysabeau-Thin-osf-sc-t4.tfm \
tex-Ysabeau-Thin-osf-sc-t4.vf \
tex-Ysabeau-Thin-osf-sc-t5--base.tfm \
tex-Ysabeau-Thin-osf-sc-t5.tfm \
tex-Ysabeau-Thin-osf-sc-t5.vf \
tex-Ysabeau-Thin-osf-sc-ts3--base.tfm \
tex-Ysabeau-Thin-osf-sc-ts3.tfm \
tex-Ysabeau-Thin-osf-sc-ts3.vf \
tex-Ysabeau-Thin-osf-t1--base.tfm \
tex-Ysabeau-Thin-osf-t1.tfm \
tex-Ysabeau-Thin-osf-t1.vf \
tex-Ysabeau-Thin-osf-t2a--base.tfm \
tex-Ysabeau-Thin-osf-t2a.tfm \
tex-Ysabeau-Thin-osf-t2a.vf \
tex-Ysabeau-Thin-osf-t2b--base.tfm \
tex-Ysabeau-Thin-osf-t2b.tfm \
tex-Ysabeau-Thin-osf-t2b.vf \
tex-Ysabeau-Thin-osf-t2c--base.tfm \
tex-Ysabeau-Thin-osf-t2c.tfm \
tex-Ysabeau-Thin-osf-t2c.vf \
tex-Ysabeau-Thin-osf-t3.tfm \
tex-Ysabeau-Thin-osf-t4--base.tfm \
tex-Ysabeau-Thin-osf-t4.tfm \
tex-Ysabeau-Thin-osf-t4.vf \
tex-Ysabeau-Thin-osf-t5--base.tfm \
tex-Ysabeau-Thin-osf-t5.tfm \
tex-Ysabeau-Thin-osf-t5.vf \
tex-Ysabeau-Thin-osf-ts1--base.tfm \
tex-Ysabeau-Thin-osf-ts1.tfm \
tex-Ysabeau-Thin-osf-ts1.vf \
tex-Ysabeau-Thin-osf-ts3.tfm \
tex-Ysabeau-Thin-sup-cs.tfm \
tex-Ysabeau-Thin-sup-l7x.tfm \
tex-Ysabeau-Thin-sup-lgr.tfm \
tex-Ysabeau-Thin-sup-ly1.tfm \
tex-Ysabeau-Thin-sup-ot1.tfm \
tex-Ysabeau-Thin-sup-qx--base.tfm \
tex-Ysabeau-Thin-sup-qx.tfm \
tex-Ysabeau-Thin-sup-qx.vf \
tex-Ysabeau-Thin-sup-t1--base.tfm \
tex-Ysabeau-Thin-sup-t1.tfm \
tex-Ysabeau-Thin-sup-t1.vf \
tex-Ysabeau-Thin-sup-t2a--base.tfm \
tex-Ysabeau-Thin-sup-t2a.tfm \
tex-Ysabeau-Thin-sup-t2a.vf \
tex-Ysabeau-Thin-sup-t2b--base.tfm \
tex-Ysabeau-Thin-sup-t2b.tfm \
tex-Ysabeau-Thin-sup-t2b.vf \
tex-Ysabeau-Thin-sup-t2c--base.tfm \
tex-Ysabeau-Thin-sup-t2c.tfm \
tex-Ysabeau-Thin-sup-t2c.vf \
tex-Ysabeau-Thin-sup-t3.tfm \
tex-Ysabeau-Thin-sup-t4--base.tfm \
tex-Ysabeau-Thin-sup-t4.tfm \
tex-Ysabeau-Thin-sup-t4.vf \
tex-Ysabeau-Thin-sup-t5--base.tfm \
tex-Ysabeau-Thin-sup-t5.tfm \
tex-Ysabeau-Thin-sup-t5.vf \
tex-Ysabeau-Thin-sup-ts3.tfm \
tex-Ysabeau-Thin-tlf-cs.tfm \
tex-Ysabeau-Thin-tlf-l7x.tfm \
tex-Ysabeau-Thin-tlf-lgr.tfm \
tex-Ysabeau-Thin-tlf-ly1.tfm \
tex-Ysabeau-Thin-tlf-ot1.tfm \
tex-Ysabeau-Thin-tlf-qx--base.tfm \
tex-Ysabeau-Thin-tlf-qx.tfm \
tex-Ysabeau-Thin-tlf-qx.vf \
tex-Ysabeau-Thin-tlf-sc-cs--base.tfm \
tex-Ysabeau-Thin-tlf-sc-cs.tfm \
tex-Ysabeau-Thin-tlf-sc-cs.vf \
tex-Ysabeau-Thin-tlf-sc-l7x--base.tfm \
tex-Ysabeau-Thin-tlf-sc-l7x.tfm \
tex-Ysabeau-Thin-tlf-sc-l7x.vf \
tex-Ysabeau-Thin-tlf-sc-lgr.tfm \
tex-Ysabeau-Thin-tlf-sc-ly1--base.tfm \
tex-Ysabeau-Thin-tlf-sc-ly1.tfm \
tex-Ysabeau-Thin-tlf-sc-ly1.vf \
tex-Ysabeau-Thin-tlf-sc-ot1--base.tfm \
tex-Ysabeau-Thin-tlf-sc-ot1.tfm \
tex-Ysabeau-Thin-tlf-sc-ot1.vf \
tex-Ysabeau-Thin-tlf-sc-qx--base.tfm \
tex-Ysabeau-Thin-tlf-sc-qx.tfm \
tex-Ysabeau-Thin-tlf-sc-qx.vf \
tex-Ysabeau-Thin-tlf-sc-t1--base.tfm \
tex-Ysabeau-Thin-tlf-sc-t1.tfm \
tex-Ysabeau-Thin-tlf-sc-t1.vf \
tex-Ysabeau-Thin-tlf-sc-t2a--base.tfm \
tex-Ysabeau-Thin-tlf-sc-t2a.tfm \
tex-Ysabeau-Thin-tlf-sc-t2a.vf \
tex-Ysabeau-Thin-tlf-sc-t2b--base.tfm \
tex-Ysabeau-Thin-tlf-sc-t2b.tfm \
tex-Ysabeau-Thin-tlf-sc-t2b.vf \
tex-Ysabeau-Thin-tlf-sc-t2c--base.tfm \
tex-Ysabeau-Thin-tlf-sc-t2c.tfm \
tex-Ysabeau-Thin-tlf-sc-t2c.vf \
tex-Ysabeau-Thin-tlf-sc-t3.tfm \
tex-Ysabeau-Thin-tlf-sc-t4--base.tfm \
tex-Ysabeau-Thin-tlf-sc-t4.tfm \
tex-Ysabeau-Thin-tlf-sc-t4.vf \
tex-Ysabeau-Thin-tlf-sc-t5--base.tfm \
tex-Ysabeau-Thin-tlf-sc-t5.tfm \
tex-Ysabeau-Thin-tlf-sc-t5.vf \
tex-Ysabeau-Thin-tlf-sc-ts3--base.tfm \
tex-Ysabeau-Thin-tlf-sc-ts3.tfm \
tex-Ysabeau-Thin-tlf-sc-ts3.vf \
tex-Ysabeau-Thin-tlf-t1--base.tfm \
tex-Ysabeau-Thin-tlf-t1.tfm \
tex-Ysabeau-Thin-tlf-t1.vf \
tex-Ysabeau-Thin-tlf-t2a--base.tfm \
tex-Ysabeau-Thin-tlf-t2a.tfm \
tex-Ysabeau-Thin-tlf-t2a.vf \
tex-Ysabeau-Thin-tlf-t2b--base.tfm \
tex-Ysabeau-Thin-tlf-t2b.tfm \
tex-Ysabeau-Thin-tlf-t2b.vf \
tex-Ysabeau-Thin-tlf-t2c--base.tfm \
tex-Ysabeau-Thin-tlf-t2c.tfm \
tex-Ysabeau-Thin-tlf-t2c.vf \
tex-Ysabeau-Thin-tlf-t3.tfm \
tex-Ysabeau-Thin-tlf-t4--base.tfm \
tex-Ysabeau-Thin-tlf-t4.tfm \
tex-Ysabeau-Thin-tlf-t4.vf \
tex-Ysabeau-Thin-tlf-t5--base.tfm \
tex-Ysabeau-Thin-tlf-t5.tfm \
tex-Ysabeau-Thin-tlf-t5.vf \
tex-Ysabeau-Thin-tlf-ts1--base.tfm \
tex-Ysabeau-Thin-tlf-ts1.tfm \
tex-Ysabeau-Thin-tlf-ts1.vf \
tex-Ysabeau-Thin-tlf-ts3.tfm \
tex-Ysabeau-Thin-tosf-cs.tfm \
tex-Ysabeau-Thin-tosf-l7x.tfm \
tex-Ysabeau-Thin-tosf-lgr.tfm \
tex-Ysabeau-Thin-tosf-ly1.tfm \
tex-Ysabeau-Thin-tosf-ot1.tfm \
tex-Ysabeau-Thin-tosf-qx--base.tfm \
tex-Ysabeau-Thin-tosf-qx.tfm \
tex-Ysabeau-Thin-tosf-qx.vf \
tex-Ysabeau-Thin-tosf-sc-cs--base.tfm \
tex-Ysabeau-Thin-tosf-sc-cs.tfm \
tex-Ysabeau-Thin-tosf-sc-cs.vf \
tex-Ysabeau-Thin-tosf-sc-l7x--base.tfm \
tex-Ysabeau-Thin-tosf-sc-l7x.tfm \
tex-Ysabeau-Thin-tosf-sc-l7x.vf \
tex-Ysabeau-Thin-tosf-sc-lgr.tfm \
tex-Ysabeau-Thin-tosf-sc-ly1--base.tfm \
tex-Ysabeau-Thin-tosf-sc-ly1.tfm \
tex-Ysabeau-Thin-tosf-sc-ly1.vf \
tex-Ysabeau-Thin-tosf-sc-ot1--base.tfm \
tex-Ysabeau-Thin-tosf-sc-ot1.tfm \
tex-Ysabeau-Thin-tosf-sc-ot1.vf \
tex-Ysabeau-Thin-tosf-sc-qx--base.tfm \
tex-Ysabeau-Thin-tosf-sc-qx.tfm \
tex-Ysabeau-Thin-tosf-sc-qx.vf \
tex-Ysabeau-Thin-tosf-sc-t1--base.tfm \
tex-Ysabeau-Thin-tosf-sc-t1.tfm \
tex-Ysabeau-Thin-tosf-sc-t1.vf \
tex-Ysabeau-Thin-tosf-sc-t2a--base.tfm \
tex-Ysabeau-Thin-tosf-sc-t2a.tfm \
tex-Ysabeau-Thin-tosf-sc-t2a.vf \
tex-Ysabeau-Thin-tosf-sc-t2b--base.tfm \
tex-Ysabeau-Thin-tosf-sc-t2b.tfm \
tex-Ysabeau-Thin-tosf-sc-t2b.vf \
tex-Ysabeau-Thin-tosf-sc-t2c--base.tfm \
tex-Ysabeau-Thin-tosf-sc-t2c.tfm \
tex-Ysabeau-Thin-tosf-sc-t2c.vf \
tex-Ysabeau-Thin-tosf-sc-t3.tfm \
tex-Ysabeau-Thin-tosf-sc-t4--base.tfm \
tex-Ysabeau-Thin-tosf-sc-t4.tfm \
tex-Ysabeau-Thin-tosf-sc-t4.vf \
tex-Ysabeau-Thin-tosf-sc-t5--base.tfm \
tex-Ysabeau-Thin-tosf-sc-t5.tfm \
tex-Ysabeau-Thin-tosf-sc-t5.vf \
tex-Ysabeau-Thin-tosf-sc-ts3--base.tfm \
tex-Ysabeau-Thin-tosf-sc-ts3.tfm \
tex-Ysabeau-Thin-tosf-sc-ts3.vf \
tex-Ysabeau-Thin-tosf-t1--base.tfm \
tex-Ysabeau-Thin-tosf-t1.tfm \
tex-Ysabeau-Thin-tosf-t1.vf \
tex-Ysabeau-Thin-tosf-t2a--base.tfm \
tex-Ysabeau-Thin-tosf-t2a.tfm \
tex-Ysabeau-Thin-tosf-t2a.vf \
tex-Ysabeau-Thin-tosf-t2b--base.tfm \
tex-Ysabeau-Thin-tosf-t2b.tfm \
tex-Ysabeau-Thin-tosf-t2b.vf \
tex-Ysabeau-Thin-tosf-t2c--base.tfm \
tex-Ysabeau-Thin-tosf-t2c.tfm \
tex-Ysabeau-Thin-tosf-t2c.vf \
tex-Ysabeau-Thin-tosf-t3.tfm \
tex-Ysabeau-Thin-tosf-t4--base.tfm \
tex-Ysabeau-Thin-tosf-t4.tfm \
tex-Ysabeau-Thin-tosf-t4.vf \
tex-Ysabeau-Thin-tosf-t5--base.tfm \
tex-Ysabeau-Thin-tosf-t5.tfm \
tex-Ysabeau-Thin-tosf-t5.vf \
tex-Ysabeau-Thin-tosf-ts1--base.tfm \
tex-Ysabeau-Thin-tosf-ts1.tfm \
tex-Ysabeau-Thin-tosf-ts1.vf \
tex-Ysabeau-Thin-tosf-ts3.tfm \
tex-Ysabeau-ThinItalic-dnom-cs.tfm \
tex-Ysabeau-ThinItalic-dnom-l7x.tfm \
tex-Ysabeau-ThinItalic-dnom-lgr.tfm \
tex-Ysabeau-ThinItalic-dnom-ly1.tfm \
tex-Ysabeau-ThinItalic-dnom-ot1.tfm \
tex-Ysabeau-ThinItalic-dnom-qx--base.tfm \
tex-Ysabeau-ThinItalic-dnom-qx.tfm \
tex-Ysabeau-ThinItalic-dnom-qx.vf \
tex-Ysabeau-ThinItalic-dnom-t1--base.tfm \
tex-Ysabeau-ThinItalic-dnom-t1.tfm \
tex-Ysabeau-ThinItalic-dnom-t1.vf \
tex-Ysabeau-ThinItalic-dnom-t2a--base.tfm \
tex-Ysabeau-ThinItalic-dnom-t2a.tfm \
tex-Ysabeau-ThinItalic-dnom-t2a.vf \
tex-Ysabeau-ThinItalic-dnom-t2b--base.tfm \
tex-Ysabeau-ThinItalic-dnom-t2b.tfm \
tex-Ysabeau-ThinItalic-dnom-t2b.vf \
tex-Ysabeau-ThinItalic-dnom-t2c--base.tfm \
tex-Ysabeau-ThinItalic-dnom-t2c.tfm \
tex-Ysabeau-ThinItalic-dnom-t2c.vf \
tex-Ysabeau-ThinItalic-dnom-t3.tfm \
tex-Ysabeau-ThinItalic-dnom-t4--base.tfm \
tex-Ysabeau-ThinItalic-dnom-t4.tfm \
tex-Ysabeau-ThinItalic-dnom-t4.vf \
tex-Ysabeau-ThinItalic-dnom-t5--base.tfm \
tex-Ysabeau-ThinItalic-dnom-t5.tfm \
tex-Ysabeau-ThinItalic-dnom-t5.vf \
tex-Ysabeau-ThinItalic-dnom-ts3.tfm \
tex-Ysabeau-ThinItalic-inf-cs.tfm \
tex-Ysabeau-ThinItalic-inf-l7x.tfm \
tex-Ysabeau-ThinItalic-inf-lgr.tfm \
tex-Ysabeau-ThinItalic-inf-ly1.tfm \
tex-Ysabeau-ThinItalic-inf-ot1.tfm \
tex-Ysabeau-ThinItalic-inf-qx--base.tfm \
tex-Ysabeau-ThinItalic-inf-qx.tfm \
tex-Ysabeau-ThinItalic-inf-qx.vf \
tex-Ysabeau-ThinItalic-inf-t1--base.tfm \
tex-Ysabeau-ThinItalic-inf-t1.tfm \
tex-Ysabeau-ThinItalic-inf-t1.vf \
tex-Ysabeau-ThinItalic-inf-t2a--base.tfm \
tex-Ysabeau-ThinItalic-inf-t2a.tfm \
tex-Ysabeau-ThinItalic-inf-t2a.vf \
tex-Ysabeau-ThinItalic-inf-t2b--base.tfm \
tex-Ysabeau-ThinItalic-inf-t2b.tfm \
tex-Ysabeau-ThinItalic-inf-t2b.vf \
tex-Ysabeau-ThinItalic-inf-t2c--base.tfm \
tex-Ysabeau-ThinItalic-inf-t2c.tfm \
tex-Ysabeau-ThinItalic-inf-t2c.vf \
tex-Ysabeau-ThinItalic-inf-t3.tfm \
tex-Ysabeau-ThinItalic-inf-t4--base.tfm \
tex-Ysabeau-ThinItalic-inf-t4.tfm \
tex-Ysabeau-ThinItalic-inf-t4.vf \
tex-Ysabeau-ThinItalic-inf-t5--base.tfm \
tex-Ysabeau-ThinItalic-inf-t5.tfm \
tex-Ysabeau-ThinItalic-inf-t5.vf \
tex-Ysabeau-ThinItalic-inf-ts3.tfm \
tex-Ysabeau-ThinItalic-lf-cs.tfm \
tex-Ysabeau-ThinItalic-lf-l7x.tfm \
tex-Ysabeau-ThinItalic-lf-lgr.tfm \
tex-Ysabeau-ThinItalic-lf-ly1.tfm \
tex-Ysabeau-ThinItalic-lf-ot1.tfm \
tex-Ysabeau-ThinItalic-lf-qx--base.tfm \
tex-Ysabeau-ThinItalic-lf-qx.tfm \
tex-Ysabeau-ThinItalic-lf-qx.vf \
tex-Ysabeau-ThinItalic-lf-swash-cs.tfm \
tex-Ysabeau-ThinItalic-lf-swash-l7x.tfm \
tex-Ysabeau-ThinItalic-lf-swash-lgr.tfm \
tex-Ysabeau-ThinItalic-lf-swash-ly1.tfm \
tex-Ysabeau-ThinItalic-lf-swash-ot1.tfm \
tex-Ysabeau-ThinItalic-lf-swash-qx--base.tfm \
tex-Ysabeau-ThinItalic-lf-swash-qx.tfm \
tex-Ysabeau-ThinItalic-lf-swash-qx.vf \
tex-Ysabeau-ThinItalic-lf-swash-t1--base.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t1.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t1.vf \
tex-Ysabeau-ThinItalic-lf-swash-t2a--base.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t2a.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t2a.vf \
tex-Ysabeau-ThinItalic-lf-swash-t2b--base.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t2b.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t2b.vf \
tex-Ysabeau-ThinItalic-lf-swash-t2c--base.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t2c.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t2c.vf \
tex-Ysabeau-ThinItalic-lf-swash-t3.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t4--base.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t4.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t4.vf \
tex-Ysabeau-ThinItalic-lf-swash-t5--base.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t5.tfm \
tex-Ysabeau-ThinItalic-lf-swash-t5.vf \
tex-Ysabeau-ThinItalic-lf-swash-ts3.tfm \
tex-Ysabeau-ThinItalic-lf-t1--base.tfm \
tex-Ysabeau-ThinItalic-lf-t1.tfm \
tex-Ysabeau-ThinItalic-lf-t1.vf \
tex-Ysabeau-ThinItalic-lf-t2a--base.tfm \
tex-Ysabeau-ThinItalic-lf-t2a.tfm \
tex-Ysabeau-ThinItalic-lf-t2a.vf \
tex-Ysabeau-ThinItalic-lf-t2b--base.tfm \
tex-Ysabeau-ThinItalic-lf-t2b.tfm \
tex-Ysabeau-ThinItalic-lf-t2b.vf \
tex-Ysabeau-ThinItalic-lf-t2c--base.tfm \
tex-Ysabeau-ThinItalic-lf-t2c.tfm \
tex-Ysabeau-ThinItalic-lf-t2c.vf \
tex-Ysabeau-ThinItalic-lf-t3.tfm \
tex-Ysabeau-ThinItalic-lf-t4--base.tfm \
tex-Ysabeau-ThinItalic-lf-t4.tfm \
tex-Ysabeau-ThinItalic-lf-t4.vf \
tex-Ysabeau-ThinItalic-lf-t5--base.tfm \
tex-Ysabeau-ThinItalic-lf-t5.tfm \
tex-Ysabeau-ThinItalic-lf-t5.vf \
tex-Ysabeau-ThinItalic-lf-ts1--base.tfm \
tex-Ysabeau-ThinItalic-lf-ts1.tfm \
tex-Ysabeau-ThinItalic-lf-ts1.vf \
tex-Ysabeau-ThinItalic-lf-ts3.tfm \
tex-Ysabeau-ThinItalic-numr-cs.tfm \
tex-Ysabeau-ThinItalic-numr-l7x.tfm \
tex-Ysabeau-ThinItalic-numr-lgr.tfm \
tex-Ysabeau-ThinItalic-numr-ly1.tfm \
tex-Ysabeau-ThinItalic-numr-ot1.tfm \
tex-Ysabeau-ThinItalic-numr-qx--base.tfm \
tex-Ysabeau-ThinItalic-numr-qx.tfm \
tex-Ysabeau-ThinItalic-numr-qx.vf \
tex-Ysabeau-ThinItalic-numr-t1--base.tfm \
tex-Ysabeau-ThinItalic-numr-t1.tfm \
tex-Ysabeau-ThinItalic-numr-t1.vf \
tex-Ysabeau-ThinItalic-numr-t2a--base.tfm \
tex-Ysabeau-ThinItalic-numr-t2a.tfm \
tex-Ysabeau-ThinItalic-numr-t2a.vf \
tex-Ysabeau-ThinItalic-numr-t2b--base.tfm \
tex-Ysabeau-ThinItalic-numr-t2b.tfm \
tex-Ysabeau-ThinItalic-numr-t2b.vf \
tex-Ysabeau-ThinItalic-numr-t2c--base.tfm \
tex-Ysabeau-ThinItalic-numr-t2c.tfm \
tex-Ysabeau-ThinItalic-numr-t2c.vf \
tex-Ysabeau-ThinItalic-numr-t3.tfm \
tex-Ysabeau-ThinItalic-numr-t4--base.tfm \
tex-Ysabeau-ThinItalic-numr-t4.tfm \
tex-Ysabeau-ThinItalic-numr-t4.vf \
tex-Ysabeau-ThinItalic-numr-t5--base.tfm \
tex-Ysabeau-ThinItalic-numr-t5.tfm \
tex-Ysabeau-ThinItalic-numr-t5.vf \
tex-Ysabeau-ThinItalic-numr-ts3.tfm \
tex-Ysabeau-ThinItalic-osf-cs.tfm \
tex-Ysabeau-ThinItalic-osf-l7x.tfm \
tex-Ysabeau-ThinItalic-osf-lgr.tfm \
tex-Ysabeau-ThinItalic-osf-ly1.tfm \
tex-Ysabeau-ThinItalic-osf-ot1.tfm \
tex-Ysabeau-ThinItalic-osf-qx--base.tfm \
tex-Ysabeau-ThinItalic-osf-qx.tfm \
tex-Ysabeau-ThinItalic-osf-qx.vf \
tex-Ysabeau-ThinItalic-osf-swash-cs.tfm \
tex-Ysabeau-ThinItalic-osf-swash-l7x.tfm \
tex-Ysabeau-ThinItalic-osf-swash-lgr.tfm \
tex-Ysabeau-ThinItalic-osf-swash-ly1.tfm \
tex-Ysabeau-ThinItalic-osf-swash-ot1.tfm \
tex-Ysabeau-ThinItalic-osf-swash-qx--base.tfm \
tex-Ysabeau-ThinItalic-osf-swash-qx.tfm \
tex-Ysabeau-ThinItalic-osf-swash-qx.vf \
tex-Ysabeau-ThinItalic-osf-swash-t1--base.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t1.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t1.vf \
tex-Ysabeau-ThinItalic-osf-swash-t2a--base.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t2a.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t2a.vf \
tex-Ysabeau-ThinItalic-osf-swash-t2b--base.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t2b.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t2b.vf \
tex-Ysabeau-ThinItalic-osf-swash-t2c--base.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t2c.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t2c.vf \
tex-Ysabeau-ThinItalic-osf-swash-t3.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t4--base.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t4.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t4.vf \
tex-Ysabeau-ThinItalic-osf-swash-t5--base.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t5.tfm \
tex-Ysabeau-ThinItalic-osf-swash-t5.vf \
tex-Ysabeau-ThinItalic-osf-swash-ts3.tfm \
tex-Ysabeau-ThinItalic-osf-t1--base.tfm \
tex-Ysabeau-ThinItalic-osf-t1.tfm \
tex-Ysabeau-ThinItalic-osf-t1.vf \
tex-Ysabeau-ThinItalic-osf-t2a--base.tfm \
tex-Ysabeau-ThinItalic-osf-t2a.tfm \
tex-Ysabeau-ThinItalic-osf-t2a.vf \
tex-Ysabeau-ThinItalic-osf-t2b--base.tfm \
tex-Ysabeau-ThinItalic-osf-t2b.tfm \
tex-Ysabeau-ThinItalic-osf-t2b.vf \
tex-Ysabeau-ThinItalic-osf-t2c--base.tfm \
tex-Ysabeau-ThinItalic-osf-t2c.tfm \
tex-Ysabeau-ThinItalic-osf-t2c.vf \
tex-Ysabeau-ThinItalic-osf-t3.tfm \
tex-Ysabeau-ThinItalic-osf-t4--base.tfm \
tex-Ysabeau-ThinItalic-osf-t4.tfm \
tex-Ysabeau-ThinItalic-osf-t4.vf \
tex-Ysabeau-ThinItalic-osf-t5--base.tfm \
tex-Ysabeau-ThinItalic-osf-t5.tfm \
tex-Ysabeau-ThinItalic-osf-t5.vf \
tex-Ysabeau-ThinItalic-osf-ts1--base.tfm \
tex-Ysabeau-ThinItalic-osf-ts1.tfm \
tex-Ysabeau-ThinItalic-osf-ts1.vf \
tex-Ysabeau-ThinItalic-osf-ts3.tfm \
tex-Ysabeau-ThinItalic-sup-cs.tfm \
tex-Ysabeau-ThinItalic-sup-l7x.tfm \
tex-Ysabeau-ThinItalic-sup-lgr.tfm \
tex-Ysabeau-ThinItalic-sup-ly1.tfm \
tex-Ysabeau-ThinItalic-sup-ot1.tfm \
tex-Ysabeau-ThinItalic-sup-qx--base.tfm \
tex-Ysabeau-ThinItalic-sup-qx.tfm \
tex-Ysabeau-ThinItalic-sup-qx.vf \
tex-Ysabeau-ThinItalic-sup-t1--base.tfm \
tex-Ysabeau-ThinItalic-sup-t1.tfm \
tex-Ysabeau-ThinItalic-sup-t1.vf \
tex-Ysabeau-ThinItalic-sup-t2a--base.tfm \
tex-Ysabeau-ThinItalic-sup-t2a.tfm \
tex-Ysabeau-ThinItalic-sup-t2a.vf \
tex-Ysabeau-ThinItalic-sup-t2b--base.tfm \
tex-Ysabeau-ThinItalic-sup-t2b.tfm \
tex-Ysabeau-ThinItalic-sup-t2b.vf \
tex-Ysabeau-ThinItalic-sup-t2c--base.tfm \
tex-Ysabeau-ThinItalic-sup-t2c.tfm \
tex-Ysabeau-ThinItalic-sup-t2c.vf \
tex-Ysabeau-ThinItalic-sup-t3.tfm \
tex-Ysabeau-ThinItalic-sup-t4--base.tfm \
tex-Ysabeau-ThinItalic-sup-t4.tfm \
tex-Ysabeau-ThinItalic-sup-t4.vf \
tex-Ysabeau-ThinItalic-sup-t5--base.tfm \
tex-Ysabeau-ThinItalic-sup-t5.tfm \
tex-Ysabeau-ThinItalic-sup-t5.vf \
tex-Ysabeau-ThinItalic-sup-ts3.tfm \
tex-Ysabeau-ThinItalic-tlf-cs.tfm \
tex-Ysabeau-ThinItalic-tlf-l7x.tfm \
tex-Ysabeau-ThinItalic-tlf-lgr.tfm \
tex-Ysabeau-ThinItalic-tlf-ly1.tfm \
tex-Ysabeau-ThinItalic-tlf-ot1.tfm \
tex-Ysabeau-ThinItalic-tlf-qx--base.tfm \
tex-Ysabeau-ThinItalic-tlf-qx.tfm \
tex-Ysabeau-ThinItalic-tlf-qx.vf \
tex-Ysabeau-ThinItalic-tlf-swash-cs.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-l7x.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-lgr.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-ly1.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-ot1.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-qx--base.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-qx.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-qx.vf \
tex-Ysabeau-ThinItalic-tlf-swash-t1--base.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t1.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t1.vf \
tex-Ysabeau-ThinItalic-tlf-swash-t2a--base.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t2a.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t2a.vf \
tex-Ysabeau-ThinItalic-tlf-swash-t2b--base.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t2b.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t2b.vf \
tex-Ysabeau-ThinItalic-tlf-swash-t2c--base.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t2c.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t2c.vf \
tex-Ysabeau-ThinItalic-tlf-swash-t3.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t4--base.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t4.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t4.vf \
tex-Ysabeau-ThinItalic-tlf-swash-t5--base.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t5.tfm \
tex-Ysabeau-ThinItalic-tlf-swash-t5.vf \
tex-Ysabeau-ThinItalic-tlf-swash-ts3.tfm \
tex-Ysabeau-ThinItalic-tlf-t1--base.tfm \
tex-Ysabeau-ThinItalic-tlf-t1.tfm \
tex-Ysabeau-ThinItalic-tlf-t1.vf \
tex-Ysabeau-ThinItalic-tlf-t2a--base.tfm \
tex-Ysabeau-ThinItalic-tlf-t2a.tfm \
tex-Ysabeau-ThinItalic-tlf-t2a.vf \
tex-Ysabeau-ThinItalic-tlf-t2b--base.tfm \
tex-Ysabeau-ThinItalic-tlf-t2b.tfm \
tex-Ysabeau-ThinItalic-tlf-t2b.vf \
tex-Ysabeau-ThinItalic-tlf-t2c--base.tfm \
tex-Ysabeau-ThinItalic-tlf-t2c.tfm \
tex-Ysabeau-ThinItalic-tlf-t2c.vf \
tex-Ysabeau-ThinItalic-tlf-t3.tfm \
tex-Ysabeau-ThinItalic-tlf-t4--base.tfm \
tex-Ysabeau-ThinItalic-tlf-t4.tfm \
tex-Ysabeau-ThinItalic-tlf-t4.vf \
tex-Ysabeau-ThinItalic-tlf-t5--base.tfm \
tex-Ysabeau-ThinItalic-tlf-t5.tfm \
tex-Ysabeau-ThinItalic-tlf-t5.vf \
tex-Ysabeau-ThinItalic-tlf-ts1--base.tfm \
tex-Ysabeau-ThinItalic-tlf-ts1.tfm \
tex-Ysabeau-ThinItalic-tlf-ts1.vf \
tex-Ysabeau-ThinItalic-tlf-ts3.tfm \
tex-Ysabeau-ThinItalic-tosf-cs.tfm \
tex-Ysabeau-ThinItalic-tosf-l7x.tfm \
tex-Ysabeau-ThinItalic-tosf-lgr.tfm \
tex-Ysabeau-ThinItalic-tosf-ly1.tfm \
tex-Ysabeau-ThinItalic-tosf-ot1.tfm \
tex-Ysabeau-ThinItalic-tosf-qx--base.tfm \
tex-Ysabeau-ThinItalic-tosf-qx.tfm \
tex-Ysabeau-ThinItalic-tosf-qx.vf \
tex-Ysabeau-ThinItalic-tosf-swash-cs.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-l7x.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-lgr.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-ly1.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-ot1.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-qx--base.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-qx.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-qx.vf \
tex-Ysabeau-ThinItalic-tosf-swash-t1--base.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t1.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t1.vf \
tex-Ysabeau-ThinItalic-tosf-swash-t2a--base.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t2a.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t2a.vf \
tex-Ysabeau-ThinItalic-tosf-swash-t2b--base.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t2b.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t2b.vf \
tex-Ysabeau-ThinItalic-tosf-swash-t2c--base.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t2c.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t2c.vf \
tex-Ysabeau-ThinItalic-tosf-swash-t3.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t4--base.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t4.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t4.vf \
tex-Ysabeau-ThinItalic-tosf-swash-t5--base.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t5.tfm \
tex-Ysabeau-ThinItalic-tosf-swash-t5.vf \
tex-Ysabeau-ThinItalic-tosf-swash-ts3.tfm \
tex-Ysabeau-ThinItalic-tosf-t1--base.tfm \
tex-Ysabeau-ThinItalic-tosf-t1.tfm \
tex-Ysabeau-ThinItalic-tosf-t1.vf \
tex-Ysabeau-ThinItalic-tosf-t2a--base.tfm \
tex-Ysabeau-ThinItalic-tosf-t2a.tfm \
tex-Ysabeau-ThinItalic-tosf-t2a.vf \
tex-Ysabeau-ThinItalic-tosf-t2b--base.tfm \
tex-Ysabeau-ThinItalic-tosf-t2b.tfm \
tex-Ysabeau-ThinItalic-tosf-t2b.vf \
tex-Ysabeau-ThinItalic-tosf-t2c--base.tfm \
tex-Ysabeau-ThinItalic-tosf-t2c.tfm \
tex-Ysabeau-ThinItalic-tosf-t2c.vf \
tex-Ysabeau-ThinItalic-tosf-t3.tfm \
tex-Ysabeau-ThinItalic-tosf-t4--base.tfm \
tex-Ysabeau-ThinItalic-tosf-t4.tfm \
tex-Ysabeau-ThinItalic-tosf-t4.vf \
tex-Ysabeau-ThinItalic-tosf-t5--base.tfm \
tex-Ysabeau-ThinItalic-tosf-t5.tfm \
tex-Ysabeau-ThinItalic-tosf-t5.vf \
tex-Ysabeau-ThinItalic-tosf-ts1--base.tfm \
tex-Ysabeau-ThinItalic-tosf-ts1.tfm \
tex-Ysabeau-ThinItalic-tosf-ts1.vf \
tex-Ysabeau-ThinItalic-tosf-ts3.tfm \
tex-a-2awb2h.enc \
tex-a-2hsygq.enc \
tex-a-2iwri2.enc \
tex-a-2mih6p.enc \
tex-a-2rpwmc.enc \
tex-a-3afw7n.enc \
tex-a-3g2ntv.enc \
tex-a-3rqgtc.enc \
tex-a-3wl3pw.enc \
tex-a-3zvmz3.enc \
tex-a-45cgat.enc \
tex-a-4ayjr7.enc \
tex-a-4bc4uu.enc \
tex-a-4kil6n.enc \
tex-a-4l2cmv.enc \
tex-a-4nrwak.enc \
tex-a-4pzptq.enc \
tex-a-4tjwz2.enc \
tex-a-4zyxel.enc \
tex-a-5e27iy.enc \
tex-a-5jcguw.enc \
tex-a-5nqhy2.enc \
tex-a-5oz3jj.enc \
tex-a-5upoxa.enc \
tex-a-5xxtup.enc \
tex-a-63tffd.enc \
tex-a-67cbot.enc \
tex-a-6biby6.enc \
tex-a-6crttf.enc \
tex-a-6e7bvt.enc \
tex-a-6f6udl.enc \
tex-a-6qv5p7.enc \
tex-a-6u3luu.enc \
tex-a-6vswzy.enc \
tex-a-6xv5br.enc \
tex-a-6z2tbg.enc \
tex-a-7aahvw.enc \
tex-a-7fznqv.enc \
tex-a-7ghrbx.enc \
tex-a-7goe5p.enc \
tex-a-7hh6sa.enc \
tex-a-7hpm7n.enc \
tex-a-7kwyu5.enc \
tex-a-7lwy6i.enc \
tex-a-7qbb7c.enc \
tex-a-7qig4j.enc \
tex-a-7sjspf.enc \
tex-a-7vyhto.enc \
tex-a-7wxdrh.enc \
tex-a-a2el54.enc \
tex-a-ame6d4.enc \
tex-a-amsxhi.enc \
tex-a-ao5l46.enc \
tex-a-aptbfp.enc \
tex-a-aqx4tx.enc \
tex-a-bgtun6.enc \
tex-a-bivwsr.enc \
tex-a-bmehwf.enc \
tex-a-bpr64g.enc \
tex-a-bvjllh.enc \
tex-a-c2y36g.enc \
tex-a-cft4v3.enc \
tex-a-chndpq.enc \
tex-a-cj73s3.enc \
tex-a-cqqoo7.enc \
tex-a-cwrvbi.enc \
tex-a-d3bvuv.enc \
tex-a-d4cgs5.enc \
tex-a-d4g2yc.enc \
tex-a-dj7mgp.enc \
tex-a-dnyhma.enc \
tex-a-e5q3zr.enc \
tex-a-e6yogu.enc \
tex-a-ehtthc.enc \
tex-a-ejizio.enc \
tex-a-elqx7b.enc \
tex-a-epysvj.enc \
tex-a-estyad.enc \
tex-a-ewt7bs.enc \
tex-a-ez272d.enc \
tex-a-falupg.enc \
tex-a-fkccsx.enc \
tex-a-fmlxqp.enc \
tex-a-fp2zub.enc \
tex-a-fpfsus.enc \
tex-a-fqxene.enc \
tex-a-fsa7rr.enc \
tex-a-ftxt7i.enc \
tex-a-fvjrzx.enc \
tex-a-fxh6vv.enc \
tex-a-g5ukx5.enc \
tex-a-ga4wss.enc \
tex-a-gaiop6.enc \
tex-a-gffk24.enc \
tex-a-gittl5.enc \
tex-a-gjfgiy.enc \
tex-a-goldrc.enc \
tex-a-gsbee5.enc \
tex-a-gttizs.enc \
tex-a-heax6a.enc \
tex-a-hk6r2d.enc \
tex-a-hpdcrr.enc \
tex-a-hraspp.enc \
tex-a-hv54f4.enc \
tex-a-hwstip.enc \
tex-a-icp7cs.enc \
tex-a-ilnbpc.enc \
tex-a-impnlt.enc \
tex-a-ipaxtu.enc \
tex-a-is7tgy.enc \
tex-a-j4qjpg.enc \
tex-a-j6huy7.enc \
tex-a-jekejo.enc \
tex-a-jnc5tj.enc \
tex-a-jogzyg.enc \
tex-a-juwsk7.enc \
tex-a-k5dwkq.enc \
tex-a-kt2pkz.enc \
tex-a-kxqulf.enc \
tex-a-l6lqd6.enc \
tex-a-lhglcm.enc \
tex-a-lsezod.enc \
tex-a-lshso2.enc \
tex-a-lz3now.enc \
tex-a-m656pc.enc \
tex-a-m7jnl7.enc \
tex-a-maguu4.enc \
tex-a-md7czj.enc \
tex-a-mg4vec.enc \
tex-a-mhefza.enc \
tex-a-mmvqss.enc \
tex-a-mo7fuq.enc \
tex-a-mogxzj.enc \
tex-a-mphva3.enc \
tex-a-muy6g4.enc \
tex-a-mvaqgd.enc \
tex-a-mx2fsw.enc \
tex-a-mz6lh6.enc \
tex-a-nacyh7.enc \
tex-a-nawmrb.enc \
tex-a-ngpmpx.enc \
tex-a-nl7jjz.enc \
tex-a-nnzjan.enc \
tex-a-nq7krm.enc \
tex-a-nql2ou.enc \
tex-a-nwraxc.enc \
tex-a-oakx3v.enc \
tex-a-oef3ii.enc \
tex-a-ogjulq.enc \
tex-a-oxjh3v.enc \
tex-a-p33yrp.enc \
tex-a-pb2vcf.enc \
tex-a-pfdlqo.enc \
tex-a-pfg4k2.enc \
tex-a-pgi4ph.enc \
tex-a-pozfx6.enc \
tex-a-prj5pa.enc \
tex-a-prvtq6.enc \
tex-a-pzya2p.enc \
tex-a-q4pijy.enc \
tex-a-q5k2sx.enc \
tex-a-qlvoqb.enc \
tex-a-qm4ywg.enc \
tex-a-qoph2m.enc \
tex-a-qreogk.enc \
tex-a-qtfspd.enc \
tex-a-r4hrwr.enc \
tex-a-rcip5i.enc \
tex-a-retlwh.enc \
tex-a-rzzjx7.enc \
tex-a-s3k5qb.enc \
tex-a-sabfno.enc \
tex-a-satg5y.enc \
tex-a-sjizce.enc \
tex-a-soj2fw.enc \
tex-a-swejhl.enc \
tex-a-ta5vtn.enc \
tex-a-tdbvem.enc \
tex-a-tg6k3c.enc \
tex-a-tnt6jh.enc \
tex-a-tqfl4b.enc \
tex-a-tqu77i.enc \
tex-a-tx2i4d.enc \
tex-a-ty6il7.enc \
tex-a-u2y6hr.enc \
tex-a-u4trxy.enc \
tex-a-ufzg3e.enc \
tex-a-ughik7.enc \
tex-a-v2lqqg.enc \
tex-a-v34wue.enc \
tex-a-v5kbqv.enc \
tex-a-vaex5b.enc \
tex-a-vaqj6u.enc \
tex-a-vl5umk.enc \
tex-a-vobwj3.enc \
tex-a-vvc2j5.enc \
tex-a-vvlu2q.enc \
tex-a-vz2xfn.enc \
tex-a-w2v5cu.enc \
tex-a-w6da3p.enc \
tex-a-wc6ok3.enc \
tex-a-wekx2p.enc \
tex-a-wwihan.enc \
tex-a-wy43ym.enc \
tex-a-x4h2xw.enc \
tex-a-xelirx.enc \
tex-a-xetder.enc \
tex-a-xigb5e.enc \
tex-a-xk4zix.enc \
tex-a-xk7jq3.enc \
tex-a-xrvrib.enc \
tex-a-xvsu4k.enc \
tex-a-yapvd7.enc \
tex-a-yfwrqa.enc \
tex-a-yjfnm5.enc \
tex-a-ykx33t.enc \
tex-a-ymbkue.enc \
tex-a-ypoc7z.enc \
tex-a-yq2tmt.enc \
tex-a-ytdozj.enc \
tex-a-zgp7b2.enc \
tex-a-zoa35r.enc \
tex-a-zqg4sk.enc \
tex-ysabeau.map \
tex-ysabeau.sty \
texlive-ysabeau"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-etoolbox.sty \
tex-fontaxes.sty \
tex-fontenc.sty \
tex-ifthen.sty \
tex-mweights.sty \
tex-scalefnt.sty \
tex-textcomp.sty \
tex-updmap.cfg \
tex-xkeyval.sty \
tex-xstring.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin \
texlive-ysabeau-fonts"

inherit rpm
