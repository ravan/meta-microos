SUMMARY = "Translations for package libKF6ItemViews6"
DESCRIPTION = "Provides translations for the 'libKF6ItemViews6' package."
LICENSE = "LGPL-2.0-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6ItemViews6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "4b60f2691ebbcfcdd40042338b706107ddf90477c13f7a3e8b73697711f291d66541d04152ff91fe8b88a7ce90088c0d06922398bd4fb2852e47cd6afdcee83e"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6ItemViews6-lang \
libKF6ItemViews6-lang-all \
locale-libKF6ItemViews6-af \
locale-libKF6ItemViews6-ar \
locale-libKF6ItemViews6-as \
locale-libKF6ItemViews6-ast \
locale-libKF6ItemViews6-az \
locale-libKF6ItemViews6-be \
locale-libKF6ItemViews6-be@latin \
locale-libKF6ItemViews6-bg \
locale-libKF6ItemViews6-bn \
locale-libKF6ItemViews6-bn-IN \
locale-libKF6ItemViews6-br \
locale-libKF6ItemViews6-bs \
locale-libKF6ItemViews6-ca \
locale-libKF6ItemViews6-ca@valencia \
locale-libKF6ItemViews6-cs \
locale-libKF6ItemViews6-cy \
locale-libKF6ItemViews6-da \
locale-libKF6ItemViews6-de \
locale-libKF6ItemViews6-el \
locale-libKF6ItemViews6-en-GB \
locale-libKF6ItemViews6-eo \
locale-libKF6ItemViews6-es \
locale-libKF6ItemViews6-et \
locale-libKF6ItemViews6-eu \
locale-libKF6ItemViews6-fa \
locale-libKF6ItemViews6-fi \
locale-libKF6ItemViews6-fr \
locale-libKF6ItemViews6-ga \
locale-libKF6ItemViews6-gd \
locale-libKF6ItemViews6-gl \
locale-libKF6ItemViews6-gu \
locale-libKF6ItemViews6-he \
locale-libKF6ItemViews6-hi \
locale-libKF6ItemViews6-hr \
locale-libKF6ItemViews6-hu \
locale-libKF6ItemViews6-ia \
locale-libKF6ItemViews6-id \
locale-libKF6ItemViews6-is \
locale-libKF6ItemViews6-it \
locale-libKF6ItemViews6-ja \
locale-libKF6ItemViews6-ka \
locale-libKF6ItemViews6-kk \
locale-libKF6ItemViews6-km \
locale-libKF6ItemViews6-kn \
locale-libKF6ItemViews6-ko \
locale-libKF6ItemViews6-lt \
locale-libKF6ItemViews6-lv \
locale-libKF6ItemViews6-mai \
locale-libKF6ItemViews6-mk \
locale-libKF6ItemViews6-ml \
locale-libKF6ItemViews6-mr \
locale-libKF6ItemViews6-ms \
locale-libKF6ItemViews6-nb \
locale-libKF6ItemViews6-nds \
locale-libKF6ItemViews6-ne \
locale-libKF6ItemViews6-nl \
locale-libKF6ItemViews6-nn \
locale-libKF6ItemViews6-oc \
locale-libKF6ItemViews6-or \
locale-libKF6ItemViews6-pa \
locale-libKF6ItemViews6-pl \
locale-libKF6ItemViews6-pt \
locale-libKF6ItemViews6-pt-BR \
locale-libKF6ItemViews6-ro \
locale-libKF6ItemViews6-ru \
locale-libKF6ItemViews6-si \
locale-libKF6ItemViews6-sk \
locale-libKF6ItemViews6-sl \
locale-libKF6ItemViews6-sq \
locale-libKF6ItemViews6-sr \
locale-libKF6ItemViews6-sr@ijekavian \
locale-libKF6ItemViews6-sr@ijekavianlatin \
locale-libKF6ItemViews6-sr@latin \
locale-libKF6ItemViews6-sv \
locale-libKF6ItemViews6-ta \
locale-libKF6ItemViews6-te \
locale-libKF6ItemViews6-th \
locale-libKF6ItemViews6-tr \
locale-libKF6ItemViews6-ug \
locale-libKF6ItemViews6-uk \
locale-libKF6ItemViews6-vi \
locale-libKF6ItemViews6-wa \
locale-libKF6ItemViews6-zh-CN \
locale-libKF6ItemViews6-zh-HK \
locale-libKF6ItemViews6-zh-TW"

RDEPENDS:${PN} += "libKF6ItemViews6"

inherit rpm
