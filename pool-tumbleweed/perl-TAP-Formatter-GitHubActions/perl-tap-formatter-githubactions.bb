SUMMARY = "TAP Formatter for GitHub Actions"
DESCRIPTION = "'TAP::Formatter::GitHubActions' provides GitHub-Actions-compatible output \
for _prove_. \
 \
It parses TAP output and tries it's best to guess where errors are located. \
For more accurate results, use in cojunction with \
Test2::Formatter::YAMLEnhancedTAP. \
 \
Test2::Formatter::YAMLEnhancedTAP enriches the TAP output generated by \
Test2 and friends (Test::More, Test::Most) with an additional context in \
YAML format (compliant with TAP version 13) that includes the precise \
location of the failure."
LICENSE = "Artistic-1.0 | GPL-1.0-or-later"

PV = "0.3.4"

RPM_NAME = "perl-TAP-Formatter-GitHubActions-0.3.4-1.14.noarch.rpm"
RPM_HASH = "46c8f87095a6de9061cbc8e38589bcfb4c61a7292323f2df76a45350b1e526dc9f79b9f3ca546db4e2f65205f554a9c5d6095de9b132c2eadfbd6ca471a88273"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "perl-TAP--Formatter--GitHubActions \
perl-TAP--Formatter--GitHubActions--Error \
perl-TAP--Formatter--GitHubActions--ErrorAggregate \
perl-TAP--Formatter--GitHubActions--ErrorGroup \
perl-TAP--Formatter--GitHubActions--Utils \
perl-TAP-Formatter-GitHubActions"

RDEPENDS:${PN} += "perl--MODULE-COMPAT-5.44.0 \
perl-TAP--Harness"

inherit rpm
