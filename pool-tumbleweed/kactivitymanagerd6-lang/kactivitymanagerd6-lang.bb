SUMMARY = "Translations for package kactivitymanagerd6"
DESCRIPTION = "Provides translations for the 'kactivitymanagerd6' package."
LICENSE = "GPL-2.0-or-later"

PV = "6.7.5"

RPM_NAME = "kactivitymanagerd6-lang-6.7.5-1.1.noarch.rpm"
RPM_HASH = "968a43a62cbb19e384cae92697266e7261cf7af0daa4ca7c85c4682e0813b27ed3aedcd69ad6237b57b11516c39381216f13570a9a730d8eb3086eedb8aff746"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "kactivitymanagerd6-lang \
kactivitymanagerd6-lang-all \
locale-kactivitymanagerd6-ar \
locale-kactivitymanagerd6-ast \
locale-kactivitymanagerd6-az \
locale-kactivitymanagerd6-bg \
locale-kactivitymanagerd6-bs \
locale-kactivitymanagerd6-ca \
locale-kactivitymanagerd6-ca@valencia \
locale-kactivitymanagerd6-cs \
locale-kactivitymanagerd6-da \
locale-kactivitymanagerd6-de \
locale-kactivitymanagerd6-el \
locale-kactivitymanagerd6-en-GB \
locale-kactivitymanagerd6-eo \
locale-kactivitymanagerd6-es \
locale-kactivitymanagerd6-et \
locale-kactivitymanagerd6-eu \
locale-kactivitymanagerd6-fi \
locale-kactivitymanagerd6-fr \
locale-kactivitymanagerd6-ga \
locale-kactivitymanagerd6-gd \
locale-kactivitymanagerd6-gl \
locale-kactivitymanagerd6-gu \
locale-kactivitymanagerd6-he \
locale-kactivitymanagerd6-hi \
locale-kactivitymanagerd6-hr \
locale-kactivitymanagerd6-hu \
locale-kactivitymanagerd6-ia \
locale-kactivitymanagerd6-id \
locale-kactivitymanagerd6-is \
locale-kactivitymanagerd6-it \
locale-kactivitymanagerd6-ja \
locale-kactivitymanagerd6-ka \
locale-kactivitymanagerd6-kk \
locale-kactivitymanagerd6-km \
locale-kactivitymanagerd6-kn \
locale-kactivitymanagerd6-ko \
locale-kactivitymanagerd6-lt \
locale-kactivitymanagerd6-lv \
locale-kactivitymanagerd6-ml \
locale-kactivitymanagerd6-mr \
locale-kactivitymanagerd6-ms \
locale-kactivitymanagerd6-nb \
locale-kactivitymanagerd6-nds \
locale-kactivitymanagerd6-nl \
locale-kactivitymanagerd6-nn \
locale-kactivitymanagerd6-pa \
locale-kactivitymanagerd6-pl \
locale-kactivitymanagerd6-pt \
locale-kactivitymanagerd6-pt-BR \
locale-kactivitymanagerd6-ro \
locale-kactivitymanagerd6-ru \
locale-kactivitymanagerd6-sk \
locale-kactivitymanagerd6-sl \
locale-kactivitymanagerd6-sr \
locale-kactivitymanagerd6-sr@ijekavian \
locale-kactivitymanagerd6-sr@ijekavianlatin \
locale-kactivitymanagerd6-sr@latin \
locale-kactivitymanagerd6-sv \
locale-kactivitymanagerd6-ta \
locale-kactivitymanagerd6-th \
locale-kactivitymanagerd6-tr \
locale-kactivitymanagerd6-ug \
locale-kactivitymanagerd6-uk \
locale-kactivitymanagerd6-vi \
locale-kactivitymanagerd6-wa \
locale-kactivitymanagerd6-zh-CN \
locale-kactivitymanagerd6-zh-TW"

RDEPENDS:${PN} += "kactivitymanagerd6"

inherit rpm
