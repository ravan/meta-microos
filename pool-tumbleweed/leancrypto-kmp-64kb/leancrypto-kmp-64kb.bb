SUMMARY = "leancrypto Kernel Module Package"
LICENSE = "BSD-3-Clause | GPL-2.0-only"

PV = "1.8.0_k7.2.4_1"

RPM_NAME = "leancrypto-kmp-64kb-1.8.0_k7.2.4_1-3.4.aarch64.rpm"
RPM_HASH = "a003ce0963aaf528eb12d5b26e5de44668a8a607874c619e50737c317991a40e881451b7a23e517420013c98023678a320189bd5013d46be761c62b1834fc40a"

RPROVIDES:${PN} += "kmod-aes-cbc-dec-tester.ko \
kmod-aes-cbc-enc-tester.ko \
kmod-aes-ctr-tester.ko \
kmod-aes-dec-tester.ko \
kmod-aes-enc-tester.ko \
kmod-aes-gcm-tester.ko \
kmod-aes-kw-tester.ko \
kmod-aes-xts-tester.ko \
kmod-ascon-256-tester.ko \
kmod-ascon-crypt-test.ko \
kmod-ascon-keccak-crypt-iuf-test.ko \
kmod-ascon-keccak-crypt-test.ko \
kmod-ascon-xof-tester.ko \
kmod-bike-1-tester.ko \
kmod-bike-3-tester.ko \
kmod-bike-5-tester.ko \
kmod-chacha20-block-tester.ko \
kmod-chacha20-drng-tester.ko \
kmod-chacha20-stream-tester.ko \
kmod-chacha20poly1305-tester.ko \
kmod-cshake-128-tester.ko \
kmod-cshake-256-tester.ko \
kmod-cshake-crypt-test.ko \
kmod-cshake-ctx-256-tester.ko \
kmod-cshake-drng-tester.ko \
kmod-ctr-drbg-tester.ko \
kmod-dilithium-44-ed25519-tester.ko \
kmod-dilithium-44-ed448-tester.ko \
kmod-dilithium-44-invalid-tester.ko \
kmod-dilithium-44-tester-c.ko \
kmod-dilithium-44-tester-common.ko \
kmod-dilithium-44-tester-official.ko \
kmod-dilithium-65-ed25519-tester.ko \
kmod-dilithium-65-ed448-tester.ko \
kmod-dilithium-65-invalid-tester.ko \
kmod-dilithium-65-tester-armv8.ko \
kmod-dilithium-65-tester-c.ko \
kmod-dilithium-65-tester-common.ko \
kmod-dilithium-65-tester-iuf-armv8.ko \
kmod-dilithium-65-tester-official.ko \
kmod-dilithium-ed25519-tester.ko \
kmod-dilithium-ed448-tester.ko \
kmod-dilithium-invalid-tester.ko \
kmod-dilithium-tester-armv8.ko \
kmod-dilithium-tester-c.ko \
kmod-dilithium-tester-common.ko \
kmod-dilithium-tester-iuf-armv8.ko \
kmod-dilithium-tester-official.ko \
kmod-hash-crypt-test.ko \
kmod-hash-drbg-tester.ko \
kmod-hkdf-tester.ko \
kmod-hmac-drbg-tester.ko \
kmod-hmac-sha2-256-tester.ko \
kmod-hqc-128-tester.ko \
kmod-hqc-192-tester.ko \
kmod-hqc-256-tester.ko \
kmod-kdf-ctr-tester.ko \
kmod-kdf-dpi-tester.ko \
kmod-kdf-fb-tester.ko \
kmod-keccak-tester.ko \
kmod-kmac-128-tester.ko \
kmod-kmac-256-tester.ko \
kmod-kmac-crypt-test.ko \
kmod-kmac-drng-tester.ko \
kmod-kmac-xof-more-tester.ko \
kmod-kmac-xof-tester.ko \
kmod-kyber-512-ies-tester.ko \
kmod-kyber-512-invalid-tester.ko \
kmod-kyber-512-kem-kdf-tester-c.ko \
kmod-kyber-512-kem-kdf-tester-common.ko \
kmod-kyber-512-kem-tester-c.ko \
kmod-kyber-512-kem-tester-common.ko \
kmod-kyber-512-kex-tester.ko \
kmod-kyber-512-modulus-tester.ko \
kmod-kyber-768-ies-tester.ko \
kmod-kyber-768-invalid-tester.ko \
kmod-kyber-768-kem-kdf-tester-armv8.ko \
kmod-kyber-768-kem-kdf-tester-c.ko \
kmod-kyber-768-kem-kdf-tester-common.ko \
kmod-kyber-768-kem-tester-armv8.ko \
kmod-kyber-768-kem-tester-c.ko \
kmod-kyber-768-kem-tester-common.ko \
kmod-kyber-768-kex-tester.ko \
kmod-kyber-768-modulus-tester.ko \
kmod-kyber-ies-tester.ko \
kmod-kyber-ies-x25519-tester.ko \
kmod-kyber-ies-x448-tester.ko \
kmod-kyber-invalid-tester.ko \
kmod-kyber-kem-kdf-tester-armv8.ko \
kmod-kyber-kem-kdf-tester-c.ko \
kmod-kyber-kem-kdf-tester-common.ko \
kmod-kyber-kem-tester-armv8.ko \
kmod-kyber-kem-tester-c.ko \
kmod-kyber-kem-tester-common.ko \
kmod-kyber-kem-x25519-tester.ko \
kmod-kyber-kem-x448-tester.ko \
kmod-kyber-kex-tester.ko \
kmod-kyber-kex-x25519-tester.ko \
kmod-kyber-kex-x448-tester.ko \
kmod-kyber-modulus-tester.ko \
kmod-leancrypto-kernel-aead-ascon-tester.ko \
kmod-leancrypto-kernel-aes-cbc-tester.ko \
kmod-leancrypto-kernel-aes-ctr-tester.ko \
kmod-leancrypto-kernel-aes-gcm-tester.ko \
kmod-leancrypto-kernel-aes-xts-tester.ko \
kmod-leancrypto-kernel-ascon-tester.ko \
kmod-leancrypto-kernel-bike-1-tester.ko \
kmod-leancrypto-kernel-bike-3-tester.ko \
kmod-leancrypto-kernel-bike-5-tester.ko \
kmod-leancrypto-kernel-chacha20-poly1305-tester.ko \
kmod-leancrypto-kernel-chacha20-tester.ko \
kmod-leancrypto-kernel-dilithium-44-ed25519-tester.ko \
kmod-leancrypto-kernel-dilithium-44-ed448-tester.ko \
kmod-leancrypto-kernel-dilithium-44-tester.ko \
kmod-leancrypto-kernel-dilithium-65-ed25519-tester.ko \
kmod-leancrypto-kernel-dilithium-65-ed448-tester.ko \
kmod-leancrypto-kernel-dilithium-65-tester.ko \
kmod-leancrypto-kernel-dilithium-87-ed25519-tester.ko \
kmod-leancrypto-kernel-dilithium-87-ed448-tester.ko \
kmod-leancrypto-kernel-dilithium-87-tester.ko \
kmod-leancrypto-kernel-hmac-tester.ko \
kmod-leancrypto-kernel-hqc-128-tester.ko \
kmod-leancrypto-kernel-hqc-192-tester.ko \
kmod-leancrypto-kernel-hqc-256-tester.ko \
kmod-leancrypto-kernel-kmac-tester.ko \
kmod-leancrypto-kernel-kyber-1024-tester.ko \
kmod-leancrypto-kernel-kyber-1024-x25519-tester.ko \
kmod-leancrypto-kernel-kyber-1024-x448-tester.ko \
kmod-leancrypto-kernel-kyber-512-tester.ko \
kmod-leancrypto-kernel-kyber-512-x25519-tester.ko \
kmod-leancrypto-kernel-kyber-512-x448-tester.ko \
kmod-leancrypto-kernel-kyber-768-tester.ko \
kmod-leancrypto-kernel-kyber-768-x25519-tester.ko \
kmod-leancrypto-kernel-kyber-768-x448-tester.ko \
kmod-leancrypto-kernel-rng-tester.ko \
kmod-leancrypto-kernel-sha256-tester.ko \
kmod-leancrypto-kernel-sha3-tester.ko \
kmod-leancrypto-kernel-sha512-tester.ko \
kmod-leancrypto-kernel-sphincs-shake-128f-tester.ko \
kmod-leancrypto-kernel-sphincs-shake-128s-tester.ko \
kmod-leancrypto-kernel-sphincs-shake-192s-tester.ko \
kmod-leancrypto-kernel-sphincs-shake-256f-tester.ko \
kmod-leancrypto-kernel-sphincs-shake-256s-tester.ko \
kmod-leancrypto.ko \
kmod-pbkdf2-tester.ko \
kmod-rerun-one-selftest-tester.ko \
kmod-rerun-selftests-tester.ko \
kmod-sha256-tester.ko \
kmod-sha3-224-tester.ko \
kmod-sha3-256-tester.ko \
kmod-sha3-384-tester.ko \
kmod-sha3-512-tester.ko \
kmod-sha384-tester.ko \
kmod-sha512-tester.ko \
kmod-shake-squeeze-more-tester.ko \
kmod-shake128-tester.ko \
kmod-shake256-tester.ko \
kmod-sphincs-tester-128f-c.ko \
kmod-sphincs-tester-128f.ko \
kmod-sphincs-tester-128s-c.ko \
kmod-sphincs-tester-128s.ko \
kmod-sphincs-tester-192f-c.ko \
kmod-sphincs-tester-192f.ko \
kmod-sphincs-tester-192s-c.ko \
kmod-sphincs-tester-192s.ko \
kmod-sphincs-tester-256f-c.ko \
kmod-sphincs-tester-256f.ko \
kmod-sphincs-tester-256s-c.ko \
kmod-sphincs-tester-256s.ko \
kmod-sphincs-tester-official.ko \
kmod-status-tester.ko \
kmod-symhmac-test.ko \
kmod-symkmac128-test.ko \
kmod-symkmac256-test.ko \
kmod-uuid-tester.ko \
kmod-xdrbg128-tester.ko \
kmod-xdrbg256-tester.ko \
kmod-xdrbg512-tester.ko \
ksym-64kb-cc20-block \
ksym-64kb-crypto-scalarmult-curve25519 \
ksym-64kb-crypto-scalarmult-curve25519-base \
ksym-64kb-lc-OID-to-data \
ksym-64kb-lc-aead-alg-status \
ksym-64kb-lc-aead-ctx-alg-status \
ksym-64kb-lc-aead-dec-final \
ksym-64kb-lc-aead-dec-init \
ksym-64kb-lc-aead-dec-update \
ksym-64kb-lc-aead-decrypt \
ksym-64kb-lc-aead-enc-final \
ksym-64kb-lc-aead-enc-init \
ksym-64kb-lc-aead-enc-update \
ksym-64kb-lc-aead-encrypt \
ksym-64kb-lc-aead-setkey \
ksym-64kb-lc-aead-setkey-from-ctx \
ksym-64kb-lc-aead-zero \
ksym-64kb-lc-aead-zero-free \
ksym-64kb-lc-aes \
ksym-64kb-lc-aes-aesni \
ksym-64kb-lc-aes-armce \
ksym-64kb-lc-aes-c \
ksym-64kb-lc-aes-cbc \
ksym-64kb-lc-aes-cbc-aesni \
ksym-64kb-lc-aes-cbc-armce \
ksym-64kb-lc-aes-cbc-c \
ksym-64kb-lc-aes-cbc-riscv64 \
ksym-64kb-lc-aes-ct \
ksym-64kb-lc-aes-ctr \
ksym-64kb-lc-aes-ctr-aesni \
ksym-64kb-lc-aes-ctr-armce \
ksym-64kb-lc-aes-ctr-c \
ksym-64kb-lc-aes-ctr-riscv64 \
ksym-64kb-lc-aes-gcm-aead \
ksym-64kb-lc-aes-gcm-alloc \
ksym-64kb-lc-aes-gcm-generate-iv \
ksym-64kb-lc-aes-kw \
ksym-64kb-lc-aes-kw-aesni \
ksym-64kb-lc-aes-kw-armce \
ksym-64kb-lc-aes-kw-c \
ksym-64kb-lc-aes-kw-decrypt \
ksym-64kb-lc-aes-kw-encrypt \
ksym-64kb-lc-aes-kw-riscv64 \
ksym-64kb-lc-aes-riscv64 \
ksym-64kb-lc-aes-sbox \
ksym-64kb-lc-aes-xts \
ksym-64kb-lc-aes-xts-aesni \
ksym-64kb-lc-aes-xts-armce \
ksym-64kb-lc-aes-xts-c \
ksym-64kb-lc-aes-xts-riscv64 \
ksym-64kb-lc-ak-alloc \
ksym-64kb-lc-ak-alloc-taglen \
ksym-64kb-lc-al-alloc \
ksym-64kb-lc-alg-disable-selftests \
ksym-64kb-lc-alloc-aligned \
ksym-64kb-lc-alloc-aligned-secure \
ksym-64kb-lc-alloc-high-aligned \
ksym-64kb-lc-ascon-128a \
ksym-64kb-lc-ascon-128a-arm-neon \
ksym-64kb-lc-ascon-128a-avx512 \
ksym-64kb-lc-ascon-128a-c \
ksym-64kb-lc-ascon-256 \
ksym-64kb-lc-ascon-256-arm-neon \
ksym-64kb-lc-ascon-256-avx512 \
ksym-64kb-lc-ascon-256-c \
ksym-64kb-lc-ascon-aead \
ksym-64kb-lc-ascon-keccak-aead \
ksym-64kb-lc-ascon-xof \
ksym-64kb-lc-ascon-xof-arm-neon \
ksym-64kb-lc-ascon-xof-avx512 \
ksym-64kb-lc-ascon-xof-c \
ksym-64kb-lc-asn1-ber-decoder \
ksym-64kb-lc-asn1-ber-encoder \
ksym-64kb-lc-asn1-ber-encoder-small \
ksym-64kb-lc-bike-1-dec \
ksym-64kb-lc-bike-1-dec-kdf \
ksym-64kb-lc-bike-1-enc \
ksym-64kb-lc-bike-1-enc-internal \
ksym-64kb-lc-bike-1-enc-kdf \
ksym-64kb-lc-bike-1-keypair \
ksym-64kb-lc-bike-1-keypair-from-seed \
ksym-64kb-lc-bike-3-dec \
ksym-64kb-lc-bike-3-dec-kdf \
ksym-64kb-lc-bike-3-enc \
ksym-64kb-lc-bike-3-enc-internal \
ksym-64kb-lc-bike-3-enc-kdf \
ksym-64kb-lc-bike-3-keypair \
ksym-64kb-lc-bike-3-keypair-from-seed \
ksym-64kb-lc-bike-5-dec \
ksym-64kb-lc-bike-5-dec-kdf \
ksym-64kb-lc-bike-5-enc \
ksym-64kb-lc-bike-5-enc-internal \
ksym-64kb-lc-bike-5-enc-kdf \
ksym-64kb-lc-bike-5-keypair \
ksym-64kb-lc-bike-5-keypair-from-seed \
ksym-64kb-lc-bike-alg-status \
ksym-64kb-lc-bike-ct-load \
ksym-64kb-lc-bike-ct-ptr \
ksym-64kb-lc-bike-ct-size \
ksym-64kb-lc-bike-ct-type \
ksym-64kb-lc-bike-dec \
ksym-64kb-lc-bike-dec-kdf \
ksym-64kb-lc-bike-enc \
ksym-64kb-lc-bike-enc-kdf \
ksym-64kb-lc-bike-keypair \
ksym-64kb-lc-bike-keypair-from-seed \
ksym-64kb-lc-bike-pk-load \
ksym-64kb-lc-bike-pk-ptr \
ksym-64kb-lc-bike-pk-size \
ksym-64kb-lc-bike-pk-type \
ksym-64kb-lc-bike-sk-load \
ksym-64kb-lc-bike-sk-ptr \
ksym-64kb-lc-bike-sk-size \
ksym-64kb-lc-bike-sk-type \
ksym-64kb-lc-bike-ss-load \
ksym-64kb-lc-bike-ss-ptr \
ksym-64kb-lc-bike-ss-size \
ksym-64kb-lc-bike-ss-type \
ksym-64kb-lc-cc-alloc \
ksym-64kb-lc-cc20-drng \
ksym-64kb-lc-cc20-drng-alloc \
ksym-64kb-lc-chacha20 \
ksym-64kb-lc-chacha20-avx2 \
ksym-64kb-lc-chacha20-avx512 \
ksym-64kb-lc-chacha20-c \
ksym-64kb-lc-chacha20-neon \
ksym-64kb-lc-chacha20-poly1305-aead \
ksym-64kb-lc-chacha20-poly1305-alloc \
ksym-64kb-lc-chacha20-riscv64-v-zbb \
ksym-64kb-lc-compare \
ksym-64kb-lc-cpu-feature-available \
ksym-64kb-lc-cpu-feature-disable \
ksym-64kb-lc-cpu-feature-enable \
ksym-64kb-lc-cpu-feature-set \
ksym-64kb-lc-cshake-aead \
ksym-64kb-lc-cshake-ctx-alloc \
ksym-64kb-lc-cshake-ctx-final \
ksym-64kb-lc-cshake-ctx-init \
ksym-64kb-lc-cshake-ctx-reinit \
ksym-64kb-lc-cshake-ctx-update \
ksym-64kb-lc-cshake-ctx-zero-free \
ksym-64kb-lc-cshake-init \
ksym-64kb-lc-cshake128 \
ksym-64kb-lc-cshake128-arm-asm \
ksym-64kb-lc-cshake128-arm-ce \
ksym-64kb-lc-cshake128-arm-neon \
ksym-64kb-lc-cshake128-avx2 \
ksym-64kb-lc-cshake128-avx512 \
ksym-64kb-lc-cshake128-c \
ksym-64kb-lc-cshake128-riscv-asm \
ksym-64kb-lc-cshake128-riscv-asm-zbb \
ksym-64kb-lc-cshake256 \
ksym-64kb-lc-cshake256-arm-asm \
ksym-64kb-lc-cshake256-arm-ce \
ksym-64kb-lc-cshake256-arm-neon \
ksym-64kb-lc-cshake256-avx2 \
ksym-64kb-lc-cshake256-avx512 \
ksym-64kb-lc-cshake256-c \
ksym-64kb-lc-cshake256-drng \
ksym-64kb-lc-cshake256-drng-alloc \
ksym-64kb-lc-cshake256-riscv-asm \
ksym-64kb-lc-cshake256-riscv-asm-zbb \
ksym-64kb-lc-ctr-drbg \
ksym-64kb-lc-dilithium-44-ctx-alloc \
ksym-64kb-lc-dilithium-44-ctx-alloc-ahat \
ksym-64kb-lc-dilithium-44-ctx-zero-free \
ksym-64kb-lc-dilithium-44-ed25519-ctx-alloc \
ksym-64kb-lc-dilithium-44-ed25519-ctx-zero-free \
ksym-64kb-lc-dilithium-44-ed25519-keypair \
ksym-64kb-lc-dilithium-44-ed25519-pk-from-sk \
ksym-64kb-lc-dilithium-44-ed25519-sign \
ksym-64kb-lc-dilithium-44-ed25519-sign-ctx \
ksym-64kb-lc-dilithium-44-ed25519-sign-final \
ksym-64kb-lc-dilithium-44-ed25519-sign-init \
ksym-64kb-lc-dilithium-44-ed25519-sign-update \
ksym-64kb-lc-dilithium-44-ed25519-verify \
ksym-64kb-lc-dilithium-44-ed25519-verify-ctx \
ksym-64kb-lc-dilithium-44-ed25519-verify-final \
ksym-64kb-lc-dilithium-44-ed25519-verify-init \
ksym-64kb-lc-dilithium-44-ed25519-verify-update \
ksym-64kb-lc-dilithium-44-ed448-ctx-alloc \
ksym-64kb-lc-dilithium-44-ed448-ctx-zero-free \
ksym-64kb-lc-dilithium-44-ed448-keypair \
ksym-64kb-lc-dilithium-44-ed448-pk-from-sk \
ksym-64kb-lc-dilithium-44-ed448-sign \
ksym-64kb-lc-dilithium-44-ed448-sign-ctx \
ksym-64kb-lc-dilithium-44-ed448-sign-final \
ksym-64kb-lc-dilithium-44-ed448-sign-init \
ksym-64kb-lc-dilithium-44-ed448-sign-update \
ksym-64kb-lc-dilithium-44-ed448-verify \
ksym-64kb-lc-dilithium-44-ed448-verify-ctx \
ksym-64kb-lc-dilithium-44-ed448-verify-final \
ksym-64kb-lc-dilithium-44-ed448-verify-init \
ksym-64kb-lc-dilithium-44-ed448-verify-update \
ksym-64kb-lc-dilithium-44-keypair \
ksym-64kb-lc-dilithium-44-keypair-c \
ksym-64kb-lc-dilithium-44-keypair-from-seed \
ksym-64kb-lc-dilithium-44-keypair-from-seed-c \
ksym-64kb-lc-dilithium-44-pk-from-sk \
ksym-64kb-lc-dilithium-44-pk-from-sk-c \
ksym-64kb-lc-dilithium-44-sign \
ksym-64kb-lc-dilithium-44-sign-c \
ksym-64kb-lc-dilithium-44-sign-ctx \
ksym-64kb-lc-dilithium-44-sign-ctx-c \
ksym-64kb-lc-dilithium-44-sign-final \
ksym-64kb-lc-dilithium-44-sign-final-c \
ksym-64kb-lc-dilithium-44-sign-init \
ksym-64kb-lc-dilithium-44-sign-init-c \
ksym-64kb-lc-dilithium-44-sign-update \
ksym-64kb-lc-dilithium-44-sign-update-c \
ksym-64kb-lc-dilithium-44-verify \
ksym-64kb-lc-dilithium-44-verify-c \
ksym-64kb-lc-dilithium-44-verify-ctx \
ksym-64kb-lc-dilithium-44-verify-ctx-c \
ksym-64kb-lc-dilithium-44-verify-final \
ksym-64kb-lc-dilithium-44-verify-final-c \
ksym-64kb-lc-dilithium-44-verify-init \
ksym-64kb-lc-dilithium-44-verify-init-c \
ksym-64kb-lc-dilithium-44-verify-update \
ksym-64kb-lc-dilithium-44-verify-update-c \
ksym-64kb-lc-dilithium-65-ctx-alloc \
ksym-64kb-lc-dilithium-65-ctx-alloc-ahat \
ksym-64kb-lc-dilithium-65-ctx-zero-free \
ksym-64kb-lc-dilithium-65-ed25519-ctx-alloc \
ksym-64kb-lc-dilithium-65-ed25519-ctx-zero-free \
ksym-64kb-lc-dilithium-65-ed25519-keypair \
ksym-64kb-lc-dilithium-65-ed25519-pk-from-sk \
ksym-64kb-lc-dilithium-65-ed25519-sign \
ksym-64kb-lc-dilithium-65-ed25519-sign-ctx \
ksym-64kb-lc-dilithium-65-ed25519-sign-final \
ksym-64kb-lc-dilithium-65-ed25519-sign-init \
ksym-64kb-lc-dilithium-65-ed25519-sign-update \
ksym-64kb-lc-dilithium-65-ed25519-verify \
ksym-64kb-lc-dilithium-65-ed25519-verify-ctx \
ksym-64kb-lc-dilithium-65-ed25519-verify-final \
ksym-64kb-lc-dilithium-65-ed25519-verify-init \
ksym-64kb-lc-dilithium-65-ed25519-verify-update \
ksym-64kb-lc-dilithium-65-ed448-ctx-alloc \
ksym-64kb-lc-dilithium-65-ed448-ctx-zero-free \
ksym-64kb-lc-dilithium-65-ed448-keypair \
ksym-64kb-lc-dilithium-65-ed448-pk-from-sk \
ksym-64kb-lc-dilithium-65-ed448-sign \
ksym-64kb-lc-dilithium-65-ed448-sign-ctx \
ksym-64kb-lc-dilithium-65-ed448-sign-final \
ksym-64kb-lc-dilithium-65-ed448-sign-init \
ksym-64kb-lc-dilithium-65-ed448-sign-update \
ksym-64kb-lc-dilithium-65-ed448-verify \
ksym-64kb-lc-dilithium-65-ed448-verify-ctx \
ksym-64kb-lc-dilithium-65-ed448-verify-final \
ksym-64kb-lc-dilithium-65-ed448-verify-init \
ksym-64kb-lc-dilithium-65-ed448-verify-update \
ksym-64kb-lc-dilithium-65-keypair \
ksym-64kb-lc-dilithium-65-keypair-armv8 \
ksym-64kb-lc-dilithium-65-keypair-c \
ksym-64kb-lc-dilithium-65-keypair-from-seed \
ksym-64kb-lc-dilithium-65-keypair-from-seed-armv8 \
ksym-64kb-lc-dilithium-65-keypair-from-seed-c \
ksym-64kb-lc-dilithium-65-pk-from-sk \
ksym-64kb-lc-dilithium-65-pk-from-sk-armv8 \
ksym-64kb-lc-dilithium-65-pk-from-sk-c \
ksym-64kb-lc-dilithium-65-sign \
ksym-64kb-lc-dilithium-65-sign-armv8 \
ksym-64kb-lc-dilithium-65-sign-c \
ksym-64kb-lc-dilithium-65-sign-ctx \
ksym-64kb-lc-dilithium-65-sign-ctx-armv8 \
ksym-64kb-lc-dilithium-65-sign-ctx-c \
ksym-64kb-lc-dilithium-65-sign-final \
ksym-64kb-lc-dilithium-65-sign-final-armv8 \
ksym-64kb-lc-dilithium-65-sign-final-c \
ksym-64kb-lc-dilithium-65-sign-init \
ksym-64kb-lc-dilithium-65-sign-init-armv8 \
ksym-64kb-lc-dilithium-65-sign-init-c \
ksym-64kb-lc-dilithium-65-sign-update \
ksym-64kb-lc-dilithium-65-sign-update-armv8 \
ksym-64kb-lc-dilithium-65-sign-update-c \
ksym-64kb-lc-dilithium-65-verify \
ksym-64kb-lc-dilithium-65-verify-armv8 \
ksym-64kb-lc-dilithium-65-verify-c \
ksym-64kb-lc-dilithium-65-verify-ctx \
ksym-64kb-lc-dilithium-65-verify-ctx-armv8 \
ksym-64kb-lc-dilithium-65-verify-ctx-c \
ksym-64kb-lc-dilithium-65-verify-final \
ksym-64kb-lc-dilithium-65-verify-final-armv8 \
ksym-64kb-lc-dilithium-65-verify-final-c \
ksym-64kb-lc-dilithium-65-verify-init \
ksym-64kb-lc-dilithium-65-verify-init-armv8 \
ksym-64kb-lc-dilithium-65-verify-init-c \
ksym-64kb-lc-dilithium-65-verify-update \
ksym-64kb-lc-dilithium-65-verify-update-armv8 \
ksym-64kb-lc-dilithium-65-verify-update-c \
ksym-64kb-lc-dilithium-87-ctx-alloc \
ksym-64kb-lc-dilithium-87-ctx-alloc-ahat \
ksym-64kb-lc-dilithium-87-ctx-zero-free \
ksym-64kb-lc-dilithium-87-ed25519-ctx-alloc \
ksym-64kb-lc-dilithium-87-ed25519-ctx-zero-free \
ksym-64kb-lc-dilithium-87-ed25519-keypair \
ksym-64kb-lc-dilithium-87-ed25519-pk-from-sk \
ksym-64kb-lc-dilithium-87-ed25519-sign \
ksym-64kb-lc-dilithium-87-ed25519-sign-ctx \
ksym-64kb-lc-dilithium-87-ed25519-sign-final \
ksym-64kb-lc-dilithium-87-ed25519-sign-init \
ksym-64kb-lc-dilithium-87-ed25519-sign-update \
ksym-64kb-lc-dilithium-87-ed25519-verify \
ksym-64kb-lc-dilithium-87-ed25519-verify-ctx \
ksym-64kb-lc-dilithium-87-ed25519-verify-final \
ksym-64kb-lc-dilithium-87-ed25519-verify-init \
ksym-64kb-lc-dilithium-87-ed25519-verify-update \
ksym-64kb-lc-dilithium-87-ed448-ctx-alloc \
ksym-64kb-lc-dilithium-87-ed448-ctx-zero-free \
ksym-64kb-lc-dilithium-87-ed448-keypair \
ksym-64kb-lc-dilithium-87-ed448-pk-from-sk \
ksym-64kb-lc-dilithium-87-ed448-sign \
ksym-64kb-lc-dilithium-87-ed448-sign-ctx \
ksym-64kb-lc-dilithium-87-ed448-sign-final \
ksym-64kb-lc-dilithium-87-ed448-sign-init \
ksym-64kb-lc-dilithium-87-ed448-sign-update \
ksym-64kb-lc-dilithium-87-ed448-verify \
ksym-64kb-lc-dilithium-87-ed448-verify-ctx \
ksym-64kb-lc-dilithium-87-ed448-verify-final \
ksym-64kb-lc-dilithium-87-ed448-verify-init \
ksym-64kb-lc-dilithium-87-ed448-verify-update \
ksym-64kb-lc-dilithium-87-keypair \
ksym-64kb-lc-dilithium-87-keypair-armv8 \
ksym-64kb-lc-dilithium-87-keypair-c \
ksym-64kb-lc-dilithium-87-keypair-from-seed \
ksym-64kb-lc-dilithium-87-keypair-from-seed-armv8 \
ksym-64kb-lc-dilithium-87-keypair-from-seed-c \
ksym-64kb-lc-dilithium-87-pk-from-sk \
ksym-64kb-lc-dilithium-87-pk-from-sk-armv8 \
ksym-64kb-lc-dilithium-87-pk-from-sk-c \
ksym-64kb-lc-dilithium-87-sign \
ksym-64kb-lc-dilithium-87-sign-armv8 \
ksym-64kb-lc-dilithium-87-sign-c \
ksym-64kb-lc-dilithium-87-sign-ctx \
ksym-64kb-lc-dilithium-87-sign-ctx-armv8 \
ksym-64kb-lc-dilithium-87-sign-ctx-c \
ksym-64kb-lc-dilithium-87-sign-final \
ksym-64kb-lc-dilithium-87-sign-final-armv8 \
ksym-64kb-lc-dilithium-87-sign-final-c \
ksym-64kb-lc-dilithium-87-sign-init \
ksym-64kb-lc-dilithium-87-sign-init-armv8 \
ksym-64kb-lc-dilithium-87-sign-init-c \
ksym-64kb-lc-dilithium-87-sign-update \
ksym-64kb-lc-dilithium-87-sign-update-armv8 \
ksym-64kb-lc-dilithium-87-sign-update-c \
ksym-64kb-lc-dilithium-87-verify \
ksym-64kb-lc-dilithium-87-verify-armv8 \
ksym-64kb-lc-dilithium-87-verify-c \
ksym-64kb-lc-dilithium-87-verify-ctx \
ksym-64kb-lc-dilithium-87-verify-ctx-armv8 \
ksym-64kb-lc-dilithium-87-verify-ctx-c \
ksym-64kb-lc-dilithium-87-verify-final \
ksym-64kb-lc-dilithium-87-verify-final-armv8 \
ksym-64kb-lc-dilithium-87-verify-final-c \
ksym-64kb-lc-dilithium-87-verify-init \
ksym-64kb-lc-dilithium-87-verify-init-armv8 \
ksym-64kb-lc-dilithium-87-verify-init-c \
ksym-64kb-lc-dilithium-87-verify-update \
ksym-64kb-lc-dilithium-87-verify-update-armv8 \
ksym-64kb-lc-dilithium-87-verify-update-c \
ksym-64kb-lc-dilithium-alg-status \
ksym-64kb-lc-dilithium-ctx-alloc \
ksym-64kb-lc-dilithium-ctx-alloc-ahat \
ksym-64kb-lc-dilithium-ctx-drop-ahat \
ksym-64kb-lc-dilithium-ctx-external-mu \
ksym-64kb-lc-dilithium-ctx-hash \
ksym-64kb-lc-dilithium-ctx-internal \
ksym-64kb-lc-dilithium-ctx-userctx \
ksym-64kb-lc-dilithium-ctx-zero \
ksym-64kb-lc-dilithium-ctx-zero-free \
ksym-64kb-lc-dilithium-ed25519-ctx-alloc \
ksym-64kb-lc-dilithium-ed25519-ctx-hash \
ksym-64kb-lc-dilithium-ed25519-ctx-internal \
ksym-64kb-lc-dilithium-ed25519-ctx-userctx \
ksym-64kb-lc-dilithium-ed25519-ctx-zero \
ksym-64kb-lc-dilithium-ed25519-ctx-zero-free \
ksym-64kb-lc-dilithium-ed25519-keypair \
ksym-64kb-lc-dilithium-ed25519-pk-from-sk \
ksym-64kb-lc-dilithium-ed25519-pk-load \
ksym-64kb-lc-dilithium-ed25519-pk-ptr \
ksym-64kb-lc-dilithium-ed25519-pk-size \
ksym-64kb-lc-dilithium-ed25519-pk-type \
ksym-64kb-lc-dilithium-ed25519-sig-load \
ksym-64kb-lc-dilithium-ed25519-sig-ptr \
ksym-64kb-lc-dilithium-ed25519-sig-size \
ksym-64kb-lc-dilithium-ed25519-sig-type \
ksym-64kb-lc-dilithium-ed25519-sign \
ksym-64kb-lc-dilithium-ed25519-sign-ctx \
ksym-64kb-lc-dilithium-ed25519-sign-final \
ksym-64kb-lc-dilithium-ed25519-sign-init \
ksym-64kb-lc-dilithium-ed25519-sign-update \
ksym-64kb-lc-dilithium-ed25519-sk-load \
ksym-64kb-lc-dilithium-ed25519-sk-ptr \
ksym-64kb-lc-dilithium-ed25519-sk-size \
ksym-64kb-lc-dilithium-ed25519-sk-type \
ksym-64kb-lc-dilithium-ed25519-verify \
ksym-64kb-lc-dilithium-ed25519-verify-ctx \
ksym-64kb-lc-dilithium-ed25519-verify-final \
ksym-64kb-lc-dilithium-ed25519-verify-init \
ksym-64kb-lc-dilithium-ed25519-verify-update \
ksym-64kb-lc-dilithium-ed448-ctx-alloc \
ksym-64kb-lc-dilithium-ed448-ctx-hash \
ksym-64kb-lc-dilithium-ed448-ctx-internal \
ksym-64kb-lc-dilithium-ed448-ctx-userctx \
ksym-64kb-lc-dilithium-ed448-ctx-zero \
ksym-64kb-lc-dilithium-ed448-ctx-zero-free \
ksym-64kb-lc-dilithium-ed448-keypair \
ksym-64kb-lc-dilithium-ed448-pk-from-sk \
ksym-64kb-lc-dilithium-ed448-pk-load \
ksym-64kb-lc-dilithium-ed448-pk-ptr \
ksym-64kb-lc-dilithium-ed448-pk-size \
ksym-64kb-lc-dilithium-ed448-pk-type \
ksym-64kb-lc-dilithium-ed448-sig-load \
ksym-64kb-lc-dilithium-ed448-sig-ptr \
ksym-64kb-lc-dilithium-ed448-sig-size \
ksym-64kb-lc-dilithium-ed448-sig-type \
ksym-64kb-lc-dilithium-ed448-sign \
ksym-64kb-lc-dilithium-ed448-sign-ctx \
ksym-64kb-lc-dilithium-ed448-sign-final \
ksym-64kb-lc-dilithium-ed448-sign-init \
ksym-64kb-lc-dilithium-ed448-sign-update \
ksym-64kb-lc-dilithium-ed448-sk-load \
ksym-64kb-lc-dilithium-ed448-sk-ptr \
ksym-64kb-lc-dilithium-ed448-sk-size \
ksym-64kb-lc-dilithium-ed448-sk-type \
ksym-64kb-lc-dilithium-ed448-verify \
ksym-64kb-lc-dilithium-ed448-verify-ctx \
ksym-64kb-lc-dilithium-ed448-verify-final \
ksym-64kb-lc-dilithium-ed448-verify-init \
ksym-64kb-lc-dilithium-ed448-verify-update \
ksym-64kb-lc-dilithium-keypair \
ksym-64kb-lc-dilithium-keypair-from-seed \
ksym-64kb-lc-dilithium-pct \
ksym-64kb-lc-dilithium-pk-from-sk \
ksym-64kb-lc-dilithium-pk-load \
ksym-64kb-lc-dilithium-pk-ptr \
ksym-64kb-lc-dilithium-pk-size \
ksym-64kb-lc-dilithium-pk-type \
ksym-64kb-lc-dilithium-sig-load \
ksym-64kb-lc-dilithium-sig-ptr \
ksym-64kb-lc-dilithium-sig-size \
ksym-64kb-lc-dilithium-sig-type \
ksym-64kb-lc-dilithium-sign \
ksym-64kb-lc-dilithium-sign-ctx \
ksym-64kb-lc-dilithium-sign-final \
ksym-64kb-lc-dilithium-sign-init \
ksym-64kb-lc-dilithium-sign-update \
ksym-64kb-lc-dilithium-sk-load \
ksym-64kb-lc-dilithium-sk-ptr \
ksym-64kb-lc-dilithium-sk-size \
ksym-64kb-lc-dilithium-sk-type \
ksym-64kb-lc-dilithium-verify \
ksym-64kb-lc-dilithium-verify-ctx \
ksym-64kb-lc-dilithium-verify-final \
ksym-64kb-lc-dilithium-verify-init \
ksym-64kb-lc-dilithium-verify-update \
ksym-64kb-lc-disable-selftest \
ksym-64kb-lc-drbg-ctr-no-df-alloc \
ksym-64kb-lc-drbg-ctr-use-df-alloc \
ksym-64kb-lc-drbg-hash-alloc \
ksym-64kb-lc-drbg-hash-healthcheck-sanity \
ksym-64kb-lc-drbg-hmac-alloc \
ksym-64kb-lc-drbg-hmac-healthcheck-sanity \
ksym-64kb-lc-ed25519-alg-status \
ksym-64kb-lc-ed25519-keypair \
ksym-64kb-lc-ed25519-pk-load \
ksym-64kb-lc-ed25519-pk-ptr \
ksym-64kb-lc-ed25519-pk-size \
ksym-64kb-lc-ed25519-sig-load \
ksym-64kb-lc-ed25519-sig-ptr \
ksym-64kb-lc-ed25519-sig-size \
ksym-64kb-lc-ed25519-sign \
ksym-64kb-lc-ed25519-sk-load \
ksym-64kb-lc-ed25519-sk-ptr \
ksym-64kb-lc-ed25519-sk-size \
ksym-64kb-lc-ed25519-verify \
ksym-64kb-lc-ed25519ph-sign \
ksym-64kb-lc-ed25519ph-verify \
ksym-64kb-lc-ed448-alg-status \
ksym-64kb-lc-ed448-keypair \
ksym-64kb-lc-ed448-pk-load \
ksym-64kb-lc-ed448-pk-ptr \
ksym-64kb-lc-ed448-pk-size \
ksym-64kb-lc-ed448-sig-load \
ksym-64kb-lc-ed448-sig-ptr \
ksym-64kb-lc-ed448-sig-size \
ksym-64kb-lc-ed448-sign \
ksym-64kb-lc-ed448-sk-load \
ksym-64kb-lc-ed448-sk-ptr \
ksym-64kb-lc-ed448-sk-size \
ksym-64kb-lc-ed448-verify \
ksym-64kb-lc-ed448ph-sign \
ksym-64kb-lc-ed448ph-verify \
ksym-64kb-lc-fips-integrity-checker \
ksym-64kb-lc-free \
ksym-64kb-lc-free-high-aligned \
ksym-64kb-lc-gmtime \
ksym-64kb-lc-hash \
ksym-64kb-lc-hash-aead \
ksym-64kb-lc-hash-alg-status \
ksym-64kb-lc-hash-alloc \
ksym-64kb-lc-hash-blocksize \
ksym-64kb-lc-hash-ctx-alg-status \
ksym-64kb-lc-hash-ctxsize \
ksym-64kb-lc-hash-digestsize \
ksym-64kb-lc-hash-drbg \
ksym-64kb-lc-hash-final \
ksym-64kb-lc-hash-init \
ksym-64kb-lc-hash-set-ctx \
ksym-64kb-lc-hash-set-digestsize \
ksym-64kb-lc-hash-update \
ksym-64kb-lc-hash-zero \
ksym-64kb-lc-hash-zero-free \
ksym-64kb-lc-hc-alloc \
ksym-64kb-lc-hkdf \
ksym-64kb-lc-hkdf-alg-status \
ksym-64kb-lc-hkdf-alloc \
ksym-64kb-lc-hkdf-expand \
ksym-64kb-lc-hkdf-expand-prk \
ksym-64kb-lc-hkdf-extract \
ksym-64kb-lc-hkdf-extract-prk \
ksym-64kb-lc-hkdf-rng \
ksym-64kb-lc-hkdf-rng-alloc \
ksym-64kb-lc-hkdf-zero \
ksym-64kb-lc-hkdf-zero-free \
ksym-64kb-lc-hmac \
ksym-64kb-lc-hmac-alg-status \
ksym-64kb-lc-hmac-alloc \
ksym-64kb-lc-hmac-ctx-alg-status \
ksym-64kb-lc-hmac-drbg \
ksym-64kb-lc-hmac-final \
ksym-64kb-lc-hmac-init \
ksym-64kb-lc-hmac-init-with-hmac-key \
ksym-64kb-lc-hmac-macsize \
ksym-64kb-lc-hmac-reinit \
ksym-64kb-lc-hmac-setkey \
ksym-64kb-lc-hmac-update \
ksym-64kb-lc-hmac-zero \
ksym-64kb-lc-hmac-zero-free \
ksym-64kb-lc-hqc-128-dec \
ksym-64kb-lc-hqc-128-dec-c \
ksym-64kb-lc-hqc-128-dec-kdf \
ksym-64kb-lc-hqc-128-dec-kdf-c \
ksym-64kb-lc-hqc-128-enc \
ksym-64kb-lc-hqc-128-enc-c \
ksym-64kb-lc-hqc-128-enc-internal \
ksym-64kb-lc-hqc-128-enc-internal-c \
ksym-64kb-lc-hqc-128-enc-kdf \
ksym-64kb-lc-hqc-128-enc-kdf-c \
ksym-64kb-lc-hqc-128-keypair \
ksym-64kb-lc-hqc-128-keypair-c \
ksym-64kb-lc-hqc-128-keypair-from-seed \
ksym-64kb-lc-hqc-128-keypair-from-seed-c \
ksym-64kb-lc-hqc-192-dec \
ksym-64kb-lc-hqc-192-dec-c \
ksym-64kb-lc-hqc-192-dec-kdf \
ksym-64kb-lc-hqc-192-dec-kdf-c \
ksym-64kb-lc-hqc-192-enc \
ksym-64kb-lc-hqc-192-enc-c \
ksym-64kb-lc-hqc-192-enc-internal \
ksym-64kb-lc-hqc-192-enc-internal-c \
ksym-64kb-lc-hqc-192-enc-kdf \
ksym-64kb-lc-hqc-192-enc-kdf-c \
ksym-64kb-lc-hqc-192-keypair \
ksym-64kb-lc-hqc-192-keypair-c \
ksym-64kb-lc-hqc-192-keypair-from-seed \
ksym-64kb-lc-hqc-192-keypair-from-seed-c \
ksym-64kb-lc-hqc-256-dec \
ksym-64kb-lc-hqc-256-dec-c \
ksym-64kb-lc-hqc-256-dec-kdf \
ksym-64kb-lc-hqc-256-dec-kdf-c \
ksym-64kb-lc-hqc-256-enc \
ksym-64kb-lc-hqc-256-enc-c \
ksym-64kb-lc-hqc-256-enc-internal \
ksym-64kb-lc-hqc-256-enc-internal-c \
ksym-64kb-lc-hqc-256-enc-kdf \
ksym-64kb-lc-hqc-256-enc-kdf-c \
ksym-64kb-lc-hqc-256-keypair \
ksym-64kb-lc-hqc-256-keypair-c \
ksym-64kb-lc-hqc-256-keypair-from-seed \
ksym-64kb-lc-hqc-256-keypair-from-seed-c \
ksym-64kb-lc-hqc-alg-status \
ksym-64kb-lc-hqc-ct-load \
ksym-64kb-lc-hqc-ct-ptr \
ksym-64kb-lc-hqc-ct-size \
ksym-64kb-lc-hqc-ct-type \
ksym-64kb-lc-hqc-dec \
ksym-64kb-lc-hqc-dec-kdf \
ksym-64kb-lc-hqc-enc \
ksym-64kb-lc-hqc-enc-kdf \
ksym-64kb-lc-hqc-keypair \
ksym-64kb-lc-hqc-keypair-from-seed \
ksym-64kb-lc-hqc-pk-load \
ksym-64kb-lc-hqc-pk-ptr \
ksym-64kb-lc-hqc-pk-size \
ksym-64kb-lc-hqc-pk-type \
ksym-64kb-lc-hqc-sk-load \
ksym-64kb-lc-hqc-sk-ptr \
ksym-64kb-lc-hqc-sk-size \
ksym-64kb-lc-hqc-sk-type \
ksym-64kb-lc-hqc-ss-load \
ksym-64kb-lc-hqc-ss-ptr \
ksym-64kb-lc-hqc-ss-size \
ksym-64kb-lc-hqc-ss-type \
ksym-64kb-lc-kc-alloc \
ksym-64kb-lc-kdf-ctr \
ksym-64kb-lc-kdf-ctr-alg-status \
ksym-64kb-lc-kdf-ctr-generate \
ksym-64kb-lc-kdf-ctr-init \
ksym-64kb-lc-kdf-ctr-rng \
ksym-64kb-lc-kdf-ctr-rng-alloc \
ksym-64kb-lc-kdf-dpi \
ksym-64kb-lc-kdf-dpi-alg-status \
ksym-64kb-lc-kdf-dpi-generate \
ksym-64kb-lc-kdf-dpi-init \
ksym-64kb-lc-kdf-fb \
ksym-64kb-lc-kdf-fb-alg-status \
ksym-64kb-lc-kdf-fb-generate \
ksym-64kb-lc-kdf-fb-init \
ksym-64kb-lc-kex-1024-ake-initiator-init \
ksym-64kb-lc-kex-1024-ake-initiator-init-internal \
ksym-64kb-lc-kex-1024-ake-initiator-ss \
ksym-64kb-lc-kex-1024-ake-responder-ss \
ksym-64kb-lc-kex-1024-ake-responder-ss-internal \
ksym-64kb-lc-kex-1024-uake-initiator-init \
ksym-64kb-lc-kex-1024-uake-initiator-init-internal \
ksym-64kb-lc-kex-1024-uake-initiator-ss \
ksym-64kb-lc-kex-1024-uake-responder-ss \
ksym-64kb-lc-kex-1024-uake-responder-ss-internal \
ksym-64kb-lc-kex-1024-x25519-ake-initiator-init \
ksym-64kb-lc-kex-1024-x25519-ake-initiator-init-internal \
ksym-64kb-lc-kex-1024-x25519-ake-initiator-ss \
ksym-64kb-lc-kex-1024-x25519-ake-responder-ss \
ksym-64kb-lc-kex-1024-x25519-ake-responder-ss-internal \
ksym-64kb-lc-kex-1024-x25519-uake-initiator-init \
ksym-64kb-lc-kex-1024-x25519-uake-initiator-init-internal \
ksym-64kb-lc-kex-1024-x25519-uake-initiator-ss \
ksym-64kb-lc-kex-1024-x25519-uake-responder-ss \
ksym-64kb-lc-kex-1024-x25519-uake-responder-ss-internal \
ksym-64kb-lc-kex-1024-x448-ake-initiator-init \
ksym-64kb-lc-kex-1024-x448-ake-initiator-init-internal \
ksym-64kb-lc-kex-1024-x448-ake-initiator-ss \
ksym-64kb-lc-kex-1024-x448-ake-responder-ss \
ksym-64kb-lc-kex-1024-x448-ake-responder-ss-internal \
ksym-64kb-lc-kex-1024-x448-uake-initiator-init \
ksym-64kb-lc-kex-1024-x448-uake-initiator-init-internal \
ksym-64kb-lc-kex-1024-x448-uake-initiator-ss \
ksym-64kb-lc-kex-1024-x448-uake-responder-ss \
ksym-64kb-lc-kex-1024-x448-uake-responder-ss-internal \
ksym-64kb-lc-kex-512-ake-initiator-init \
ksym-64kb-lc-kex-512-ake-initiator-init-internal \
ksym-64kb-lc-kex-512-ake-initiator-ss \
ksym-64kb-lc-kex-512-ake-responder-ss \
ksym-64kb-lc-kex-512-ake-responder-ss-internal \
ksym-64kb-lc-kex-512-uake-initiator-init \
ksym-64kb-lc-kex-512-uake-initiator-init-internal \
ksym-64kb-lc-kex-512-uake-initiator-ss \
ksym-64kb-lc-kex-512-uake-responder-ss \
ksym-64kb-lc-kex-512-uake-responder-ss-internal \
ksym-64kb-lc-kex-512-x25519-ake-initiator-init \
ksym-64kb-lc-kex-512-x25519-ake-initiator-init-internal \
ksym-64kb-lc-kex-512-x25519-ake-initiator-ss \
ksym-64kb-lc-kex-512-x25519-ake-responder-ss \
ksym-64kb-lc-kex-512-x25519-ake-responder-ss-internal \
ksym-64kb-lc-kex-512-x25519-uake-initiator-init \
ksym-64kb-lc-kex-512-x25519-uake-initiator-init-internal \
ksym-64kb-lc-kex-512-x25519-uake-initiator-ss \
ksym-64kb-lc-kex-512-x25519-uake-responder-ss \
ksym-64kb-lc-kex-512-x25519-uake-responder-ss-internal \
ksym-64kb-lc-kex-512-x448-ake-initiator-init \
ksym-64kb-lc-kex-512-x448-ake-initiator-init-internal \
ksym-64kb-lc-kex-512-x448-ake-initiator-ss \
ksym-64kb-lc-kex-512-x448-ake-responder-ss \
ksym-64kb-lc-kex-512-x448-ake-responder-ss-internal \
ksym-64kb-lc-kex-512-x448-uake-initiator-init \
ksym-64kb-lc-kex-512-x448-uake-initiator-init-internal \
ksym-64kb-lc-kex-512-x448-uake-initiator-ss \
ksym-64kb-lc-kex-512-x448-uake-responder-ss \
ksym-64kb-lc-kex-512-x448-uake-responder-ss-internal \
ksym-64kb-lc-kex-768-ake-initiator-init \
ksym-64kb-lc-kex-768-ake-initiator-init-internal \
ksym-64kb-lc-kex-768-ake-initiator-ss \
ksym-64kb-lc-kex-768-ake-responder-ss \
ksym-64kb-lc-kex-768-ake-responder-ss-internal \
ksym-64kb-lc-kex-768-uake-initiator-init \
ksym-64kb-lc-kex-768-uake-initiator-init-internal \
ksym-64kb-lc-kex-768-uake-initiator-ss \
ksym-64kb-lc-kex-768-uake-responder-ss \
ksym-64kb-lc-kex-768-uake-responder-ss-internal \
ksym-64kb-lc-kex-768-x25519-ake-initiator-init \
ksym-64kb-lc-kex-768-x25519-ake-initiator-init-internal \
ksym-64kb-lc-kex-768-x25519-ake-initiator-ss \
ksym-64kb-lc-kex-768-x25519-ake-responder-ss \
ksym-64kb-lc-kex-768-x25519-ake-responder-ss-internal \
ksym-64kb-lc-kex-768-x25519-uake-initiator-init \
ksym-64kb-lc-kex-768-x25519-uake-initiator-init-internal \
ksym-64kb-lc-kex-768-x25519-uake-initiator-ss \
ksym-64kb-lc-kex-768-x25519-uake-responder-ss \
ksym-64kb-lc-kex-768-x25519-uake-responder-ss-internal \
ksym-64kb-lc-kex-768-x448-ake-initiator-init \
ksym-64kb-lc-kex-768-x448-ake-initiator-init-internal \
ksym-64kb-lc-kex-768-x448-ake-initiator-ss \
ksym-64kb-lc-kex-768-x448-ake-responder-ss \
ksym-64kb-lc-kex-768-x448-ake-responder-ss-internal \
ksym-64kb-lc-kex-768-x448-uake-initiator-init \
ksym-64kb-lc-kex-768-x448-uake-initiator-init-internal \
ksym-64kb-lc-kex-768-x448-uake-initiator-ss \
ksym-64kb-lc-kex-768-x448-uake-responder-ss \
ksym-64kb-lc-kex-768-x448-uake-responder-ss-internal \
ksym-64kb-lc-kex-ake-initiator-init \
ksym-64kb-lc-kex-ake-initiator-ss \
ksym-64kb-lc-kex-ake-responder-ss \
ksym-64kb-lc-kex-uake-initiator-init \
ksym-64kb-lc-kex-uake-initiator-ss \
ksym-64kb-lc-kex-uake-responder-ss \
ksym-64kb-lc-kex-x25519-ake-initiator-init \
ksym-64kb-lc-kex-x25519-ake-initiator-ss \
ksym-64kb-lc-kex-x25519-ake-responder-ss \
ksym-64kb-lc-kex-x25519-uake-initiator-init \
ksym-64kb-lc-kex-x25519-uake-initiator-ss \
ksym-64kb-lc-kex-x25519-uake-responder-ss \
ksym-64kb-lc-kex-x448-ake-initiator-init \
ksym-64kb-lc-kex-x448-ake-initiator-ss \
ksym-64kb-lc-kex-x448-ake-responder-ss \
ksym-64kb-lc-kex-x448-uake-initiator-init \
ksym-64kb-lc-kex-x448-uake-initiator-ss \
ksym-64kb-lc-kex-x448-uake-responder-ss \
ksym-64kb-lc-kh-alloc \
ksym-64kb-lc-kmac \
ksym-64kb-lc-kmac-aead \
ksym-64kb-lc-kmac-alg-status \
ksym-64kb-lc-kmac-alloc \
ksym-64kb-lc-kmac-ctx-alg-status \
ksym-64kb-lc-kmac-final \
ksym-64kb-lc-kmac-final-xof \
ksym-64kb-lc-kmac-init \
ksym-64kb-lc-kmac-macsize \
ksym-64kb-lc-kmac-reinit \
ksym-64kb-lc-kmac-rng \
ksym-64kb-lc-kmac-rng-alloc \
ksym-64kb-lc-kmac-update \
ksym-64kb-lc-kmac-xof \
ksym-64kb-lc-kmac-zero \
ksym-64kb-lc-kmac-zero-free \
ksym-64kb-lc-kmac256-drng \
ksym-64kb-lc-kmac256-drng-alloc \
ksym-64kb-lc-kyber-1024-dec \
ksym-64kb-lc-kyber-1024-dec-c \
ksym-64kb-lc-kyber-1024-dec-kdf \
ksym-64kb-lc-kyber-1024-dec-kdf-c \
ksym-64kb-lc-kyber-1024-enc \
ksym-64kb-lc-kyber-1024-enc-c \
ksym-64kb-lc-kyber-1024-enc-internal \
ksym-64kb-lc-kyber-1024-enc-kdf \
ksym-64kb-lc-kyber-1024-enc-kdf-c \
ksym-64kb-lc-kyber-1024-enc-kdf-internal \
ksym-64kb-lc-kyber-1024-ies-dec \
ksym-64kb-lc-kyber-1024-ies-dec-init \
ksym-64kb-lc-kyber-1024-ies-enc \
ksym-64kb-lc-kyber-1024-ies-enc-init \
ksym-64kb-lc-kyber-1024-ies-enc-init-internal \
ksym-64kb-lc-kyber-1024-ies-enc-internal \
ksym-64kb-lc-kyber-1024-keypair \
ksym-64kb-lc-kyber-1024-keypair-c \
ksym-64kb-lc-kyber-1024-keypair-from-seed \
ksym-64kb-lc-kyber-1024-keypair-from-seed-c \
ksym-64kb-lc-kyber-1024-pk-from-sk \
ksym-64kb-lc-kyber-1024-pk-from-sk-c \
ksym-64kb-lc-kyber-1024-x25519-dec \
ksym-64kb-lc-kyber-1024-x25519-dec-kdf \
ksym-64kb-lc-kyber-1024-x25519-enc \
ksym-64kb-lc-kyber-1024-x25519-enc-kdf \
ksym-64kb-lc-kyber-1024-x25519-enc-kdf-internal \
ksym-64kb-lc-kyber-1024-x25519-ies-dec \
ksym-64kb-lc-kyber-1024-x25519-ies-dec-init \
ksym-64kb-lc-kyber-1024-x25519-ies-enc \
ksym-64kb-lc-kyber-1024-x25519-ies-enc-init \
ksym-64kb-lc-kyber-1024-x25519-ies-enc-init-internal \
ksym-64kb-lc-kyber-1024-x25519-ies-enc-internal \
ksym-64kb-lc-kyber-1024-x25519-keypair \
ksym-64kb-lc-kyber-1024-x25519-pk-from-sk \
ksym-64kb-lc-kyber-1024-x448-dec \
ksym-64kb-lc-kyber-1024-x448-dec-kdf \
ksym-64kb-lc-kyber-1024-x448-enc \
ksym-64kb-lc-kyber-1024-x448-enc-kdf \
ksym-64kb-lc-kyber-1024-x448-enc-kdf-internal \
ksym-64kb-lc-kyber-1024-x448-ies-dec \
ksym-64kb-lc-kyber-1024-x448-ies-dec-init \
ksym-64kb-lc-kyber-1024-x448-ies-enc \
ksym-64kb-lc-kyber-1024-x448-ies-enc-init \
ksym-64kb-lc-kyber-1024-x448-ies-enc-init-internal \
ksym-64kb-lc-kyber-1024-x448-ies-enc-internal \
ksym-64kb-lc-kyber-1024-x448-keypair \
ksym-64kb-lc-kyber-1024-x448-pk-from-sk \
ksym-64kb-lc-kyber-512-dec \
ksym-64kb-lc-kyber-512-dec-c \
ksym-64kb-lc-kyber-512-dec-kdf \
ksym-64kb-lc-kyber-512-dec-kdf-c \
ksym-64kb-lc-kyber-512-enc \
ksym-64kb-lc-kyber-512-enc-c \
ksym-64kb-lc-kyber-512-enc-internal \
ksym-64kb-lc-kyber-512-enc-kdf \
ksym-64kb-lc-kyber-512-enc-kdf-c \
ksym-64kb-lc-kyber-512-enc-kdf-internal \
ksym-64kb-lc-kyber-512-ies-dec \
ksym-64kb-lc-kyber-512-ies-dec-init \
ksym-64kb-lc-kyber-512-ies-enc \
ksym-64kb-lc-kyber-512-ies-enc-init \
ksym-64kb-lc-kyber-512-ies-enc-init-internal \
ksym-64kb-lc-kyber-512-ies-enc-internal \
ksym-64kb-lc-kyber-512-keypair \
ksym-64kb-lc-kyber-512-keypair-c \
ksym-64kb-lc-kyber-512-keypair-from-seed \
ksym-64kb-lc-kyber-512-keypair-from-seed-c \
ksym-64kb-lc-kyber-512-pk-from-sk \
ksym-64kb-lc-kyber-512-pk-from-sk-c \
ksym-64kb-lc-kyber-512-x25519-dec \
ksym-64kb-lc-kyber-512-x25519-dec-kdf \
ksym-64kb-lc-kyber-512-x25519-enc \
ksym-64kb-lc-kyber-512-x25519-enc-kdf \
ksym-64kb-lc-kyber-512-x25519-enc-kdf-internal \
ksym-64kb-lc-kyber-512-x25519-ies-dec \
ksym-64kb-lc-kyber-512-x25519-ies-dec-init \
ksym-64kb-lc-kyber-512-x25519-ies-enc \
ksym-64kb-lc-kyber-512-x25519-ies-enc-init \
ksym-64kb-lc-kyber-512-x25519-ies-enc-init-internal \
ksym-64kb-lc-kyber-512-x25519-ies-enc-internal \
ksym-64kb-lc-kyber-512-x25519-keypair \
ksym-64kb-lc-kyber-512-x25519-pk-from-sk \
ksym-64kb-lc-kyber-512-x448-dec \
ksym-64kb-lc-kyber-512-x448-dec-kdf \
ksym-64kb-lc-kyber-512-x448-enc \
ksym-64kb-lc-kyber-512-x448-enc-kdf \
ksym-64kb-lc-kyber-512-x448-enc-kdf-internal \
ksym-64kb-lc-kyber-512-x448-ies-dec \
ksym-64kb-lc-kyber-512-x448-ies-dec-init \
ksym-64kb-lc-kyber-512-x448-ies-enc \
ksym-64kb-lc-kyber-512-x448-ies-enc-init \
ksym-64kb-lc-kyber-512-x448-ies-enc-init-internal \
ksym-64kb-lc-kyber-512-x448-ies-enc-internal \
ksym-64kb-lc-kyber-512-x448-keypair \
ksym-64kb-lc-kyber-512-x448-pk-from-sk \
ksym-64kb-lc-kyber-768-dec \
ksym-64kb-lc-kyber-768-dec-c \
ksym-64kb-lc-kyber-768-dec-kdf \
ksym-64kb-lc-kyber-768-dec-kdf-c \
ksym-64kb-lc-kyber-768-enc \
ksym-64kb-lc-kyber-768-enc-c \
ksym-64kb-lc-kyber-768-enc-internal \
ksym-64kb-lc-kyber-768-enc-kdf \
ksym-64kb-lc-kyber-768-enc-kdf-c \
ksym-64kb-lc-kyber-768-enc-kdf-internal \
ksym-64kb-lc-kyber-768-ies-dec \
ksym-64kb-lc-kyber-768-ies-dec-init \
ksym-64kb-lc-kyber-768-ies-enc \
ksym-64kb-lc-kyber-768-ies-enc-init \
ksym-64kb-lc-kyber-768-ies-enc-init-internal \
ksym-64kb-lc-kyber-768-ies-enc-internal \
ksym-64kb-lc-kyber-768-keypair \
ksym-64kb-lc-kyber-768-keypair-c \
ksym-64kb-lc-kyber-768-keypair-from-seed \
ksym-64kb-lc-kyber-768-keypair-from-seed-c \
ksym-64kb-lc-kyber-768-pk-from-sk \
ksym-64kb-lc-kyber-768-pk-from-sk-c \
ksym-64kb-lc-kyber-768-x25519-dec \
ksym-64kb-lc-kyber-768-x25519-dec-kdf \
ksym-64kb-lc-kyber-768-x25519-enc \
ksym-64kb-lc-kyber-768-x25519-enc-kdf \
ksym-64kb-lc-kyber-768-x25519-enc-kdf-internal \
ksym-64kb-lc-kyber-768-x25519-ies-dec \
ksym-64kb-lc-kyber-768-x25519-ies-dec-init \
ksym-64kb-lc-kyber-768-x25519-ies-enc \
ksym-64kb-lc-kyber-768-x25519-ies-enc-init \
ksym-64kb-lc-kyber-768-x25519-ies-enc-init-internal \
ksym-64kb-lc-kyber-768-x25519-ies-enc-internal \
ksym-64kb-lc-kyber-768-x25519-keypair \
ksym-64kb-lc-kyber-768-x25519-pk-from-sk \
ksym-64kb-lc-kyber-768-x448-dec \
ksym-64kb-lc-kyber-768-x448-dec-kdf \
ksym-64kb-lc-kyber-768-x448-enc \
ksym-64kb-lc-kyber-768-x448-enc-kdf \
ksym-64kb-lc-kyber-768-x448-enc-kdf-internal \
ksym-64kb-lc-kyber-768-x448-ies-dec \
ksym-64kb-lc-kyber-768-x448-ies-dec-init \
ksym-64kb-lc-kyber-768-x448-ies-enc \
ksym-64kb-lc-kyber-768-x448-ies-enc-init \
ksym-64kb-lc-kyber-768-x448-ies-enc-init-internal \
ksym-64kb-lc-kyber-768-x448-ies-enc-internal \
ksym-64kb-lc-kyber-768-x448-keypair \
ksym-64kb-lc-kyber-768-x448-pk-from-sk \
ksym-64kb-lc-kyber-alg-status \
ksym-64kb-lc-kyber-ct-load \
ksym-64kb-lc-kyber-ct-ptr \
ksym-64kb-lc-kyber-ct-size \
ksym-64kb-lc-kyber-ct-type \
ksym-64kb-lc-kyber-dec \
ksym-64kb-lc-kyber-dec-kdf \
ksym-64kb-lc-kyber-enc \
ksym-64kb-lc-kyber-enc-kdf \
ksym-64kb-lc-kyber-ies-dec \
ksym-64kb-lc-kyber-ies-dec-final \
ksym-64kb-lc-kyber-ies-dec-init \
ksym-64kb-lc-kyber-ies-dec-update \
ksym-64kb-lc-kyber-ies-enc \
ksym-64kb-lc-kyber-ies-enc-final \
ksym-64kb-lc-kyber-ies-enc-init \
ksym-64kb-lc-kyber-ies-enc-update \
ksym-64kb-lc-kyber-keypair \
ksym-64kb-lc-kyber-keypair-from-seed \
ksym-64kb-lc-kyber-pct \
ksym-64kb-lc-kyber-pk-from-sk \
ksym-64kb-lc-kyber-pk-load \
ksym-64kb-lc-kyber-pk-ptr \
ksym-64kb-lc-kyber-pk-size \
ksym-64kb-lc-kyber-pk-type \
ksym-64kb-lc-kyber-sk-load \
ksym-64kb-lc-kyber-sk-ptr \
ksym-64kb-lc-kyber-sk-size \
ksym-64kb-lc-kyber-sk-type \
ksym-64kb-lc-kyber-ss-load \
ksym-64kb-lc-kyber-ss-ptr \
ksym-64kb-lc-kyber-ss-size \
ksym-64kb-lc-kyber-ss-type \
ksym-64kb-lc-kyber-x25519-ct-load \
ksym-64kb-lc-kyber-x25519-ct-ptr \
ksym-64kb-lc-kyber-x25519-ct-size \
ksym-64kb-lc-kyber-x25519-ct-type \
ksym-64kb-lc-kyber-x25519-dec \
ksym-64kb-lc-kyber-x25519-dec-kdf \
ksym-64kb-lc-kyber-x25519-enc \
ksym-64kb-lc-kyber-x25519-enc-kdf \
ksym-64kb-lc-kyber-x25519-ies-dec \
ksym-64kb-lc-kyber-x25519-ies-dec-final \
ksym-64kb-lc-kyber-x25519-ies-dec-init \
ksym-64kb-lc-kyber-x25519-ies-dec-update \
ksym-64kb-lc-kyber-x25519-ies-enc \
ksym-64kb-lc-kyber-x25519-ies-enc-final \
ksym-64kb-lc-kyber-x25519-ies-enc-init \
ksym-64kb-lc-kyber-x25519-ies-enc-update \
ksym-64kb-lc-kyber-x25519-keypair \
ksym-64kb-lc-kyber-x25519-pk-from-sk \
ksym-64kb-lc-kyber-x25519-pk-load \
ksym-64kb-lc-kyber-x25519-pk-ptr \
ksym-64kb-lc-kyber-x25519-pk-size \
ksym-64kb-lc-kyber-x25519-pk-type \
ksym-64kb-lc-kyber-x25519-sk-load \
ksym-64kb-lc-kyber-x25519-sk-ptr \
ksym-64kb-lc-kyber-x25519-sk-size \
ksym-64kb-lc-kyber-x25519-sk-type \
ksym-64kb-lc-kyber-x25519-ss-load \
ksym-64kb-lc-kyber-x25519-ss-ptr \
ksym-64kb-lc-kyber-x25519-ss-size \
ksym-64kb-lc-kyber-x25519-ss-type \
ksym-64kb-lc-kyber-x448-ct-load \
ksym-64kb-lc-kyber-x448-ct-ptr \
ksym-64kb-lc-kyber-x448-ct-size \
ksym-64kb-lc-kyber-x448-ct-type \
ksym-64kb-lc-kyber-x448-dec \
ksym-64kb-lc-kyber-x448-dec-kdf \
ksym-64kb-lc-kyber-x448-enc \
ksym-64kb-lc-kyber-x448-enc-kdf \
ksym-64kb-lc-kyber-x448-ies-dec \
ksym-64kb-lc-kyber-x448-ies-dec-final \
ksym-64kb-lc-kyber-x448-ies-dec-init \
ksym-64kb-lc-kyber-x448-ies-dec-update \
ksym-64kb-lc-kyber-x448-ies-enc \
ksym-64kb-lc-kyber-x448-ies-enc-final \
ksym-64kb-lc-kyber-x448-ies-enc-init \
ksym-64kb-lc-kyber-x448-ies-enc-update \
ksym-64kb-lc-kyber-x448-keypair \
ksym-64kb-lc-kyber-x448-pk-from-sk \
ksym-64kb-lc-kyber-x448-pk-load \
ksym-64kb-lc-kyber-x448-pk-ptr \
ksym-64kb-lc-kyber-x448-pk-size \
ksym-64kb-lc-kyber-x448-pk-type \
ksym-64kb-lc-kyber-x448-sk-load \
ksym-64kb-lc-kyber-x448-sk-ptr \
ksym-64kb-lc-kyber-x448-sk-size \
ksym-64kb-lc-kyber-x448-sk-type \
ksym-64kb-lc-kyber-x448-ss-load \
ksym-64kb-lc-kyber-x448-ss-ptr \
ksym-64kb-lc-kyber-x448-ss-size \
ksym-64kb-lc-kyber-x448-ss-type \
ksym-64kb-lc-lib-alg-status \
ksym-64kb-lc-look-up-OID \
ksym-64kb-lc-memcmp-secure \
ksym-64kb-lc-memcpy-secure \
ksym-64kb-lc-mode-cbc-c \
ksym-64kb-lc-mode-ctr-c \
ksym-64kb-lc-mode-xts-c \
ksym-64kb-lc-pbkdf2 \
ksym-64kb-lc-pbkdf2-alg-status \
ksym-64kb-lc-pem-decode \
ksym-64kb-lc-pem-decode-len \
ksym-64kb-lc-pem-encode \
ksym-64kb-lc-pem-encode-len \
ksym-64kb-lc-pem-is-encoded \
ksym-64kb-lc-pem-type \
ksym-64kb-lc-pkcs7-decode \
ksym-64kb-lc-pkcs7-decode-ctx \
ksym-64kb-lc-pkcs7-decode-ctx-clear \
ksym-64kb-lc-pkcs7-decode-ctx-init \
ksym-64kb-lc-pkcs7-decode-ctx-set-aa-content-type \
ksym-64kb-lc-pkcs7-decode-ctx-set-pkcs7 \
ksym-64kb-lc-pkcs7-encode \
ksym-64kb-lc-pkcs7-encode-ctx \
ksym-64kb-lc-pkcs7-encode-ctx-clear \
ksym-64kb-lc-pkcs7-encode-ctx-init \
ksym-64kb-lc-pkcs7-encode-ctx-set-pkcs7 \
ksym-64kb-lc-pkcs7-encode-ctx-set-signer-data-type \
ksym-64kb-lc-pkcs7-get-content-data \
ksym-64kb-lc-pkcs7-get-digest \
ksym-64kb-lc-pkcs7-message-clear \
ksym-64kb-lc-pkcs7-set-certificate \
ksym-64kb-lc-pkcs7-set-data \
ksym-64kb-lc-pkcs7-set-data-with-type \
ksym-64kb-lc-pkcs7-set-signer \
ksym-64kb-lc-pkcs7-supply-detached-data \
ksym-64kb-lc-pkcs7-trust-store-add \
ksym-64kb-lc-pkcs7-trust-store-clear \
ksym-64kb-lc-pkcs7-verify \
ksym-64kb-lc-pkcs8-decode \
ksym-64kb-lc-pkcs8-encode \
ksym-64kb-lc-pkcs8-get-signature-size-from-sk \
ksym-64kb-lc-pkcs8-key-type \
ksym-64kb-lc-pkcs8-message-clear \
ksym-64kb-lc-pkcs8-set-privkey \
ksym-64kb-lc-pkcs8-signature-gen \
ksym-64kb-lc-poly1305-final \
ksym-64kb-lc-poly1305-init \
ksym-64kb-lc-poly1305-update \
ksym-64kb-lc-rerun-one-selftest \
ksym-64kb-lc-rerun-selftests \
ksym-64kb-lc-rng-alg-status \
ksym-64kb-lc-rng-check \
ksym-64kb-lc-rng-ctx-alg-status \
ksym-64kb-lc-rng-generate \
ksym-64kb-lc-rng-seed \
ksym-64kb-lc-rng-set-seeded \
ksym-64kb-lc-rng-zero \
ksym-64kb-lc-rng-zero-free \
ksym-64kb-lc-seeded-rng \
ksym-64kb-lc-sh-alloc \
ksym-64kb-lc-sha256 \
ksym-64kb-lc-sha256-arm-ce \
ksym-64kb-lc-sha256-arm-neon \
ksym-64kb-lc-sha256-avx2 \
ksym-64kb-lc-sha256-c \
ksym-64kb-lc-sha256-riscv \
ksym-64kb-lc-sha256-riscv-zbb \
ksym-64kb-lc-sha256-shani \
ksym-64kb-lc-sha3-224 \
ksym-64kb-lc-sha3-224-arm-asm \
ksym-64kb-lc-sha3-224-arm-ce \
ksym-64kb-lc-sha3-224-arm-neon \
ksym-64kb-lc-sha3-224-avx2 \
ksym-64kb-lc-sha3-224-avx512 \
ksym-64kb-lc-sha3-224-c \
ksym-64kb-lc-sha3-224-riscv-asm \
ksym-64kb-lc-sha3-224-riscv-asm-zbb \
ksym-64kb-lc-sha3-256 \
ksym-64kb-lc-sha3-256-arm-asm \
ksym-64kb-lc-sha3-256-arm-ce \
ksym-64kb-lc-sha3-256-arm-neon \
ksym-64kb-lc-sha3-256-avx2 \
ksym-64kb-lc-sha3-256-avx512 \
ksym-64kb-lc-sha3-256-c \
ksym-64kb-lc-sha3-256-riscv-asm \
ksym-64kb-lc-sha3-256-riscv-asm-zbb \
ksym-64kb-lc-sha3-384 \
ksym-64kb-lc-sha3-384-arm-asm \
ksym-64kb-lc-sha3-384-arm-ce \
ksym-64kb-lc-sha3-384-arm-neon \
ksym-64kb-lc-sha3-384-avx2 \
ksym-64kb-lc-sha3-384-avx512 \
ksym-64kb-lc-sha3-384-c \
ksym-64kb-lc-sha3-384-riscv-asm \
ksym-64kb-lc-sha3-384-riscv-asm-zbb \
ksym-64kb-lc-sha3-512 \
ksym-64kb-lc-sha3-512-arm-asm \
ksym-64kb-lc-sha3-512-arm-ce \
ksym-64kb-lc-sha3-512-arm-neon \
ksym-64kb-lc-sha3-512-avx2 \
ksym-64kb-lc-sha3-512-avx512 \
ksym-64kb-lc-sha3-512-c \
ksym-64kb-lc-sha3-512-riscv-asm \
ksym-64kb-lc-sha3-512-riscv-asm-zbb \
ksym-64kb-lc-sha384 \
ksym-64kb-lc-sha384-arm-ce \
ksym-64kb-lc-sha384-arm-neon \
ksym-64kb-lc-sha384-avx2 \
ksym-64kb-lc-sha384-c \
ksym-64kb-lc-sha384-riscv \
ksym-64kb-lc-sha384-riscv-zbb \
ksym-64kb-lc-sha384-shani \
ksym-64kb-lc-sha512 \
ksym-64kb-lc-sha512-arm-ce \
ksym-64kb-lc-sha512-arm-neon \
ksym-64kb-lc-sha512-avx2 \
ksym-64kb-lc-sha512-c \
ksym-64kb-lc-sha512-riscv \
ksym-64kb-lc-sha512-riscv-zbb \
ksym-64kb-lc-sha512-shani \
ksym-64kb-lc-shake128 \
ksym-64kb-lc-shake128-arm-asm \
ksym-64kb-lc-shake128-arm-ce \
ksym-64kb-lc-shake128-arm-neon \
ksym-64kb-lc-shake128-avx2 \
ksym-64kb-lc-shake128-avx512 \
ksym-64kb-lc-shake128-c \
ksym-64kb-lc-shake128-riscv-asm \
ksym-64kb-lc-shake128-riscv-asm-zbb \
ksym-64kb-lc-shake256 \
ksym-64kb-lc-shake256-arm-asm \
ksym-64kb-lc-shake256-arm-ce \
ksym-64kb-lc-shake256-arm-neon \
ksym-64kb-lc-shake256-avx2 \
ksym-64kb-lc-shake256-avx512 \
ksym-64kb-lc-shake256-c \
ksym-64kb-lc-shake256-riscv-asm \
ksym-64kb-lc-shake256-riscv-asm-zbb \
ksym-64kb-lc-shake512 \
ksym-64kb-lc-shake512-arm-asm \
ksym-64kb-lc-shake512-arm-ce \
ksym-64kb-lc-shake512-arm-neon \
ksym-64kb-lc-shake512-avx2 \
ksym-64kb-lc-shake512-avx512 \
ksym-64kb-lc-shake512-c \
ksym-64kb-lc-shake512-riscv-asm \
ksym-64kb-lc-shake512-riscv-asm-zbb \
ksym-64kb-lc-sphincs-alg-status \
ksym-64kb-lc-sphincs-ctx-alloc \
ksym-64kb-lc-sphincs-ctx-hash \
ksym-64kb-lc-sphincs-ctx-internal \
ksym-64kb-lc-sphincs-ctx-userctx \
ksym-64kb-lc-sphincs-ctx-zero \
ksym-64kb-lc-sphincs-ctx-zero-free \
ksym-64kb-lc-sphincs-keypair \
ksym-64kb-lc-sphincs-keypair-from-seed \
ksym-64kb-lc-sphincs-pct \
ksym-64kb-lc-sphincs-pk-from-sk \
ksym-64kb-lc-sphincs-pk-load \
ksym-64kb-lc-sphincs-pk-ptr \
ksym-64kb-lc-sphincs-pk-set-keytype-fast \
ksym-64kb-lc-sphincs-pk-set-keytype-small \
ksym-64kb-lc-sphincs-pk-size \
ksym-64kb-lc-sphincs-pk-type \
ksym-64kb-lc-sphincs-shake-128f-ctx-alloc \
ksym-64kb-lc-sphincs-shake-128f-ctx-zero-free \
ksym-64kb-lc-sphincs-shake-128f-keypair \
ksym-64kb-lc-sphincs-shake-128f-keypair-from-seed \
ksym-64kb-lc-sphincs-shake-128f-pk-from-sk \
ksym-64kb-lc-sphincs-shake-128f-sign \
ksym-64kb-lc-sphincs-shake-128f-sign-ctx \
ksym-64kb-lc-sphincs-shake-128f-sign-final \
ksym-64kb-lc-sphincs-shake-128f-sign-init \
ksym-64kb-lc-sphincs-shake-128f-sign-update \
ksym-64kb-lc-sphincs-shake-128f-verify \
ksym-64kb-lc-sphincs-shake-128f-verify-ctx \
ksym-64kb-lc-sphincs-shake-128f-verify-final \
ksym-64kb-lc-sphincs-shake-128f-verify-init \
ksym-64kb-lc-sphincs-shake-128f-verify-update \
ksym-64kb-lc-sphincs-shake-128s-ctx-alloc \
ksym-64kb-lc-sphincs-shake-128s-ctx-zero-free \
ksym-64kb-lc-sphincs-shake-128s-keypair \
ksym-64kb-lc-sphincs-shake-128s-keypair-from-seed \
ksym-64kb-lc-sphincs-shake-128s-pk-from-sk \
ksym-64kb-lc-sphincs-shake-128s-sign \
ksym-64kb-lc-sphincs-shake-128s-sign-ctx \
ksym-64kb-lc-sphincs-shake-128s-sign-final \
ksym-64kb-lc-sphincs-shake-128s-sign-init \
ksym-64kb-lc-sphincs-shake-128s-sign-update \
ksym-64kb-lc-sphincs-shake-128s-verify \
ksym-64kb-lc-sphincs-shake-128s-verify-ctx \
ksym-64kb-lc-sphincs-shake-128s-verify-final \
ksym-64kb-lc-sphincs-shake-128s-verify-init \
ksym-64kb-lc-sphincs-shake-128s-verify-update \
ksym-64kb-lc-sphincs-shake-192f-ctx-alloc \
ksym-64kb-lc-sphincs-shake-192f-ctx-zero-free \
ksym-64kb-lc-sphincs-shake-192f-keypair \
ksym-64kb-lc-sphincs-shake-192f-keypair-from-seed \
ksym-64kb-lc-sphincs-shake-192f-pk-from-sk \
ksym-64kb-lc-sphincs-shake-192f-sign \
ksym-64kb-lc-sphincs-shake-192f-sign-ctx \
ksym-64kb-lc-sphincs-shake-192f-sign-final \
ksym-64kb-lc-sphincs-shake-192f-sign-init \
ksym-64kb-lc-sphincs-shake-192f-sign-update \
ksym-64kb-lc-sphincs-shake-192f-verify \
ksym-64kb-lc-sphincs-shake-192f-verify-ctx \
ksym-64kb-lc-sphincs-shake-192f-verify-final \
ksym-64kb-lc-sphincs-shake-192f-verify-init \
ksym-64kb-lc-sphincs-shake-192f-verify-update \
ksym-64kb-lc-sphincs-shake-192s-ctx-alloc \
ksym-64kb-lc-sphincs-shake-192s-ctx-zero-free \
ksym-64kb-lc-sphincs-shake-192s-keypair \
ksym-64kb-lc-sphincs-shake-192s-keypair-from-seed \
ksym-64kb-lc-sphincs-shake-192s-pk-from-sk \
ksym-64kb-lc-sphincs-shake-192s-sign \
ksym-64kb-lc-sphincs-shake-192s-sign-ctx \
ksym-64kb-lc-sphincs-shake-192s-sign-final \
ksym-64kb-lc-sphincs-shake-192s-sign-init \
ksym-64kb-lc-sphincs-shake-192s-sign-update \
ksym-64kb-lc-sphincs-shake-192s-verify \
ksym-64kb-lc-sphincs-shake-192s-verify-ctx \
ksym-64kb-lc-sphincs-shake-192s-verify-final \
ksym-64kb-lc-sphincs-shake-192s-verify-init \
ksym-64kb-lc-sphincs-shake-192s-verify-update \
ksym-64kb-lc-sphincs-shake-256f-ctx-alloc \
ksym-64kb-lc-sphincs-shake-256f-ctx-zero-free \
ksym-64kb-lc-sphincs-shake-256f-keypair \
ksym-64kb-lc-sphincs-shake-256f-keypair-from-seed \
ksym-64kb-lc-sphincs-shake-256f-pk-from-sk \
ksym-64kb-lc-sphincs-shake-256f-sign \
ksym-64kb-lc-sphincs-shake-256f-sign-ctx \
ksym-64kb-lc-sphincs-shake-256f-sign-final \
ksym-64kb-lc-sphincs-shake-256f-sign-init \
ksym-64kb-lc-sphincs-shake-256f-sign-update \
ksym-64kb-lc-sphincs-shake-256f-verify \
ksym-64kb-lc-sphincs-shake-256f-verify-ctx \
ksym-64kb-lc-sphincs-shake-256f-verify-final \
ksym-64kb-lc-sphincs-shake-256f-verify-init \
ksym-64kb-lc-sphincs-shake-256f-verify-update \
ksym-64kb-lc-sphincs-shake-256s-ctx-alloc \
ksym-64kb-lc-sphincs-shake-256s-ctx-zero-free \
ksym-64kb-lc-sphincs-shake-256s-keypair \
ksym-64kb-lc-sphincs-shake-256s-keypair-from-seed \
ksym-64kb-lc-sphincs-shake-256s-pk-from-sk \
ksym-64kb-lc-sphincs-shake-256s-sign \
ksym-64kb-lc-sphincs-shake-256s-sign-ctx \
ksym-64kb-lc-sphincs-shake-256s-sign-final \
ksym-64kb-lc-sphincs-shake-256s-sign-init \
ksym-64kb-lc-sphincs-shake-256s-sign-update \
ksym-64kb-lc-sphincs-shake-256s-verify \
ksym-64kb-lc-sphincs-shake-256s-verify-ctx \
ksym-64kb-lc-sphincs-shake-256s-verify-final \
ksym-64kb-lc-sphincs-shake-256s-verify-init \
ksym-64kb-lc-sphincs-shake-256s-verify-update \
ksym-64kb-lc-sphincs-sig-load \
ksym-64kb-lc-sphincs-sig-ptr \
ksym-64kb-lc-sphincs-sig-size \
ksym-64kb-lc-sphincs-sig-type \
ksym-64kb-lc-sphincs-sign \
ksym-64kb-lc-sphincs-sign-ctx \
ksym-64kb-lc-sphincs-sign-final \
ksym-64kb-lc-sphincs-sign-init \
ksym-64kb-lc-sphincs-sign-update \
ksym-64kb-lc-sphincs-sk-load \
ksym-64kb-lc-sphincs-sk-ptr \
ksym-64kb-lc-sphincs-sk-set-keytype-fast \
ksym-64kb-lc-sphincs-sk-set-keytype-small \
ksym-64kb-lc-sphincs-sk-size \
ksym-64kb-lc-sphincs-sk-type \
ksym-64kb-lc-sphincs-verify \
ksym-64kb-lc-sphincs-verify-ctx \
ksym-64kb-lc-sphincs-verify-final \
ksym-64kb-lc-sphincs-verify-init \
ksym-64kb-lc-sphincs-verify-update \
ksym-64kb-lc-sponge \
ksym-64kb-lc-sponge-add-bytes \
ksym-64kb-lc-sponge-extract-bytes \
ksym-64kb-lc-sponge-newstate \
ksym-64kb-lc-status \
ksym-64kb-lc-status-get-result \
ksym-64kb-lc-sym-alg-status \
ksym-64kb-lc-sym-alloc \
ksym-64kb-lc-sym-ctx-alg-status \
ksym-64kb-lc-sym-decrypt \
ksym-64kb-lc-sym-decrypt-iv \
ksym-64kb-lc-sym-encrypt \
ksym-64kb-lc-sym-encrypt-iv \
ksym-64kb-lc-sym-getiv \
ksym-64kb-lc-sym-init \
ksym-64kb-lc-sym-init-iv \
ksym-64kb-lc-sym-setiv \
ksym-64kb-lc-sym-setkey \
ksym-64kb-lc-sym-zero \
ksym-64kb-lc-sym-zero-free \
ksym-64kb-lc-symhmac-aead \
ksym-64kb-lc-symkmac-aead \
ksym-64kb-lc-uuid-bin2hex \
ksym-64kb-lc-uuid-hex2bin \
ksym-64kb-lc-uuid-random \
ksym-64kb-lc-uuid-time \
ksym-64kb-lc-x25519-alg-status \
ksym-64kb-lc-x25519-keypair \
ksym-64kb-lc-x25519-pk-load \
ksym-64kb-lc-x25519-pk-ptr \
ksym-64kb-lc-x25519-sk-load \
ksym-64kb-lc-x25519-sk-ptr \
ksym-64kb-lc-x25519-ss \
ksym-64kb-lc-x25519-ss-load \
ksym-64kb-lc-x25519-ss-ptr \
ksym-64kb-lc-x448-alg-status \
ksym-64kb-lc-x448-keypair \
ksym-64kb-lc-x448-pk-load \
ksym-64kb-lc-x448-pk-ptr \
ksym-64kb-lc-x448-sk-load \
ksym-64kb-lc-x448-sk-ptr \
ksym-64kb-lc-x448-ss \
ksym-64kb-lc-x448-ss-load \
ksym-64kb-lc-x448-ss-ptr \
ksym-64kb-lc-x509-cert-check-issuer-ca \
ksym-64kb-lc-x509-cert-clear \
ksym-64kb-lc-x509-cert-decode \
ksym-64kb-lc-x509-cert-encode \
ksym-64kb-lc-x509-cert-get-akid \
ksym-64kb-lc-x509-cert-get-eku \
ksym-64kb-lc-x509-cert-get-eku-val \
ksym-64kb-lc-x509-cert-get-issuer-c \
ksym-64kb-lc-x509-cert-get-issuer-cn \
ksym-64kb-lc-x509-cert-get-issuer-email \
ksym-64kb-lc-x509-cert-get-issuer-o \
ksym-64kb-lc-x509-cert-get-issuer-ou \
ksym-64kb-lc-x509-cert-get-issuer-st \
ksym-64kb-lc-x509-cert-get-keyusage \
ksym-64kb-lc-x509-cert-get-keyusage-val \
ksym-64kb-lc-x509-cert-get-pubkey \
ksym-64kb-lc-x509-cert-get-san-dns \
ksym-64kb-lc-x509-cert-get-san-ip \
ksym-64kb-lc-x509-cert-get-serial \
ksym-64kb-lc-x509-cert-get-skid \
ksym-64kb-lc-x509-cert-get-subject-c \
ksym-64kb-lc-x509-cert-get-subject-cn \
ksym-64kb-lc-x509-cert-get-subject-email \
ksym-64kb-lc-x509-cert-get-subject-o \
ksym-64kb-lc-x509-cert-get-subject-ou \
ksym-64kb-lc-x509-cert-get-subject-st \
ksym-64kb-lc-x509-cert-get-valid-from \
ksym-64kb-lc-x509-cert-get-valid-to \
ksym-64kb-lc-x509-cert-load-pk-dilithium-ed25519 \
ksym-64kb-lc-x509-cert-load-pk-dilithium-ed448 \
ksym-64kb-lc-x509-cert-set-akid \
ksym-64kb-lc-x509-cert-set-ca \
ksym-64kb-lc-x509-cert-set-ca-pathlen \
ksym-64kb-lc-x509-cert-set-eku \
ksym-64kb-lc-x509-cert-set-eku-val \
ksym-64kb-lc-x509-cert-set-issuer-c \
ksym-64kb-lc-x509-cert-set-issuer-cn \
ksym-64kb-lc-x509-cert-set-issuer-email \
ksym-64kb-lc-x509-cert-set-issuer-o \
ksym-64kb-lc-x509-cert-set-issuer-ou \
ksym-64kb-lc-x509-cert-set-issuer-st \
ksym-64kb-lc-x509-cert-set-keyusage \
ksym-64kb-lc-x509-cert-set-keyusage-val \
ksym-64kb-lc-x509-cert-set-san-dns \
ksym-64kb-lc-x509-cert-set-san-email \
ksym-64kb-lc-x509-cert-set-san-ip \
ksym-64kb-lc-x509-cert-set-serial \
ksym-64kb-lc-x509-cert-set-signer \
ksym-64kb-lc-x509-cert-set-skid \
ksym-64kb-lc-x509-cert-set-subject-c \
ksym-64kb-lc-x509-cert-set-subject-cn \
ksym-64kb-lc-x509-cert-set-subject-email \
ksym-64kb-lc-x509-cert-set-subject-o \
ksym-64kb-lc-x509-cert-set-subject-ou \
ksym-64kb-lc-x509-cert-set-subject-st \
ksym-64kb-lc-x509-cert-set-valid-from \
ksym-64kb-lc-x509-cert-set-valid-to \
ksym-64kb-lc-x509-cert-verify \
ksym-64kb-lc-x509-csr-decode \
ksym-64kb-lc-x509-csr-encode \
ksym-64kb-lc-x509-dec-san-ip \
ksym-64kb-lc-x509-enc-san-ip \
ksym-64kb-lc-x509-get-signature-size-from-cert \
ksym-64kb-lc-x509-get-signature-size-from-sk \
ksym-64kb-lc-x509-hash-to-name \
ksym-64kb-lc-x509-hash-to-oid \
ksym-64kb-lc-x509-keypair-data-alloc \
ksym-64kb-lc-x509-keypair-data-zero-free \
ksym-64kb-lc-x509-keypair-gen \
ksym-64kb-lc-x509-keypair-load \
ksym-64kb-lc-x509-keypair-pk \
ksym-64kb-lc-x509-keys-alloc \
ksym-64kb-lc-x509-keys-dilithium-alloc \
ksym-64kb-lc-x509-keys-dilithium-ed25519-alloc \
ksym-64kb-lc-x509-keys-dilithium-ed448-alloc \
ksym-64kb-lc-x509-keys-sphincs-alloc \
ksym-64kb-lc-x509-keys-zero-free \
ksym-64kb-lc-x509-name-to-eku \
ksym-64kb-lc-x509-name-to-hash \
ksym-64kb-lc-x509-name-to-keyusage \
ksym-64kb-lc-x509-oid-to-hash \
ksym-64kb-lc-x509-pk-decode \
ksym-64kb-lc-x509-pkey-name-to-algorithm \
ksym-64kb-lc-x509-policy-can-validate-crls \
ksym-64kb-lc-x509-policy-cert-subject-match \
ksym-64kb-lc-x509-policy-cert-valid \
ksym-64kb-lc-x509-policy-is-ca \
ksym-64kb-lc-x509-policy-is-root-ca \
ksym-64kb-lc-x509-policy-is-selfsigned \
ksym-64kb-lc-x509-policy-match-akid \
ksym-64kb-lc-x509-policy-match-extended-key-usage \
ksym-64kb-lc-x509-policy-match-key-usage \
ksym-64kb-lc-x509-policy-match-skid \
ksym-64kb-lc-x509-policy-time-valid \
ksym-64kb-lc-x509-policy-time-valid-now \
ksym-64kb-lc-x509-policy-verify-cert \
ksym-64kb-lc-x509-privkeys-alloc \
ksym-64kb-lc-x509-privkeys-dilithium-alloc \
ksym-64kb-lc-x509-privkeys-dilithium-ed25519-alloc \
ksym-64kb-lc-x509-privkeys-dilithium-ed448-alloc \
ksym-64kb-lc-x509-privkeys-sphincs-alloc \
ksym-64kb-lc-x509-sig-type-to-hash \
ksym-64kb-lc-x509-sig-type-to-name \
ksym-64kb-lc-x509-signature-gen \
ksym-64kb-lc-x509-signature-verify \
ksym-64kb-lc-x509-sk-decode \
ksym-64kb-lc-x509-sk-encode \
ksym-64kb-lc-x509-sufficient-size \
ksym-64kb-lc-xdrbg128-drng \
ksym-64kb-lc-xdrbg128-drng-alloc \
ksym-64kb-lc-xdrbg256-drng \
ksym-64kb-lc-xdrbg256-drng-alloc \
ksym-64kb-lc-xdrbg512-drng \
ksym-64kb-lc-xdrbg512-drng-alloc \
ksym-64kb-lc-xof \
leancrypto-kmp \
leancrypto-kmp-64kb \
leancrypto-kmp-64kb-k7.2.4-1 \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
grep \
ksym-64kb---crypto-memneq \
ksym-64kb---fortify-panic \
ksym-64kb---free-pages \
ksym-64kb---init-swait-queue-head \
ksym-64kb---kmalloc-cache-noprof \
ksym-64kb---kmalloc-noprof \
ksym-64kb---stack-chk-fail \
ksym-64kb---warn-printk \
ksym-64kb---write-overflow-field \
ksym-64kb--printk \
ksym-64kb-alloc-pages-noprof \
ksym-64kb-alt-cb-patch-nops \
ksym-64kb-bin2hex \
ksym-64kb-complete \
ksym-64kb-crypto-aead-decrypt \
ksym-64kb-crypto-aead-encrypt \
ksym-64kb-crypto-aead-setauthsize \
ksym-64kb-crypto-aead-setkey \
ksym-64kb-crypto-alloc-aead \
ksym-64kb-crypto-alloc-kpp \
ksym-64kb-crypto-alloc-rng \
ksym-64kb-crypto-alloc-shash \
ksym-64kb-crypto-alloc-sig \
ksym-64kb-crypto-alloc-skcipher \
ksym-64kb-crypto-destroy-tfm \
ksym-64kb-crypto-register-aeads \
ksym-64kb-crypto-register-alg \
ksym-64kb-crypto-register-kpp \
ksym-64kb-crypto-register-rngs \
ksym-64kb-crypto-register-shashes \
ksym-64kb-crypto-register-sig \
ksym-64kb-crypto-register-skciphers \
ksym-64kb-crypto-rng-reset \
ksym-64kb-crypto-shash-finup \
ksym-64kb-crypto-shash-init \
ksym-64kb-crypto-shash-setkey \
ksym-64kb-crypto-skcipher-decrypt \
ksym-64kb-crypto-skcipher-encrypt \
ksym-64kb-crypto-skcipher-setkey \
ksym-64kb-crypto-unregister-aeads \
ksym-64kb-crypto-unregister-alg \
ksym-64kb-crypto-unregister-kpp \
ksym-64kb-crypto-unregister-rngs \
ksym-64kb-crypto-unregister-shashes \
ksym-64kb-crypto-unregister-sig \
ksym-64kb-crypto-unregister-skciphers \
ksym-64kb-get-random-bytes \
ksym-64kb-jiffies \
ksym-64kb-kernel-neon-begin \
ksym-64kb-kernel-neon-end \
ksym-64kb-kfree \
ksym-64kb-kfree-sensitive \
ksym-64kb-kmalloc-caches \
ksym-64kb-ktime-get-with-offset \
ksym-64kb-memcmp \
ksym-64kb-memcpy \
ksym-64kb-memcpy-from-sglist \
ksym-64kb-memcpy-to-sglist \
ksym-64kb-memset \
ksym-64kb-memstart-addr \
ksym-64kb-module-layout \
ksym-64kb-mutex-init-generic \
ksym-64kb-mutex-lock \
ksym-64kb-mutex-unlock \
ksym-64kb-param-ops-uint \
ksym-64kb-pfn-is-map-memory \
ksym-64kb-proc-create-single-data \
ksym-64kb-random-kmalloc-seed \
ksym-64kb-remove-proc-subtree \
ksym-64kb-scatterwalk-ffwd \
ksym-64kb-seq-write \
ksym-64kb-sg-copy-from-buffer \
ksym-64kb-sg-copy-to-buffer \
ksym-64kb-sg-init-one \
ksym-64kb-sg-init-table \
ksym-64kb-sg-nents-for-len \
ksym-64kb-sg-pcopy-from-buffer \
ksym-64kb-skcipher-walk-aead-decrypt \
ksym-64kb-skcipher-walk-aead-encrypt \
ksym-64kb-skcipher-walk-done \
ksym-64kb-skcipher-walk-virt \
ksym-64kb-snprintf \
ksym-64kb-strlen \
ksym-64kb-strnlen \
ksym-64kb-wait-for-completion \
suse-kernel-rpm-scriptlets"

inherit rpm
