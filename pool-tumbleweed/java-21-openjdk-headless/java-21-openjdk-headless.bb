SUMMARY = "OpenJDK 21 Runtime Environment"
DESCRIPTION = "The OpenJDK 21 runtime environment without audio and video support."
LICENSE = "Apache-1.1 & Apache-2.0 & GPL-1.0-or-later & GPL-2.0-only & GPL-2.0-only-with-Classpath-exception-2.0 & LGPL-2.0-only & MPL-1.0 & MPL-1.1 & LicenseRef-SUSE-Public-Domain & W3C"

PV = "21.0.12.1"

RPM_NAME = "java-21-openjdk-headless-21.0.12.1-1.1.aarch64.rpm"
RPM_HASH = "11ebc7a68a2a33a8a2d7674d1bc01ae4cb278eccd9fbc5114726d711fe2d8ace7e771206979c4b40fff47c57e27ad2387966cb741b8badf9b151c98fa1859674"

RPROVIDES:${PN} += "config-java-21-openjdk-headless \
jaas \
java-21-headless \
java-21-openjdk-headless \
java-headless \
java-openjdk-headless \
java-sasl \
jce \
jdbc-stdext \
jndi \
jndi-cos \
jndi-dns \
jndi-ldap \
jndi-rmi \
jre-21-headless \
jre-21-openjdk-headless \
jre-headless \
jre-openjdk-headless \
jsse \
libawt-headless.so \
libawt.so \
libdt-socket.so \
libextnet.so \
libfontmanager.so \
libinstrument.so \
libj2gss.so \
libj2pcsc.so \
libj2pkcs11.so \
libjaas.so \
libjava.so \
libjavajpeg.so \
libjdwp.so \
libjimage.so \
libjli.so \
libjsig.so \
libjsound.so \
libjvm.so \
liblcms.so \
lible.so \
libmanagement-agent.so \
libmanagement-ext.so \
libmanagement.so \
libmlib-image.so \
libnet.so \
libnio.so \
libprefs.so \
librmi.so \
libsctp.so \
libsyslookup.so \
libsystemconf.so \
libverify.so \
libzip.so \
timezone-java \
tzdata-java"

RDEPENDS:${PN} += "/usr/bin/sh \
alts \
file \
java-ca-certificates \
jpackage-utils \
ld-linux-aarch64.so.1 \
libasound.so.2 \
libc.so.6 \
libfreetype.so.6 \
libgcc-s.so.1 \
libjpeg.so.8 \
liblcms2.so.2 \
libm.so.6 \
libnss3.so \
libpcsclite.so.1 \
libstdc++.so.6 \
libz.so.1 \
mozilla-nss \
rtld-GNU-HASH"

inherit rpm
