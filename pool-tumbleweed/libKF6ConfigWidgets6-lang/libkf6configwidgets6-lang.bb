SUMMARY = "Translations for package libKF6ConfigWidgets6"
DESCRIPTION = "Provides translations for the 'libKF6ConfigWidgets6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6ConfigWidgets6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "ddb2a6f469bb6df24044fbe779fb3934d00d220585064615605d13835dc5b7c343bcc91a4f1dd255f8247547f9bb9ac0e3a990c82d146f5664b0b9baaace0ebf"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6ConfigWidgets6-lang \
libKF6ConfigWidgets6-lang-all \
locale-libKF6ConfigWidgets6-af \
locale-libKF6ConfigWidgets6-ar \
locale-libKF6ConfigWidgets6-as \
locale-libKF6ConfigWidgets6-ast \
locale-libKF6ConfigWidgets6-az \
locale-libKF6ConfigWidgets6-be \
locale-libKF6ConfigWidgets6-be@latin \
locale-libKF6ConfigWidgets6-bg \
locale-libKF6ConfigWidgets6-bn \
locale-libKF6ConfigWidgets6-bn-IN \
locale-libKF6ConfigWidgets6-br \
locale-libKF6ConfigWidgets6-bs \
locale-libKF6ConfigWidgets6-ca \
locale-libKF6ConfigWidgets6-ca@valencia \
locale-libKF6ConfigWidgets6-cs \
locale-libKF6ConfigWidgets6-cy \
locale-libKF6ConfigWidgets6-da \
locale-libKF6ConfigWidgets6-de \
locale-libKF6ConfigWidgets6-el \
locale-libKF6ConfigWidgets6-en-GB \
locale-libKF6ConfigWidgets6-eo \
locale-libKF6ConfigWidgets6-es \
locale-libKF6ConfigWidgets6-et \
locale-libKF6ConfigWidgets6-eu \
locale-libKF6ConfigWidgets6-fa \
locale-libKF6ConfigWidgets6-fi \
locale-libKF6ConfigWidgets6-fr \
locale-libKF6ConfigWidgets6-ga \
locale-libKF6ConfigWidgets6-gd \
locale-libKF6ConfigWidgets6-gl \
locale-libKF6ConfigWidgets6-gu \
locale-libKF6ConfigWidgets6-he \
locale-libKF6ConfigWidgets6-hi \
locale-libKF6ConfigWidgets6-hr \
locale-libKF6ConfigWidgets6-hu \
locale-libKF6ConfigWidgets6-ia \
locale-libKF6ConfigWidgets6-id \
locale-libKF6ConfigWidgets6-is \
locale-libKF6ConfigWidgets6-it \
locale-libKF6ConfigWidgets6-ja \
locale-libKF6ConfigWidgets6-ka \
locale-libKF6ConfigWidgets6-kk \
locale-libKF6ConfigWidgets6-km \
locale-libKF6ConfigWidgets6-kn \
locale-libKF6ConfigWidgets6-ko \
locale-libKF6ConfigWidgets6-lt \
locale-libKF6ConfigWidgets6-lv \
locale-libKF6ConfigWidgets6-mai \
locale-libKF6ConfigWidgets6-mk \
locale-libKF6ConfigWidgets6-ml \
locale-libKF6ConfigWidgets6-mr \
locale-libKF6ConfigWidgets6-ms \
locale-libKF6ConfigWidgets6-nb \
locale-libKF6ConfigWidgets6-nds \
locale-libKF6ConfigWidgets6-ne \
locale-libKF6ConfigWidgets6-nl \
locale-libKF6ConfigWidgets6-nn \
locale-libKF6ConfigWidgets6-oc \
locale-libKF6ConfigWidgets6-or \
locale-libKF6ConfigWidgets6-pa \
locale-libKF6ConfigWidgets6-pl \
locale-libKF6ConfigWidgets6-pt \
locale-libKF6ConfigWidgets6-pt-BR \
locale-libKF6ConfigWidgets6-ro \
locale-libKF6ConfigWidgets6-ru \
locale-libKF6ConfigWidgets6-si \
locale-libKF6ConfigWidgets6-sk \
locale-libKF6ConfigWidgets6-sl \
locale-libKF6ConfigWidgets6-sq \
locale-libKF6ConfigWidgets6-sr \
locale-libKF6ConfigWidgets6-sr@ijekavian \
locale-libKF6ConfigWidgets6-sr@ijekavianlatin \
locale-libKF6ConfigWidgets6-sr@latin \
locale-libKF6ConfigWidgets6-sv \
locale-libKF6ConfigWidgets6-ta \
locale-libKF6ConfigWidgets6-te \
locale-libKF6ConfigWidgets6-th \
locale-libKF6ConfigWidgets6-tr \
locale-libKF6ConfigWidgets6-ug \
locale-libKF6ConfigWidgets6-uk \
locale-libKF6ConfigWidgets6-vi \
locale-libKF6ConfigWidgets6-wa \
locale-libKF6ConfigWidgets6-zh-CN \
locale-libKF6ConfigWidgets6-zh-HK \
locale-libKF6ConfigWidgets6-zh-TW"

RDEPENDS:${PN} += "libKF6ConfigWidgets6"

inherit rpm
