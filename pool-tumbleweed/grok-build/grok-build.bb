SUMMARY = "Terminal AI coding agent by xAI"
DESCRIPTION = "Grok is xAI's terminal-based AI coding agent: an interactive TUI that pairs \
with the Grok models to read, edit and reason about code in your working \
directory, run shell commands and drive common developer workflows from the \
command line. \
 \
This package ships the agent as the /usr/bin/grok command."
LICENSE = "Apache-2.0 & MPL-2.0 & GPL-2.0-with-Linking-exception & LGPL-2.1-or-later"

PV = "0+git20260828.bc7f02e"

RPM_NAME = "grok-build-0+git20260828.bc7f02e-1.1.aarch64.rpm"
RPM_HASH = "ab0744ddea275e1b726f7212bb96d9d09d9f1a594e0b60ab1f847470a4783be7876b20d14215a2c69c65cf5191f5653131fe225497938b012ad129735bf62948"

RPROVIDES:${PN} += "bundled-rust-crate-addr2line \
bundled-rust-crate-adler2 \
bundled-rust-crate-aes \
bundled-rust-crate-agent-client-protocol \
bundled-rust-crate-agent-client-protocol-schema \
bundled-rust-crate-ahash \
bundled-rust-crate-aho-corasick \
bundled-rust-crate-aligned-vec \
bundled-rust-crate-alloc-no-stdlib \
bundled-rust-crate-alloc-stdlib \
bundled-rust-crate-allocator-api2 \
bundled-rust-crate-ansi-to-tui \
bundled-rust-crate-anstream \
bundled-rust-crate-anstyle \
bundled-rust-crate-anstyle-lossy \
bundled-rust-crate-anstyle-parse \
bundled-rust-crate-anstyle-query \
bundled-rust-crate-anstyle-syntect \
bundled-rust-crate-anyhow \
bundled-rust-crate-arboard \
bundled-rust-crate-arc-swap \
bundled-rust-crate-arrayref \
bundled-rust-crate-arrayvec \
bundled-rust-crate-ashpd \
bundled-rust-crate-async-broadcast \
bundled-rust-crate-async-channel \
bundled-rust-crate-async-compression \
bundled-rust-crate-async-executor \
bundled-rust-crate-async-fs \
bundled-rust-crate-async-global-executor \
bundled-rust-crate-async-io \
bundled-rust-crate-async-lock \
bundled-rust-crate-async-lsp \
bundled-rust-crate-async-net \
bundled-rust-crate-async-openai \
bundled-rust-crate-async-openai-macros \
bundled-rust-crate-async-process \
bundled-rust-crate-async-recursion \
bundled-rust-crate-async-signal \
bundled-rust-crate-async-std \
bundled-rust-crate-async-stream \
bundled-rust-crate-async-stream-impl \
bundled-rust-crate-async-task \
bundled-rust-crate-async-trait \
bundled-rust-crate-atoi-simd \
bundled-rust-crate-atomic \
bundled-rust-crate-atomic-waker \
bundled-rust-crate-autocfg \
bundled-rust-crate-aws-config \
bundled-rust-crate-aws-credential-types \
bundled-rust-crate-aws-lc-rs \
bundled-rust-crate-aws-lc-sys \
bundled-rust-crate-aws-runtime \
bundled-rust-crate-aws-sdk-s3 \
bundled-rust-crate-aws-sdk-sso \
bundled-rust-crate-aws-sdk-ssooidc \
bundled-rust-crate-aws-sdk-sts \
bundled-rust-crate-aws-sigv4 \
bundled-rust-crate-aws-smithy-async \
bundled-rust-crate-aws-smithy-checksums \
bundled-rust-crate-aws-smithy-eventstream \
bundled-rust-crate-aws-smithy-http \
bundled-rust-crate-aws-smithy-http-client \
bundled-rust-crate-aws-smithy-json \
bundled-rust-crate-aws-smithy-observability \
bundled-rust-crate-aws-smithy-query \
bundled-rust-crate-aws-smithy-runtime \
bundled-rust-crate-aws-smithy-runtime-api \
bundled-rust-crate-aws-smithy-runtime-api-macros \
bundled-rust-crate-aws-smithy-schema \
bundled-rust-crate-aws-smithy-types \
bundled-rust-crate-aws-smithy-xml \
bundled-rust-crate-aws-types \
bundled-rust-crate-axum \
bundled-rust-crate-axum-core \
bundled-rust-crate-axum-macros \
bundled-rust-crate-backoff \
bundled-rust-crate-backon \
bundled-rust-crate-backtrace \
bundled-rust-crate-base16ct \
bundled-rust-crate-base64 \
bundled-rust-crate-base64-simd \
bundled-rust-crate-base64ct \
bundled-rust-crate-bincode \
bundled-rust-crate-bit-set \
bundled-rust-crate-bit-vec \
bundled-rust-crate-bitflags \
bundled-rust-crate-blake3 \
bundled-rust-crate-block-buffer \
bundled-rust-crate-block-padding \
bundled-rust-crate-blocking \
bundled-rust-crate-bm25 \
bundled-rust-crate-borrow-or-share \
bundled-rust-crate-brotli \
bundled-rust-crate-brotli-decompressor \
bundled-rust-crate-bstr \
bundled-rust-crate-bumpalo \
bundled-rust-crate-bytecount \
bundled-rust-crate-bytemuck \
bundled-rust-crate-bytemuck-derive \
bundled-rust-crate-byteorder \
bundled-rust-crate-byteorder-lite \
bundled-rust-crate-bytes \
bundled-rust-crate-bytes-utils \
bundled-rust-crate-cached \
bundled-rust-crate-cached-proc-macro \
bundled-rust-crate-cached-proc-macro-types \
bundled-rust-crate-camino \
bundled-rust-crate-cassowary \
bundled-rust-crate-castaway \
bundled-rust-crate-cbc \
bundled-rust-crate-cc \
bundled-rust-crate-cfb \
bundled-rust-crate-cfg-aliases \
bundled-rust-crate-cfg-if \
bundled-rust-crate-chacha20 \
bundled-rust-crate-chrono \
bundled-rust-crate-cipher \
bundled-rust-crate-clap \
bundled-rust-crate-clap-builder \
bundled-rust-crate-clap-complete \
bundled-rust-crate-clap-derive \
bundled-rust-crate-clap-lex \
bundled-rust-crate-clru \
bundled-rust-crate-cmake \
bundled-rust-crate-cmov \
bundled-rust-crate-cmpv2 \
bundled-rust-crate-cms \
bundled-rust-crate-color-quant \
bundled-rust-crate-colorchoice \
bundled-rust-crate-command-fds \
bundled-rust-crate-compact-str \
bundled-rust-crate-compression-codecs \
bundled-rust-crate-compression-core \
bundled-rust-crate-concurrent-queue \
bundled-rust-crate-console \
bundled-rust-crate-const-hex \
bundled-rust-crate-const-oid \
bundled-rust-crate-const-random \
bundled-rust-crate-const-random-macro \
bundled-rust-crate-constant-time-eq \
bundled-rust-crate-convert-case \
bundled-rust-crate-core-maths \
bundled-rust-crate-cpp-demangle \
bundled-rust-crate-cpubits \
bundled-rust-crate-cpufeatures \
bundled-rust-crate-crc-fast \
bundled-rust-crate-crc32fast \
bundled-rust-crate-crmf \
bundled-rust-crate-crossbeam \
bundled-rust-crate-crossbeam-channel \
bundled-rust-crate-crossbeam-deque \
bundled-rust-crate-crossbeam-epoch \
bundled-rust-crate-crossbeam-queue \
bundled-rust-crate-crossbeam-utils \
bundled-rust-crate-crossterm \
bundled-rust-crate-crunchy \
bundled-rust-crate-cryptify \
bundled-rust-crate-crypto-bigint \
bundled-rust-crate-crypto-common \
bundled-rust-crate-cssparser \
bundled-rust-crate-cssparser-macros \
bundled-rust-crate-ctutils \
bundled-rust-crate-cursor-icon \
bundled-rust-crate-curve25519-dalek \
bundled-rust-crate-dagre-rust \
bundled-rust-crate-dark-light \
bundled-rust-crate-darling \
bundled-rust-crate-darling-core \
bundled-rust-crate-darling-macro \
bundled-rust-crate-dashmap \
bundled-rust-crate-data-encoding \
bundled-rust-crate-data-url \
bundled-rust-crate-debug-unsafe \
bundled-rust-crate-debugid \
bundled-rust-crate-defmt \
bundled-rust-crate-defmt-macros \
bundled-rust-crate-defmt-parser \
bundled-rust-crate-der \
bundled-rust-crate-der-derive \
bundled-rust-crate-deranged \
bundled-rust-crate-derive-builder \
bundled-rust-crate-derive-builder-core \
bundled-rust-crate-derive-builder-macro \
bundled-rust-crate-derive-more \
bundled-rust-crate-derive-more-impl \
bundled-rust-crate-deunicode \
bundled-rust-crate-digest \
bundled-rust-crate-dirs \
bundled-rust-crate-dirs-sys \
bundled-rust-crate-displaydoc \
bundled-rust-crate-document-features \
bundled-rust-crate-documented \
bundled-rust-crate-documented-macros \
bundled-rust-crate-downcast-rs \
bundled-rust-crate-dtoa \
bundled-rust-crate-dtoa-short \
bundled-rust-crate-dunce \
bundled-rust-crate-dyn-clone \
bundled-rust-crate-ecdsa \
bundled-rust-crate-ed25519 \
bundled-rust-crate-ed25519-dalek \
bundled-rust-crate-educe \
bundled-rust-crate-ego-tree \
bundled-rust-crate-either \
bundled-rust-crate-elliptic-curve \
bundled-rust-crate-email-address \
bundled-rust-crate-encoding-rs \
bundled-rust-crate-endi \
bundled-rust-crate-enum-ordinalize \
bundled-rust-crate-enum-ordinalize-derive \
bundled-rust-crate-enumflags2 \
bundled-rust-crate-enumflags2-derive \
bundled-rust-crate-env-filter \
bundled-rust-crate-env-logger \
bundled-rust-crate-equator \
bundled-rust-crate-equator-macro \
bundled-rust-crate-equivalent \
bundled-rust-crate-errno \
bundled-rust-crate-euclid \
bundled-rust-crate-event-listener \
bundled-rust-crate-event-listener-strategy \
bundled-rust-crate-eventsource-stream \
bundled-rust-crate-fallible-iterator \
bundled-rust-crate-fallible-streaming-iterator \
bundled-rust-crate-fancy-regex \
bundled-rust-crate-fast-float2 \
bundled-rust-crate-fast-image-resize \
bundled-rust-crate-fastant \
bundled-rust-crate-faster-hex \
bundled-rust-crate-fastrace \
bundled-rust-crate-fastrace-macro \
bundled-rust-crate-fastrace-opentelemetry \
bundled-rust-crate-fastrace-reqwest \
bundled-rust-crate-fastrace-tonic \
bundled-rust-crate-fastrand \
bundled-rust-crate-fax \
bundled-rust-crate-fdeflate \
bundled-rust-crate-ff \
bundled-rust-crate-file-id \
bundled-rust-crate-filedescriptor \
bundled-rust-crate-filetime \
bundled-rust-crate-find-msvc-tools \
bundled-rust-crate-findshlibs \
bundled-rust-crate-fixedbitset \
bundled-rust-crate-flagset \
bundled-rust-crate-flate2 \
bundled-rust-crate-float-cmp \
bundled-rust-crate-fluent-uri \
bundled-rust-crate-fnv \
bundled-rust-crate-foldhash \
bundled-rust-crate-font-types \
bundled-rust-crate-fontconfig-parser \
bundled-rust-crate-fontdb \
bundled-rust-crate-form-urlencoded \
bundled-rust-crate-fraction \
bundled-rust-crate-fs-extra \
bundled-rust-crate-fs2 \
bundled-rust-crate-futf \
bundled-rust-crate-futures \
bundled-rust-crate-futures-channel \
bundled-rust-crate-futures-core \
bundled-rust-crate-futures-executor \
bundled-rust-crate-futures-io \
bundled-rust-crate-futures-lite \
bundled-rust-crate-futures-macro \
bundled-rust-crate-futures-sink \
bundled-rust-crate-futures-task \
bundled-rust-crate-futures-timer \
bundled-rust-crate-futures-util \
bundled-rust-crate-fxhash \
bundled-rust-crate-gcloud-auth \
bundled-rust-crate-gcloud-metadata \
bundled-rust-crate-gcloud-storage \
bundled-rust-crate-generic-array \
bundled-rust-crate-gethostname \
bundled-rust-crate-getopts \
bundled-rust-crate-getrandom \
bundled-rust-crate-gif \
bundled-rust-crate-gimli \
bundled-rust-crate-git2 \
bundled-rust-crate-gix \
bundled-rust-crate-gix-actor \
bundled-rust-crate-gix-archive \
bundled-rust-crate-gix-attributes \
bundled-rust-crate-gix-bitmap \
bundled-rust-crate-gix-blame \
bundled-rust-crate-gix-chunk \
bundled-rust-crate-gix-command \
bundled-rust-crate-gix-commitgraph \
bundled-rust-crate-gix-config \
bundled-rust-crate-gix-config-value \
bundled-rust-crate-gix-date \
bundled-rust-crate-gix-diff \
bundled-rust-crate-gix-dir \
bundled-rust-crate-gix-discover \
bundled-rust-crate-gix-error \
bundled-rust-crate-gix-features \
bundled-rust-crate-gix-filter \
bundled-rust-crate-gix-fs \
bundled-rust-crate-gix-glob \
bundled-rust-crate-gix-hash \
bundled-rust-crate-gix-hashtable \
bundled-rust-crate-gix-ignore \
bundled-rust-crate-gix-imara-diff \
bundled-rust-crate-gix-index \
bundled-rust-crate-gix-lock \
bundled-rust-crate-gix-merge \
bundled-rust-crate-gix-negotiate \
bundled-rust-crate-gix-object \
bundled-rust-crate-gix-odb \
bundled-rust-crate-gix-pack \
bundled-rust-crate-gix-packetline \
bundled-rust-crate-gix-path \
bundled-rust-crate-gix-pathspec \
bundled-rust-crate-gix-protocol \
bundled-rust-crate-gix-quote \
bundled-rust-crate-gix-ref \
bundled-rust-crate-gix-refspec \
bundled-rust-crate-gix-revision \
bundled-rust-crate-gix-revwalk \
bundled-rust-crate-gix-sec \
bundled-rust-crate-gix-shallow \
bundled-rust-crate-gix-status \
bundled-rust-crate-gix-submodule \
bundled-rust-crate-gix-tempfile \
bundled-rust-crate-gix-trace \
bundled-rust-crate-gix-transport \
bundled-rust-crate-gix-traverse \
bundled-rust-crate-gix-url \
bundled-rust-crate-gix-utils \
bundled-rust-crate-gix-validate \
bundled-rust-crate-gix-worktree \
bundled-rust-crate-gix-worktree-state \
bundled-rust-crate-gix-worktree-stream \
bundled-rust-crate-glob \
bundled-rust-crate-globset \
bundled-rust-crate-graphlib-rust \
bundled-rust-crate-grid \
bundled-rust-crate-group \
bundled-rust-crate-h2 \
bundled-rust-crate-half \
bundled-rust-crate-harfrust \
bundled-rust-crate-hash32 \
bundled-rust-crate-hashbrown \
bundled-rust-crate-hashlink \
bundled-rust-crate-hayro-ccitt \
bundled-rust-crate-hayro-jbig2 \
bundled-rust-crate-hayro-jpeg2000 \
bundled-rust-crate-hdrhistogram \
bundled-rust-crate-heapless \
bundled-rust-crate-heck \
bundled-rust-crate-hex \
bundled-rust-crate-hkdf \
bundled-rust-crate-hmac \
bundled-rust-crate-hmac-sha256 \
bundled-rust-crate-home \
bundled-rust-crate-hostname \
bundled-rust-crate-htmd \
bundled-rust-crate-html-escape \
bundled-rust-crate-html5ever \
bundled-rust-crate-http \
bundled-rust-crate-http-body \
bundled-rust-crate-http-body-util \
bundled-rust-crate-httparse \
bundled-rust-crate-httpdate \
bundled-rust-crate-humantime \
bundled-rust-crate-humantime-serde \
bundled-rust-crate-hybrid-array \
bundled-rust-crate-hyper \
bundled-rust-crate-hyper-rustls \
bundled-rust-crate-hyper-timeout \
bundled-rust-crate-hyper-util \
bundled-rust-crate-iana-time-zone \
bundled-rust-crate-icu-collections \
bundled-rust-crate-icu-locale-core \
bundled-rust-crate-icu-normalizer \
bundled-rust-crate-icu-normalizer-data \
bundled-rust-crate-icu-properties \
bundled-rust-crate-icu-properties-data \
bundled-rust-crate-icu-provider \
bundled-rust-crate-ident-case \
bundled-rust-crate-idna \
bundled-rust-crate-idna-adapter \
bundled-rust-crate-ignore \
bundled-rust-crate-image \
bundled-rust-crate-image-webp \
bundled-rust-crate-imagesize \
bundled-rust-crate-indexmap \
bundled-rust-crate-indicatif \
bundled-rust-crate-indoc \
bundled-rust-crate-infer \
bundled-rust-crate-inotify \
bundled-rust-crate-inotify-sys \
bundled-rust-crate-inout \
bundled-rust-crate-instability \
bundled-rust-crate-instant \
bundled-rust-crate-io-close \
bundled-rust-crate-ipnet \
bundled-rust-crate-is-ci \
bundled-rust-crate-is-terminal-polyfill \
bundled-rust-crate-itertools \
bundled-rust-crate-itoa \
bundled-rust-crate-jiff \
bundled-rust-crate-jiff-core \
bundled-rust-crate-jiff-static \
bundled-rust-crate-jobserver \
bundled-rust-crate-jpeg-decoder \
bundled-rust-crate-jsonschema \
bundled-rust-crate-jsonwebtoken \
bundled-rust-crate-kanal \
bundled-rust-crate-kasuari \
bundled-rust-crate-kstring \
bundled-rust-crate-kurbo \
bundled-rust-crate-kv-log-macro \
bundled-rust-crate-labyrinth-macros \
bundled-rust-crate-landlock \
bundled-rust-crate-lazy-static \
bundled-rust-crate-libc \
bundled-rust-crate-libgit2-sys \
bundled-rust-crate-libm \
bundled-rust-crate-libmimalloc-sys \
bundled-rust-crate-libsqlite3-sys \
bundled-rust-crate-libz-sys \
bundled-rust-crate-linked-hash-map \
bundled-rust-crate-linkify \
bundled-rust-crate-linux-raw-sys \
bundled-rust-crate-litemap \
bundled-rust-crate-litrs \
bundled-rust-crate-lock-api \
bundled-rust-crate-log \
bundled-rust-crate-lru \
bundled-rust-crate-lru-slab \
bundled-rust-crate-lsp-types \
bundled-rust-crate-mac \
bundled-rust-crate-markup5ever \
bundled-rust-crate-markup5ever-rcdom \
bundled-rust-crate-match-token \
bundled-rust-crate-matchers \
bundled-rust-crate-matchit \
bundled-rust-crate-maybe-async \
bundled-rust-crate-md-5 \
bundled-rust-crate-memchr \
bundled-rust-crate-memmap2 \
bundled-rust-crate-memo-map \
bundled-rust-crate-mermaid-to-svg \
bundled-rust-crate-mid \
bundled-rust-crate-mimalloc \
bundled-rust-crate-mime \
bundled-rust-crate-mime-guess \
bundled-rust-crate-minijinja \
bundled-rust-crate-minimal-lexical \
bundled-rust-crate-miniz-oxide \
bundled-rust-crate-mio \
bundled-rust-crate-moka \
bundled-rust-crate-moxcms \
bundled-rust-crate-multer \
bundled-rust-crate-multimap \
bundled-rust-crate-new-debug-unreachable \
bundled-rust-crate-nix \
bundled-rust-crate-nohash-hasher \
bundled-rust-crate-nom \
bundled-rust-crate-nonempty \
bundled-rust-crate-nono \
bundled-rust-crate-notify \
bundled-rust-crate-notify-debouncer-full \
bundled-rust-crate-notify-debouncer-mini \
bundled-rust-crate-notify-types \
bundled-rust-crate-nu-ansi-term \
bundled-rust-crate-nucleo \
bundled-rust-crate-nucleo-matcher \
bundled-rust-crate-num \
bundled-rust-crate-num-bigint \
bundled-rust-crate-num-bigint-dig \
bundled-rust-crate-num-cmp \
bundled-rust-crate-num-complex \
bundled-rust-crate-num-conv \
bundled-rust-crate-num-cpus \
bundled-rust-crate-num-integer \
bundled-rust-crate-num-iter \
bundled-rust-crate-num-rational \
bundled-rust-crate-num-traits \
bundled-rust-crate-oauth2 \
bundled-rust-crate-obfstr \
bundled-rust-crate-object \
bundled-rust-crate-office-oxide \
bundled-rust-crate-once-cell \
bundled-rust-crate-openssl-probe \
bundled-rust-crate-opentelemetry \
bundled-rust-crate-opentelemetry-http \
bundled-rust-crate-opentelemetry-otlp \
bundled-rust-crate-opentelemetry-proto \
bundled-rust-crate-opentelemetry-sdk \
bundled-rust-crate-optfield \
bundled-rust-crate-option-ext \
bundled-rust-crate-ordered-hashmap \
bundled-rust-crate-ordered-stream \
bundled-rust-crate-os-pipe \
bundled-rust-crate-outref \
bundled-rust-crate-p256 \
bundled-rust-crate-p384 \
bundled-rust-crate-parking \
bundled-rust-crate-parking-lot \
bundled-rust-crate-parking-lot-core \
bundled-rust-crate-paste \
bundled-rust-crate-pastey \
bundled-rust-crate-path-clean \
bundled-rust-crate-pbjson-build \
bundled-rust-crate-pdf-oxide \
bundled-rust-crate-pem \
bundled-rust-crate-pem-rfc7468 \
bundled-rust-crate-percent-encoding \
bundled-rust-crate-petgraph \
bundled-rust-crate-phf \
bundled-rust-crate-phf-codegen \
bundled-rust-crate-phf-generator \
bundled-rust-crate-phf-macros \
bundled-rust-crate-phf-shared \
bundled-rust-crate-pico-args \
bundled-rust-crate-pin-project \
bundled-rust-crate-pin-project-internal \
bundled-rust-crate-pin-project-lite \
bundled-rust-crate-pin-utils \
bundled-rust-crate-piper \
bundled-rust-crate-pkcs1 \
bundled-rust-crate-pkcs8 \
bundled-rust-crate-pkg-config \
bundled-rust-crate-plist \
bundled-rust-crate-png \
bundled-rust-crate-polling \
bundled-rust-crate-pollster \
bundled-rust-crate-polycool \
bundled-rust-crate-portable-atomic \
bundled-rust-crate-portable-pty \
bundled-rust-crate-potential-utf \
bundled-rust-crate-powerfmt \
bundled-rust-crate-pprof \
bundled-rust-crate-ppv-lite86 \
bundled-rust-crate-precomputed-hash \
bundled-rust-crate-prettyplease \
bundled-rust-crate-primeorder \
bundled-rust-crate-proc-macro-crate \
bundled-rust-crate-proc-macro2 \
bundled-rust-crate-process-wrap \
bundled-rust-crate-procfs \
bundled-rust-crate-procfs-core \
bundled-rust-crate-prod-mc-cli-chat-proxy-types \
bundled-rust-crate-prodash \
bundled-rust-crate-prometheus \
bundled-rust-crate-prometheus-parse \
bundled-rust-crate-proptest \
bundled-rust-crate-prost \
bundled-rust-crate-prost-build \
bundled-rust-crate-prost-derive \
bundled-rust-crate-prost-reflect \
bundled-rust-crate-prost-types \
bundled-rust-crate-protobuf \
bundled-rust-crate-protobuf-support \
bundled-rust-crate-pulldown-cmark \
bundled-rust-crate-pulldown-cmark-escape \
bundled-rust-crate-pulldown-cmark-to-cmark \
bundled-rust-crate-pxfm \
bundled-rust-crate-qcms \
bundled-rust-crate-quick-error \
bundled-rust-crate-quick-xml \
bundled-rust-crate-quinn \
bundled-rust-crate-quinn-proto \
bundled-rust-crate-quinn-udp \
bundled-rust-crate-quote \
bundled-rust-crate-rand \
bundled-rust-crate-rand-chacha \
bundled-rust-crate-rand-core \
bundled-rust-crate-rand-pcg \
bundled-rust-crate-rand-xorshift \
bundled-rust-crate-rapidhash \
bundled-rust-crate-ratatui \
bundled-rust-crate-ratatui-core \
bundled-rust-crate-rayon \
bundled-rust-crate-rayon-core \
bundled-rust-crate-read-fonts \
bundled-rust-crate-ref-cast \
bundled-rust-crate-ref-cast-impl \
bundled-rust-crate-referencing \
bundled-rust-crate-reflink-copy \
bundled-rust-crate-regex \
bundled-rust-crate-regex-automata \
bundled-rust-crate-regex-lite \
bundled-rust-crate-regex-syntax \
bundled-rust-crate-regress \
bundled-rust-crate-reqwest \
bundled-rust-crate-reqwest-eventsource \
bundled-rust-crate-reqwest-middleware \
bundled-rust-crate-resvg \
bundled-rust-crate-rfc6979 \
bundled-rust-crate-rgb \
bundled-rust-crate-rhai \
bundled-rust-crate-rhai-codegen \
bundled-rust-crate-ring \
bundled-rust-crate-rmcp \
bundled-rust-crate-rmcp-macros \
bundled-rust-crate-roxmltree \
bundled-rust-crate-rsa \
bundled-rust-crate-rtrb \
bundled-rust-crate-rusqlite \
bundled-rust-crate-rust-stemmers \
bundled-rust-crate-rustc-demangle \
bundled-rust-crate-rustc-hash \
bundled-rust-crate-rustc-version \
bundled-rust-crate-rustix \
bundled-rust-crate-rustls \
bundled-rust-crate-rustls-native-certs \
bundled-rust-crate-rustls-pki-types \
bundled-rust-crate-rustls-platform-verifier \
bundled-rust-crate-rustls-webpki \
bundled-rust-crate-rustversion \
bundled-rust-crate-rustybuzz \
bundled-rust-crate-ryu \
bundled-rust-crate-ryu-js \
bundled-rust-crate-same-file \
bundled-rust-crate-schemars \
bundled-rust-crate-schemars-derive \
bundled-rust-crate-scopeguard \
bundled-rust-crate-scraper \
bundled-rust-crate-sec1 \
bundled-rust-crate-secrecy \
bundled-rust-crate-selectors \
bundled-rust-crate-semver \
bundled-rust-crate-sentry \
bundled-rust-crate-sentry-anyhow \
bundled-rust-crate-sentry-backtrace \
bundled-rust-crate-sentry-contexts \
bundled-rust-crate-sentry-core \
bundled-rust-crate-sentry-debug-images \
bundled-rust-crate-sentry-panic \
bundled-rust-crate-sentry-tracing \
bundled-rust-crate-sentry-types \
bundled-rust-crate-serde \
bundled-rust-crate-serde-core \
bundled-rust-crate-serde-derive \
bundled-rust-crate-serde-derive-internals \
bundled-rust-crate-serde-ignored \
bundled-rust-crate-serde-json \
bundled-rust-crate-serde-json-canonicalizer \
bundled-rust-crate-serde-path-to-error \
bundled-rust-crate-serde-repr \
bundled-rust-crate-serde-spanned \
bundled-rust-crate-serde-tokenstream \
bundled-rust-crate-serde-urlencoded \
bundled-rust-crate-serde-yaml \
bundled-rust-crate-serial2 \
bundled-rust-crate-servo-arc \
bundled-rust-crate-sha1 \
bundled-rust-crate-sha1-checked \
bundled-rust-crate-sha1-smol \
bundled-rust-crate-sha2 \
bundled-rust-crate-sharded-slab \
bundled-rust-crate-shell-words \
bundled-rust-crate-shellexpand \
bundled-rust-crate-shlex \
bundled-rust-crate-signal-hook \
bundled-rust-crate-signal-hook-mio \
bundled-rust-crate-signal-hook-registry \
bundled-rust-crate-signature \
bundled-rust-crate-sigstore-bundle \
bundled-rust-crate-sigstore-crypto \
bundled-rust-crate-sigstore-merkle \
bundled-rust-crate-sigstore-rekor \
bundled-rust-crate-sigstore-trust-root \
bundled-rust-crate-sigstore-tsa \
bundled-rust-crate-sigstore-types \
bundled-rust-crate-sigstore-verify \
bundled-rust-crate-simd-adler32 \
bundled-rust-crate-simdutf8 \
bundled-rust-crate-similar \
bundled-rust-crate-simple-asn1 \
bundled-rust-crate-simplecss \
bundled-rust-crate-siphasher \
bundled-rust-crate-skrifa \
bundled-rust-crate-slab \
bundled-rust-crate-slotmap \
bundled-rust-crate-small-ctor \
bundled-rust-crate-smallvec \
bundled-rust-crate-smartstring \
bundled-rust-crate-smawk \
bundled-rust-crate-socket2 \
bundled-rust-crate-spin \
bundled-rust-crate-spki \
bundled-rust-crate-sqlite-vec \
bundled-rust-crate-sse-stream \
bundled-rust-crate-stable-deref-trait \
bundled-rust-crate-static-assertions \
bundled-rust-crate-stop-words \
bundled-rust-crate-streaming-iterator \
bundled-rust-crate-strict-num \
bundled-rust-crate-string-cache \
bundled-rust-crate-string-cache-codegen \
bundled-rust-crate-stringprep \
bundled-rust-crate-strip-ansi-escapes \
bundled-rust-crate-strsim \
bundled-rust-crate-strum \
bundled-rust-crate-strum-macros \
bundled-rust-crate-subsetter \
bundled-rust-crate-subtle \
bundled-rust-crate-supports-color \
bundled-rust-crate-svgtypes \
bundled-rust-crate-symbolic-common \
bundled-rust-crate-symbolic-demangle \
bundled-rust-crate-symlink \
bundled-rust-crate-syn \
bundled-rust-crate-sync-wrapper \
bundled-rust-crate-synstructure \
bundled-rust-crate-syntect \
bundled-rust-crate-taffy \
bundled-rust-crate-tagptr \
bundled-rust-crate-tar \
bundled-rust-crate-tdigests \
bundled-rust-crate-tempfile \
bundled-rust-crate-tendril \
bundled-rust-crate-textwrap \
bundled-rust-crate-thin-vec \
bundled-rust-crate-thiserror \
bundled-rust-crate-thiserror-impl \
bundled-rust-crate-thread-local \
bundled-rust-crate-tiff \
bundled-rust-crate-tikv-jemalloc-ctl \
bundled-rust-crate-tikv-jemalloc-sys \
bundled-rust-crate-tikv-jemallocator \
bundled-rust-crate-time \
bundled-rust-crate-time-core \
bundled-rust-crate-time-macros \
bundled-rust-crate-tiny-keccak \
bundled-rust-crate-tiny-skia \
bundled-rust-crate-tiny-skia-path \
bundled-rust-crate-tinystr \
bundled-rust-crate-tinyvec \
bundled-rust-crate-tinyvec-macros \
bundled-rust-crate-tls-codec \
bundled-rust-crate-tls-codec-derive \
bundled-rust-crate-token-source \
bundled-rust-crate-tokio \
bundled-rust-crate-tokio-macros \
bundled-rust-crate-tokio-retry \
bundled-rust-crate-tokio-rustls \
bundled-rust-crate-tokio-stream \
bundled-rust-crate-tokio-tungstenite \
bundled-rust-crate-tokio-util \
bundled-rust-crate-toml \
bundled-rust-crate-toml-datetime \
bundled-rust-crate-toml-edit \
bundled-rust-crate-toml-parser \
bundled-rust-crate-toml-write \
bundled-rust-crate-toml-writer \
bundled-rust-crate-tonic \
bundled-rust-crate-tonic-build \
bundled-rust-crate-tonic-prost \
bundled-rust-crate-tonic-prost-build \
bundled-rust-crate-tonic-types \
bundled-rust-crate-tower \
bundled-rust-crate-tower-http \
bundled-rust-crate-tower-layer \
bundled-rust-crate-tower-service \
bundled-rust-crate-tracing \
bundled-rust-crate-tracing-appender \
bundled-rust-crate-tracing-attributes \
bundled-rust-crate-tracing-chrome \
bundled-rust-crate-tracing-core \
bundled-rust-crate-tracing-log \
bundled-rust-crate-tracing-opentelemetry \
bundled-rust-crate-tracing-serde \
bundled-rust-crate-tracing-subscriber \
bundled-rust-crate-tree-magic-mini \
bundled-rust-crate-tree-sitter \
bundled-rust-crate-tree-sitter-bash \
bundled-rust-crate-tree-sitter-go \
bundled-rust-crate-tree-sitter-javascript \
bundled-rust-crate-tree-sitter-language \
bundled-rust-crate-tree-sitter-python \
bundled-rust-crate-tree-sitter-rust \
bundled-rust-crate-tree-sitter-typescript \
bundled-rust-crate-try-lock \
bundled-rust-crate-ttf-parser \
bundled-rust-crate-tui-scrollbar \
bundled-rust-crate-tungstenite \
bundled-rust-crate-two-face \
bundled-rust-crate-typed-path \
bundled-rust-crate-typenum \
bundled-rust-crate-typeshare \
bundled-rust-crate-typeshare-annotation \
bundled-rust-crate-typify \
bundled-rust-crate-typify-impl \
bundled-rust-crate-typify-macro \
bundled-rust-crate-uname \
bundled-rust-crate-unarray \
bundled-rust-crate-unicase \
bundled-rust-crate-unicode-bidi \
bundled-rust-crate-unicode-bidi-mirroring \
bundled-rust-crate-unicode-bom \
bundled-rust-crate-unicode-ccc \
bundled-rust-crate-unicode-ident \
bundled-rust-crate-unicode-linebreak \
bundled-rust-crate-unicode-normalization \
bundled-rust-crate-unicode-properties \
bundled-rust-crate-unicode-script \
bundled-rust-crate-unicode-segmentation \
bundled-rust-crate-unicode-truncate \
bundled-rust-crate-unicode-vo \
bundled-rust-crate-unicode-width \
bundled-rust-crate-unicode-xid \
bundled-rust-crate-unit-prefix \
bundled-rust-crate-unsafe-libyaml \
bundled-rust-crate-untrusted \
bundled-rust-crate-ureq \
bundled-rust-crate-ureq-proto \
bundled-rust-crate-url \
bundled-rust-crate-urlencoding \
bundled-rust-crate-usvg \
bundled-rust-crate-utf-8 \
bundled-rust-crate-utf8-iter \
bundled-rust-crate-utf8-zero \
bundled-rust-crate-utf8parse \
bundled-rust-crate-uuid \
bundled-rust-crate-uuid-simd \
bundled-rust-crate-value-bag \
bundled-rust-crate-vcpkg \
bundled-rust-crate-version-check \
bundled-rust-crate-vsimd \
bundled-rust-crate-vte \
bundled-rust-crate-wait-timeout \
bundled-rust-crate-waitpid-any \
bundled-rust-crate-walkdir \
bundled-rust-crate-want \
bundled-rust-crate-wayland-backend \
bundled-rust-crate-wayland-client \
bundled-rust-crate-wayland-protocols \
bundled-rust-crate-wayland-protocols-wlr \
bundled-rust-crate-wayland-scanner \
bundled-rust-crate-wayland-sys \
bundled-rust-crate-web-atoms \
bundled-rust-crate-web-time \
bundled-rust-crate-webbrowser \
bundled-rust-crate-webpki-roots \
bundled-rust-crate-weezl \
bundled-rust-crate-which \
bundled-rust-crate-whoami \
bundled-rust-crate-wildmatch \
bundled-rust-crate-winnow \
bundled-rust-crate-wl-clipboard-rs \
bundled-rust-crate-write-fonts \
bundled-rust-crate-writeable \
bundled-rust-crate-x11rb \
bundled-rust-crate-x11rb-protocol \
bundled-rust-crate-x509-cert \
bundled-rust-crate-x509-tsp \
bundled-rust-crate-xai-acp-lib \
bundled-rust-crate-xai-agent-lifecycle \
bundled-rust-crate-xai-chat-state \
bundled-rust-crate-xai-circuit-breaker \
bundled-rust-crate-xai-codebase-graph \
bundled-rust-crate-xai-compaction-transcript \
bundled-rust-crate-xai-computer-hub-core \
bundled-rust-crate-xai-computer-hub-mcp-adapter \
bundled-rust-crate-xai-computer-hub-sdk \
bundled-rust-crate-xai-crash-handler \
bundled-rust-crate-xai-dirs \
bundled-rust-crate-xai-fast-worktree \
bundled-rust-crate-xai-file-utils \
bundled-rust-crate-xai-fsnotify \
bundled-rust-crate-xai-fuzzy-file-search \
bundled-rust-crate-xai-gix-status \
bundled-rust-crate-xai-grok-active-sessions \
bundled-rust-crate-xai-grok-agent \
bundled-rust-crate-xai-grok-announcements \
bundled-rust-crate-xai-grok-auth \
bundled-rust-crate-xai-grok-bundle \
bundled-rust-crate-xai-grok-compaction \
bundled-rust-crate-xai-grok-config \
bundled-rust-crate-xai-grok-config-types \
bundled-rust-crate-xai-grok-dashboard-store \
bundled-rust-crate-xai-grok-diag-server \
bundled-rust-crate-xai-grok-env \
bundled-rust-crate-xai-grok-extra-ca \
bundled-rust-crate-xai-grok-foreign-sessions \
bundled-rust-crate-xai-grok-gboom \
bundled-rust-crate-xai-grok-hooks \
bundled-rust-crate-xai-grok-http \
bundled-rust-crate-xai-grok-markdown \
bundled-rust-crate-xai-grok-markdown-core \
bundled-rust-crate-xai-grok-mcp \
bundled-rust-crate-xai-grok-memory \
bundled-rust-crate-xai-grok-mermaid \
bundled-rust-crate-xai-grok-models \
bundled-rust-crate-xai-grok-pager \
bundled-rust-crate-xai-grok-pager-bin \
bundled-rust-crate-xai-grok-pager-diff \
bundled-rust-crate-xai-grok-pager-minimal \
bundled-rust-crate-xai-grok-pager-render \
bundled-rust-crate-xai-grok-paths \
bundled-rust-crate-xai-grok-plugin-marketplace \
bundled-rust-crate-xai-grok-sampler \
bundled-rust-crate-xai-grok-sampling-types \
bundled-rust-crate-xai-grok-sandbox \
bundled-rust-crate-xai-grok-secrets \
bundled-rust-crate-xai-grok-session-events \
bundled-rust-crate-xai-grok-session-search \
bundled-rust-crate-xai-grok-shared \
bundled-rust-crate-xai-grok-shell \
bundled-rust-crate-xai-grok-shell-base \
bundled-rust-crate-xai-grok-shell-session-support \
bundled-rust-crate-xai-grok-shell-terminal \
bundled-rust-crate-xai-grok-status-line \
bundled-rust-crate-xai-grok-subagent-resolution \
bundled-rust-crate-xai-grok-telemetry \
bundled-rust-crate-xai-grok-tools \
bundled-rust-crate-xai-grok-tools-api \
bundled-rust-crate-xai-grok-update \
bundled-rust-crate-xai-grok-version \
bundled-rust-crate-xai-grok-voice \
bundled-rust-crate-xai-grok-workspace \
bundled-rust-crate-xai-grok-workspace-client \
bundled-rust-crate-xai-grok-workspace-daemon \
bundled-rust-crate-xai-grok-workspace-types \
bundled-rust-crate-xai-hooks-plugins-types \
bundled-rust-crate-xai-hunk-tracker \
bundled-rust-crate-xai-interjection-core \
bundled-rust-crate-xai-message-delivery-core \
bundled-rust-crate-xai-mixpanel \
bundled-rust-crate-xai-prompt-queue \
bundled-rust-crate-xai-proto-build \
bundled-rust-crate-xai-ratatui-inline \
bundled-rust-crate-xai-ratatui-textarea \
bundled-rust-crate-xai-sqlite-journal \
bundled-rust-crate-xai-system-power \
bundled-rust-crate-xai-token-estimation \
bundled-rust-crate-xai-tool-protocol \
bundled-rust-crate-xai-tool-runtime \
bundled-rust-crate-xai-tool-types \
bundled-rust-crate-xai-tracing \
bundled-rust-crate-xai-tracing-macros \
bundled-rust-crate-xai-tty-utils \
bundled-rust-crate-xai-workflow \
bundled-rust-crate-xattr \
bundled-rust-crate-xml5ever \
bundled-rust-crate-xmlparser \
bundled-rust-crate-xmlwriter \
bundled-rust-crate-yaml-rust \
bundled-rust-crate-yoke \
bundled-rust-crate-yoke-derive \
bundled-rust-crate-zbus \
bundled-rust-crate-zbus-macros \
bundled-rust-crate-zbus-names \
bundled-rust-crate-zcheapstr \
bundled-rust-crate-zerocopy \
bundled-rust-crate-zerocopy-derive \
bundled-rust-crate-zerofrom \
bundled-rust-crate-zerofrom-derive \
bundled-rust-crate-zeroize \
bundled-rust-crate-zeroize-derive \
bundled-rust-crate-zerotrie \
bundled-rust-crate-zerovec \
bundled-rust-crate-zerovec-derive \
bundled-rust-crate-zip \
bundled-rust-crate-zlib-rs \
bundled-rust-crate-zmij \
bundled-rust-crate-zopfli \
bundled-rust-crate-zstd \
bundled-rust-crate-zstd-safe \
bundled-rust-crate-zstd-sys \
bundled-rust-crate-zune-core \
bundled-rust-crate-zune-jpeg \
bundled-rust-crate-zvariant \
bundled-rust-crate-zvariant-derive \
bundled-rust-crate-zvariant-utils \
grok-build"

RDEPENDS:${PN} += "libc.so.6 \
libgcc-s.so.1 \
libm.so.6 \
ripgrep"

inherit rpm
