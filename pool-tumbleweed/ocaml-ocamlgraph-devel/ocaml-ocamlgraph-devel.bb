SUMMARY = "Development files for ocaml-ocamlgraph"
DESCRIPTION = "The ocaml-ocamlgraph-devel package contains libraries and signature files for \
developing applications that use ocaml-ocamlgraph."
LICENSE = "LGPL-2.1"

PV = "2.2.0"

RPM_NAME = "ocaml-ocamlgraph-devel-2.2.0-2.1.aarch64.rpm"
RPM_HASH = "56dfaefb75a283c166dce4011bd922f8c972f86e82395c49fabc7bdb31dd9928cb4aed90504514675b2907928a89b0b83495a184e52b71b225e871522b5d5ef0"

RPROVIDES:${PN} += "ocaml-Graph \
ocaml-Graph-- \
ocaml-Graph--Bitv \
ocaml-Graph--Blocks \
ocaml-Graph--Builder \
ocaml-Graph--ChaoticIteration \
ocaml-Graph--Classic \
ocaml-Graph--Clique \
ocaml-Graph--Cliquetree \
ocaml-Graph--Coloring \
ocaml-Graph--Components \
ocaml-Graph--Contraction \
ocaml-Graph--Cycles \
ocaml-Graph--DGraphModel \
ocaml-Graph--DGraphRandModel \
ocaml-Graph--DGraphSubTree \
ocaml-Graph--DGraphTreeLayout \
ocaml-Graph--DGraphTreeModel \
ocaml-Graph--Delaunay \
ocaml-Graph--Deque \
ocaml-Graph--Dominator \
ocaml-Graph--Dot \
ocaml-Graph--Dot-ast \
ocaml-Graph--Dot-lexer \
ocaml-Graph--Dot-parser \
ocaml-Graph--Eulerian \
ocaml-Graph--Fixpoint \
ocaml-Graph--Flow \
ocaml-Graph--Gmap \
ocaml-Graph--Gml \
ocaml-Graph--Graphml \
ocaml-Graph--Graphviz \
ocaml-Graph--Heap \
ocaml-Graph--Imperative \
ocaml-Graph--Kruskal \
ocaml-Graph--Leaderlist \
ocaml-Graph--Mcs-m \
ocaml-Graph--Md \
ocaml-Graph--Merge \
ocaml-Graph--Mincut \
ocaml-Graph--Minsep \
ocaml-Graph--Nonnegative \
ocaml-Graph--Oper \
ocaml-Graph--Pack \
ocaml-Graph--Path \
ocaml-Graph--Persistent \
ocaml-Graph--PersistentQueue \
ocaml-Graph--Prim \
ocaml-Graph--Rand \
ocaml-Graph--Sig \
ocaml-Graph--Sig-pack \
ocaml-Graph--Strat \
ocaml-Graph--Topological \
ocaml-Graph--Traverse \
ocaml-Graph--Unionfind \
ocaml-Graph--Util \
ocaml-Graph--WeakTopological \
ocaml-Graph--XDot \
ocaml-Graph--XDotDraw \
ocaml-ocamlgraph-devel \
ocamlfind-ocamlgraph \
ocamlx-Graph \
ocamlx-Graph-- \
ocamlx-Graph--Bitv \
ocamlx-Graph--Blocks \
ocamlx-Graph--Builder \
ocamlx-Graph--ChaoticIteration \
ocamlx-Graph--Classic \
ocamlx-Graph--Clique \
ocamlx-Graph--Cliquetree \
ocamlx-Graph--Coloring \
ocamlx-Graph--Components \
ocamlx-Graph--Contraction \
ocamlx-Graph--Cycles \
ocamlx-Graph--DGraphModel \
ocamlx-Graph--DGraphRandModel \
ocamlx-Graph--DGraphSubTree \
ocamlx-Graph--DGraphTreeLayout \
ocamlx-Graph--DGraphTreeModel \
ocamlx-Graph--Delaunay \
ocamlx-Graph--Deque \
ocamlx-Graph--Dominator \
ocamlx-Graph--Dot \
ocamlx-Graph--Dot-lexer \
ocamlx-Graph--Dot-parser \
ocamlx-Graph--Eulerian \
ocamlx-Graph--Fixpoint \
ocamlx-Graph--Flow \
ocamlx-Graph--Gmap \
ocamlx-Graph--Gml \
ocamlx-Graph--Graphml \
ocamlx-Graph--Graphviz \
ocamlx-Graph--Heap \
ocamlx-Graph--Imperative \
ocamlx-Graph--Kruskal \
ocamlx-Graph--Leaderlist \
ocamlx-Graph--Mcs-m \
ocamlx-Graph--Md \
ocamlx-Graph--Merge \
ocamlx-Graph--Mincut \
ocamlx-Graph--Minsep \
ocamlx-Graph--Nonnegative \
ocamlx-Graph--Oper \
ocamlx-Graph--Pack \
ocamlx-Graph--Path \
ocamlx-Graph--Persistent \
ocamlx-Graph--PersistentQueue \
ocamlx-Graph--Prim \
ocamlx-Graph--Rand \
ocamlx-Graph--Strat \
ocamlx-Graph--Topological \
ocamlx-Graph--Traverse \
ocamlx-Graph--Unionfind \
ocamlx-Graph--Util \
ocamlx-Graph--WeakTopological \
ocamlx-Graph--XDot \
ocamlx-Graph--XDotDraw"

RDEPENDS:${PN} += "ocaml-CamlinternalFormatBasics \
ocaml-CamlinternalLazy \
ocaml-CamlinternalMod \
ocaml-CamlinternalOO \
ocaml-Stdlib \
ocaml-Stdlib--Array \
ocaml-Stdlib--Buffer \
ocaml-Stdlib--Domain \
ocaml-Stdlib--Either \
ocaml-Stdlib--Filename \
ocaml-Stdlib--Format \
ocaml-Stdlib--Fun \
ocaml-Stdlib--Hashtbl \
ocaml-Stdlib--Int32 \
ocaml-Stdlib--Int64 \
ocaml-Stdlib--Lazy \
ocaml-Stdlib--Lexing \
ocaml-Stdlib--List \
ocaml-Stdlib--Map \
ocaml-Stdlib--Nativeint \
ocaml-Stdlib--Obj \
ocaml-Stdlib--Option \
ocaml-Stdlib--Parsing \
ocaml-Stdlib--Printf \
ocaml-Stdlib--Queue \
ocaml-Stdlib--Random \
ocaml-Stdlib--Scanf \
ocaml-Stdlib--Seq \
ocaml-Stdlib--Set \
ocaml-Stdlib--Stack \
ocaml-Stdlib--String \
ocaml-Stdlib--Sys \
ocaml-Stdlib--Uchar \
ocaml-ocamlgraph \
ocamlx-CamlinternalLazy \
ocamlx-CamlinternalMod \
ocamlx-CamlinternalOO \
ocamlx-Stdlib \
ocamlx-Stdlib--Array \
ocamlx-Stdlib--Buffer \
ocamlx-Stdlib--Filename \
ocamlx-Stdlib--Format \
ocamlx-Stdlib--Fun \
ocamlx-Stdlib--Hashtbl \
ocamlx-Stdlib--Int64 \
ocamlx-Stdlib--Lexing \
ocamlx-Stdlib--List \
ocamlx-Stdlib--Map \
ocamlx-Stdlib--Option \
ocamlx-Stdlib--Parsing \
ocamlx-Stdlib--Printf \
ocamlx-Stdlib--Queue \
ocamlx-Stdlib--Random \
ocamlx-Stdlib--Scanf \
ocamlx-Stdlib--Set \
ocamlx-Stdlib--Stack \
ocamlx-Stdlib--String \
ocamlx-Stdlib--Sys"

inherit rpm
