SUMMARY = "Creates Helm chart from Kubernetes yaml"
DESCRIPTION = "CLI that creates Helm charts from kubernetes yamls. \
 \
Helmify reads a list of supported k8s objects from stdin and converts it to a helm chart. Designed to generate charts for k8s operators but not limited to. See examples of charts generated by helmify. \
 \
Supports Helm >=v3.6.0"
LICENSE = "MIT"

PV = "0.4.20"

RPM_NAME = "helmify-0.4.20-1.4.aarch64.rpm"
RPM_HASH = "ea66a8e686df97119b50429429cc684a6ff2b433efef51a0092b642126279d3705c24cab42aef9d54a5291f82193f9a12fb77a3129686a4b624b5ab46426abbd"

RPROVIDES:${PN} += "helmify"

RDEPENDS:${PN} += "libc.so.6"

inherit rpm
