SUMMARY = "A virtual Lighttable and Darkroom"
DESCRIPTION = "darktable is a virtual lighttable and darkroom for photographers: it manages \
digital negatives in a database and can show them through a zoomable \
lighttable. It also enables developing raw images and enhance them."
LICENSE = "AGPL-3.0-or-later & GPL-3.0-or-later"

PV = "5.6.1"

RPM_NAME = "darktable-5.6.1-1.1.aarch64.rpm"
RPM_HASH = "84d687b75dbfe050ea0a3b92c1f31bfcd5d5f2929c292620662c3aff308ab05e2456a778698a898c791a0216f13bdda6348e5981fe17fba12777e2f2a14570b4"

RPROVIDES:${PN} += "darktable \
darktable-docs \
libagx.so \
libashift.so \
libatrous.so \
libavif.so \
libbackgroundjobs.so \
libbasecurve.so \
libbasicadj.so \
libbilat.so \
libbilateral.so \
libbloom.so \
libblurs.so \
libborders.so \
libcacorrect.so \
libcacorrectrgb.so \
libcamera.so \
libcensorize.so \
libchannelmixer.so \
libchannelmixerrgb.so \
libclahe.so \
libclipping.so \
libcolisa.so \
libcollect.so \
libcolorbalance.so \
libcolorbalancergb.so \
libcolorchecker.so \
libcolorcontrast.so \
libcolorcorrection.so \
libcolorequal.so \
libcolorharmonizer.so \
libcolorin.so \
libcolorize.so \
libcolorlabels.so \
libcolormapping.so \
libcolorout.so \
libcolorpicker.so \
libcolorreconstruct.so \
libcolortransfer.so \
libcolorzones.so \
libcopy-history.so \
libcopy.so \
libcrop.so \
libdarkroom.so \
libdarktable-label.so \
libdarktable.so \
libdefringe.so \
libdemosaic.so \
libdenoiseprofile.so \
libdiffuse.so \
libdisk.so \
libdither.so \
libduplicate.so \
libemail.so \
libenlargecanvas.so \
libequalizer.so \
libexport.so \
libexposure.so \
libexr.so \
libfilmic.so \
libfilmicrgb.so \
libfilmstrip.so \
libfilter.so \
libfiltering.so \
libfinalscale.so \
libflip.so \
libgallery.so \
libgamepad.so \
libgamma.so \
libgeotagging.so \
libglobal-toolbox.so \
libglobaltonemap.so \
libgraduatednd.so \
libgrain.so \
libhazeremoval.so \
libheif.so \
libhighlights.so \
libhighpass.so \
libhinter.so \
libhistogram.so \
libhistory.so \
libhotpixels.so \
libimage-infos.so \
libimage.so \
libimport.so \
libinvert.so \
libioporder.so \
libj2k.so \
libjpeg.so \
libjpegxl.so \
liblatex.so \
liblens.so \
liblevels.so \
liblighttable-mode.so \
liblighttable.so \
libliquify.so \
liblive-view.so \
liblocation.so \
liblog-history.so \
liblowlight.so \
liblowpass.so \
liblut3d.so \
libmap-locations.so \
libmap-settings.so \
libmap.so \
libmask-manager.so \
libmasks.so \
libmetadata-view.so \
libmetadata.so \
libmidi.so \
libmodule-toolbox.so \
libmodulegroups.so \
libmonochrome.so \
libnavigation.so \
libnegadoctor.so \
libnlmeans.so \
liboverexposed.so \
liboverlay.so \
libpdf.so \
libpfm.so \
libpiwigo.so \
libpng.so \
libppm.so \
libprimaries.so \
libprint-settings.so \
libprint.so \
libprofile-gamma.so \
librasterfile.so \
libratings.so \
librawdenoise.so \
librawoverexposed.so \
librawprepare.so \
librecentcollect.so \
librelight.so \
libretouch.so \
librgbcurve.so \
librgblevels.so \
librotatepixels.so \
libscalepixels.so \
libselect.so \
libsession.so \
libshadhi.so \
libsharpen.so \
libsigmoid.so \
libslideshow.so \
libsnapshots.so \
libsoften.so \
libsplittoning.so \
libspots.so \
libstyles.so \
libtagging.so \
libtemperature.so \
libtethering.so \
libtiff.so \
libtimeline.so \
libtonecurve.so \
libtoneequal.so \
libtonemap.so \
libvelvia.so \
libvibrance.so \
libview-toolbox.so \
libviewswitcher.so \
libvignette.so \
libwatermark.so \
libwebp.so \
libxcf.so \
libzonesystem.so"

RDEPENDS:${PN} += "/usr/bin/bash \
/usr/bin/env \
iso-codes \
ld-linux-aarch64.so.1 \
libIex-3-4.so.33 \
libImath-3-2.so.30 \
libOpenEXR-3-4.so.33 \
libSDL2-2.0.so.0 \
libX11.so.6 \
libXrandr.so.2 \
libavif.so.16 \
libc.so.6 \
libcairo.so.2 \
libcolord-gtk.so.1 \
libcolord.so.2 \
libcups.so.2 \
libcurl.so.4 \
libexiv2.so.28 \
libgcc-s.so.1 \
libgdk-3.so.0 \
libgdk-pixbuf-2.0.so.0 \
libgio-2.0.so.0 \
libglib-2.0.so.0 \
libgmic.so.4 \
libgmodule-2.0.so.0 \
libgobject-2.0.so.0 \
libgomp.so.1 \
libgphoto2-port.so.12 \
libgphoto2.so.6 \
libgtk-3.so.0 \
libheif.so.1 \
libicui18n.so.78 \
libicuuc.so.78 \
libjpeg.so.8 \
libjson-glib-1.0.so.0 \
libjxl-threads.so.0.11 \
libjxl.so.0.11 \
liblcms2.so.2 \
liblensfun.so.1 \
liblua5.4.so.5 \
libm.so.6 \
libopenjp2.so.7 \
libosmgpsmap-1.0.so.1 \
libpango-1.0.so.0 \
libpangocairo-1.0.so.0 \
libpng16.so.16 \
libportmidi.so.2 \
libpotrace.so.0 \
libpugixml.so.1 \
libraw.so.25 \
librsvg-2.so.2 \
libsecret-1.so.0 \
libsqlite3.so.0 \
libstdc++.so.6 \
libtiff.so.6 \
libwayland-client.so.0 \
libwebp.so.7 \
libwebpmux.so.3 \
libxml2.so.16 \
libz.so.1"

inherit rpm
