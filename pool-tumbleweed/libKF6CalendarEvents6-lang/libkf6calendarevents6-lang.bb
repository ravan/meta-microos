SUMMARY = "Translations for package libKF6CalendarEvents6"
DESCRIPTION = "Provides translations for the 'libKF6CalendarEvents6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6CalendarEvents6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "371424ae89135b5156f051eb07bbd0796d61aa67c3b696b09842013f9e903e094d8a8ff5e9baa0635eb85ae5e762f20c22c480fddce31b7f359090c5670f51b3"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6CalendarEvents6-lang \
libKF6CalendarEvents6-lang-all \
locale-libKF6CalendarEvents6-af \
locale-libKF6CalendarEvents6-ar \
locale-libKF6CalendarEvents6-as \
locale-libKF6CalendarEvents6-ast \
locale-libKF6CalendarEvents6-az \
locale-libKF6CalendarEvents6-be \
locale-libKF6CalendarEvents6-be@latin \
locale-libKF6CalendarEvents6-bg \
locale-libKF6CalendarEvents6-bn \
locale-libKF6CalendarEvents6-bn-IN \
locale-libKF6CalendarEvents6-br \
locale-libKF6CalendarEvents6-bs \
locale-libKF6CalendarEvents6-ca \
locale-libKF6CalendarEvents6-ca@valencia \
locale-libKF6CalendarEvents6-cs \
locale-libKF6CalendarEvents6-cy \
locale-libKF6CalendarEvents6-da \
locale-libKF6CalendarEvents6-de \
locale-libKF6CalendarEvents6-el \
locale-libKF6CalendarEvents6-en-GB \
locale-libKF6CalendarEvents6-eo \
locale-libKF6CalendarEvents6-es \
locale-libKF6CalendarEvents6-et \
locale-libKF6CalendarEvents6-eu \
locale-libKF6CalendarEvents6-fa \
locale-libKF6CalendarEvents6-fi \
locale-libKF6CalendarEvents6-fr \
locale-libKF6CalendarEvents6-ga \
locale-libKF6CalendarEvents6-gd \
locale-libKF6CalendarEvents6-gl \
locale-libKF6CalendarEvents6-gu \
locale-libKF6CalendarEvents6-he \
locale-libKF6CalendarEvents6-hi \
locale-libKF6CalendarEvents6-hr \
locale-libKF6CalendarEvents6-hu \
locale-libKF6CalendarEvents6-ia \
locale-libKF6CalendarEvents6-id \
locale-libKF6CalendarEvents6-is \
locale-libKF6CalendarEvents6-it \
locale-libKF6CalendarEvents6-ja \
locale-libKF6CalendarEvents6-ka \
locale-libKF6CalendarEvents6-kk \
locale-libKF6CalendarEvents6-km \
locale-libKF6CalendarEvents6-kn \
locale-libKF6CalendarEvents6-ko \
locale-libKF6CalendarEvents6-lt \
locale-libKF6CalendarEvents6-lv \
locale-libKF6CalendarEvents6-mai \
locale-libKF6CalendarEvents6-mk \
locale-libKF6CalendarEvents6-ml \
locale-libKF6CalendarEvents6-mr \
locale-libKF6CalendarEvents6-ms \
locale-libKF6CalendarEvents6-nb \
locale-libKF6CalendarEvents6-nds \
locale-libKF6CalendarEvents6-ne \
locale-libKF6CalendarEvents6-nl \
locale-libKF6CalendarEvents6-nn \
locale-libKF6CalendarEvents6-oc \
locale-libKF6CalendarEvents6-or \
locale-libKF6CalendarEvents6-pa \
locale-libKF6CalendarEvents6-pl \
locale-libKF6CalendarEvents6-pt \
locale-libKF6CalendarEvents6-pt-BR \
locale-libKF6CalendarEvents6-ro \
locale-libKF6CalendarEvents6-ru \
locale-libKF6CalendarEvents6-si \
locale-libKF6CalendarEvents6-sk \
locale-libKF6CalendarEvents6-sl \
locale-libKF6CalendarEvents6-sq \
locale-libKF6CalendarEvents6-sr \
locale-libKF6CalendarEvents6-sr@ijekavian \
locale-libKF6CalendarEvents6-sr@ijekavianlatin \
locale-libKF6CalendarEvents6-sr@latin \
locale-libKF6CalendarEvents6-sv \
locale-libKF6CalendarEvents6-ta \
locale-libKF6CalendarEvents6-te \
locale-libKF6CalendarEvents6-th \
locale-libKF6CalendarEvents6-tr \
locale-libKF6CalendarEvents6-ug \
locale-libKF6CalendarEvents6-uk \
locale-libKF6CalendarEvents6-vi \
locale-libKF6CalendarEvents6-wa \
locale-libKF6CalendarEvents6-zh-CN \
locale-libKF6CalendarEvents6-zh-HK \
locale-libKF6CalendarEvents6-zh-TW"

RDEPENDS:${PN} += "libKF6CalendarEvents6"

inherit rpm
