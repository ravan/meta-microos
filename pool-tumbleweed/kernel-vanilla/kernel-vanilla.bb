ksym-vanilla-regmap-bulk-read \
ksym-vanilla-regmap-bulk-write \
ksym-vanilla-regmap-can-raw-write \
ksym-vanilla-regmap-check-range-table \
ksym-vanilla-regmap-del-irq-chip \
ksym-vanilla-regmap-encx24j600-spi-read \
ksym-vanilla-regmap-encx24j600-spi-write \
ksym-vanilla-regmap-exit \
ksym-vanilla-regmap-field-alloc \
ksym-vanilla-regmap-field-bulk-alloc \
ksym-vanilla-regmap-field-bulk-free \
ksym-vanilla-regmap-field-free \
ksym-vanilla-regmap-field-read \
ksym-vanilla-regmap-field-test-bits \
ksym-vanilla-regmap-field-update-bits-base \
ksym-vanilla-regmap-fields-read \
ksym-vanilla-regmap-fields-update-bits-base \
ksym-vanilla-regmap-get-device \
ksym-vanilla-regmap-get-max-register \
ksym-vanilla-regmap-get-raw-read-max \
ksym-vanilla-regmap-get-raw-write-max \
ksym-vanilla-regmap-get-reg-stride \
ksym-vanilla-regmap-get-val-bytes \
ksym-vanilla-regmap-get-val-endian \
ksym-vanilla-regmap-irq-chip-get-base \
ksym-vanilla-regmap-irq-get-domain \
ksym-vanilla-regmap-irq-get-irq-reg-linear \
ksym-vanilla-regmap-irq-get-virq \
ksym-vanilla-regmap-irq-set-type-config-simple \
ksym-vanilla-regmap-might-sleep \
ksym-vanilla-regmap-mmio-attach-clk \
ksym-vanilla-regmap-mmio-detach-clk \
ksym-vanilla-regmap-multi-reg-read \
ksym-vanilla-regmap-multi-reg-write \
ksym-vanilla-regmap-multi-reg-write-bypassed \
ksym-vanilla-regmap-noinc-read \
ksym-vanilla-regmap-noinc-write \
ksym-vanilla-regmap-parse-val \
ksym-vanilla-regmap-raw-read \
ksym-vanilla-regmap-raw-write \
ksym-vanilla-regmap-raw-write-async \
ksym-vanilla-regmap-read \
ksym-vanilla-regmap-read-bypassed \
ksym-vanilla-regmap-reg-in-ranges \
ksym-vanilla-regmap-register-patch \
ksym-vanilla-regmap-reinit-cache \
ksym-vanilla-regmap-test-bits \
ksym-vanilla-regmap-update-bits-base \
ksym-vanilla-regmap-write \
ksym-vanilla-regmap-write-async \
ksym-vanilla-regset-get \
ksym-vanilla-regset-get-alloc \
ksym-vanilla-regulator-allow-bypass \
ksym-vanilla-regulator-bulk-disable \
ksym-vanilla-regulator-bulk-enable \
ksym-vanilla-regulator-bulk-force-disable \
ksym-vanilla-regulator-bulk-free \
ksym-vanilla-regulator-bulk-get \
ksym-vanilla-regulator-bulk-register-supply-alias \
ksym-vanilla-regulator-bulk-set-supply-names \
ksym-vanilla-regulator-bulk-unregister-supply-alias \
ksym-vanilla-regulator-count-voltages \
ksym-vanilla-regulator-desc-list-voltage-linear \
ksym-vanilla-regulator-desc-list-voltage-linear-range \
ksym-vanilla-regulator-disable \
ksym-vanilla-regulator-disable-deferred \
ksym-vanilla-regulator-disable-regmap \
ksym-vanilla-regulator-enable \
ksym-vanilla-regulator-enable-regmap \
ksym-vanilla-regulator-find-closest-bigger \
ksym-vanilla-regulator-force-disable \
ksym-vanilla-regulator-free-power-budget \
ksym-vanilla-regulator-get \
ksym-vanilla-regulator-get-bypass-regmap \
ksym-vanilla-regulator-get-current-limit \
ksym-vanilla-regulator-get-current-limit-regmap \
ksym-vanilla-regulator-get-drvdata \
ksym-vanilla-regulator-get-error-flags \
ksym-vanilla-regulator-get-exclusive \
ksym-vanilla-regulator-get-hardware-vsel-register \
ksym-vanilla-regulator-get-init-drvdata \
ksym-vanilla-regulator-get-linear-step \
ksym-vanilla-regulator-get-mode \
ksym-vanilla-regulator-get-optional \
ksym-vanilla-regulator-get-regmap \
ksym-vanilla-regulator-get-unclaimed-power-budget \
ksym-vanilla-regulator-get-voltage \
ksym-vanilla-regulator-get-voltage-rdev \
ksym-vanilla-regulator-get-voltage-sel-pickable-regmap \
ksym-vanilla-regulator-get-voltage-sel-regmap \
ksym-vanilla-regulator-hardware-enable \
ksym-vanilla-regulator-has-full-constraints \
ksym-vanilla-regulator-irq-helper \
ksym-vanilla-regulator-irq-helper-cancel \
ksym-vanilla-regulator-irq-map-event-simple \
ksym-vanilla-regulator-is-enabled \
ksym-vanilla-regulator-is-enabled-regmap \
ksym-vanilla-regulator-is-equal \
ksym-vanilla-regulator-is-supported-voltage \
ksym-vanilla-regulator-list-hardware-vsel \
ksym-vanilla-regulator-list-voltage \
ksym-vanilla-regulator-list-voltage-linear \
ksym-vanilla-regulator-list-voltage-linear-range \
ksym-vanilla-regulator-list-voltage-pickable-linear-range \
ksym-vanilla-regulator-list-voltage-table \
ksym-vanilla-regulator-map-voltage-ascend \
ksym-vanilla-regulator-map-voltage-iterate \
ksym-vanilla-regulator-map-voltage-linear \
ksym-vanilla-regulator-map-voltage-linear-range \
ksym-vanilla-regulator-map-voltage-pickable-linear-range \
ksym-vanilla-regulator-mode-to-status \
ksym-vanilla-regulator-notifier-call-chain \
ksym-vanilla-regulator-put \
ksym-vanilla-regulator-register \
ksym-vanilla-regulator-register-notifier \
ksym-vanilla-regulator-register-supply-alias \
ksym-vanilla-regulator-request-power-budget \
ksym-vanilla-regulator-set-active-discharge-regmap \
ksym-vanilla-regulator-set-bypass-regmap \
ksym-vanilla-regulator-set-current-limit \
ksym-vanilla-regulator-set-current-limit-regmap \
ksym-vanilla-regulator-set-drvdata \
ksym-vanilla-regulator-set-load \
ksym-vanilla-regulator-set-mode \
ksym-vanilla-regulator-set-pull-down-regmap \
ksym-vanilla-regulator-set-ramp-delay-regmap \
ksym-vanilla-regulator-set-soft-start-regmap \
ksym-vanilla-regulator-set-suspend-voltage \
ksym-vanilla-regulator-set-voltage \
ksym-vanilla-regulator-set-voltage-rdev \
ksym-vanilla-regulator-set-voltage-sel-pickable-regmap \
ksym-vanilla-regulator-set-voltage-sel-regmap \
ksym-vanilla-regulator-set-voltage-time \
ksym-vanilla-regulator-set-voltage-time-sel \
ksym-vanilla-regulator-suspend-disable \
ksym-vanilla-regulator-suspend-enable \
ksym-vanilla-regulator-sync-voltage \
ksym-vanilla-regulator-unregister \
ksym-vanilla-regulator-unregister-notifier \
ksym-vanilla-regulator-unregister-supply-alias \
ksym-vanilla-regulatory-hint \
ksym-vanilla-regulatory-pre-cac-allowed \
ksym-vanilla-regulatory-set-wiphy-regd \
ksym-vanilla-regulatory-set-wiphy-regd-sync \
ksym-vanilla-relay-buf-full \
ksym-vanilla-relay-close \
ksym-vanilla-relay-file-operations \
ksym-vanilla-relay-flush \
ksym-vanilla-relay-open \
ksym-vanilla-relay-reset \
ksym-vanilla-relay-subbufs-consumed \
ksym-vanilla-relay-switch-subbuf \
ksym-vanilla-release-and-free-resource \
ksym-vanilla-release-dentry-name-snapshot \
ksym-vanilla-release-firmware \
ksym-vanilla-release-pages \
ksym-vanilla-release-resource \
ksym-vanilla-release-sock \
ksym-vanilla-remap-pfn-range \
ksym-vanilla-remap-verify-area \
ksym-vanilla-remap-vmalloc-range \
ksym-vanilla-remove-arg-zero \
ksym-vanilla-remove-cpu \
ksym-vanilla-remove-memory \
ksym-vanilla-remove-proc-entry \
ksym-vanilla-remove-proc-subtree \
ksym-vanilla-remove-resource \
ksym-vanilla-remove-wait-queue \
ksym-vanilla-remove-watch-from-object \
ksym-vanilla-rename-lock \
ksym-vanilla-renesas-sdhi-probe \
ksym-vanilla-renesas-sdhi-remove \
ksym-vanilla-renesas-sdhi-resume \
ksym-vanilla-renesas-sdhi-suspend \
ksym-vanilla-replace-page-cache-folio \
ksym-vanilla-report-iommu-fault \
ksym-vanilla-request-any-context-irq \
ksym-vanilla-request-firmware \
ksym-vanilla-request-firmware-direct \
ksym-vanilla-request-firmware-into-buf \
ksym-vanilla-request-firmware-nowait \
ksym-vanilla-request-firmware-nowait-cancel \
ksym-vanilla-request-free-mem-region \
ksym-vanilla-request-key-rcu \
ksym-vanilla-request-key-tag \
ksym-vanilla-request-key-with-auxdata \
ksym-vanilla-request-partial-firmware-into-buf \
ksym-vanilla-request-percpu-irq-affinity \
ksym-vanilla-request-resource \
ksym-vanilla-request-threaded-irq \
ksym-vanilla-rescale-process-offset \
ksym-vanilla-rescale-process-scale \
ksym-vanilla-reservation-ww-class \
ksym-vanilla-reserve-iova \
ksym-vanilla-reserve-mem-find-by-name \
ksym-vanilla-reset-control-acquire \
ksym-vanilla-reset-control-assert \
ksym-vanilla-reset-control-bulk-acquire \
ksym-vanilla-reset-control-bulk-assert \
ksym-vanilla-reset-control-bulk-deassert \
ksym-vanilla-reset-control-bulk-put \
ksym-vanilla-reset-control-bulk-release \
ksym-vanilla-reset-control-bulk-reset \
ksym-vanilla-reset-control-deassert \
ksym-vanilla-reset-control-get-count \
ksym-vanilla-reset-control-put \
ksym-vanilla-reset-control-rearm \
ksym-vanilla-reset-control-release \
ksym-vanilla-reset-control-reset \
ksym-vanilla-reset-control-status \
ksym-vanilla-reset-controller-register \
ksym-vanilla-reset-controller-unregister \
ksym-vanilla-reset-devices \
ksym-vanilla-reset-hung-task-detector \
ksym-vanilla-reset-simple-ops \
ksym-vanilla-resilient-queued-spin-lock-slowpath \
ksym-vanilla-resilient-tas-spin-lock \
ksym-vanilla-resource-list-create-entry \
ksym-vanilla-resource-list-free \
ksym-vanilla-restore-online-page-callback \
ksym-vanilla-retire-super \
ksym-vanilla-return-address \
ksym-vanilla-reuseport-add-sock \
ksym-vanilla-reuseport-alloc \
ksym-vanilla-reuseport-attach-prog \
ksym-vanilla-reuseport-detach-prog \
ksym-vanilla-reuseport-detach-sock \
ksym-vanilla-reuseport-has-conns-set \
ksym-vanilla-reuseport-migrate-sock \
ksym-vanilla-reuseport-select-sock \
ksym-vanilla-reuseport-stop-listen-sock \
ksym-vanilla-rfc1042-header \
ksym-vanilla-rfkill-alloc \
ksym-vanilla-rfkill-blocked \
ksym-vanilla-rfkill-destroy \
ksym-vanilla-rfkill-find-type \
ksym-vanilla-rfkill-get-led-trigger-name \
ksym-vanilla-rfkill-init-sw-state \
ksym-vanilla-rfkill-pause-polling \
ksym-vanilla-rfkill-register \
ksym-vanilla-rfkill-resume-polling \
ksym-vanilla-rfkill-set-hw-state-reason \
ksym-vanilla-rfkill-set-led-trigger-name \
ksym-vanilla-rfkill-set-states \
ksym-vanilla-rfkill-set-sw-state \
ksym-vanilla-rfkill-soft-blocked \
ksym-vanilla-rfkill-unregister \
ksym-vanilla-rfs-needed \
ksym-vanilla-rhashtable-destroy \
ksym-vanilla-rhashtable-free-and-destroy \
ksym-vanilla-rhashtable-insert-slow \
ksym-vanilla-rhashtable-next-key \
ksym-vanilla-rhashtable-walk-enter \
ksym-vanilla-rhashtable-walk-exit \
ksym-vanilla-rhashtable-walk-next \
ksym-vanilla-rhashtable-walk-peek \
ksym-vanilla-rhashtable-walk-start-check \
ksym-vanilla-rhashtable-walk-stop \
ksym-vanilla-rht-bucket-nested \
ksym-vanilla-rht-bucket-nested-insert \
ksym-vanilla-ring-buffer-alloc-read-page \
ksym-vanilla-ring-buffer-bytes-cpu \
ksym-vanilla-ring-buffer-change-overwrite \
ksym-vanilla-ring-buffer-commit-overrun-cpu \
ksym-vanilla-ring-buffer-consume \
ksym-vanilla-ring-buffer-discard-commit \
ksym-vanilla-ring-buffer-dropped-events-cpu \
ksym-vanilla-ring-buffer-empty \
ksym-vanilla-ring-buffer-empty-cpu \
ksym-vanilla-ring-buffer-entries \
ksym-vanilla-ring-buffer-entries-cpu \
ksym-vanilla-ring-buffer-event-data \
ksym-vanilla-ring-buffer-event-length \
ksym-vanilla-ring-buffer-free \
ksym-vanilla-ring-buffer-free-read-page \
ksym-vanilla-ring-buffer-iter-advance \
ksym-vanilla-ring-buffer-iter-dropped \
ksym-vanilla-ring-buffer-iter-empty \
ksym-vanilla-ring-buffer-iter-peek \
ksym-vanilla-ring-buffer-iter-reset \
ksym-vanilla-ring-buffer-lock-reserve \
ksym-vanilla-ring-buffer-max-event-size \
ksym-vanilla-ring-buffer-normalize-time-stamp \
ksym-vanilla-ring-buffer-oldest-event-ts \
ksym-vanilla-ring-buffer-overrun-cpu \
ksym-vanilla-ring-buffer-overruns \
ksym-vanilla-ring-buffer-peek \
ksym-vanilla-ring-buffer-read-events-cpu \
ksym-vanilla-ring-buffer-read-finish \
ksym-vanilla-ring-buffer-read-page \
ksym-vanilla-ring-buffer-read-page-data \
ksym-vanilla-ring-buffer-read-start \
ksym-vanilla-ring-buffer-record-disable \
ksym-vanilla-ring-buffer-record-disable-cpu \
ksym-vanilla-ring-buffer-record-enable \
ksym-vanilla-ring-buffer-record-enable-cpu \
ksym-vanilla-ring-buffer-record-off \
ksym-vanilla-ring-buffer-record-on \
ksym-vanilla-ring-buffer-reset \
ksym-vanilla-ring-buffer-reset-cpu \
ksym-vanilla-ring-buffer-resize \
ksym-vanilla-ring-buffer-size \
ksym-vanilla-ring-buffer-subbuf-order-get \
ksym-vanilla-ring-buffer-subbuf-order-set \
ksym-vanilla-ring-buffer-subbuf-size-get \
ksym-vanilla-ring-buffer-swap-cpu \
ksym-vanilla-ring-buffer-time-stamp \
ksym-vanilla-ring-buffer-unlock-commit \
ksym-vanilla-ring-buffer-write \
ksym-vanilla-rio-add-device \
ksym-vanilla-rio-add-mport-pw-handler \
ksym-vanilla-rio-add-net \
ksym-vanilla-rio-alloc-net \
ksym-vanilla-rio-attach-device \
ksym-vanilla-rio-bus-type \
ksym-vanilla-rio-del-device \
ksym-vanilla-rio-del-mport-pw-handler \
ksym-vanilla-rio-dev-get \
ksym-vanilla-rio-dev-put \
ksym-vanilla-rio-dma-prep-xfer \
ksym-vanilla-rio-enable-rx-tx-port \
ksym-vanilla-rio-free-net \
ksym-vanilla-rio-get-comptag \
ksym-vanilla-rio-inb-pwrite-handler \
ksym-vanilla-rio-init-mports \
ksym-vanilla-rio-local-get-device-id \
ksym-vanilla-rio-local-set-device-id \
ksym-vanilla-rio-lock-device \
ksym-vanilla-rio-map-inb-region \
ksym-vanilla-rio-map-outb-region \
ksym-vanilla-rio-mport-chk-dev-access \
ksym-vanilla-rio-mport-class \
ksym-vanilla-rio-mport-get-efb \
ksym-vanilla-rio-mport-get-feature \
ksym-vanilla-rio-mport-get-physefb \
ksym-vanilla-rio-mport-initialize \
ksym-vanilla-rio-mport-read-config-16 \
ksym-vanilla-rio-mport-read-config-32 \
ksym-vanilla-rio-mport-read-config-8 \
ksym-vanilla-rio-mport-send-doorbell \
ksym-vanilla-rio-mport-write-config-16 \
ksym-vanilla-rio-mport-write-config-32 \
ksym-vanilla-rio-mport-write-config-8 \
ksym-vanilla-rio-pw-enable \
ksym-vanilla-rio-query-mport \
ksym-vanilla-rio-register-driver \
ksym-vanilla-rio-register-mport \
ksym-vanilla-rio-register-scan \
ksym-vanilla-rio-release-dma \
ksym-vanilla-rio-release-inb-dbell \
ksym-vanilla-rio-release-inb-mbox \
ksym-vanilla-rio-release-inb-pwrite \
ksym-vanilla-rio-release-outb-dbell \
ksym-vanilla-rio-release-outb-mbox \
ksym-vanilla-rio-request-inb-dbell \
ksym-vanilla-rio-request-inb-mbox \
ksym-vanilla-rio-request-inb-pwrite \
ksym-vanilla-rio-request-mport-dma \
ksym-vanilla-rio-request-outb-dbell \
ksym-vanilla-rio-request-outb-mbox \
ksym-vanilla-rio-route-add-entry \
ksym-vanilla-rio-route-clr-table \
ksym-vanilla-rio-route-get-entry \
ksym-vanilla-rio-set-port-lockout \
ksym-vanilla-rio-unlock-device \
ksym-vanilla-rio-unmap-inb-region \
ksym-vanilla-rio-unmap-outb-region \
ksym-vanilla-rio-unregister-driver \
ksym-vanilla-rio-unregister-mport \
ksym-vanilla-rk8xx-probe \
ksym-vanilla-rk8xx-resume \
ksym-vanilla-rk8xx-shutdown \
ksym-vanilla-rk8xx-suspend \
ksym-vanilla-rl6231-calc-dmic-clk \
ksym-vanilla-rl6231-get-clk-info \
ksym-vanilla-rl6231-get-pre-div \
ksym-vanilla-rl6231-pll-calc \
ksym-vanilla-rm3100-common-probe \
ksym-vanilla-rm3100-readable-table \
ksym-vanilla-rm3100-volatile-table \
ksym-vanilla-rm3100-writable-table \
ksym-vanilla-rmi-2d-sensor-abs-process \
ksym-vanilla-rmi-2d-sensor-abs-report \
ksym-vanilla-rmi-2d-sensor-configure-input \
ksym-vanilla-rmi-2d-sensor-of-probe \
ksym-vanilla-rmi-2d-sensor-rel-report \
ksym-vanilla-rmi-dbg \
ksym-vanilla-rmi-driver-resume \
ksym-vanilla-rmi-driver-suspend \
ksym-vanilla-rmi-of-property-read-u32 \
ksym-vanilla-rmi-register-transport-device \
ksym-vanilla-rmi-set-attn-data \
ksym-vanilla-rmi-unregister-function-handler \
ksym-vanilla-rmi-unregister-transport-device \
ksym-vanilla-rndis-add-hdr \
ksym-vanilla-rndis-borrow-net \
ksym-vanilla-rndis-command \
ksym-vanilla-rndis-deregister \
ksym-vanilla-rndis-free-response \
ksym-vanilla-rndis-get-next-response \
ksym-vanilla-rndis-msg-parser \
ksym-vanilla-rndis-register \
ksym-vanilla-rndis-rm-hdr \
ksym-vanilla-rndis-rx-fixup \
ksym-vanilla-rndis-set-host-mac \
ksym-vanilla-rndis-set-param-dev \
ksym-vanilla-rndis-set-param-medium \
ksym-vanilla-rndis-set-param-vendor \
ksym-vanilla-rndis-signal-connect \
ksym-vanilla-rndis-signal-disconnect \
ksym-vanilla-rndis-status \
ksym-vanilla-rndis-tx-fixup \
ksym-vanilla-rndis-unbind \
ksym-vanilla-rndis-uninit \
ksym-vanilla-rng-is-initialized \
ksym-vanilla-roccat-common2-device-init-struct \
ksym-vanilla-roccat-common2-receive \
ksym-vanilla-roccat-common2-send \
ksym-vanilla-roccat-common2-send-with-status \
ksym-vanilla-roccat-common2-sysfs-read \
ksym-vanilla-roccat-common2-sysfs-write \
ksym-vanilla-roccat-connect \
ksym-vanilla-roccat-disconnect \
ksym-vanilla-roccat-report-event \
ksym-vanilla-roce-del-all-netdev-gids \
ksym-vanilla-roce-gid-type-mask-support \
ksym-vanilla-rockchip-clk-add-grf \
ksym-vanilla-rockchip-clk-finalize \
ksym-vanilla-rockchip-clk-find-max-clk-id \
ksym-vanilla-rockchip-clk-init \
ksym-vanilla-rockchip-clk-init-early \
ksym-vanilla-rockchip-clk-of-add-provider \
ksym-vanilla-rockchip-clk-protect-critical \
ksym-vanilla-rockchip-clk-register-armclk \
ksym-vanilla-rockchip-clk-register-armclk-multi-pll \
ksym-vanilla-rockchip-clk-register-branches \
ksym-vanilla-rockchip-clk-register-ddrclk \
ksym-vanilla-rockchip-clk-register-late-branches \
ksym-vanilla-rockchip-clk-register-plls \
ksym-vanilla-rockchip-drm-wait-vact-end \
ksym-vanilla-rockchip-pcie-cfg-configuration-accesses \
ksym-vanilla-rockchip-pcie-deinit-phys \
ksym-vanilla-rockchip-pcie-disable-clocks \
ksym-vanilla-rockchip-pcie-enable-clocks \
ksym-vanilla-rockchip-pcie-get-phys \
ksym-vanilla-rockchip-pcie-init-port \
ksym-vanilla-rockchip-pcie-parse-dt \
ksym-vanilla-rockchip-pmu-block \
ksym-vanilla-rockchip-pmu-unblock \
ksym-vanilla-rockchip-register-restart-notifier \
ksym-vanilla-rockchip-register-softrst-lut \
ksym-vanilla-rockchip-rgb-fini \
ksym-vanilla-rockchip-rgb-init \
ksym-vanilla-rocket-pm-ops \
ksym-vanilla-rohm-regulator-set-dvs-levels \
ksym-vanilla-rohm-regulator-set-voltage-sel-restricted \
ksym-vanilla-root-device-unregister \
ksym-vanilla-root-mem-cgroup \
ksym-vanilla-round-jiffies \
ksym-vanilla-round-jiffies-relative \
ksym-vanilla-round-jiffies-up \
ksym-vanilla-round-jiffies-up-relative \
ksym-vanilla-rpc-add-pipe-dir-object \
ksym-vanilla-rpc-alloc-iostats \
ksym-vanilla-rpc-bind-new-program \
ksym-vanilla-rpc-calc-rto \
ksym-vanilla-rpc-call-async \
ksym-vanilla-rpc-call-null \
ksym-vanilla-rpc-call-start \
ksym-vanilla-rpc-call-sync \
ksym-vanilla-rpc-cancel-tasks \
ksym-vanilla-rpc-clnt-add-xprt \
ksym-vanilla-rpc-clnt-disconnect \
ksym-vanilla-rpc-clnt-iterate-for-each-xprt \
ksym-vanilla-rpc-clnt-manage-trunked-xprts \
ksym-vanilla-rpc-clnt-probe-trunked-xprts \
ksym-vanilla-rpc-clnt-setup-test-and-add-xprt \
ksym-vanilla-rpc-clnt-show-stats \
ksym-vanilla-rpc-clnt-swap-activate \
ksym-vanilla-rpc-clnt-swap-deactivate \
ksym-vanilla-rpc-clnt-test-and-add-xprt \
ksym-vanilla-rpc-clnt-xprt-switch-add-xprt \
ksym-vanilla-rpc-clnt-xprt-switch-has-addr \
ksym-vanilla-rpc-clnt-xprt-switch-remove-xprt \
ksym-vanilla-rpc-clone-client \
ksym-vanilla-rpc-clone-client-set-auth \
ksym-vanilla-rpc-count-iostats \
ksym-vanilla-rpc-count-iostats-metrics \
ksym-vanilla-rpc-create \
ksym-vanilla-rpc-d-lookup-sb \
ksym-vanilla-rpc-debug \
ksym-vanilla-rpc-delay \
ksym-vanilla-rpc-destroy-pipe-data \
ksym-vanilla-rpc-destroy-wait-queue \
ksym-vanilla-rpc-exit \
ksym-vanilla-rpc-find-or-alloc-pipe-dir-object \
ksym-vanilla-rpc-force-rebind \
ksym-vanilla-rpc-free-iostats \
ksym-vanilla-rpc-get-sb-net \
ksym-vanilla-rpc-init-pipe-dir-head \
ksym-vanilla-rpc-init-pipe-dir-object \
ksym-vanilla-rpc-init-priority-wait-queue \
ksym-vanilla-rpc-init-rtt \
ksym-vanilla-rpc-init-wait-queue \
ksym-vanilla-rpc-killall-tasks \
ksym-vanilla-rpc-localaddr \
ksym-vanilla-rpc-machine-cred \
ksym-vanilla-rpc-max-bc-payload \
ksym-vanilla-rpc-max-payload \
ksym-vanilla-rpc-mkpipe-data \
ksym-vanilla-rpc-mkpipe-dentry \
ksym-vanilla-rpc-net-ns \
ksym-vanilla-rpc-ntop \
ksym-vanilla-rpc-num-bc-slots \
ksym-vanilla-rpc-peeraddr \
ksym-vanilla-rpc-peeraddr2str \
ksym-vanilla-rpc-pipe-generic-upcall \
ksym-vanilla-rpc-pipefs-notifier-register \
ksym-vanilla-rpc-pipefs-notifier-unregister \
ksym-vanilla-rpc-prepare-reply-pages \
ksym-vanilla-rpc-proc-register \
ksym-vanilla-rpc-proc-unregister \
ksym-vanilla-rpc-pton \
ksym-vanilla-rpc-put-sb-net \
ksym-vanilla-rpc-put-task \
ksym-vanilla-rpc-put-task-async \
ksym-vanilla-rpc-queue-upcall \
ksym-vanilla-rpc-release-client \
ksym-vanilla-rpc-remove-pipe-dir-object \
ksym-vanilla-rpc-restart-call \
ksym-vanilla-rpc-restart-call-prepare \
ksym-vanilla-rpc-run-task \
ksym-vanilla-rpc-set-connect-timeout \
ksym-vanilla-rpc-setbufsize \
ksym-vanilla-rpc-shutdown-client \
ksym-vanilla-rpc-sleep-on \
ksym-vanilla-rpc-sleep-on-priority \
ksym-vanilla-rpc-sleep-on-priority-timeout \
ksym-vanilla-rpc-sleep-on-timeout \
ksym-vanilla-rpc-switch-client-transport \
ksym-vanilla-rpc-task-gfp-mask \
ksym-vanilla-rpc-task-release-transport \
ksym-vanilla-rpc-task-timeout \
ksym-vanilla-rpc-uaddr2sockaddr \
ksym-vanilla-rpc-unlink \
ksym-vanilla-rpc-update-rtt \
ksym-vanilla-rpc-wait-for-completion-task \
ksym-vanilla-rpc-wake-up \
ksym-vanilla-rpc-wake-up-first \
ksym-vanilla-rpc-wake-up-next \
ksym-vanilla-rpc-wake-up-queued-task \
ksym-vanilla-rpc-wake-up-status \
ksym-vanilla-rpcauth-create \
ksym-vanilla-rpcauth-destroy-credcache \
ksym-vanilla-rpcauth-get-gssinfo \
ksym-vanilla-rpcauth-get-pseudoflavor \
ksym-vanilla-rpcauth-init-cred \
ksym-vanilla-rpcauth-init-credcache \
ksym-vanilla-rpcauth-lookup-credcache \
ksym-vanilla-rpcauth-lookupcred \
ksym-vanilla-rpcauth-register \
ksym-vanilla-rpcauth-stringify-acceptor \
ksym-vanilla-rpcauth-unregister \
ksym-vanilla-rpcauth-unwrap-resp-decode \
ksym-vanilla-rpcauth-wrap-req-encode \
ksym-vanilla-rpcb-getport-async \
ksym-vanilla-rpcif-dirmap-read \
ksym-vanilla-rpcif-hw-init \
ksym-vanilla-rpcif-manual-xfer \
ksym-vanilla-rpcif-prepare \
ksym-vanilla-rpcif-sw-init \
ksym-vanilla-rpi-firmware-clk-get-max-rate \
ksym-vanilla-rpi-firmware-find-node \
ksym-vanilla-rpi-firmware-get \
ksym-vanilla-rpi-firmware-property \
ksym-vanilla-rpi-firmware-property-list \
ksym-vanilla-rpi-firmware-put \
ksym-vanilla-rpmb-dev-find-device \
ksym-vanilla-rpmb-dev-get \
ksym-vanilla-rpmb-dev-put \
ksym-vanilla-rpmb-dev-register \
ksym-vanilla-rpmb-dev-unregister \
ksym-vanilla-rpmb-interface-register \
ksym-vanilla-rpmb-interface-unregister \
ksym-vanilla-rpmb-route-frames \
ksym-vanilla-rpmh-invalidate \
ksym-vanilla-rpmh-write \
ksym-vanilla-rpmh-write-async \
ksym-vanilla-rpmh-write-batch \
ksym-vanilla-rpmsg-chrdev-eptdev-create \
ksym-vanilla-rpmsg-chrdev-eptdev-destroy \
ksym-vanilla-rpmsg-class \
ksym-vanilla-rpmsg-create-channel \
ksym-vanilla-rpmsg-create-ept \
ksym-vanilla-rpmsg-destroy-ept \
ksym-vanilla-rpmsg-find-device \
ksym-vanilla-rpmsg-get-mtu \
ksym-vanilla-rpmsg-ns-register-device \
ksym-vanilla-rpmsg-poll \
ksym-vanilla-rpmsg-register-device \
ksym-vanilla-rpmsg-register-device-override \
ksym-vanilla-rpmsg-release-channel \
ksym-vanilla-rpmsg-send \
ksym-vanilla-rpmsg-sendto \
ksym-vanilla-rpmsg-set-flow-control \
ksym-vanilla-rpmsg-trysend \
ksym-vanilla-rpmsg-trysendto \
ksym-vanilla-rpmsg-unregister-device \
ksym-vanilla-rproc-add \
ksym-vanilla-rproc-add-carveout \
ksym-vanilla-rproc-add-subdev \
ksym-vanilla-rproc-alloc \
ksym-vanilla-rproc-boot \
ksym-vanilla-rproc-coredump \
ksym-vanilla-rproc-coredump-add-custom-segment \
ksym-vanilla-rproc-coredump-add-segment \
ksym-vanilla-rproc-coredump-cleanup \
ksym-vanilla-rproc-coredump-set-elf-info \
ksym-vanilla-rproc-coredump-using-sections \
ksym-vanilla-rproc-da-to-va \
ksym-vanilla-rproc-del \
ksym-vanilla-rproc-detach \
ksym-vanilla-rproc-elf-find-loaded-rsc-table \
ksym-vanilla-rproc-elf-get-boot-addr \
ksym-vanilla-rproc-elf-load-rsc-table \
ksym-vanilla-rproc-elf-load-segments \
ksym-vanilla-rproc-elf-sanity-check \
ksym-vanilla-rproc-free \
ksym-vanilla-rproc-get-by-child \
ksym-vanilla-rproc-get-by-phandle \
ksym-vanilla-rproc-mem-entry-init \
ksym-vanilla-rproc-of-parse-firmware \
ksym-vanilla-rproc-of-resm-mem-entry-init \
ksym-vanilla-rproc-put \
ksym-vanilla-rproc-remove-subdev \
ksym-vanilla-rproc-report-crash \
ksym-vanilla-rproc-resource-cleanup \
ksym-vanilla-rproc-set-firmware \
ksym-vanilla-rproc-shutdown \
ksym-vanilla-rproc-vq-interrupt \
ksym-vanilla-rps-may-expire-flow \
ksym-vanilla-rps-needed \
ksym-vanilla-rqspinlock-held-locks \
ksym-vanilla-rs-pretty-print-rate \
ksym-vanilla-rsa-parse-priv-key \
ksym-vanilla-rsa-parse-pub-key \
ksym-vanilla-rsi-91x-deinit \
ksym-vanilla-rsi-91x-init \
ksym-vanilla-rsi-bt-ops \
ksym-vanilla-rsi-config-wowlan \
ksym-vanilla-rsi-dbg \
ksym-vanilla-rsi-hal-device-init \
ksym-vanilla-rsi-mac80211-detach \
ksym-vanilla-rsi-mac80211-rfkill-exit \
ksym-vanilla-rsi-present \
ksym-vanilla-rsi-read-pkt \
ksym-vanilla-rsi-zone-enabled \
ksym-vanilla-rt-dst-alloc \
ksym-vanilla-rt-mutex-base-init \
ksym-vanilla-rt-mutex-lock \
ksym-vanilla-rt-mutex-lock-interruptible \
ksym-vanilla-rt-mutex-lock-killable \
ksym-vanilla-rt-mutex-trylock \
ksym-vanilla-rt-mutex-unlock \
ksym-vanilla-rt2800-ampdu-action \
ksym-vanilla-rt2800-check-firmware \
ksym-vanilla-rt2800-clear-beacon \
ksym-vanilla-rt2800-conf-tx \
ksym-vanilla-rt2800-config \
ksym-vanilla-rt2800-config-ant \
ksym-vanilla-rt2800-config-erp \
ksym-vanilla-rt2800-config-filter \
ksym-vanilla-rt2800-config-intf \
ksym-vanilla-rt2800-config-pairwise-key \
ksym-vanilla-rt2800-config-shared-key \
ksym-vanilla-rt2800-disable-radio \
ksym-vanilla-rt2800-disable-wpdma \
ksym-vanilla-rt2800-efuse-detect \
ksym-vanilla-rt2800-enable-radio \
ksym-vanilla-rt2800-gain-calibration \
ksym-vanilla-rt2800-get-key-seq \
ksym-vanilla-rt2800-get-survey \
ksym-vanilla-rt2800-get-tsf \
ksym-vanilla-rt2800-get-txwi-rxwi-size \
ksym-vanilla-rt2800-link-stats \
ksym-vanilla-rt2800-link-tuner \
ksym-vanilla-rt2800-load-firmware \
ksym-vanilla-rt2800-mcu-request \
ksym-vanilla-rt2800-pre-reset-hw \
ksym-vanilla-rt2800-probe-hw \
ksym-vanilla-rt2800-process-rxwi \
ksym-vanilla-rt2800-read-eeprom-efuse \
ksym-vanilla-rt2800-read-eeprom-nvmem \
ksym-vanilla-rt2800-reset-tuner \
ksym-vanilla-rt2800-rfkill-poll \
ksym-vanilla-rt2800-set-rts-threshold \
ksym-vanilla-rt2800-sta-add \
ksym-vanilla-rt2800-sta-remove \
ksym-vanilla-rt2800-txdone \
ksym-vanilla-rt2800-txdone-entry \
ksym-vanilla-rt2800-txdone-nostatus \
ksym-vanilla-rt2800-txstatus-pending \
ksym-vanilla-rt2800-txstatus-timeout \
ksym-vanilla-rt2800-vco-calibration \
ksym-vanilla-rt2800-wait-csr-ready \
ksym-vanilla-rt2800-wait-wpdma-ready \
ksym-vanilla-rt2800-watchdog \
ksym-vanilla-rt2800-write-beacon \
ksym-vanilla-rt2800-write-tx-data \
ksym-vanilla-rt2800mmio-autowake-tasklet \
ksym-vanilla-rt2800mmio-clear-entry \
ksym-vanilla-rt2800mmio-enable-radio \
ksym-vanilla-rt2800mmio-fill-rxdone \
ksym-vanilla-rt2800mmio-flush-queue \
ksym-vanilla-rt2800mmio-get-dma-done \
ksym-vanilla-rt2800mmio-get-entry-state \
ksym-vanilla-rt2800mmio-get-txwi \
ksym-vanilla-rt2800mmio-init-queues \
ksym-vanilla-rt2800mmio-init-registers \
ksym-vanilla-rt2800mmio-interrupt \
ksym-vanilla-rt2800mmio-kick-queue \
ksym-vanilla-rt2800mmio-pretbtt-tasklet \
ksym-vanilla-rt2800mmio-probe-hw \
ksym-vanilla-rt2800mmio-queue-init \
ksym-vanilla-rt2800mmio-rxdone-tasklet \
ksym-vanilla-rt2800mmio-start-queue \
ksym-vanilla-rt2800mmio-stop-queue \
ksym-vanilla-rt2800mmio-tbtt-tasklet \
ksym-vanilla-rt2800mmio-toggle-irq \
ksym-vanilla-rt2800mmio-txstatus-tasklet \
ksym-vanilla-rt2800mmio-write-tx-desc \
ksym-vanilla-rt2x00lib-beacondone \
ksym-vanilla-rt2x00lib-dmadone \
ksym-vanilla-rt2x00lib-dmastart \
ksym-vanilla-rt2x00lib-get-bssidx \
ksym-vanilla-rt2x00lib-pretbtt \
ksym-vanilla-rt2x00lib-probe-dev \
ksym-vanilla-rt2x00lib-remove-dev \
ksym-vanilla-rt2x00lib-resume \
ksym-vanilla-rt2x00lib-rxdone \
ksym-vanilla-rt2x00lib-set-mac-address \
ksym-vanilla-rt2x00lib-suspend \
ksym-vanilla-rt2x00lib-txdone \
ksym-vanilla-rt2x00lib-txdone-noinfo \
ksym-vanilla-rt2x00lib-txdone-nomatch \
ksym-vanilla-rt2x00mac-add-interface \
ksym-vanilla-rt2x00mac-bss-info-changed \
ksym-vanilla-rt2x00mac-conf-tx \
ksym-vanilla-rt2x00mac-config \
ksym-vanilla-rt2x00mac-configure-filter \
ksym-vanilla-rt2x00mac-flush \
ksym-vanilla-rt2x00mac-get-antenna \
ksym-vanilla-rt2x00mac-get-ringparam \
ksym-vanilla-rt2x00mac-get-stats \
ksym-vanilla-rt2x00mac-reconfig-complete \
ksym-vanilla-rt2x00mac-remove-interface \
ksym-vanilla-rt2x00mac-rfkill-poll \
ksym-vanilla-rt2x00mac-set-antenna \
ksym-vanilla-rt2x00mac-set-key \
ksym-vanilla-rt2x00mac-set-tim \
ksym-vanilla-rt2x00mac-start \
ksym-vanilla-rt2x00mac-stop \
ksym-vanilla-rt2x00mac-sw-scan-complete \
ksym-vanilla-rt2x00mac-sw-scan-start \
ksym-vanilla-rt2x00mac-tx \
ksym-vanilla-rt2x00mac-tx-frames-pending \
ksym-vanilla-rt2x00mmio-flush-queue \
ksym-vanilla-rt2x00mmio-initialize \
ksym-vanilla-rt2x00mmio-regbusy-read \
ksym-vanilla-rt2x00mmio-rxdone \
ksym-vanilla-rt2x00mmio-uninitialize \
ksym-vanilla-rt2x00pci-pm-ops \
ksym-vanilla-rt2x00pci-probe \
ksym-vanilla-rt2x00pci-remove \
ksym-vanilla-rt2x00queue-flush-queue \
ksym-vanilla-rt2x00queue-flush-queues \
ksym-vanilla-rt2x00queue-for-each-entry \
ksym-vanilla-rt2x00queue-get-entry \
ksym-vanilla-rt2x00queue-map-txskb \
ksym-vanilla-rt2x00queue-pause-queue \
ksym-vanilla-rt2x00queue-start-queue \
ksym-vanilla-rt2x00queue-start-queues \
ksym-vanilla-rt2x00queue-stop-queue \
ksym-vanilla-rt2x00queue-stop-queues \
ksym-vanilla-rt2x00queue-unmap-skb \
ksym-vanilla-rt2x00queue-unpause-queue \
ksym-vanilla-rt2x00usb-clear-entry \
ksym-vanilla-rt2x00usb-disable-radio \
ksym-vanilla-rt2x00usb-disconnect \
ksym-vanilla-rt2x00usb-flush-queue \
ksym-vanilla-rt2x00usb-initialize \
ksym-vanilla-rt2x00usb-kick-queue \
ksym-vanilla-rt2x00usb-probe \
ksym-vanilla-rt2x00usb-regbusy-read \
ksym-vanilla-rt2x00usb-register-read-async \
ksym-vanilla-rt2x00usb-resume \
ksym-vanilla-rt2x00usb-suspend \
ksym-vanilla-rt2x00usb-uninitialize \
ksym-vanilla-rt2x00usb-vendor-req-buff-lock \
ksym-vanilla-rt2x00usb-vendor-request \
ksym-vanilla-rt2x00usb-vendor-request-buff \
ksym-vanilla-rt2x00usb-watchdog \
ksym-vanilla-rt5514-spi-burst-read \
ksym-vanilla-rt5514-spi-burst-write \
ksym-vanilla-rt5640-detect-headset \
ksym-vanilla-rt5640-disable-micbias1-for-ovcd \
ksym-vanilla-rt5640-dmic-enable \
ksym-vanilla-rt5640-enable-micbias1-for-ovcd \
ksym-vanilla-rt5640-sel-asrc-clk-src \
ksym-vanilla-rt5640-set-ovcd-params \
ksym-vanilla-rt5645-components \
ksym-vanilla-rt5645-sel-asrc-clk-src \
ksym-vanilla-rt5645-set-jack-detect \
ksym-vanilla-rt5659-set-jack-detect \
ksym-vanilla-rt5663-sel-asrc-clk-src \
ksym-vanilla-rt5682-aif1-dai-ops \
ksym-vanilla-rt5682-aif2-dai-ops \
ksym-vanilla-rt5682-apply-patch-list \
ksym-vanilla-rt5682-calibrate \
ksym-vanilla-rt5682-get-ldo1 \
ksym-vanilla-rt5682-jack-detect-handler \
ksym-vanilla-rt5682-parse-dt \
ksym-vanilla-rt5682-readable-register \
ksym-vanilla-rt5682-reg \
ksym-vanilla-rt5682-register-dai-clks \
ksym-vanilla-rt5682-reset \
ksym-vanilla-rt5682-sel-asrc-clk-src \
ksym-vanilla-rt5682-soc-component-dev \
ksym-vanilla-rt5682-supply-names \
ksym-vanilla-rt5682-volatile-register \
ksym-vanilla-rt5682s-sel-asrc-clk-src \
ksym-vanilla-rt6-lookup \
ksym-vanilla-rtc-add-group \
ksym-vanilla-rtc-add-groups \
ksym-vanilla-rtc-alarm-irq-enable \
ksym-vanilla-rtc-class-close \
ksym-vanilla-rtc-class-open \
ksym-vanilla-rtc-initialize-alarm \
ksym-vanilla-rtc-ktime-to-tm \
ksym-vanilla-rtc-month-days \
ksym-vanilla-rtc-read-alarm \
ksym-vanilla-rtc-read-next-alarm \
ksym-vanilla-rtc-read-time \
ksym-vanilla-rtc-set-alarm \
ksym-vanilla-rtc-set-time \
ksym-vanilla-rtc-time64-to-tm \
ksym-vanilla-rtc-tm-to-ktime \
ksym-vanilla-rtc-tm-to-time64 \
ksym-vanilla-rtc-update-irq \
ksym-vanilla-rtc-update-irq-enable \
ksym-vanilla-rtc-valid-tm \
ksym-vanilla-rtc-year-days \
ksym-vanilla-rtd-pinctrl-probe \
ksym-vanilla-rtl-action-proc \
ksym-vanilla-rtl-addr-delay \
ksym-vanilla-rtl-beacon-statistic \
ksym-vanilla-rtl-btc-get-ops-pointer \
ksym-vanilla-rtl-btc-status-false \
ksym-vanilla-rtl-c2hcmd-enqueue \
ksym-vanilla-rtl-cam-add-one-entry \
ksym-vanilla-rtl-cam-del-entry \
ksym-vanilla-rtl-cam-delete-one-entry \
ksym-vanilla-rtl-cam-empty-entry \
ksym-vanilla-rtl-cam-get-free-entry \
ksym-vanilla-rtl-cam-mark-invalid \
ksym-vanilla-rtl-cam-reset-all-entry \
ksym-vanilla-rtl-cmd-send-packet \
ksym-vanilla-rtl-collect-scan-list \
ksym-vanilla-rtl-debug-add-one \
ksym-vanilla-rtl-debug-remove-one \
ksym-vanilla-rtl-deinit-core \
ksym-vanilla-rtl-deinit-deferred-work \
ksym-vanilla-rtl-deinit-rfkill \
ksym-vanilla-rtl-dm-diginit \
ksym-vanilla-rtl-efuse-ops-init \
ksym-vanilla-rtl-efuse-shadow-map-update \
ksym-vanilla-rtl-evm-db-to-percentage \
ksym-vanilla-rtl-fill-dummy \
ksym-vanilla-rtl-fw-block-write \
ksym-vanilla-rtl-fw-cb \
ksym-vanilla-rtl-fw-page-write \
ksym-vanilla-rtl-get-hal-edca-param \
ksym-vanilla-rtl-get-hwinfo \
ksym-vanilla-rtl-get-tcb-desc \
ksym-vanilla-rtl-hal-pwrseqcmdparsing \
ksym-vanilla-rtl-init-core \
ksym-vanilla-rtl-init-rfkill \
ksym-vanilla-rtl-init-rx-config \
ksym-vanilla-rtl-init-sw-leds \
ksym-vanilla-rtl-ips-nic-on \
ksym-vanilla-rtl-is-special-data \
ksym-vanilla-rtl-lps-change-work-callback \
ksym-vanilla-rtl-lps-enter \
ksym-vanilla-rtl-lps-leave \
ksym-vanilla-rtl-mrate-idx-to-arfr-id \
ksym-vanilla-rtl-ops \
ksym-vanilla-rtl-p2p-info \
ksym-vanilla-rtl-pci-disconnect \
ksym-vanilla-rtl-pci-probe \
ksym-vanilla-rtl-pci-resume \
ksym-vanilla-rtl-pci-suspend \
ksym-vanilla-rtl-phy-scan-operation-backup \
ksym-vanilla-rtl-process-phyinfo \
ksym-vanilla-rtl-ps-disable-nic \
ksym-vanilla-rtl-ps-enable-nic \
ksym-vanilla-rtl-query-rxpwrpercentage \
ksym-vanilla-rtl-recognize-peer \
ksym-vanilla-rtl-rfreg-delay \
ksym-vanilla-rtl-rx-ampdu-apply \
ksym-vanilla-rtl-send-smps-action \
ksym-vanilla-rtl-set-tx-report \
ksym-vanilla-rtl-signal-scale-mapping \
ksym-vanilla-rtl-swlps-beacon \
ksym-vanilla-rtl-tid-to-ac \
ksym-vanilla-rtl-tx-ackqueue \
ksym-vanilla-rtl-tx-mgmt-proc \
ksym-vanilla-rtl-tx-report-handler \
ksym-vanilla-rtl-update-beacon-work-callback \
ksym-vanilla-rtl-usb-disconnect \
ksym-vanilla-rtl-usb-probe \
ksym-vanilla-rtl-wowlan-fw-cb \
ksym-vanilla-rtl8152-get-version \
ksym-vanilla-rtl8192-phy-check-is-legal-rfpath \
ksym-vanilla-rtl8366-enable-vlan \
ksym-vanilla-rtl8366-enable-vlan4k \
ksym-vanilla-rtl8366-get-ethtool-stats \
ksym-vanilla-rtl8366-get-sset-count \
ksym-vanilla-rtl8366-get-strings \
ksym-vanilla-rtl8366-mc-is-used \
ksym-vanilla-rtl8366-reset-vlan \
ksym-vanilla-rtl8366-set-pvid \
ksym-vanilla-rtl8366-set-vlan \
ksym-vanilla-rtl8366-vlan-add \
ksym-vanilla-rtl8366-vlan-del \
ksym-vanilla-rtl83xx-lock \
ksym-vanilla-rtl83xx-port-bridge-flags \
ksym-vanilla-rtl83xx-port-bridge-join \
ksym-vanilla-rtl83xx-port-bridge-leave \
ksym-vanilla-rtl83xx-port-fast-age \
ksym-vanilla-rtl83xx-port-fdb-add \
ksym-vanilla-rtl83xx-port-fdb-del \
ksym-vanilla-rtl83xx-port-fdb-dump \
ksym-vanilla-rtl83xx-port-mdb-add \
ksym-vanilla-rtl83xx-port-mdb-del \
ksym-vanilla-rtl83xx-probe \
ksym-vanilla-rtl83xx-register-switch \
ksym-vanilla-rtl83xx-remove \
ksym-vanilla-rtl83xx-setup-port-flood-control \
ksym-vanilla-rtl83xx-setup-user-mdio \
ksym-vanilla-rtl83xx-shutdown \
ksym-vanilla-rtl83xx-unlock \
ksym-vanilla-rtl83xx-unregister-switch \
ksym-vanilla-rtl8723-dm-init-dynamic-bb-powersaving \
ksym-vanilla-rtl8723-dm-init-dynamic-txpower \
ksym-vanilla-rtl8723-dm-init-edca-turbo \
ksym-vanilla-rtl8723-download-fw \
ksym-vanilla-rtl8723-enable-fw-download \
ksym-vanilla-rtl8723-fw-free-to-go \
ksym-vanilla-rtl8723-phy-init-bb-rf-reg-def \
ksym-vanilla-rtl8723-phy-mac-setting-calibration \
ksym-vanilla-rtl8723-phy-path-a-fill-iqk-matrix \
ksym-vanilla-rtl8723-phy-path-a-standby \
ksym-vanilla-rtl8723-phy-path-adda-on \
ksym-vanilla-rtl8723-phy-pi-mode-switch \
ksym-vanilla-rtl8723-phy-query-bb-reg \
ksym-vanilla-rtl8723-phy-reload-adda-registers \
ksym-vanilla-rtl8723-phy-reload-mac-registers \
ksym-vanilla-rtl8723-phy-rf-serial-read \
ksym-vanilla-rtl8723-phy-rf-serial-write \
ksym-vanilla-rtl8723-phy-save-mac-registers \
ksym-vanilla-rtl8723-phy-set-bb-reg \
ksym-vanilla-rtl8723-phy-set-sw-chnl-cmdarray \
ksym-vanilla-rtl8723-phy-txpwr-idx-to-dbm \
ksym-vanilla-rtl8723-save-adda-registers \
ksym-vanilla-rtl8723-write-fw \
ksym-vanilla-rtl8723ae-firmware-selfreset \
ksym-vanilla-rtl8723be-firmware-selfreset \
ksym-vanilla-rtl92c-bt-rssi-state-change \
ksym-vanilla-rtl92c-dm-bt-coexist \
ksym-vanilla-rtl92c-dm-check-txpower-tracking \
ksym-vanilla-rtl92c-dm-init \
ksym-vanilla-rtl92c-dm-init-edca-turbo \
ksym-vanilla-rtl92c-dm-init-rate-adaptive-mask \
ksym-vanilla-rtl92c-dm-rf-saving \
ksym-vanilla-rtl92c-dm-watchdog \
ksym-vanilla-rtl92c-dm-write-dig \
ksym-vanilla-rtl92c-download-fw \
ksym-vanilla-rtl92c-fill-h2c-cmd \
ksym-vanilla-rtl92c-firmware-selfreset \
ksym-vanilla-rtl92c-phy-ap-calibrate \
ksym-vanilla-rtl92c-phy-iq-calibrate \
ksym-vanilla-rtl92c-phy-lc-calibrate \
ksym-vanilla-rtl92c-phy-query-bb-reg \
ksym-vanilla-rtl92c-phy-rf-config \
ksym-vanilla-rtl92c-phy-set-bb-reg \
ksym-vanilla-rtl92c-phy-set-bw-mode \
ksym-vanilla-rtl92c-phy-set-io \
ksym-vanilla-rtl92c-phy-set-io-cmd \
ksym-vanilla-rtl92c-phy-set-rfpath-switch \
ksym-vanilla-rtl92c-phy-set-txpower-level \
ksym-vanilla-rtl92c-phy-sw-chnl \
ksym-vanilla-rtl92c-phy-sw-chnl-callback \
ksym-vanilla-rtl92c-phy-update-txpower-dbm \
ksym-vanilla-rtl92c-set-fw-joinbss-report-cmd \
ksym-vanilla-rtl92c-set-fw-pwrmode-cmd \
ksym-vanilla-rtl92c-set-fw-rsvdpagepkt \
ksym-vanilla-rtl92c-set-p2p-ps-offload-cmd \
ksym-vanilla-rtl92ce-phy-set-rf-on \
ksym-vanilla-rtl92d-dm-check-edca-turbo \
ksym-vanilla-rtl92d-dm-check-txpower-tracking-thermal-meter \
ksym-vanilla-rtl92d-dm-dig \
ksym-vanilla-rtl92d-dm-false-alarm-counter-statistics \
ksym-vanilla-rtl92d-dm-find-minimum-rssi \
ksym-vanilla-rtl92d-dm-init-edca-turbo \
ksym-vanilla-rtl92d-dm-init-rate-adaptive-mask \
ksym-vanilla-rtl92d-dm-initialize-txpower-tracking \
ksym-vanilla-rtl92d-dm-write-dig \
ksym-vanilla-rtl92d-enable-fw-download \
ksym-vanilla-rtl92d-enable-hw-security-config \
ksym-vanilla-rtl92d-fill-h2c-cmd \
ksym-vanilla-rtl92d-firmware-selfreset \
ksym-vanilla-rtl92d-fw-free-to-go \
ksym-vanilla-rtl92d-fw-init \
ksym-vanilla-rtl92d-get-chnlgroup-fromarray \
ksym-vanilla-rtl92d-get-desc \
ksym-vanilla-rtl92d-get-hw-reg \
ksym-vanilla-rtl92d-get-rightchnlplace-for-iqk \
ksym-vanilla-rtl92d-gpio-radio-on-off-checking \
ksym-vanilla-rtl92d-is-fw-downloaded \
ksym-vanilla-rtl92d-llt-write \
ksym-vanilla-rtl92d-phy-calc-curvindex \
ksym-vanilla-rtl92d-phy-config-maccoexist-rfpage \
ksym-vanilla-rtl92d-phy-config-macphymode \
ksym-vanilla-rtl92d-phy-config-macphymode-info \
ksym-vanilla-rtl92d-phy-enable-rf-env \
ksym-vanilla-rtl92d-phy-get-hw-reg-originalvalue \
ksym-vanilla-rtl92d-phy-init-bb-rf-register-definition \
ksym-vanilla-rtl92d-phy-mac-setting-calibration \
ksym-vanilla-rtl92d-phy-path-adda-on \
ksym-vanilla-rtl92d-phy-query-rf-reg \
ksym-vanilla-rtl92d-phy-reset-iqk-result \
ksym-vanilla-rtl92d-phy-restore-rf-env \
ksym-vanilla-rtl92d-phy-rf6052-set-bandwidth \
ksym-vanilla-rtl92d-phy-rf6052-set-cck-txpower \
ksym-vanilla-rtl92d-phy-rf6052-set-ofdm-txpower \
ksym-vanilla-rtl92d-phy-save-adda-registers \
ksym-vanilla-rtl92d-phy-save-mac-registers \
ksym-vanilla-rtl92d-phy-set-io-cmd \
ksym-vanilla-rtl92d-phy-set-rf-reg \
ksym-vanilla-rtl92d-phy-set-txpower-level \
ksym-vanilla-rtl92d-read-eeprom-info \
ksym-vanilla-rtl92d-resume-tx-beacon \
ksym-vanilla-rtl92d-rx-query-desc \
ksym-vanilla-rtl92d-set-desc \
ksym-vanilla-rtl92d-set-fw-joinbss-report-cmd \
ksym-vanilla-rtl92d-set-hw-reg \
ksym-vanilla-rtl92d-set-key \
ksym-vanilla-rtl92d-set-qos \
ksym-vanilla-rtl92d-stop-tx-beacon \
ksym-vanilla-rtl92d-store-pwrindex-diffrate-offset \
ksym-vanilla-rtl92d-update-channel-access-setting \
ksym-vanilla-rtl92d-update-hal-rate-tbl \
ksym-vanilla-rtl92d-write-fw \
ksym-vanilla-rtlwifi-rate-mapping \
ksym-vanilla-rtm-getroute-parse-ip-proto \
ksym-vanilla-rtnetlink-put-metrics \
ksym-vanilla-rtnl-af-register \
ksym-vanilla-rtnl-af-unregister \
ksym-vanilla-rtnl-configure-link \
ksym-vanilla-rtnl-create-link \
ksym-vanilla-rtnl-delete-link \
ksym-vanilla-rtnl-dev-link-net-capable \
ksym-vanilla-rtnl-get-net-ns-capable \
ksym-vanilla-rtnl-is-locked \
ksym-vanilla-rtnl-kfree-skbs \
ksym-vanilla-rtnl-link-get-net \
ksym-vanilla-rtnl-link-register \
ksym-vanilla-rtnl-link-unregister \
ksym-vanilla-rtnl-lock \
ksym-vanilla-rtnl-nla-parse-ifinfomsg \
ksym-vanilla-rtnl-notify \
ksym-vanilla-rtnl-offload-xstats-notify \
ksym-vanilla-rtnl-put-cacheinfo \
ksym-vanilla-rtnl-set-sk-err \
ksym-vanilla-rtnl-trylock \
ksym-vanilla-rtnl-unicast \
ksym-vanilla-rtnl-unlock \
ksym-vanilla-rtnl-unregister-all \
ksym-vanilla-rtrs-addr-to-sockaddr \
ksym-vanilla-rtrs-addr-to-str \
ksym-vanilla-rtrs-clt-close \
ksym-vanilla-rtrs-clt-get-permit \
ksym-vanilla-rtrs-clt-open \
ksym-vanilla-rtrs-clt-put-permit \
ksym-vanilla-rtrs-clt-query \
ksym-vanilla-rtrs-clt-rdma-cq-direct \
ksym-vanilla-rtrs-clt-request \
ksym-vanilla-rtrs-cq-qp-create \
ksym-vanilla-rtrs-cq-qp-destroy \
ksym-vanilla-rtrs-ib-dev-find-or-add \
ksym-vanilla-rtrs-ib-dev-put \
ksym-vanilla-rtrs-init-hb \
ksym-vanilla-rtrs-iu-alloc \
ksym-vanilla-rtrs-iu-free \
ksym-vanilla-rtrs-iu-post-rdma-write-imm \
ksym-vanilla-rtrs-iu-post-recv \
ksym-vanilla-rtrs-iu-post-send \
ksym-vanilla-rtrs-post-recv-empty \
ksym-vanilla-rtrs-rdma-dev-pd-deinit \
ksym-vanilla-rtrs-rdma-dev-pd-init \
ksym-vanilla-rtrs-send-hb-ack \
ksym-vanilla-rtrs-srv-close \
ksym-vanilla-rtrs-srv-get-path-name \
ksym-vanilla-rtrs-srv-get-queue-depth \
ksym-vanilla-rtrs-srv-open \
ksym-vanilla-rtrs-srv-resp-rdma \
ksym-vanilla-rtrs-srv-set-sess-priv \
ksym-vanilla-rtrs-start-hb \
ksym-vanilla-rtrs-stop-hb \
ksym-vanilla-rtsx-pci-add-cmd \
ksym-vanilla-rtsx-pci-card-exclusive-check \
ksym-vanilla-rtsx-pci-card-exist \
ksym-vanilla-rtsx-pci-card-power-off \
ksym-vanilla-rtsx-pci-card-power-on \
ksym-vanilla-rtsx-pci-card-pull-ctl-disable \
ksym-vanilla-rtsx-pci-card-pull-ctl-enable \
ksym-vanilla-rtsx-pci-complete-unfinished-transfer \
ksym-vanilla-rtsx-pci-dma-map-sg \
ksym-vanilla-rtsx-pci-dma-transfer \
ksym-vanilla-rtsx-pci-dma-unmap-sg \
ksym-vanilla-rtsx-pci-read-phy-register \
ksym-vanilla-rtsx-pci-read-ppbuf \
ksym-vanilla-rtsx-pci-read-register \
ksym-vanilla-rtsx-pci-send-cmd \
ksym-vanilla-rtsx-pci-send-cmd-no-wait \
ksym-vanilla-rtsx-pci-start-run \
ksym-vanilla-rtsx-pci-stop-cmd \
ksym-vanilla-rtsx-pci-switch-clock \
ksym-vanilla-rtsx-pci-switch-output-voltage \
ksym-vanilla-rtsx-pci-write-phy-register \
ksym-vanilla-rtsx-pci-write-ppbuf \
ksym-vanilla-rtsx-pci-write-register \
ksym-vanilla-rtsx-usb-add-cmd \
ksym-vanilla-rtsx-usb-card-exclusive-check \
ksym-vanilla-rtsx-usb-ep0-read-register \
ksym-vanilla-rtsx-usb-ep0-write-register \
ksym-vanilla-rtsx-usb-get-card-status \
ksym-vanilla-rtsx-usb-get-rsp \
ksym-vanilla-rtsx-usb-read-ppbuf \
ksym-vanilla-rtsx-usb-read-register \
ksym-vanilla-rtsx-usb-send-cmd \
ksym-vanilla-rtsx-usb-switch-clock \
ksym-vanilla-rtsx-usb-transfer-data \
ksym-vanilla-rtsx-usb-write-ppbuf \
ksym-vanilla-rtsx-usb-write-register \
ksym-vanilla-rtw-bf-cfg-csi-rate \
ksym-vanilla-rtw-bf-enable-bfee-mu \
ksym-vanilla-rtw-bf-enable-bfee-su \
ksym-vanilla-rtw-bf-phy-init \
ksym-vanilla-rtw-bf-remove-bfee-mu \
ksym-vanilla-rtw-bf-remove-bfee-su \
ksym-vanilla-rtw-bf-set-gid-table \
ksym-vanilla-rtw-chip-info-setup \
ksym-vanilla-rtw-coex-init-hw-config \
ksym-vanilla-rtw-coex-power-off-setting \
ksym-vanilla-rtw-coex-power-on-setting \
ksym-vanilla-rtw-coex-read-indirect-reg \
ksym-vanilla-rtw-coex-write-indirect-reg \
ksym-vanilla-rtw-coex-write-scbd \
ksym-vanilla-rtw-core-deinit \
ksym-vanilla-rtw-core-init \
ksym-vanilla-rtw-debug-mask \
ksym-vanilla-rtw-disable-lps-deep-mode \
ksym-vanilla-rtw-download-firmware \
ksym-vanilla-rtw-dump-fw \
ksym-vanilla-rtw-dump-reg \
ksym-vanilla-rtw-fw-c2h-cmd-isr \
ksym-vanilla-rtw-fw-c2h-cmd-rx-irqsafe \
ksym-vanilla-rtw-fw-do-iqk \
ksym-vanilla-rtw-fw-inform-rfk-status \
ksym-vanilla-rtw-fw-recovery \
ksym-vanilla-rtw-ops \
ksym-vanilla-rtw-parse-tbl-bb-pg \
ksym-vanilla-rtw-parse-tbl-phy-cond \
ksym-vanilla-rtw-parse-tbl-txpwr-lmt \
ksym-vanilla-rtw-pci-err-handler \
ksym-vanilla-rtw-pci-probe \
ksym-vanilla-rtw-pci-remove \
ksym-vanilla-rtw-pci-shutdown \
ksym-vanilla-rtw-phy-cfg-agc \
ksym-vanilla-rtw-phy-cfg-bb \
ksym-vanilla-rtw-phy-cfg-mac \
ksym-vanilla-rtw-phy-cfg-rf \
ksym-vanilla-rtw-phy-config-swing-table \
ksym-vanilla-rtw-phy-get-tx-power-index \
ksym-vanilla-rtw-phy-init \
ksym-vanilla-rtw-phy-load-tables \
ksym-vanilla-rtw-phy-parsing-cfo \
ksym-vanilla-rtw-phy-pwrtrack-avg \
ksym-vanilla-rtw-phy-pwrtrack-get-delta \
ksym-vanilla-rtw-phy-pwrtrack-get-pwridx \
ksym-vanilla-rtw-phy-pwrtrack-need-iqk \
ksym-vanilla-rtw-phy-pwrtrack-need-lck \
ksym-vanilla-rtw-phy-pwrtrack-thermal-changed \
ksym-vanilla-rtw-phy-read-rf \
ksym-vanilla-rtw-phy-read-rf-sipi \
ksym-vanilla-rtw-phy-rf-power-2-rssi \
ksym-vanilla-rtw-phy-set-edcca-th \
ksym-vanilla-rtw-phy-set-tx-power-level \
ksym-vanilla-rtw-phy-write-rf-reg-mix \
ksym-vanilla-rtw-phy-write-rf-reg-sipi \
ksym-vanilla-rtw-pm-ops \
ksym-vanilla-rtw-power-mode-change \
ksym-vanilla-rtw-power-off \
ksym-vanilla-rtw-power-on \
ksym-vanilla-rtw-pwr-seq-parser \
ksym-vanilla-rtw-rate-section \
ksym-vanilla-rtw-rate-size \
ksym-vanilla-rtw-read8-physical-efuse \
ksym-vanilla-rtw-regd-get \
ksym-vanilla-rtw-regd-srrc \
ksym-vanilla-rtw-register-hw \
ksym-vanilla-rtw-restore-reg \
ksym-vanilla-rtw-rx-query-rx-desc \
ksym-vanilla-rtw-rx-stats \
ksym-vanilla-rtw-sdio-pm-ops \
ksym-vanilla-rtw-sdio-probe \
ksym-vanilla-rtw-sdio-remove \
ksym-vanilla-rtw-sdio-shutdown \
ksym-vanilla-rtw-set-channel-mac \
ksym-vanilla-rtw-set-rx-freq-band \
ksym-vanilla-rtw-set-trx-fifo-info \
ksym-vanilla-rtw-tx-ac-to-hwq \
ksym-vanilla-rtw-tx-fill-tx-desc \
ksym-vanilla-rtw-tx-queue-mapping \
ksym-vanilla-rtw-tx-report-enqueue \
ksym-vanilla-rtw-tx-write-data-h2c-get \
ksym-vanilla-rtw-tx-write-data-rsvd-page-get \
ksym-vanilla-rtw-unregister-hw \
ksym-vanilla-rtw-update-rx-freq-from-ie \
ksym-vanilla-rtw-usb-disconnect \
ksym-vanilla-rtw-usb-probe \
ksym-vanilla-rtw-wait-firmware-completion \
ksym-vanilla-rtw-write-firmware-page \
ksym-vanilla-rtw8703b-hw-spec \
ksym-vanilla-rtw8723d-hw-spec \
ksym-vanilla-rtw8723x-common \
ksym-vanilla-rtw8812a-hw-spec \
ksym-vanilla-rtw8814a-hw-spec \
ksym-vanilla-rtw8821a-hw-spec \
ksym-vanilla-rtw8821c-hw-spec \
ksym-vanilla-rtw8822b-hw-spec \
ksym-vanilla-rtw8822c-hw-spec \
ksym-vanilla-rtw8851b-chip-info \
ksym-vanilla-rtw8852a-chip-info \
ksym-vanilla-rtw8852b-chip-info \
ksym-vanilla-rtw8852bt-chip-info \
ksym-vanilla-rtw8852bx-info \
ksym-vanilla-rtw8852c-chip-info \
ksym-vanilla-rtw88xxa-efuse-grant \
ksym-vanilla-rtw88xxa-false-alarm-statistics \
ksym-vanilla-rtw88xxa-iqk-backup-afe \
ksym-vanilla-rtw88xxa-iqk-backup-mac-bb \
ksym-vanilla-rtw88xxa-iqk-configure-mac \
ksym-vanilla-rtw88xxa-iqk-finish \
ksym-vanilla-rtw88xxa-iqk-restore-mac-bb \
ksym-vanilla-rtw88xxa-phy-cck-pd-set \
ksym-vanilla-rtw88xxa-phy-pwrtrack \
ksym-vanilla-rtw88xxa-phy-read-rf \
ksym-vanilla-rtw88xxa-power-off \
ksym-vanilla-rtw88xxa-power-on \
ksym-vanilla-rtw88xxa-query-phy-status \
ksym-vanilla-rtw88xxa-read-efuse \
ksym-vanilla-rtw88xxa-set-channel \
ksym-vanilla-rtw88xxa-set-tx-power-index \
ksym-vanilla-rtw89-alloc-ieee80211-hw \
ksym-vanilla-rtw89-bd-ram-table-dual \
ksym-vanilla-rtw89-bd-ram-table-single \
ksym-vanilla-rtw89-btc-ntfy-conn-rfk \
ksym-vanilla-rtw89-btc-ntfy-preserve-bt-time \
ksym-vanilla-rtw89-btc-ntfy-wl-rfk \
ksym-vanilla-rtw89-btc-set-policy \
ksym-vanilla-rtw89-btc-set-policy-v1 \
ksym-vanilla-rtw89-check-quirks \
ksym-vanilla-rtw89-chip-info-setup \
ksym-vanilla-rtw89-core-deinit \
ksym-vanilla-rtw89-core-fill-txdesc \
ksym-vanilla-rtw89-core-fill-txdesc-fwcmd-v1 \
ksym-vanilla-rtw89-core-fill-txdesc-fwcmd-v2 \
ksym-vanilla-rtw89-core-fill-txdesc-v1 \
ksym-vanilla-rtw89-core-fill-txdesc-v2 \
ksym-vanilla-rtw89-core-fill-txdesc-v3 \
ksym-vanilla-rtw89-core-get-ch-dma \
ksym-vanilla-rtw89-core-get-ch-dma-v1 \
ksym-vanilla-rtw89-core-get-ch-dma-v2 \
ksym-vanilla-rtw89-core-init \
ksym-vanilla-rtw89-core-napi-deinit \
ksym-vanilla-rtw89-core-napi-init \
ksym-vanilla-rtw89-core-napi-start \
ksym-vanilla-rtw89-core-napi-stop \
ksym-vanilla-rtw89-core-query-rxdesc \
ksym-vanilla-rtw89-core-query-rxdesc-v2 \
ksym-vanilla-rtw89-core-query-rxdesc-v3 \
ksym-vanilla-rtw89-core-register \
ksym-vanilla-rtw89-core-rx \
ksym-vanilla-rtw89-core-unregister \
ksym-vanilla-rtw89-db-quarter-to-linear \
ksym-vanilla-rtw89-db-to-linear \
ksym-vanilla-rtw89-decode-chan-idx \
ksym-vanilla-rtw89-efuse-read-ecv-be \
ksym-vanilla-rtw89-encode-chan-idx \
ksym-vanilla-rtw89-entity-get-conf \
ksym-vanilla-rtw89-free-ieee80211-hw \
ksym-vanilla-rtw89-fw-blacklist-default \
ksym-vanilla-rtw89-fw-h2c-ampdu-cmac-tbl-be \
ksym-vanilla-rtw89-fw-h2c-ampdu-cmac-tbl-g7 \
ksym-vanilla-rtw89-fw-h2c-assoc-cmac-tbl \
ksym-vanilla-rtw89-fw-h2c-assoc-cmac-tbl-be \
ksym-vanilla-rtw89-fw-h2c-assoc-cmac-tbl-g7 \
ksym-vanilla-rtw89-fw-h2c-ba-cam \
ksym-vanilla-rtw89-fw-h2c-ba-cam-v1 \
ksym-vanilla-rtw89-fw-h2c-dctl-sec-cam-v1 \
ksym-vanilla-rtw89-fw-h2c-dctl-sec-cam-v2 \
ksym-vanilla-rtw89-fw-h2c-dctl-sec-cam-v3 \
ksym-vanilla-rtw89-fw-h2c-default-cmac-tbl \
ksym-vanilla-rtw89-fw-h2c-default-cmac-tbl-be \
ksym-vanilla-rtw89-fw-h2c-default-cmac-tbl-g7 \
ksym-vanilla-rtw89-fw-h2c-default-dmac-tbl-v2 \
ksym-vanilla-rtw89-fw-h2c-default-dmac-tbl-v3 \
ksym-vanilla-rtw89-fw-h2c-punctured-cmac-tbl-be \
ksym-vanilla-rtw89-fw-h2c-punctured-cmac-tbl-g7 \
ksym-vanilla-rtw89-fw-h2c-rf-ntfy-mcc \
ksym-vanilla-rtw89-fw-h2c-rf-ps-info \
ksym-vanilla-rtw89-fw-h2c-txtime-cmac-tbl \
ksym-vanilla-rtw89-fw-h2c-txtime-cmac-tbl-be \
ksym-vanilla-rtw89-fw-h2c-txtime-cmac-tbl-g7 \
ksym-vanilla-rtw89-fw-h2c-update-beacon \
ksym-vanilla-rtw89-fw-h2c-update-beacon-be \
ksym-vanilla-rtw89-fw-h2c-wow-cam-update \
ksym-vanilla-rtw89-fw-h2c-wow-cam-update-v1 \
ksym-vanilla-rtw89-linear-to-db \
ksym-vanilla-rtw89-linear-to-db-quarter \
ksym-vanilla-rtw89-mac-cfg-ctrl-path \
ksym-vanilla-rtw89-mac-cfg-ctrl-path-v1 \
ksym-vanilla-rtw89-mac-cfg-ctrl-path-v2 \
ksym-vanilla-rtw89-mac-cfg-gnt \
ksym-vanilla-rtw89-mac-cfg-gnt-v1 \
ksym-vanilla-rtw89-mac-cfg-gnt-v2 \
ksym-vanilla-rtw89-mac-cfg-gnt-v3 \
ksym-vanilla-rtw89-mac-cfg-phy-rpt-be \
ksym-vanilla-rtw89-mac-coex-init \
ksym-vanilla-rtw89-mac-coex-init-v1 \
ksym-vanilla-rtw89-mac-disable-bb-rf \
ksym-vanilla-rtw89-mac-enable-bb-rf \
ksym-vanilla-rtw89-mac-gen-ax \
ksym-vanilla-rtw89-mac-gen-be \
ksym-vanilla-rtw89-mac-get-err-status \
ksym-vanilla-rtw89-mac-resume-sch-tx \
ksym-vanilla-rtw89-mac-resume-sch-tx-v1 \
ksym-vanilla-rtw89-mac-resume-sch-tx-v2 \
ksym-vanilla-rtw89-mac-set-err-status \
ksym-vanilla-rtw89-mac-size \
ksym-vanilla-rtw89-mac-stop-sch-tx \
ksym-vanilla-rtw89-mac-stop-sch-tx-v1 \
ksym-vanilla-rtw89-mac-stop-sch-tx-v2 \
ksym-vanilla-rtw89-ops \
ksym-vanilla-rtw89-pci-ch-dma-addr-set \
ksym-vanilla-rtw89-pci-ch-dma-addr-set-be \
ksym-vanilla-rtw89-pci-ch-dma-addr-set-be-v1 \
ksym-vanilla-rtw89-pci-ch-dma-addr-set-v1 \
ksym-vanilla-rtw89-pci-config-intr-mask \
ksym-vanilla-rtw89-pci-config-intr-mask-v1 \
ksym-vanilla-rtw89-pci-config-intr-mask-v2 \
ksym-vanilla-rtw89-pci-config-intr-mask-v3 \
ksym-vanilla-rtw89-pci-disable-intr \
ksym-vanilla-rtw89-pci-disable-intr-v1 \
ksym-vanilla-rtw89-pci-disable-intr-v2 \
ksym-vanilla-rtw89-pci-disable-intr-v3 \
ksym-vanilla-rtw89-pci-enable-intr \
ksym-vanilla-rtw89-pci-enable-intr-v1 \
ksym-vanilla-rtw89-pci-enable-intr-v2 \
ksym-vanilla-rtw89-pci-enable-intr-v3 \
ksym-vanilla-rtw89-pci-err-handler \
ksym-vanilla-rtw89-pci-fill-txaddr-info \
ksym-vanilla-rtw89-pci-fill-txaddr-info-v1 \
ksym-vanilla-rtw89-pci-gen-ax \
ksym-vanilla-rtw89-pci-gen-be \
ksym-vanilla-rtw89-pci-isr-ax \
ksym-vanilla-rtw89-pci-isr-be \
ksym-vanilla-rtw89-pci-isr-be-v1 \
ksym-vanilla-rtw89-pci-ltr-set \
ksym-vanilla-rtw89-pci-ltr-set-v1 \
ksym-vanilla-rtw89-pci-ltr-set-v2 \
ksym-vanilla-rtw89-pci-parse-rpp \
ksym-vanilla-rtw89-pci-parse-rpp-v1 \
ksym-vanilla-rtw89-pci-probe \
ksym-vanilla-rtw89-pci-recognize-intrs \
ksym-vanilla-rtw89-pci-recognize-intrs-v1 \
ksym-vanilla-rtw89-pci-recognize-intrs-v2 \
ksym-vanilla-rtw89-pci-recognize-intrs-v3 \
ksym-vanilla-rtw89-pci-remove \
ksym-vanilla-rtw89-pci-shutdown \
ksym-vanilla-rtw89-phy-ant-gain-pwr-offset \
ksym-vanilla-rtw89-phy-bb-wrap-set-rfsi-bandedge-ch \
ksym-vanilla-rtw89-phy-bb-wrap-set-rfsi-ct-opt \
ksym-vanilla-rtw89-phy-config-rf-reg-v1 \
ksym-vanilla-rtw89-phy-gen-ax \
ksym-vanilla-rtw89-phy-gen-be \
ksym-vanilla-rtw89-phy-gen-be-v1 \
ksym-vanilla-rtw89-phy-get-kpath \
ksym-vanilla-rtw89-phy-get-syn-sel \
ksym-vanilla-rtw89-phy-get-txsb \
ksym-vanilla-rtw89-phy-get-txsc \
ksym-vanilla-rtw89-phy-load-txpwr-byrate \
ksym-vanilla-rtw89-phy-read-rf \
ksym-vanilla-rtw89-phy-read-rf-v1 \
ksym-vanilla-rtw89-phy-read-rf-v2 \
ksym-vanilla-rtw89-phy-read-rf-v3 \
ksym-vanilla-rtw89-phy-read-txpwr-limit \
ksym-vanilla-rtw89-phy-read32-idx \
ksym-vanilla-rtw89-phy-rfk-cim3k-and-wait \
ksym-vanilla-rtw89-phy-rfk-dack-and-wait \
ksym-vanilla-rtw89-phy-rfk-dpk-and-wait \
ksym-vanilla-rtw89-phy-rfk-iqk-and-wait \
ksym-vanilla-rtw89-phy-rfk-pre-ntfy-and-wait \
ksym-vanilla-rtw89-phy-rfk-rxdck-and-wait \
ksym-vanilla-rtw89-phy-rfk-tssi-and-wait \
ksym-vanilla-rtw89-phy-rfk-txgapk-and-wait \
ksym-vanilla-rtw89-phy-rfk-txiqk-and-wait \
ksym-vanilla-rtw89-phy-set-phy-regs \
ksym-vanilla-rtw89-phy-tssi-ctrl-set-bandedge-cfg \
ksym-vanilla-rtw89-phy-write-reg3-tbl \
ksym-vanilla-rtw89-phy-write-rf \
ksym-vanilla-rtw89-phy-write-rf-v1 \
ksym-vanilla-rtw89-phy-write-rf-v2 \
ksym-vanilla-rtw89-phy-write-rf-v3 \
ksym-vanilla-rtw89-phy-write32-idx \
ksym-vanilla-rtw89-phy-write32-idx-clr \
ksym-vanilla-rtw89-phy-write32-idx-set \
ksym-vanilla-rtw89-pm-ops \
ksym-vanilla-rtw89-pm-ops-be \
ksym-vanilla-rtw89-query-sar \
ksym-vanilla-rtw89-read-efuse-ver \
ksym-vanilla-rtw89-rfk-chan-lookup \
ksym-vanilla-rtw89-rfk-parser \
ksym-vanilla-rtw89-ser-notify \
ksym-vanilla-rtw89-tas-chanctx-cb \
ksym-vanilla-rtw89-usb-disconnect \
ksym-vanilla-rtw89-usb-probe \
ksym-vanilla-rtw8922a-chip-info \
ksym-vanilla-rtw8922ae-vs-variant \
ksym-vanilla-run-dax \
ksym-vanilla-rvu-mbox-handler-npa-cn20k-aq-enq \
ksym-vanilla-rw-verify-area \
ksym-vanilla-rxgk-kernel-query-challenge \
ksym-vanilla-rxgk-kernel-respond-to-challenge \
ksym-vanilla-rxkad-kernel-respond-to-challenge \
ksym-vanilla-rxrpc-debug-id \
ksym-vanilla-rxrpc-get-null-key \
ksym-vanilla-rxrpc-get-server-data-key \
ksym-vanilla-rxrpc-kernel-abort-call \
ksym-vanilla-rxrpc-kernel-begin-call \
ksym-vanilla-rxrpc-kernel-charge-accept \
ksym-vanilla-rxrpc-kernel-check-life \
ksym-vanilla-rxrpc-kernel-dequeue-oob \
ksym-vanilla-rxrpc-kernel-free-oob \
ksym-vanilla-rxrpc-kernel-get-call-peer \
ksym-vanilla-rxrpc-kernel-get-peer \
ksym-vanilla-rxrpc-kernel-get-peer-data \
ksym-vanilla-rxrpc-kernel-get-srtt \
ksym-vanilla-rxrpc-kernel-lookup-peer \
ksym-vanilla-rxrpc-kernel-put-call \
ksym-vanilla-rxrpc-kernel-put-peer \
ksym-vanilla-rxrpc-kernel-query-call-security \
ksym-vanilla-rxrpc-kernel-query-challenge \
ksym-vanilla-rxrpc-kernel-query-oob \
ksym-vanilla-rxrpc-kernel-recv-data \
ksym-vanilla-rxrpc-kernel-reject-challenge \
ksym-vanilla-rxrpc-kernel-remote-addr \
ksym-vanilla-rxrpc-kernel-remote-srx \
ksym-vanilla-rxrpc-kernel-send-data \
ksym-vanilla-rxrpc-kernel-set-notifications \
ksym-vanilla-rxrpc-kernel-set-peer-data \
ksym-vanilla-rxrpc-kernel-set-tx-length \
ksym-vanilla-rxrpc-kernel-shutdown-call \
ksym-vanilla-rxrpc-sock-set-manage-response \
ksym-vanilla-rxrpc-sock-set-min-security-level \
ksym-vanilla-rxrpc-sock-set-security-keyring \
ksym-vanilla-rzg2l-cpg-dsi-div-set-divider \
ksym-vanilla-rzt2h-icu-register-dma-req \
ksym-vanilla-rzv2h-get-pll-divs-pars \
ksym-vanilla-rzv2h-get-pll-pars \
ksym-vanilla-rzv2h-icu-register-dma-ack \
ksym-vanilla-rzv2h-icu-register-dma-req \
ksym-vanilla-rzv2m-usb3drd-reset \
ksym-vanilla-s2idle-wake \
ksym-vanilla-s3fwrn5-phy-get-mode \
ksym-vanilla-s3fwrn5-phy-power-ctrl \
ksym-vanilla-s3fwrn5-phy-set-mode \
ksym-vanilla-s3fwrn5-phy-set-wake \
ksym-vanilla-s3fwrn5-probe \
ksym-vanilla-s3fwrn5-recv-frame \
ksym-vanilla-s3fwrn5-remove \
ksym-vanilla-s5h1409-attach \
ksym-vanilla-s5h1411-attach \
ksym-vanilla-s5h1420-attach \
ksym-vanilla-s5h1420-get-tuner-i2c-adapter \
ksym-vanilla-s5h1432-attach \
ksym-vanilla-s6e63m0-probe \
ksym-vanilla-s6e63m0-remove \
ksym-vanilla-s921-attach \
ksym-vanilla-sa1100-rtc-init \
ksym-vanilla-saa-dsp-writel \
ksym-vanilla-saa7134-boards \
ksym-vanilla-saa7134-devlist \
ksym-vanilla-saa7134-devlist-lock \
ksym-vanilla-saa7134-dmasound-exit \
ksym-vanilla-saa7134-dmasound-init \
ksym-vanilla-saa7134-enum-input \
ksym-vanilla-saa7134-g-frequency \
ksym-vanilla-saa7134-g-input \
ksym-vanilla-saa7134-g-std \
ksym-vanilla-saa7134-g-tuner \
ksym-vanilla-saa7134-pgtable-alloc \
ksym-vanilla-saa7134-pgtable-build \
ksym-vanilla-saa7134-pgtable-free \
ksym-vanilla-saa7134-querycap \
ksym-vanilla-saa7134-querystd \
ksym-vanilla-saa7134-s-frequency \
ksym-vanilla-saa7134-s-input \
ksym-vanilla-saa7134-s-std \
ksym-vanilla-saa7134-s-tuner \
ksym-vanilla-saa7134-set-dmabits \
ksym-vanilla-saa7134-set-gpio \
ksym-vanilla-saa7134-stop-streaming \
ksym-vanilla-saa7134-ts-buffer-init \
ksym-vanilla-saa7134-ts-buffer-prepare \
ksym-vanilla-saa7134-ts-qops \
ksym-vanilla-saa7134-ts-queue-setup \
ksym-vanilla-saa7134-ts-register \
ksym-vanilla-saa7134-ts-start-streaming \
ksym-vanilla-saa7134-ts-stop-streaming \
ksym-vanilla-saa7134-ts-unregister \
ksym-vanilla-saa7134-tuner-callback \
ksym-vanilla-saa7134-tvaudio-setmute \
ksym-vanilla-saa7134-vb2-buffer-queue \
ksym-vanilla-saa7146-debug \
ksym-vanilla-saa7146-i2c-adapter-prepare \
ksym-vanilla-saa7146-pgtable-alloc \
ksym-vanilla-saa7146-pgtable-build-single \
ksym-vanilla-saa7146-pgtable-free \
ksym-vanilla-saa7146-register-device \
ksym-vanilla-saa7146-register-extension \
ksym-vanilla-saa7146-set-hps-source-and-sync \
ksym-vanilla-saa7146-setgpio \
ksym-vanilla-saa7146-unregister-device \
ksym-vanilla-saa7146-unregister-extension \
ksym-vanilla-saa7146-vfree-destroy-pgtable \
ksym-vanilla-saa7146-vmalloc-build-pgtable \
ksym-vanilla-saa7146-vv-init \
ksym-vanilla-saa7146-vv-release \
ksym-vanilla-saa7146-wait-for-debi-done \
ksym-vanilla-safe-candev-priv \
ksym-vanilla-sampling-rate-store \
ksym-vanilla-samsung-asoc-dma-platform-register \
ksym-vanilla-samsung-sdi-battery-get-info \
ksym-vanilla-san-client-link \
ksym-vanilla-san-dgpu-notifier-register \
ksym-vanilla-san-dgpu-notifier-unregister \
ksym-vanilla-sas-abort-task \
ksym-vanilla-sas-abort-task-set \
ksym-vanilla-sas-ata-device-link-abort \
ksym-vanilla-sas-ata-ncq-prio-supported \
ksym-vanilla-sas-ata-schedule-reset \
ksym-vanilla-sas-ata-sdev-attr-group \
ksym-vanilla-sas-attach-transport \
ksym-vanilla-sas-bios-param \
ksym-vanilla-sas-change-queue-depth \
ksym-vanilla-sas-clear-task-set \
ksym-vanilla-sas-disable-tlr \
ksym-vanilla-sas-domain-attach-transport \
ksym-vanilla-sas-drain-work \
ksym-vanilla-sas-eh-abort-handler \
ksym-vanilla-sas-eh-device-reset-handler \
ksym-vanilla-sas-eh-target-reset-handler \
ksym-vanilla-sas-eh-timed-out \
ksym-vanilla-sas-enable-tlr \
ksym-vanilla-sas-end-device-alloc \
ksym-vanilla-sas-execute-ata-cmd \
ksym-vanilla-sas-execute-internal-abort-dev \
ksym-vanilla-sas-execute-internal-abort-single \
ksym-vanilla-sas-expander-alloc \
ksym-vanilla-sas-find-attached-phy-id \
ksym-vanilla-sas-get-address \
ksym-vanilla-sas-get-local-phy \
ksym-vanilla-sas-ioctl \
ksym-vanilla-sas-is-tlr-enabled \
ksym-vanilla-sas-lu-reset \
ksym-vanilla-sas-notify-phy-event \
ksym-vanilla-sas-notify-port-event \
ksym-vanilla-sas-phy-add \
ksym-vanilla-sas-phy-alloc \
ksym-vanilla-sas-phy-delete \
ksym-vanilla-sas-phy-enable \
ksym-vanilla-sas-phy-free \
ksym-vanilla-sas-phy-reset \
ksym-vanilla-sas-port-add \
ksym-vanilla-sas-port-add-phy \
ksym-vanilla-sas-port-alloc \
ksym-vanilla-sas-port-alloc-num \
ksym-vanilla-sas-port-delete \
ksym-vanilla-sas-port-delete-phy \
ksym-vanilla-sas-port-free \
ksym-vanilla-sas-port-get-phy \
ksym-vanilla-sas-port-mark-backlink \
ksym-vanilla-sas-prep-resume-ha \
ksym-vanilla-sas-query-task \
ksym-vanilla-sas-queuecommand \
ksym-vanilla-sas-read-port-mode-page \
ksym-vanilla-sas-register-ha \
ksym-vanilla-sas-release-transport \
ksym-vanilla-sas-remove-children \
ksym-vanilla-sas-remove-host \
ksym-vanilla-sas-request-addr \
ksym-vanilla-sas-resume-ha \
ksym-vanilla-sas-rphy-add \
ksym-vanilla-sas-rphy-delete \
ksym-vanilla-sas-rphy-free \
ksym-vanilla-sas-rphy-remove \
ksym-vanilla-sas-rphy-unlink \
ksym-vanilla-sas-sdev-configure \
ksym-vanilla-sas-sdev-init \
ksym-vanilla-sas-ssp-task-response \
ksym-vanilla-sas-suspend-ha \
ksym-vanilla-sas-target-alloc \
ksym-vanilla-sas-target-destroy \
ksym-vanilla-sas-task-abort \
ksym-vanilla-sas-tlr-supported \
ksym-vanilla-sas-unregister-ha \
ksym-vanilla-sata-async-notification \
ksym-vanilla-sata-deb-timing-hotplug \
ksym-vanilla-sata-deb-timing-long \
ksym-vanilla-sata-deb-timing-normal \
ksym-vanilla-sata-link-debounce \
ksym-vanilla-sata-link-hardreset \
ksym-vanilla-sata-link-resume \
ksym-vanilla-sata-link-scr-lpm \
ksym-vanilla-sata-lpm-ignore-phy-events \
ksym-vanilla-sata-pmp-error-handler \
ksym-vanilla-sata-pmp-port-ops \
ksym-vanilla-sata-pmp-qc-defer-cmd-switch \
ksym-vanilla-sata-port-ops \
ksym-vanilla-sata-scr-read \
ksym-vanilla-sata-scr-valid \
ksym-vanilla-sata-scr-write \
ksym-vanilla-sata-scr-write-flush \
ksym-vanilla-sata-set-spd \
ksym-vanilla-sata-sff-hardreset \
ksym-vanilla-sata-std-hardreset \
ksym-vanilla-sb-init-dio-done-wq \
ksym-vanilla-sb-min-blocksize \
ksym-vanilla-sb-set-blocksize \
ksym-vanilla-sb800-prefetch \
ksym-vanilla-sbc-attrib-attrs \
ksym-vanilla-sbc-dif-copy-prot \
ksym-vanilla-sbc-dif-verify \
ksym-vanilla-sbc-get-device-type \
ksym-vanilla-sbc-get-write-same-sectors \
ksym-vanilla-sbc-parse-cdb \
ksym-vanilla-sbitmap-add-wait-queue \
ksym-vanilla-sbitmap-any-bit-set \
ksym-vanilla-sbitmap-bitmap-show \
ksym-vanilla-sbitmap-del-wait-queue \
ksym-vanilla-sbitmap-finish-wait \
ksym-vanilla-sbitmap-get \
ksym-vanilla-sbitmap-init-node \
ksym-vanilla-sbitmap-prepare-to-wait \
ksym-vanilla-sbitmap-queue-clear \
ksym-vanilla-sbitmap-queue-get-shallow \
ksym-vanilla-sbitmap-queue-init-node \
ksym-vanilla-sbitmap-queue-min-shallow-depth \
ksym-vanilla-sbitmap-queue-recalculate-wake-batch \
ksym-vanilla-sbitmap-queue-resize \
ksym-vanilla-sbitmap-queue-show \
ksym-vanilla-sbitmap-queue-wake-all \
ksym-vanilla-sbitmap-queue-wake-up \
ksym-vanilla-sbitmap-resize \
ksym-vanilla-sbitmap-show \
ksym-vanilla-sbitmap-weight \
ksym-vanilla-sc16is74x-devtype \
ksym-vanilla-sc16is750-devtype \
ksym-vanilla-sc16is752-devtype \
ksym-vanilla-sc16is760-devtype \
ksym-vanilla-sc16is762-devtype \
ksym-vanilla-sc16is7xx-dt-ids \
ksym-vanilla-sc16is7xx-probe \
ksym-vanilla-sc16is7xx-regcfg \
ksym-vanilla-sc16is7xx-regmap-name \
ksym-vanilla-sc16is7xx-regmap-port-mask \
ksym-vanilla-sc16is7xx-remove \
ksym-vanilla-scatterwalk-ffwd \
ksym-vanilla-scatterwalk-skip \
ksym-vanilla-scd30-pm-ops \
ksym-vanilla-scd30-probe \
ksym-vanilla-sch-default-prio2band \
ksym-vanilla-sch-frag-xmit-hook \
ksym-vanilla-sch56xx-read-virtual-reg \
ksym-vanilla-sch56xx-read-virtual-reg12 \
ksym-vanilla-sch56xx-read-virtual-reg16 \
ksym-vanilla-sch56xx-regmap-read16 \
ksym-vanilla-sch56xx-regmap-write16 \
ksym-vanilla-sch56xx-watchdog-register \
ksym-vanilla-sch56xx-write-virtual-reg \
ksym-vanilla-sched-clock \
ksym-vanilla-sched-clock-register \
ksym-vanilla-sched-numa-find-nth-cpu \
ksym-vanilla-sched-numa-hop-mask \
ksym-vanilla-sched-set-fifo \
ksym-vanilla-sched-set-fifo-low \
ksym-vanilla-sched-set-normal \
ksym-vanilla-sched-setattr-nocheck \
ksym-vanilla-sched-show-task \
ksym-vanilla-sched-smt-present \
ksym-vanilla-schedule \
ksym-vanilla-schedule-cxl-memdev-detach \
ksym-vanilla-schedule-hrtimeout \
ksym-vanilla-schedule-hrtimeout-range \
ksym-vanilla-schedule-hrtimeout-range-clock \
ksym-vanilla-schedule-timeout \
ksym-vanilla-schedule-timeout-idle \
ksym-vanilla-schedule-timeout-interruptible \
ksym-vanilla-schedule-timeout-killable \
ksym-vanilla-schedule-timeout-uninterruptible \
ksym-vanilla-sci-config-port \
ksym-vanilla-sci-pm \
ksym-vanilla-sci-port-disable \
ksym-vanilla-sci-port-enable \
ksym-vanilla-sci-release-port \
ksym-vanilla-sci-request-port \
ksym-vanilla-sci-scbrr-calc \
ksym-vanilla-sci-shutdown \
ksym-vanilla-sci-startup \
ksym-vanilla-sci-verify-port \
ksym-vanilla-scm-detach-fds \
ksym-vanilla-scm-fp-dup \
ksym-vanilla-scm-recv \
ksym-vanilla-scmd-printk \
ksym-vanilla-scmi-bus-type \
ksym-vanilla-scmi-device-create \
ksym-vanilla-scmi-device-destroy \
ksym-vanilla-scmi-driver-register \
ksym-vanilla-scmi-driver-unregister \
ksym-vanilla-scmi-imx-cpu-reset-vector-set \
ksym-vanilla-scmi-imx-cpu-start \
ksym-vanilla-scmi-imx-cpu-started \
ksym-vanilla-scmi-imx-lmm-info \
ksym-vanilla-scmi-imx-lmm-operation \
ksym-vanilla-scmi-imx-lmm-reset-vector-set \
ksym-vanilla-scmi-imx-misc-ctrl-get \
ksym-vanilla-scmi-imx-misc-ctrl-set \
ksym-vanilla-scmi-protocol-register \
ksym-vanilla-scmi-protocol-unregister \
ksym-vanilla-scmi-requested-devices-nh \
ksym-vanilla-scnprintf \
ksym-vanilla-scp-get \
ksym-vanilla-scp-get-device \
ksym-vanilla-scp-get-rproc \
ksym-vanilla-scp-get-vdec-hw-capa \
ksym-vanilla-scp-get-venc-hw-capa \
ksym-vanilla-scp-ipi-lock \
ksym-vanilla-scp-ipi-register \
ksym-vanilla-scp-ipi-send \
ksym-vanilla-scp-ipi-unlock \
ksym-vanilla-scp-ipi-unregister \
ksym-vanilla-scp-mapping-dm-addr \
ksym-vanilla-scp-memcpy-aligned \
ksym-vanilla-scp-put \
ksym-vanilla-screen-glyph \
ksym-vanilla-screen-glyph-unicode \
ksym-vanilla-screen-info-pci-dev \
ksym-vanilla-screen-info-pixel-format \
ksym-vanilla-screen-info-resources \
ksym-vanilla-screen-pos \
ksym-vanilla-scsi-add-device \
ksym-vanilla-scsi-add-host-with-dma \
ksym-vanilla-scsi-alloc-request \
ksym-vanilla-scsi-alloc-sgtables \
ksym-vanilla-scsi-autopm-get-device \
ksym-vanilla-scsi-autopm-put-device \
ksym-vanilla-scsi-bios-ptable \
ksym-vanilla-scsi-block-requests \
ksym-vanilla-scsi-block-targets \
ksym-vanilla-scsi-block-when-processing-errors \
ksym-vanilla-scsi-build-sense \
ksym-vanilla-scsi-build-sense-buffer \
ksym-vanilla-scsi-change-queue-depth \
ksym-vanilla-scsi-check-sense \
ksym-vanilla-scsi-cmd-allowed \
ksym-vanilla-scsi-command-normalize-sense \
ksym-vanilla-scsi-command-size-tbl \
ksym-vanilla-scsi-dev-info-add-list \
ksym-vanilla-scsi-dev-info-list-add-keyed \
ksym-vanilla-scsi-dev-info-remove-list \
ksym-vanilla-scsi-device-get \
ksym-vanilla-scsi-device-lookup \
ksym-vanilla-scsi-device-lookup-by-target \
ksym-vanilla-scsi-device-put \
ksym-vanilla-scsi-device-quiesce \
ksym-vanilla-scsi-device-resume \
ksym-vanilla-scsi-device-set-state \
ksym-vanilla-scsi-device-type \
ksym-vanilla-scsi-dh-activate \
ksym-vanilla-scsi-dh-attach \
ksym-vanilla-scsi-dh-attached-handler-name \
ksym-vanilla-scsi-dh-set-params \
ksym-vanilla-scsi-dma-map \
ksym-vanilla-scsi-dma-unmap \
ksym-vanilla-scsi-done \
ksym-vanilla-scsi-done-direct \
ksym-vanilla-scsi-eh-finish-cmd \
ksym-vanilla-scsi-eh-flush-done-q \
ksym-vanilla-scsi-eh-get-sense \
ksym-vanilla-scsi-eh-prep-cmnd \
ksym-vanilla-scsi-eh-ready-devs \
ksym-vanilla-scsi-eh-restore-cmnd \
ksym-vanilla-scsi-esp-cmd \
ksym-vanilla-scsi-esp-intr \
ksym-vanilla-scsi-esp-register \
ksym-vanilla-scsi-esp-template \
ksym-vanilla-scsi-esp-unregister \
ksym-vanilla-scsi-execute-cmd \
ksym-vanilla-scsi-extd-sense-format \
ksym-vanilla-scsi-failures-reset-retries \
ksym-vanilla-scsi-flush-work \
ksym-vanilla-scsi-free-sgtables \
ksym-vanilla-scsi-get-device-flags-keyed \
ksym-vanilla-scsi-get-internal-cmd \
ksym-vanilla-scsi-get-sense-info-fld \
ksym-vanilla-scsi-get-vpd-page \
ksym-vanilla-scsi-host-alloc \
ksym-vanilla-scsi-host-block \
ksym-vanilla-scsi-host-busy \
ksym-vanilla-scsi-host-busy-iter \
ksym-vanilla-scsi-host-complete-all-commands \
ksym-vanilla-scsi-host-get \
ksym-vanilla-scsi-host-lookup \
ksym-vanilla-scsi-host-put \
ksym-vanilla-scsi-host-unblock \
ksym-vanilla-scsi-hostbyte-string \
ksym-vanilla-scsi-init-limits \
ksym-vanilla-scsi-internal-device-block-nowait \
ksym-vanilla-scsi-internal-device-unblock-nowait \
ksym-vanilla-scsi-ioctl \
ksym-vanilla-scsi-ioctl-block-when-processing-errors \
ksym-vanilla-scsi-is-fc-rport \
ksym-vanilla-scsi-is-host-device \
ksym-vanilla-scsi-is-sas-phy \
ksym-vanilla-scsi-is-sas-port \
ksym-vanilla-scsi-is-sas-rphy \
ksym-vanilla-scsi-is-sdev-device \
ksym-vanilla-scsi-is-target-device \
ksym-vanilla-scsi-kmap-atomic-sg \
ksym-vanilla-scsi-kunmap-atomic-sg \
ksym-vanilla-scsi-logging-level \
ksym-vanilla-scsi-mlreturn-string \
ksym-vanilla-scsi-mode-select \
ksym-vanilla-scsi-mode-sense \
ksym-vanilla-scsi-nl-sock \
ksym-vanilla-scsi-normalize-sense \
ksym-vanilla-scsi-partsize \
ksym-vanilla-scsi-pr-type-to-block \
ksym-vanilla-scsi-print-command \
ksym-vanilla-scsi-print-result \
ksym-vanilla-scsi-print-sense \
ksym-vanilla-scsi-print-sense-hdr \
ksym-vanilla-scsi-put-internal-cmd \
ksym-vanilla-scsi-queue-work \
ksym-vanilla-scsi-register-device-handler \
ksym-vanilla-scsi-register-interface \
ksym-vanilla-scsi-remove-device \
ksym-vanilla-scsi-remove-host \
ksym-vanilla-scsi-remove-target \
ksym-vanilla-scsi-report-bus-reset \
ksym-vanilla-scsi-report-device-reset \
ksym-vanilla-scsi-report-opcode \
ksym-vanilla-scsi-rescan-device \
ksym-vanilla-scsi-resume-device \
ksym-vanilla-scsi-sanitize-inquiry-string \
ksym-vanilla-scsi-scan-host \
ksym-vanilla-scsi-scan-target \
ksym-vanilla-scsi-schedule-eh \
ksym-vanilla-scsi-sense-desc-find \
ksym-vanilla-scsi-sense-key-string \
ksym-vanilla-scsi-set-medium-removal \
ksym-vanilla-scsi-set-sense-field-pointer \
ksym-vanilla-scsi-set-sense-information \
ksym-vanilla-scsi-target-quiesce \
ksym-vanilla-scsi-target-resume \
ksym-vanilla-scsi-target-unblock \
ksym-vanilla-scsi-template-proc-dir \
ksym-vanilla-scsi-test-unit-ready \
ksym-vanilla-scsi-track-queue-full \
ksym-vanilla-scsi-unblock-requests \
ksym-vanilla-scsi-unregister-device-handler \
ksym-vanilla-scsi-vpd-lun-id \
ksym-vanilla-scsi-vpd-lun-serial \
ksym-vanilla-scsi-vpd-tpg-id \
ksym-vanilla-scsicam-bios-param \
ksym-vanilla-scsilun-to-int \
ksym-vanilla-sctp-for-each-endpoint \
ksym-vanilla-sctp-get-sctp-info \
ksym-vanilla-sctp-transport-lookup-process \
ksym-vanilla-sctp-transport-traverse-process \
ksym-vanilla-sdca-add-hid-device \
ksym-vanilla-sdca-asoc-count-component \
ksym-vanilla-sdca-asoc-free-constraints \
ksym-vanilla-sdca-asoc-get-port \
ksym-vanilla-sdca-asoc-hw-params \
ksym-vanilla-sdca-asoc-pde-poll-actual-ps \
ksym-vanilla-sdca-asoc-populate-component \
ksym-vanilla-sdca-asoc-populate-controls \
ksym-vanilla-sdca-asoc-populate-dais \
ksym-vanilla-sdca-asoc-populate-dapm \
ksym-vanilla-sdca-asoc-q78-get-volsw \
ksym-vanilla-sdca-asoc-q78-put-volsw \
ksym-vanilla-sdca-asoc-set-constraints \
ksym-vanilla-sdca-control-find-range \
ksym-vanilla-sdca-dev-register-functions \
ksym-vanilla-sdca-dev-unregister-functions \
ksym-vanilla-sdca-device-quirk-match \
ksym-vanilla-sdca-fdl-alloc-state \
ksym-vanilla-sdca-fdl-free-state \
ksym-vanilla-sdca-fdl-process \
ksym-vanilla-sdca-fdl-sync \
ksym-vanilla-sdca-find-terminal-name \
ksym-vanilla-sdca-hid-process-report \
ksym-vanilla-sdca-id-find-cluster \
ksym-vanilla-sdca-irq-cleanup \
ksym-vanilla-sdca-irq-cleanup-late \
ksym-vanilla-sdca-irq-data-populate \
ksym-vanilla-sdca-irq-disable \
ksym-vanilla-sdca-irq-enable \
ksym-vanilla-sdca-irq-enable-early \
ksym-vanilla-sdca-irq-free \
ksym-vanilla-sdca-irq-populate \
ksym-vanilla-sdca-irq-populate-early \
ksym-vanilla-sdca-irq-request \
ksym-vanilla-sdca-jack-alloc-state \
ksym-vanilla-sdca-jack-free-state \
ksym-vanilla-sdca-jack-init-state \
ksym-vanilla-sdca-jack-process \
ksym-vanilla-sdca-jack-report \
ksym-vanilla-sdca-jack-set-jack \
ksym-vanilla-sdca-lookup-functions \
ksym-vanilla-sdca-lookup-interface-revision \
ksym-vanilla-sdca-lookup-swft \
ksym-vanilla-sdca-parse-function \
ksym-vanilla-sdca-regmap-count-constants \
ksym-vanilla-sdca-regmap-deferrable \
ksym-vanilla-sdca-regmap-mbq-size \
ksym-vanilla-sdca-regmap-populate-constants \
ksym-vanilla-sdca-regmap-readable \
ksym-vanilla-sdca-regmap-volatile \
ksym-vanilla-sdca-regmap-write-defaults \
ksym-vanilla-sdca-regmap-write-init \
ksym-vanilla-sdca-regmap-writeable \
ksym-vanilla-sdca-reset-function \
ksym-vanilla-sdca-selector-find-control \
ksym-vanilla-sdca-selector-find-range \
ksym-vanilla-sdca-ump-cancel-timeout \
ksym-vanilla-sdca-ump-get-owner-host \
ksym-vanilla-sdca-ump-read-message \
ksym-vanilla-sdca-ump-schedule-timeout \
ksym-vanilla-sdca-ump-set-owner-device \
ksym-vanilla-sdca-ump-write-message \
ksym-vanilla-sdev-disable-disk-events \
ksym-vanilla-sdev-enable-disk-events \
ksym-vanilla-sdev-evt-alloc \
ksym-vanilla-sdev-evt-send \
ksym-vanilla-sdev-evt-send-simple \
ksym-vanilla-sdev-prefix-printk \
ksym-vanilla-sdhci-abort-tuning \
ksym-vanilla-sdhci-add-host \
ksym-vanilla-sdhci-adma-write-desc \
ksym-vanilla-sdhci-alloc-host \
ksym-vanilla-sdhci-calc-clk \
ksym-vanilla-sdhci-cleanup-host \
ksym-vanilla-sdhci-complete-work \
ksym-vanilla-sdhci-cqe-disable \
ksym-vanilla-sdhci-cqe-enable \
ksym-vanilla-sdhci-cqe-irq \
ksym-vanilla-sdhci-data-line-cmd \
ksym-vanilla-sdhci-disable-irq-wakeups \
ksym-vanilla-sdhci-do-reset \
ksym-vanilla-sdhci-dumpregs \
ksym-vanilla-sdhci-enable-clk \
ksym-vanilla-sdhci-enable-irq-wakeups \
ksym-vanilla-sdhci-enable-preset-value \
ksym-vanilla-sdhci-enable-sdio-irq \
ksym-vanilla-sdhci-enable-v4-mode \
ksym-vanilla-sdhci-end-tuning \
ksym-vanilla-sdhci-execute-tuning \
ksym-vanilla-sdhci-finish-mrq \
ksym-vanilla-sdhci-get-cd-nogpio \
ksym-vanilla-sdhci-get-property \
ksym-vanilla-sdhci-get-ro \
ksym-vanilla-sdhci-get-vdd-value \
ksym-vanilla-sdhci-initialize-data \
ksym-vanilla-sdhci-mod-timer \
ksym-vanilla-sdhci-needs-reset \
ksym-vanilla-sdhci-pltfm-clk-get-max-clock \
ksym-vanilla-sdhci-pltfm-init \
ksym-vanilla-sdhci-pltfm-init-and-add-host \
ksym-vanilla-sdhci-pltfm-pmops \
ksym-vanilla-sdhci-pltfm-remove \
ksym-vanilla-sdhci-pltfm-resume \
ksym-vanilla-sdhci-pltfm-suspend \
ksym-vanilla-sdhci-prepare-dma \
ksym-vanilla-sdhci-present-error \
ksym-vanilla-sdhci-remove-host \
ksym-vanilla-sdhci-request \
ksym-vanilla-sdhci-request-atomic \
ksym-vanilla-sdhci-request-done-dma \
ksym-vanilla-sdhci-reset \
ksym-vanilla-sdhci-reset-tuning \
ksym-vanilla-sdhci-resume-host \
ksym-vanilla-sdhci-runtime-resume-host \
ksym-vanilla-sdhci-runtime-suspend-host \
ksym-vanilla-sdhci-send-tuning \
ksym-vanilla-sdhci-set-bus-width \
ksym-vanilla-sdhci-set-clock \
ksym-vanilla-sdhci-set-data-timeout-irq \
ksym-vanilla-sdhci-set-ios \
ksym-vanilla-sdhci-set-ios-common \
ksym-vanilla-sdhci-set-power \
ksym-vanilla-sdhci-set-power-and-bus-voltage \
ksym-vanilla-sdhci-set-power-noreg \
ksym-vanilla-sdhci-set-uhs-signaling \
ksym-vanilla-sdhci-setup-host \
ksym-vanilla-sdhci-start-signal-voltage-switch \
ksym-vanilla-sdhci-start-tuning \
ksym-vanilla-sdhci-suspend-host \
ksym-vanilla-sdhci-switch-external-dma \
ksym-vanilla-sdhci-thread-irq \
ksym-vanilla-sdhci-uhs2-add-host \
ksym-vanilla-sdhci-uhs2-clear-set-irqs \
ksym-vanilla-sdhci-uhs2-dump-regs \
ksym-vanilla-sdhci-uhs2-irq \
ksym-vanilla-sdhci-uhs2-remove-host \
ksym-vanilla-sdhci-uhs2-reset \
ksym-vanilla-sdhci-uhs2-set-power \
ksym-vanilla-sdhci-uhs2-set-timeout \
ksym-vanilla-sdio-align-size \
ksym-vanilla-sdio-claim-host \
ksym-vanilla-sdio-claim-irq \
ksym-vanilla-sdio-disable-func \
ksym-vanilla-sdio-enable-func \
ksym-vanilla-sdio-f0-readb \
ksym-vanilla-sdio-f0-writeb \
ksym-vanilla-sdio-get-host-pm-caps \
ksym-vanilla-sdio-memcpy-fromio \
ksym-vanilla-sdio-memcpy-toio \
ksym-vanilla-sdio-readb \
ksym-vanilla-sdio-readl \
ksym-vanilla-sdio-readsb \
ksym-vanilla-sdio-readw \
ksym-vanilla-sdio-release-host \
ksym-vanilla-sdio-release-irq \
ksym-vanilla-sdio-retune-crc-disable \
ksym-vanilla-sdio-retune-crc-enable \
ksym-vanilla-sdio-retune-hold-now \
ksym-vanilla-sdio-retune-release \
ksym-vanilla-sdio-set-block-size \
ksym-vanilla-sdio-set-host-pm-flags \
ksym-vanilla-sdio-signal-irq \
ksym-vanilla-sdio-unregister-driver \
ksym-vanilla-sdio-writeb \
ksym-vanilla-sdio-writeb-readb \
ksym-vanilla-sdio-writel \
ksym-vanilla-sdio-writesb \
ksym-vanilla-sdio-writew \
ksym-vanilla-sdw-alloc-stream \
ksym-vanilla-sdw-amd-exit \
ksym-vanilla-sdw-amd-get-slave-info \
ksym-vanilla-sdw-amd-probe \
ksym-vanilla-sdw-bpt-send-async \
ksym-vanilla-sdw-bpt-send-sync \
ksym-vanilla-sdw-bpt-wait \
ksym-vanilla-sdw-bread-no-pm-unlocked \
ksym-vanilla-sdw-bus-clk-stop \
ksym-vanilla-sdw-bus-exit-clk-stop \
ksym-vanilla-sdw-bus-master-add \
ksym-vanilla-sdw-bus-master-delete \
ksym-vanilla-sdw-bus-prep-clk-stop \
ksym-vanilla-sdw-bus-type \
ksym-vanilla-sdw-bwrite-no-pm-unlocked \
ksym-vanilla-sdw-clear-slave-status \
ksym-vanilla-sdw-cols \
ksym-vanilla-sdw-compare-devid \
ksym-vanilla-sdw-compute-params \
ksym-vanilla-sdw-compute-slave-ports \
ksym-vanilla-sdw-deprepare-stream \
ksym-vanilla-sdw-disable-stream \
ksym-vanilla-sdw-enable-stream \
ksym-vanilla-sdw-extract-slave-id \
ksym-vanilla-sdw-find-col-index \
ksym-vanilla-sdw-find-row-index \
ksym-vanilla-sdw-handle-slave-status \
ksym-vanilla-sdw-intel-acpi-scan \
ksym-vanilla-sdw-master-read-prop \
ksym-vanilla-sdw-nread \
ksym-vanilla-sdw-nread-no-pm \
ksym-vanilla-sdw-nwrite \
ksym-vanilla-sdw-nwrite-no-pm \
ksym-vanilla-sdw-prepare-stream \
ksym-vanilla-sdw-read \
ksym-vanilla-sdw-read-no-pm \
ksym-vanilla-sdw-release-stream \
ksym-vanilla-sdw-rows \
ksym-vanilla-sdw-show-ping-status \
ksym-vanilla-sdw-shutdown-stream \
ksym-vanilla-sdw-slave-add \
ksym-vanilla-sdw-slave-get-current-bank \
ksym-vanilla-sdw-slave-get-scale-index \
ksym-vanilla-sdw-slave-read-lane-mapping \
ksym-vanilla-sdw-slave-read-prop \
ksym-vanilla-sdw-slave-type \
ksym-vanilla-sdw-startup-stream \
ksym-vanilla-sdw-stream-add-master \
ksym-vanilla-sdw-stream-add-slave \
ksym-vanilla-sdw-stream-remove-master \
ksym-vanilla-sdw-stream-remove-slave \
ksym-vanilla-sdw-unregister-driver \
ksym-vanilla-sdw-update \
ksym-vanilla-sdw-update-no-pm \
ksym-vanilla-sdw-write \
ksym-vanilla-sdw-write-no-pm \
ksym-vanilla-sec-pmic-pm-ops \
ksym-vanilla-sec-pmic-probe \
ksym-vanilla-sec-pmic-shutdown \
ksym-vanilla-secpath-set \
ksym-vanilla-sections-per-block \
ksym-vanilla-secure-ipv4-port-ephemeral \
ksym-vanilla-secure-ipv6-port-ephemeral \
ksym-vanilla-secure-tcp-seq-and-ts-off \
ksym-vanilla-secure-tcpv6-seq-and-ts-off \
ksym-vanilla-security-bdev-alloc \
ksym-vanilla-security-bdev-free \
ksym-vanilla-security-bdev-setintegrity \
ksym-vanilla-security-cred-getlsmprop \
ksym-vanilla-security-cred-getsecid \
ksym-vanilla-security-current-getlsmprop-subj \
ksym-vanilla-security-d-instantiate \
ksym-vanilla-security-dentry-create-files-as \
ksym-vanilla-security-dentry-init-security \
ksym-vanilla-security-file-ioctl \
ksym-vanilla-security-file-ioctl-compat \
ksym-vanilla-security-file-post-open \
ksym-vanilla-security-free-mnt-opts \
ksym-vanilla-security-ib-alloc-security \
ksym-vanilla-security-ib-endport-manage-subnet \
ksym-vanilla-security-ib-free-security \
ksym-vanilla-security-ib-pkey-access \
ksym-vanilla-security-inet-conn-established \
ksym-vanilla-security-inet-conn-request \
ksym-vanilla-security-inode-copy-up \
ksym-vanilla-security-inode-copy-up-xattr \
ksym-vanilla-security-inode-create \
ksym-vanilla-security-inode-getsecctx \
ksym-vanilla-security-inode-init-security \
ksym-vanilla-security-inode-invalidate-secctx \
ksym-vanilla-security-inode-listsecurity \
ksym-vanilla-security-inode-mkdir \
ksym-vanilla-security-inode-notifysecctx \
ksym-vanilla-security-inode-setattr \
ksym-vanilla-security-inode-setintegrity \
ksym-vanilla-security-inode-setsecctx \
ksym-vanilla-security-ismaclabel \
ksym-vanilla-security-kernel-load-data \
ksym-vanilla-security-kernel-post-load-data \
ksym-vanilla-security-kernel-post-read-file \
ksym-vanilla-security-kernel-read-file \
ksym-vanilla-security-locked-down \
ksym-vanilla-security-lsmprop-to-secctx \
ksym-vanilla-security-mmap-backing-file \
ksym-vanilla-security-path-mkdir \
ksym-vanilla-security-path-mknod \
ksym-vanilla-security-path-rename \
ksym-vanilla-security-path-unlink \
ksym-vanilla-security-release-secctx \
ksym-vanilla-security-req-classify-flow \
ksym-vanilla-security-sb-clone-mnt-opts \
ksym-vanilla-security-sb-eat-lsm-opts \
ksym-vanilla-security-sb-mnt-opts-compat \
ksym-vanilla-security-sb-remount \
ksym-vanilla-security-sb-set-mnt-opts \
ksym-vanilla-security-sctp-assoc-established \
ksym-vanilla-security-sctp-assoc-request \
ksym-vanilla-security-sctp-bind-connect \
ksym-vanilla-security-sctp-sk-clone \
ksym-vanilla-security-secctx-to-secid \
ksym-vanilla-security-secid-to-secctx \
ksym-vanilla-security-secmark-refcount-dec \
ksym-vanilla-security-secmark-refcount-inc \
ksym-vanilla-security-secmark-relabel-packet \
ksym-vanilla-security-sk-classify-flow \
ksym-vanilla-security-sk-clone \
ksym-vanilla-security-skb-classify-flow \
ksym-vanilla-security-sock-graft \
ksym-vanilla-security-sock-rcv-skb \
ksym-vanilla-security-socket-getpeersec-dgram \
ksym-vanilla-security-socket-socketpair \
ksym-vanilla-security-task-getlsmprop-obj \
ksym-vanilla-security-tun-dev-alloc-security \
ksym-vanilla-security-tun-dev-attach \
ksym-vanilla-security-tun-dev-attach-queue \
ksym-vanilla-security-tun-dev-create \
ksym-vanilla-security-tun-dev-free-security \
ksym-vanilla-security-tun-dev-open \
ksym-vanilla-security-unix-find \
ksym-vanilla-security-unix-may-send \
ksym-vanilla-security-unix-stream-connect \
ksym-vanilla-security-xfrm-policy-alloc \
ksym-vanilla-security-xfrm-policy-free \
ksym-vanilla-security-xfrm-state-alloc \
ksym-vanilla-security-xfrm-state-delete \
ksym-vanilla-securityfs-create-dir \
ksym-vanilla-securityfs-create-file \
ksym-vanilla-securityfs-create-symlink \
ksym-vanilla-securityfs-remove \
ksym-vanilla-sed-ioctl \
ksym-vanilla-seg6-do-srh-encap \
ksym-vanilla-seg6-do-srh-inline \
ksym-vanilla-seg6-hmac-compute \
ksym-vanilla-seg6-hmac-info-add \
ksym-vanilla-seg6-hmac-info-del \
ksym-vanilla-seg6-hmac-info-lookup \
ksym-vanilla-seg6-hmac-net-exit \
ksym-vanilla-seg6-hmac-validate-skb \
ksym-vanilla-seg6-push-hmac \
ksym-vanilla-send-implementation-id \
ksym-vanilla-send-sig \
ksym-vanilla-send-sig-info \
ksym-vanilla-send-sig-mceerr \
ksym-vanilla-sensor-hub-device-close \
ksym-vanilla-sensor-hub-device-open \
ksym-vanilla-sensor-hub-get-feature \
ksym-vanilla-sensor-hub-input-attr-get-raw-value \
ksym-vanilla-sensor-hub-input-attr-read-values \
ksym-vanilla-sensor-hub-input-get-attribute-info \
ksym-vanilla-sensor-hub-register-callback \
ksym-vanilla-sensor-hub-remove-callback \
ksym-vanilla-sensor-hub-set-feature \
ksym-vanilla-seq-bprintf \
ksym-vanilla-seq-buf-do-printk \
ksym-vanilla-seq-buf-printf \
ksym-vanilla-seq-buf-putc \
ksym-vanilla-seq-buf-putmem-hex \
ksym-vanilla-seq-buf-puts \
ksym-vanilla-seq-dentry \
ksym-vanilla-seq-escape-mem \
ksym-vanilla-seq-file-path \
ksym-vanilla-seq-hex-dump \
ksym-vanilla-seq-hlist-next \
ksym-vanilla-seq-hlist-next-percpu \
ksym-vanilla-seq-hlist-next-rcu \
ksym-vanilla-seq-hlist-start \
ksym-vanilla-seq-hlist-start-head \
ksym-vanilla-seq-hlist-start-head-rcu \
ksym-vanilla-seq-hlist-start-percpu \
ksym-vanilla-seq-hlist-start-rcu \
ksym-vanilla-seq-list-next \
ksym-vanilla-seq-list-next-rcu \
ksym-vanilla-seq-list-start \
ksym-vanilla-seq-list-start-head \
ksym-vanilla-seq-list-start-head-rcu \
ksym-vanilla-seq-list-start-rcu \
ksym-vanilla-seq-lseek \
ksym-vanilla-seq-open \
ksym-vanilla-seq-open-private \
ksym-vanilla-seq-pad \
ksym-vanilla-seq-path \
ksym-vanilla-seq-printf \
ksym-vanilla-seq-put-decimal-ll \
ksym-vanilla-seq-put-decimal-ull \
ksym-vanilla-seq-putc \
ksym-vanilla-seq-read \
ksym-vanilla-seq-read-iter \
ksym-vanilla-seq-release \
ksym-vanilla-seq-release-private \
ksym-vanilla-seq-vprintf \
ksym-vanilla-seq-write \
ksym-vanilla-serdev-acpi-get-uart-resource \
ksym-vanilla-serdev-controller-add \
ksym-vanilla-serdev-controller-alloc \
ksym-vanilla-serdev-controller-remove \
ksym-vanilla-serdev-device-add \
ksym-vanilla-serdev-device-alloc \
ksym-vanilla-serdev-device-break-ctl \
ksym-vanilla-serdev-device-close \
ksym-vanilla-serdev-device-get-tiocm \
ksym-vanilla-serdev-device-open \
ksym-vanilla-serdev-device-remove \
ksym-vanilla-serdev-device-set-baudrate \
ksym-vanilla-serdev-device-set-flow-control \
ksym-vanilla-serdev-device-set-parity \
ksym-vanilla-serdev-device-set-tiocm \
ksym-vanilla-serdev-device-wait-until-sent \
ksym-vanilla-serdev-device-write \
ksym-vanilla-serdev-device-write-buf \
ksym-vanilla-serdev-device-write-flush \
ksym-vanilla-serdev-device-write-wakeup \
ksym-vanilla-serial-8250-warn-need-ioport \
ksym-vanilla-serial8250-clear-and-reinit-fifos \
ksym-vanilla-serial8250-clear-fifos \
ksym-vanilla-serial8250-do-get-mctrl \
ksym-vanilla-serial8250-do-pm \
ksym-vanilla-serial8250-do-set-divisor \
ksym-vanilla-serial8250-do-set-ldisc \
ksym-vanilla-serial8250-do-set-mctrl \
ksym-vanilla-serial8250-do-set-termios \
ksym-vanilla-serial8250-do-shutdown \
ksym-vanilla-serial8250-do-startup \
ksym-vanilla-serial8250-em485-config \
ksym-vanilla-serial8250-em485-destroy \
ksym-vanilla-serial8250-em485-start-tx \
ksym-vanilla-serial8250-em485-stop-tx \
ksym-vanilla-serial8250-em485-supported \
ksym-vanilla-serial8250-fifo-wait-for-lsr-thre \
ksym-vanilla-serial8250-get-port \
ksym-vanilla-serial8250-handle-irq \
ksym-vanilla-serial8250-handle-irq-locked \
ksym-vanilla-serial8250-init-port \
ksym-vanilla-serial8250-modem-status \
ksym-vanilla-serial8250-pci-setup-port \
ksym-vanilla-serial8250-read-char \
ksym-vanilla-serial8250-register-8250-port \
ksym-vanilla-serial8250-release-dma \
ksym-vanilla-serial8250-request-dma \
ksym-vanilla-serial8250-resume-port \
ksym-vanilla-serial8250-rpm-get \
ksym-vanilla-serial8250-rpm-put \
ksym-vanilla-serial8250-rx-chars \
ksym-vanilla-serial8250-rx-dma-flush \
ksym-vanilla-serial8250-set-defaults \
ksym-vanilla-serial8250-set-isa-configurator \
ksym-vanilla-serial8250-suspend-port \
ksym-vanilla-serial8250-tx-chars \
ksym-vanilla-serial8250-unregister-port \
ksym-vanilla-serial8250-update-uartclk \
ksym-vanilla-serio-bus \
ksym-vanilla-serio-close \
ksym-vanilla-serio-interrupt \
ksym-vanilla-serio-open \
ksym-vanilla-serio-reconnect \
ksym-vanilla-serio-rescan \
ksym-vanilla-serio-unregister-child-port \
ksym-vanilla-serio-unregister-driver \
ksym-vanilla-serio-unregister-port \
ksym-vanilla-serpent-setkey \
ksym-vanilla-servreg-get-domain-list-req-ei \
ksym-vanilla-servreg-get-domain-list-resp-ei \
ksym-vanilla-servreg-loc-pfr-req-ei \
ksym-vanilla-servreg-loc-pfr-resp-ei \
ksym-vanilla-servreg-register-listener-req-ei \
ksym-vanilla-servreg-register-listener-resp-ei \
ksym-vanilla-servreg-restart-pd-req-ei \
ksym-vanilla-servreg-restart-pd-resp-ei \
ksym-vanilla-servreg-set-ack-req-ei \
ksym-vanilla-servreg-set-ack-resp-ei \
ksym-vanilla-servreg-state-updated-ind-ei \
ksym-vanilla-set-and-calc-slave-port-state \
ksym-vanilla-set-anon-super \
ksym-vanilla-set-anon-super-fc \
ksym-vanilla-set-binfmt \
ksym-vanilla-set-blocksize \
ksym-vanilla-set-cached-acl \
ksym-vanilla-set-capacity \
ksym-vanilla-set-capacity-and-notify \
ksym-vanilla-set-cpus-allowed-ptr \
ksym-vanilla-set-create-files-as \
ksym-vanilla-set-current-groups \
ksym-vanilla-set-dax-nocache \
ksym-vanilla-set-dax-nomc \
ksym-vanilla-set-dax-synchronous \
ksym-vanilla-set-default-d-op \
ksym-vanilla-set-disk-ro \
ksym-vanilla-set-exclusive-cxl-commands \
ksym-vanilla-set-freezable \
ksym-vanilla-set-groups \
ksym-vanilla-set-memory-decrypted \
ksym-vanilla-set-memory-encrypted \
ksym-vanilla-set-movable-ops \
ksym-vanilla-set-nlink \
ksym-vanilla-set-normalized-timespec64 \
ksym-vanilla-set-online-page-callback \
ksym-vanilla-set-page-dirty \
ksym-vanilla-set-page-dirty-lock \
ksym-vanilla-set-page-writeback \
ksym-vanilla-set-phv-bit \
ksym-vanilla-set-posix-acl \
ksym-vanilla-set-primary-fwnode \
ksym-vanilla-set-secondary-fwnode \
ksym-vanilla-set-security-override \
ksym-vanilla-set-selection-kernel \
ksym-vanilla-set-task-ioprio \
ksym-vanilla-set-user-nice \
ksym-vanilla-set-worker-desc \
ksym-vanilla-setattr-copy \
ksym-vanilla-setattr-prepare \
ksym-vanilla-setattr-should-drop-sgid \
ksym-vanilla-setattr-should-drop-suidgid \
ksym-vanilla-setup-arg-pages \
ksym-vanilla-setup-bdev-super \
ksym-vanilla-setup-cn23xx-octeon-pf-device \
ksym-vanilla-setup-fault-attr \
ksym-vanilla-setup-max-cpus \
ksym-vanilla-setup-new-exec \
ksym-vanilla-setup-rx-oom-poll-fn \
ksym-vanilla-setup-udp-tunnel-sock \
ksym-vanilla-setup-ufile-idr-uobject \
ksym-vanilla-sfp-add-phy \
ksym-vanilla-sfp-bus-add-upstream \
ksym-vanilla-sfp-bus-del-upstream \
ksym-vanilla-sfp-bus-find-fwnode \
ksym-vanilla-sfp-bus-put \
ksym-vanilla-sfp-get-module-caps \
ksym-vanilla-sfp-get-module-eeprom \
ksym-vanilla-sfp-get-module-eeprom-by-page \
ksym-vanilla-sfp-get-module-info \
ksym-vanilla-sfp-get-name \
ksym-vanilla-sfp-link-down \
ksym-vanilla-sfp-link-up \
ksym-vanilla-sfp-module-insert \
ksym-vanilla-sfp-module-remove \
ksym-vanilla-sfp-module-start \
ksym-vanilla-sfp-module-stop \
ksym-vanilla-sfp-register-socket \
ksym-vanilla-sfp-remove-phy \
ksym-vanilla-sfp-select-interface \
ksym-vanilla-sfp-unregister-socket \
ksym-vanilla-sfp-upstream-set-signal-rate \
ksym-vanilla-sfp-upstream-start \
ksym-vanilla-sfp-upstream-stop \
ksym-vanilla-sg-alloc-append-table-from-pages \
ksym-vanilla-sg-alloc-table \
ksym-vanilla-sg-alloc-table-chained \
ksym-vanilla-sg-alloc-table-from-pages-segment \
ksym-vanilla-sg-copy-buffer \
ksym-vanilla-sg-copy-from-buffer \
ksym-vanilla-sg-copy-to-buffer \
ksym-vanilla-sg-free-append-table \
ksym-vanilla-sg-free-table \
ksym-vanilla-sg-free-table-chained \
ksym-vanilla-sg-init-one \
ksym-vanilla-sg-init-table \
ksym-vanilla-sg-last \
ksym-vanilla-sg-miter-next \
ksym-vanilla-sg-miter-skip \
ksym-vanilla-sg-miter-start \
ksym-vanilla-sg-miter-stop \
ksym-vanilla-sg-nents \
ksym-vanilla-sg-nents-for-dma \
ksym-vanilla-sg-nents-for-len \
ksym-vanilla-sg-pcopy-from-buffer \
ksym-vanilla-sg-pcopy-to-buffer \
ksym-vanilla-sg-split \
ksym-vanilla-sg-zero-buffer \
ksym-vanilla-sg2042-cfg-ops \
ksym-vanilla-sg2042-pconf-ops \
ksym-vanilla-sg2042-pctrl-ops \
ksym-vanilla-sg2042-pmx-ops \
ksym-vanilla-sget-dev \
ksym-vanilla-sget-fc \
ksym-vanilla-sgl-alloc \
ksym-vanilla-sgl-alloc-order \
ksym-vanilla-sgl-free \
ksym-vanilla-sgl-free-n-order \
ksym-vanilla-sgl-free-order \
ksym-vanilla-sha1 \
ksym-vanilla-sha1-final \
ksym-vanilla-sha1-init \
ksym-vanilla-sha1-update \
ksym-vanilla-sha1-zero-message-hash \
ksym-vanilla-sha224 \
ksym-vanilla-sha224-final \
ksym-vanilla-sha224-init \
ksym-vanilla-sha224-zero-message-hash \
ksym-vanilla-sha256 \
ksym-vanilla-sha256-final \
ksym-vanilla-sha256-finup-2x \
ksym-vanilla-sha256-finup-2x-is-optimized \
ksym-vanilla-sha256-init \
ksym-vanilla-sha256-zero-message-hash \
ksym-vanilla-sha3-224 \
ksym-vanilla-sha3-256 \
ksym-vanilla-sha3-384 \
ksym-vanilla-sha3-512 \
ksym-vanilla-sha3-final \
ksym-vanilla-sha384 \
ksym-vanilla-sha384-final \
ksym-vanilla-sha384-init \
ksym-vanilla-sha384-zero-message-hash \
ksym-vanilla-sha512 \
ksym-vanilla-sha512-final \
ksym-vanilla-sha512-init \
ksym-vanilla-sha512-zero-message-hash \
ksym-vanilla-shake-folio \
ksym-vanilla-shake-squeeze \
ksym-vanilla-shake128 \
ksym-vanilla-shake256 \
ksym-vanilla-shash-ahash-digest \
ksym-vanilla-shash-ahash-finup \
ksym-vanilla-shash-ahash-update \
ksym-vanilla-shash-free-singlespawn-instance \
ksym-vanilla-shash-no-setkey \
ksym-vanilla-shash-register-instance \
ksym-vanilla-shmem-file-setup \
ksym-vanilla-shmem-file-setup-with-mnt \
ksym-vanilla-shmem-get-folio \
ksym-vanilla-shmem-kernel-file-setup \
ksym-vanilla-shmem-mapping \
ksym-vanilla-shmem-read-folio-gfp \
ksym-vanilla-shmem-read-mapping-page-gfp \
ksym-vanilla-shmem-truncate-range \
ksym-vanilla-shmem-writeout \
ksym-vanilla-should-fail \
ksym-vanilla-show-class-attr-string \
ksym-vanilla-show-rcu-gp-kthreads \
ksym-vanilla-show-rcu-tasks-classic-gp-kthread \
ksym-vanilla-show-rcu-tasks-rude-gp-kthread \
ksym-vanilla-shrink-dcache-parent \
ksym-vanilla-shrink-dcache-sb \
ksym-vanilla-shrink-dentry-list \
ksym-vanilla-shrinker-alloc \
ksym-vanilla-shrinker-free \
ksym-vanilla-shrinker-register \
ksym-vanilla-si-mem-available \
ksym-vanilla-si-meminfo \
ksym-vanilla-si21xx-attach \
ksym-vanilla-si470x-ctrl-ops \
ksym-vanilla-si470x-set-freq \
ksym-vanilla-si470x-start \
ksym-vanilla-si470x-stop \
ksym-vanilla-si470x-viddev-template \
ksym-vanilla-sig-register-instance \
ksym-vanilla-sigmadsp-attach \
ksym-vanilla-sigmadsp-reset \
ksym-vanilla-sigmadsp-restrict-params \
ksym-vanilla-sigmadsp-setup \
ksym-vanilla-sigprocmask \
ksym-vanilla-simple-attr-open \
ksym-vanilla-simple-attr-read \
ksym-vanilla-simple-attr-release \
ksym-vanilla-simple-attr-write \
ksym-vanilla-simple-attr-write-signed \
ksym-vanilla-simple-dir-inode-operations \
ksym-vanilla-simple-dir-operations \
ksym-vanilla-simple-done-creating \
ksym-vanilla-simple-empty \
ksym-vanilla-simple-fill-super \
ksym-vanilla-simple-fsync \
ksym-vanilla-simple-fsync-noflush \
ksym-vanilla-simple-get-link \
ksym-vanilla-simple-getattr \
ksym-vanilla-simple-inode-init-ts \
ksym-vanilla-simple-link \
ksym-vanilla-simple-lookup \
ksym-vanilla-simple-map-init \
ksym-vanilla-simple-open \
ksym-vanilla-simple-pin-fs \
ksym-vanilla-simple-read-from-buffer \
ksym-vanilla-simple-recursive-removal \
ksym-vanilla-simple-release-fs \
ksym-vanilla-simple-remove-by-name \
ksym-vanilla-simple-rename \
ksym-vanilla-simple-rename-exchange \
ksym-vanilla-simple-rename-timestamp \
ksym-vanilla-simple-rmdir \
ksym-vanilla-simple-setattr \
ksym-vanilla-simple-start-creating \
ksym-vanilla-simple-statfs \
ksym-vanilla-simple-strtol \
ksym-vanilla-simple-strtoll \
ksym-vanilla-simple-strtoul \
ksym-vanilla-simple-strtoull \
ksym-vanilla-simple-symlink-inode-operations \
ksym-vanilla-simple-transaction-get \
ksym-vanilla-simple-transaction-read \
ksym-vanilla-simple-transaction-release \
ksym-vanilla-simple-transaction-set \
ksym-vanilla-simple-tuner-attach \
ksym-vanilla-simple-unlink \
ksym-vanilla-simple-util-be-hw-params-fixup \
ksym-vanilla-simple-util-canonicalize-cpu \
ksym-vanilla-simple-util-canonicalize-platform \
ksym-vanilla-simple-util-clean-reference \
ksym-vanilla-simple-util-dai-init \
ksym-vanilla-simple-util-get-sample-fmt \
ksym-vanilla-simple-util-hw-params \
ksym-vanilla-simple-util-init-aux-jacks \
ksym-vanilla-simple-util-init-jack \
ksym-vanilla-simple-util-init-priv \
ksym-vanilla-simple-util-is-convert-required \
ksym-vanilla-simple-util-parse-card-name \
ksym-vanilla-simple-util-parse-clk \
ksym-vanilla-simple-util-parse-convert \
ksym-vanilla-simple-util-parse-daifmt \
ksym-vanilla-simple-util-parse-pin-switches \
ksym-vanilla-simple-util-parse-routing \
ksym-vanilla-simple-util-parse-tdm-width-map \
ksym-vanilla-simple-util-parse-widgets \
ksym-vanilla-simple-util-remove \
ksym-vanilla-simple-util-set-dailink-name \
ksym-vanilla-simple-util-shutdown \
ksym-vanilla-simple-util-startup \
ksym-vanilla-simple-write-begin \
ksym-vanilla-simple-write-to-buffer \
ksym-vanilla-single-open \
ksym-vanilla-single-open-size \
ksym-vanilla-single-release \
ksym-vanilla-single-task-running \
ksym-vanilla-siphash-1u32 \
ksym-vanilla-siphash-1u64 \
ksym-vanilla-siphash-2u64 \
ksym-vanilla-siphash-3u32 \
ksym-vanilla-siphash-3u64 \
ksym-vanilla-siphash-4u64 \
ksym-vanilla-sis-info133-for-sata \
ksym-vanilla-sized-strscpy \
ksym-vanilla-sja1000-interrupt \
ksym-vanilla-sk-alloc \
ksym-vanilla-sk-attach-filter \
ksym-vanilla-sk-busy-loop-end \
ksym-vanilla-sk-capable \
ksym-vanilla-sk-clear-memalloc \
ksym-vanilla-sk-clone \
ksym-vanilla-sk-common-release \
ksym-vanilla-sk-detach-filter \
ksym-vanilla-sk-dst-check \
ksym-vanilla-sk-error-report \
ksym-vanilla-sk-filter-trim-cap \
ksym-vanilla-sk-free \
ksym-vanilla-sk-ioctl \
ksym-vanilla-sk-mc-loop \
ksym-vanilla-sk-msg-alloc \
ksym-vanilla-sk-msg-clone \
ksym-vanilla-sk-msg-free \
ksym-vanilla-sk-msg-free-nocharge \
ksym-vanilla-sk-msg-free-partial \
ksym-vanilla-sk-msg-is-readable \
ksym-vanilla-sk-msg-memcopy-from-iter \
ksym-vanilla-sk-msg-recvmsg \
ksym-vanilla-sk-msg-return \
ksym-vanilla-sk-msg-return-zero \
ksym-vanilla-sk-msg-trim \
ksym-vanilla-sk-msg-zerocopy-from-iter \
ksym-vanilla-sk-net-capable \
ksym-vanilla-sk-net-refcnt-upgrade \
ksym-vanilla-sk-ns-capable \
ksym-vanilla-sk-page-frag-refill \
ksym-vanilla-sk-psock-drop \
ksym-vanilla-sk-psock-init \
ksym-vanilla-sk-psock-msg-verdict \
ksym-vanilla-sk-reset-timer \
ksym-vanilla-sk-send-sigurg \
ksym-vanilla-sk-set-memalloc \
ksym-vanilla-sk-set-peek-off \
ksym-vanilla-sk-setup-caps \
ksym-vanilla-sk-skb-reason-drop \
ksym-vanilla-sk-stop-timer \
ksym-vanilla-sk-stop-timer-sync \
ksym-vanilla-sk-stream-error \
ksym-vanilla-sk-stream-kill-queues \
ksym-vanilla-sk-stream-wait-connect \
ksym-vanilla-sk-stream-wait-memory \
ksym-vanilla-sk-tx-queue-get \
ksym-vanilla-sk-wait-data \
ksym-vanilla-skb-abort-seq-read \
ksym-vanilla-skb-append \
ksym-vanilla-skb-append-pagefrags \
ksym-vanilla-skb-checksum \
ksym-vanilla-skb-checksum-help \
ksym-vanilla-skb-checksum-setup \
ksym-vanilla-skb-checksum-trimmed \
ksym-vanilla-skb-clone \
ksym-vanilla-skb-clone-sk \
ksym-vanilla-skb-coalesce-rx-frag \
ksym-vanilla-skb-complete-tx-timestamp \
ksym-vanilla-skb-complete-wifi-ack \
ksym-vanilla-skb-condense \
ksym-vanilla-skb-copy \
ksym-vanilla-skb-copy-and-crc32c-datagram-iter \
ksym-vanilla-skb-copy-and-csum-bits \
ksym-vanilla-skb-copy-and-csum-datagram-msg \
ksym-vanilla-skb-copy-and-csum-dev \
ksym-vanilla-skb-copy-bits \
ksym-vanilla-skb-copy-datagram-from-iter \
ksym-vanilla-skb-copy-datagram-from-iter-full \
ksym-vanilla-skb-copy-datagram-iter \
ksym-vanilla-skb-copy-expand \
ksym-vanilla-skb-copy-header \
ksym-vanilla-skb-copy-seq-read \
ksym-vanilla-skb-copy-ubufs \
ksym-vanilla-skb-cow-data \
ksym-vanilla-skb-cow-data-for-xdp \
ksym-vanilla-skb-crc32c \
ksym-vanilla-skb-crc32c-csum-help \
ksym-vanilla-skb-csum-hwoffload-help \
ksym-vanilla-skb-dequeue \
ksym-vanilla-skb-dequeue-tail \
ksym-vanilla-skb-dump \
ksym-vanilla-skb-ensure-writable \
ksym-vanilla-skb-ensure-writable-head-tail \
ksym-vanilla-skb-errqueue-purge \
ksym-vanilla-skb-eth-gso-segment \
ksym-vanilla-skb-eth-pop \
ksym-vanilla-skb-eth-push \
ksym-vanilla-skb-expand-head \
ksym-vanilla-skb-ext-add \
ksym-vanilla-skb-find-text \
ksym-vanilla-skb-flow-dissect-ct \
ksym-vanilla-skb-flow-dissect-hash \
ksym-vanilla-skb-flow-dissect-meta \
ksym-vanilla-skb-flow-dissect-tunnel-info \
ksym-vanilla-skb-flow-dissector-init \
ksym-vanilla-skb-flow-get-icmp-tci \
ksym-vanilla-skb-flow-get-ports \
ksym-vanilla-skb-free-datagram \
ksym-vanilla-skb-get-hash-perturb \
ksym-vanilla-skb-gso-validate-mac-len \
ksym-vanilla-skb-gso-validate-network-len \
ksym-vanilla-skb-headers-offset-update \
ksym-vanilla-skb-kill-datagram \
ksym-vanilla-skb-mac-gso-segment \
ksym-vanilla-skb-morph \
ksym-vanilla-skb-mpls-dec-ttl \
ksym-vanilla-skb-mpls-pop \
ksym-vanilla-skb-mpls-push \
ksym-vanilla-skb-mpls-update-lse \
ksym-vanilla-skb-orphan-partial \
ksym-vanilla-skb-page-frag-refill \
ksym-vanilla-skb-partial-csum-set \
ksym-vanilla-skb-pp-cow-data \
ksym-vanilla-skb-prepare-seq-read \
ksym-vanilla-skb-pull \
ksym-vanilla-skb-pull-data \
ksym-vanilla-skb-pull-rcsum \
ksym-vanilla-skb-push \
ksym-vanilla-skb-put \
ksym-vanilla-skb-queue-head \
ksym-vanilla-skb-queue-purge-reason \
ksym-vanilla-skb-queue-tail \
ksym-vanilla-skb-realloc-headroom \
ksym-vanilla-skb-recv-datagram \
ksym-vanilla-skb-scrub-packet \
ksym-vanilla-skb-segment \
ksym-vanilla-skb-segment-list \
ksym-vanilla-skb-send-sock-locked \
ksym-vanilla-skb-send-sock-locked-with-flags \
ksym-vanilla-skb-seq-read \
ksym-vanilla-skb-set-owner-w \
ksym-vanilla-skb-splice-bits \
ksym-vanilla-skb-splice-from-iter \
ksym-vanilla-skb-split \
ksym-vanilla-skb-store-bits \
ksym-vanilla-skb-to-sgvec \
ksym-vanilla-skb-to-sgvec-nomark \
ksym-vanilla-skb-trim \
ksym-vanilla-skb-try-coalesce \
ksym-vanilla-skb-tstamp-tx \
ksym-vanilla-skb-tunnel-check-pmtu \
ksym-vanilla-skb-tx-error \
ksym-vanilla-skb-unlink \
ksym-vanilla-skb-vlan-pop \
ksym-vanilla-skb-vlan-push \
ksym-vanilla-skb-vlan-untag \
ksym-vanilla-skb-zerocopy \
ksym-vanilla-skb-zerocopy-headlen \
ksym-vanilla-skb-zerocopy-iter-stream \
ksym-vanilla-skcipher-alloc-instance-simple \
ksym-vanilla-skcipher-register-instance \
ksym-vanilla-skcipher-walk-aead-decrypt \
ksym-vanilla-skcipher-walk-aead-encrypt \
ksym-vanilla-skcipher-walk-done \
ksym-vanilla-skcipher-walk-virt \
ksym-vanilla-skip-spaces \
ksym-vanilla-sky1-base-pinctrl-probe \
ksym-vanilla-sl811h-driver \
ksym-vanilla-slab-build-skb \
ksym-vanilla-slash-name \
ksym-vanilla-slhc-compress \
ksym-vanilla-slhc-free \
ksym-vanilla-slhc-init \
ksym-vanilla-slhc-remember \
ksym-vanilla-slhc-toss \
ksym-vanilla-slhc-uncompress \
ksym-vanilla-slim-alloc-txn-tid \
ksym-vanilla-slim-ctrl-clk-pause \
ksym-vanilla-slim-device-report-present \
ksym-vanilla-slim-do-transfer \
ksym-vanilla-slim-driver-unregister \
ksym-vanilla-slim-free-txn-tid \
ksym-vanilla-slim-get-device \
ksym-vanilla-slim-get-logical-addr \
ksym-vanilla-slim-msg-response \
ksym-vanilla-slim-read \
ksym-vanilla-slim-readb \
ksym-vanilla-slim-register-controller \
ksym-vanilla-slim-report-absent \
ksym-vanilla-slim-stream-allocate \
ksym-vanilla-slim-stream-disable \
ksym-vanilla-slim-stream-enable \
ksym-vanilla-slim-stream-free \
ksym-vanilla-slim-stream-prepare \
ksym-vanilla-slim-stream-unprepare \
ksym-vanilla-slim-unregister-controller \
ksym-vanilla-slim-write \
ksym-vanilla-slim-writeb \
ksym-vanilla-slim-xfer-msg \
ksym-vanilla-slimbus-bus \
ksym-vanilla-sm-register-device \
ksym-vanilla-sm3 \
ksym-vanilla-sm3-final \
ksym-vanilla-sm3-init \
ksym-vanilla-sm3-update \
ksym-vanilla-sm4-ce-cbc-enc \
ksym-vanilla-sm4-ce-crypt-block \
ksym-vanilla-sm4-ce-expand-key \
ksym-vanilla-sm4-crypt-block \
ksym-vanilla-sm4-expandkey \
ksym-vanilla-smb-compression-compress-chained \
ksym-vanilla-smb-compression-decompress \
ksym-vanilla-smb-lz77-compress \
ksym-vanilla-smb-lz77-decompress \
ksym-vanilla-smc-proto \
ksym-vanilla-smc-proto6 \
ksym-vanilla-smp-ata-check-ready-type \
ksym-vanilla-smp-call-function \
ksym-vanilla-smp-call-function-any \
ksym-vanilla-smp-call-function-many \
ksym-vanilla-smp-call-function-single \
ksym-vanilla-smp-call-function-single-async \
ksym-vanilla-smp-call-on-cpu \
ksym-vanilla-smpboot-register-percpu-thread \
ksym-vanilla-smpboot-unregister-percpu-thread \
ksym-vanilla-sms-board-event \
ksym-vanilla-sms-board-led-feedback \
ksym-vanilla-sms-board-lna-control \
ksym-vanilla-sms-board-load-modules \
ksym-vanilla-sms-board-power \
ksym-vanilla-sms-board-setup \
ksym-vanilla-sms-get-board \
ksym-vanilla-smsc-phy-config-init \
ksym-vanilla-smsc-phy-config-intr \
ksym-vanilla-smsc-phy-get-tunable \
ksym-vanilla-smsc-phy-handle-interrupt \
ksym-vanilla-smsc-phy-probe \
ksym-vanilla-smsc-phy-set-tunable \
ksym-vanilla-smsclient-sendrequest \
ksym-vanilla-smscore-get-board-id \
ksym-vanilla-smscore-get-device-mode \
ksym-vanilla-smscore-getbuffer \
ksym-vanilla-smscore-onresponse \
ksym-vanilla-smscore-putbuffer \
ksym-vanilla-smscore-register-client \
ksym-vanilla-smscore-register-device \
ksym-vanilla-smscore-register-hotplug \
ksym-vanilla-smscore-registry-getmode \
ksym-vanilla-smscore-set-board-id \
ksym-vanilla-smscore-start-device \
ksym-vanilla-smscore-translate-msg \
ksym-vanilla-smscore-unregister-client \
ksym-vanilla-smscore-unregister-device \
ksym-vanilla-smscore-unregister-hotplug \
ksym-vanilla-smsendian-handle-message-header \
ksym-vanilla-smsendian-handle-rx-message \
ksym-vanilla-smsendian-handle-tx-message \
ksym-vanilla-snd-ac97-bus \
ksym-vanilla-snd-ac97-get-short-name \
ksym-vanilla-snd-ac97-mixer \
ksym-vanilla-snd-ac97-pcm-assign \
ksym-vanilla-snd-ac97-pcm-close \
ksym-vanilla-snd-ac97-pcm-double-rate-rules \
ksym-vanilla-snd-ac97-pcm-open \
ksym-vanilla-snd-ac97-read \
ksym-vanilla-snd-ac97-reset \
ksym-vanilla-snd-ac97-resume \
ksym-vanilla-snd-ac97-set-rate \
ksym-vanilla-snd-ac97-suspend \
ksym-vanilla-snd-ac97-tune-hardware \
ksym-vanilla-snd-ac97-update \
ksym-vanilla-snd-ac97-update-bits \
ksym-vanilla-snd-ac97-update-power \
ksym-vanilla-snd-ac97-write \
ksym-vanilla-snd-ac97-write-cache \
ksym-vanilla-snd-ak4113-build \
ksym-vanilla-snd-ak4113-check-rate-and-errors \
ksym-vanilla-snd-ak4113-create \
ksym-vanilla-snd-ak4113-external-rate \
ksym-vanilla-snd-ak4113-reg-write \
ksym-vanilla-snd-ak4113-reinit \
ksym-vanilla-snd-ak4113-resume \
ksym-vanilla-snd-ak4113-suspend \
ksym-vanilla-snd-ak4114-build \
ksym-vanilla-snd-ak4114-check-rate-and-errors \
ksym-vanilla-snd-ak4114-create \
ksym-vanilla-snd-ak4114-external-rate \
ksym-vanilla-snd-ak4114-reg-write \
ksym-vanilla-snd-ak4114-reinit \
ksym-vanilla-snd-ak4114-resume \
ksym-vanilla-snd-ak4114-suspend \
ksym-vanilla-snd-akm4xxx-build-controls \
ksym-vanilla-snd-akm4xxx-init \
ksym-vanilla-snd-akm4xxx-reset \
ksym-vanilla-snd-akm4xxx-write \
ksym-vanilla-snd-amd-acp-find-config \
ksym-vanilla-snd-array-free \
ksym-vanilla-snd-array-new \
ksym-vanilla-snd-card-add-dev-attr \
ksym-vanilla-snd-card-disconnect \
ksym-vanilla-snd-card-disconnect-sync \
ksym-vanilla-snd-card-file-add \
ksym-vanilla-snd-card-file-remove \
ksym-vanilla-snd-card-free \
ksym-vanilla-snd-card-free-on-error \
ksym-vanilla-snd-card-free-when-closed \
ksym-vanilla-snd-card-new \
ksym-vanilla-snd-card-ref \
ksym-vanilla-snd-card-register \
ksym-vanilla-snd-card-rw-proc-new \
ksym-vanilla-snd-card-set-id \
ksym-vanilla-snd-component-add \
ksym-vanilla-snd-compr-free-pages \
ksym-vanilla-snd-compr-malloc-pages \
ksym-vanilla-snd-compr-stop-error \
ksym-vanilla-snd-compr-task-finished \
ksym-vanilla-snd-compress-new \
ksym-vanilla-snd-ctl-activate-id \
ksym-vanilla-snd-ctl-add \
ksym-vanilla-snd-ctl-add-followers \
ksym-vanilla-snd-ctl-add-vmaster-hook \
ksym-vanilla-snd-ctl-apply-vmaster-followers \
ksym-vanilla-snd-ctl-boolean-mono-info \
ksym-vanilla-snd-ctl-boolean-stereo-info \
ksym-vanilla-snd-ctl-disconnect-layer \
ksym-vanilla-snd-ctl-enum-info \
ksym-vanilla-snd-ctl-find-id \
ksym-vanilla-snd-ctl-find-numid \
ksym-vanilla-snd-ctl-free-one \
ksym-vanilla-snd-ctl-get-preferred-subdevice \
ksym-vanilla-snd-ctl-make-virtual-master \
ksym-vanilla-snd-ctl-new1 \
ksym-vanilla-snd-ctl-notify \
ksym-vanilla-snd-ctl-notify-one \
ksym-vanilla-snd-ctl-register-ioctl \
ksym-vanilla-snd-ctl-register-ioctl-compat \
ksym-vanilla-snd-ctl-register-layer \
ksym-vanilla-snd-ctl-remove \
ksym-vanilla-snd-ctl-remove-id \
ksym-vanilla-snd-ctl-rename \
ksym-vanilla-snd-ctl-rename-id \
ksym-vanilla-snd-ctl-replace \
ksym-vanilla-snd-ctl-request-layer \
ksym-vanilla-snd-ctl-sync-vmaster \
ksym-vanilla-snd-ctl-unregister-ioctl \
ksym-vanilla-snd-ctl-unregister-ioctl-compat \
ksym-vanilla-snd-device-alloc \
ksym-vanilla-snd-device-disconnect \
ksym-vanilla-snd-device-free \
ksym-vanilla-snd-device-new \
ksym-vanilla-snd-device-register \
ksym-vanilla-snd-devm-alloc-dir-pages \
ksym-vanilla-snd-devm-card-new \
ksym-vanilla-snd-dma-alloc-dir-pages \
ksym-vanilla-snd-dma-alloc-pages-fallback \
ksym-vanilla-snd-dma-buffer-mmap \
ksym-vanilla-snd-dma-buffer-sync \
ksym-vanilla-snd-dma-free-pages \
ksym-vanilla-snd-dmaengine-pcm-close \
ksym-vanilla-snd-dmaengine-pcm-close-release-chan \
ksym-vanilla-snd-dmaengine-pcm-get-chan \
ksym-vanilla-snd-dmaengine-pcm-open \
ksym-vanilla-snd-dmaengine-pcm-pointer \
ksym-vanilla-snd-dmaengine-pcm-pointer-no-residue \
ksym-vanilla-snd-dmaengine-pcm-prepare-slave-config \
ksym-vanilla-snd-dmaengine-pcm-refine-runtime-hwparams \
ksym-vanilla-snd-dmaengine-pcm-register \
ksym-vanilla-snd-dmaengine-pcm-request-channel \
ksym-vanilla-snd-dmaengine-pcm-set-config-from-dai-data \
ksym-vanilla-snd-dmaengine-pcm-sync-stop \
ksym-vanilla-snd-dmaengine-pcm-trigger \
ksym-vanilla-snd-dmaengine-pcm-unregister \
ksym-vanilla-snd-ecards-limit \
ksym-vanilla-snd-fasync-free \
ksym-vanilla-snd-fasync-helper \
ksym-vanilla-snd-fw-transaction \
ksym-vanilla-snd-hda-activate-path \
ksym-vanilla-snd-hda-add-imux-item \
ksym-vanilla-snd-hda-add-new-ctls \
ksym-vanilla-snd-hda-add-new-path \
ksym-vanilla-snd-hda-add-verbs \
ksym-vanilla-snd-hda-add-vmaster-hook \
ksym-vanilla-snd-hda-apply-fixup \
ksym-vanilla-snd-hda-apply-pincfgs \
ksym-vanilla-snd-hda-apply-verbs \
ksym-vanilla-snd-hda-attach-beep-device \
ksym-vanilla-snd-hda-bus-type \
ksym-vanilla-snd-hda-check-amp-caps \
ksym-vanilla-snd-hda-check-amp-list-power \
ksym-vanilla-snd-hda-codec-amp-init \
ksym-vanilla-snd-hda-codec-amp-init-stereo \
ksym-vanilla-snd-hda-codec-amp-stereo \
ksym-vanilla-snd-hda-codec-amp-update \
ksym-vanilla-snd-hda-codec-build-controls \
ksym-vanilla-snd-hda-codec-cleanup \
ksym-vanilla-snd-hda-codec-cleanup-for-unbind \
ksym-vanilla-snd-hda-codec-configure \
ksym-vanilla-snd-hda-codec-device-init \
ksym-vanilla-snd-hda-codec-device-new \
ksym-vanilla-snd-hda-codec-eapd-power-filter \
ksym-vanilla-snd-hda-codec-get-pin-target \
ksym-vanilla-snd-hda-codec-get-pincfg \
ksym-vanilla-snd-hda-codec-load-dsp-cleanup \
ksym-vanilla-snd-hda-codec-load-dsp-prepare \
ksym-vanilla-snd-hda-codec-load-dsp-trigger \
ksym-vanilla-snd-hda-codec-new \
ksym-vanilla-snd-hda-codec-parse-pcms \
ksym-vanilla-snd-hda-codec-pcm-new \
ksym-vanilla-snd-hda-codec-prepare \
ksym-vanilla-snd-hda-codec-register \
ksym-vanilla-snd-hda-codec-set-gpio \
ksym-vanilla-snd-hda-codec-set-name \
ksym-vanilla-snd-hda-codec-set-pin-target \
ksym-vanilla-snd-hda-codec-set-pincfg \
ksym-vanilla-snd-hda-codec-set-power-save \
ksym-vanilla-snd-hda-codec-set-power-to-all \
ksym-vanilla-snd-hda-codec-setup-stream \
ksym-vanilla-snd-hda-codec-unregister \
ksym-vanilla-snd-hda-codec-update-widgets \
ksym-vanilla-snd-hda-correct-pin-ctl \
ksym-vanilla-snd-hda-create-dig-out-ctls \
ksym-vanilla-snd-hda-create-spdif-in-ctls \
ksym-vanilla-snd-hda-create-spdif-share-sw \
ksym-vanilla-snd-hda-ctl-add \
ksym-vanilla-snd-hda-detach-beep-device \
ksym-vanilla-snd-hda-enable-beep-device \
ksym-vanilla-snd-hda-enum-helper-info \
ksym-vanilla-snd-hda-ext-driver-register \
ksym-vanilla-snd-hda-ext-driver-unregister \
ksym-vanilla-snd-hda-find-mixer-ctl \
ksym-vanilla-snd-hda-gen-add-kctl \
ksym-vanilla-snd-hda-gen-add-micmute-led-cdev \
ksym-vanilla-snd-hda-gen-add-mute-led-cdev \
ksym-vanilla-snd-hda-gen-build-controls \
ksym-vanilla-snd-hda-gen-build-pcms \
ksym-vanilla-snd-hda-gen-check-power-status \
ksym-vanilla-snd-hda-gen-fix-pin-power \
ksym-vanilla-snd-hda-gen-hp-automute \
ksym-vanilla-snd-hda-gen-init \
ksym-vanilla-snd-hda-gen-line-automute \
ksym-vanilla-snd-hda-gen-mic-autoswitch \
ksym-vanilla-snd-hda-gen-parse-auto-config \
ksym-vanilla-snd-hda-gen-path-power-filter \
ksym-vanilla-snd-hda-gen-remove \
ksym-vanilla-snd-hda-gen-shutup-speakers \
ksym-vanilla-snd-hda-gen-spec-init \
ksym-vanilla-snd-hda-gen-stream-pm \
ksym-vanilla-snd-hda-gen-update-outputs \
ksym-vanilla-snd-hda-get-bool-hint \
ksym-vanilla-snd-hda-get-conn-index \
ksym-vanilla-snd-hda-get-conn-list \
ksym-vanilla-snd-hda-get-connections \
ksym-vanilla-snd-hda-get-default-vref \
ksym-vanilla-snd-hda-get-dev-select \
ksym-vanilla-snd-hda-get-hint \
ksym-vanilla-snd-hda-get-input-pin-attr \
ksym-vanilla-snd-hda-get-int-hint \
ksym-vanilla-snd-hda-get-num-devices \
ksym-vanilla-snd-hda-get-path-from-idx \
ksym-vanilla-snd-hda-get-path-idx \
ksym-vanilla-snd-hda-get-pin-label \
ksym-vanilla-snd-hda-hdmi-acomp-init \
ksym-vanilla-snd-hda-hdmi-acomp-master-bind \
ksym-vanilla-snd-hda-hdmi-acomp-master-unbind \
ksym-vanilla-snd-hda-hdmi-acomp-pin-eld-notify \
ksym-vanilla-snd-hda-hdmi-check-presence-and-report \
ksym-vanilla-snd-hda-hdmi-generic-alloc \
ksym-vanilla-snd-hda-hdmi-generic-build-controls \
ksym-vanilla-snd-hda-hdmi-generic-build-pcms \
ksym-vanilla-snd-hda-hdmi-generic-init \
ksym-vanilla-snd-hda-hdmi-generic-init-per-pins \
ksym-vanilla-snd-hda-hdmi-generic-pcm-cleanup \
ksym-vanilla-snd-hda-hdmi-generic-pcm-prepare \
ksym-vanilla-snd-hda-hdmi-generic-probe \
ksym-vanilla-snd-hda-hdmi-generic-remove \
ksym-vanilla-snd-hda-hdmi-generic-resume \
ksym-vanilla-snd-hda-hdmi-generic-spec-free \
ksym-vanilla-snd-hda-hdmi-generic-suspend \
ksym-vanilla-snd-hda-hdmi-generic-unsol-event \
ksym-vanilla-snd-hda-hdmi-parse-codec \
ksym-vanilla-snd-hda-hdmi-pin-id-to-pin-index \
ksym-vanilla-snd-hda-hdmi-setup-audio-infoframe \
ksym-vanilla-snd-hda-hdmi-setup-drm-audio-ops \
ksym-vanilla-snd-hda-hdmi-setup-stream \
ksym-vanilla-snd-hda-hdmi-simple-build-controls \
ksym-vanilla-snd-hda-hdmi-simple-build-pcms \
ksym-vanilla-snd-hda-hdmi-simple-init \
ksym-vanilla-snd-hda-hdmi-simple-pcm-open \
ksym-vanilla-snd-hda-hdmi-simple-probe \
ksym-vanilla-snd-hda-hdmi-simple-remove \
ksym-vanilla-snd-hda-hdmi-simple-unsol-event \
ksym-vanilla-snd-hda-input-mux-info \
ksym-vanilla-snd-hda-input-mux-put \
ksym-vanilla-snd-hda-jack-add-kctl-mst \
ksym-vanilla-snd-hda-jack-add-kctls \
ksym-vanilla-snd-hda-jack-bind-keymap \
ksym-vanilla-snd-hda-jack-detect-enable \
ksym-vanilla-snd-hda-jack-detect-enable-callback-mst \
ksym-vanilla-snd-hda-jack-detect-state-mst \
ksym-vanilla-snd-hda-jack-pin-sense \
ksym-vanilla-snd-hda-jack-poll-all \
ksym-vanilla-snd-hda-jack-report-sync \
ksym-vanilla-snd-hda-jack-set-button-state \
ksym-vanilla-snd-hda-jack-set-dirty-all \
ksym-vanilla-snd-hda-jack-set-gating-jack \
ksym-vanilla-snd-hda-jack-tbl-get-from-tag \
ksym-vanilla-snd-hda-jack-tbl-get-mst \
ksym-vanilla-snd-hda-jack-unsol-event \
ksym-vanilla-snd-hda-load-patch \
ksym-vanilla-snd-hda-lock-devices \
ksym-vanilla-snd-hda-mixer-amp-switch-get \
ksym-vanilla-snd-hda-mixer-amp-switch-get-beep \
ksym-vanilla-snd-hda-mixer-amp-switch-info \
ksym-vanilla-snd-hda-mixer-amp-switch-put \
ksym-vanilla-snd-hda-mixer-amp-switch-put-beep \
ksym-vanilla-snd-hda-mixer-amp-tlv \
ksym-vanilla-snd-hda-mixer-amp-volume-get \
ksym-vanilla-snd-hda-mixer-amp-volume-info \
ksym-vanilla-snd-hda-mixer-amp-volume-put \
ksym-vanilla-snd-hda-multi-out-analog-cleanup \
ksym-vanilla-snd-hda-multi-out-analog-open \
ksym-vanilla-snd-hda-multi-out-analog-prepare \
ksym-vanilla-snd-hda-multi-out-dig-cleanup \
ksym-vanilla-snd-hda-multi-out-dig-close \
ksym-vanilla-snd-hda-multi-out-dig-open \
ksym-vanilla-snd-hda-multi-out-dig-prepare \
ksym-vanilla-snd-hda-override-amp-caps \
ksym-vanilla-snd-hda-override-conn-list \
ksym-vanilla-snd-hda-parse-pin-defcfg \
ksym-vanilla-snd-hda-pick-fixup \
ksym-vanilla-snd-hda-pick-pin-fixup \
ksym-vanilla-snd-hda-sequence-write \
ksym-vanilla-snd-hda-set-dev-select \
ksym-vanilla-snd-hda-set-power-save \
ksym-vanilla-snd-hda-set-vmaster-tlv \
ksym-vanilla-snd-hda-shutup-pins \
ksym-vanilla-snd-hda-spdif-ctls-assign \
ksym-vanilla-snd-hda-spdif-ctls-unassign \
ksym-vanilla-snd-hda-spdif-out-of-nid \
ksym-vanilla-snd-hda-sync-vmaster-hook \
ksym-vanilla-snd-hda-unlock-devices \
ksym-vanilla-snd-hdac-acomp-exit \
ksym-vanilla-snd-hdac-acomp-get-eld \
ksym-vanilla-snd-hdac-acomp-init \
ksym-vanilla-snd-hdac-acomp-register-notifier \
ksym-vanilla-snd-hdac-add-chmap-ctls \
ksym-vanilla-snd-hdac-aligned-read \
ksym-vanilla-snd-hdac-aligned-write \
ksym-vanilla-snd-hdac-bus-alloc-stream-pages \
ksym-vanilla-snd-hdac-bus-enter-link-reset \
ksym-vanilla-snd-hdac-bus-exec-verb-unlocked \
ksym-vanilla-snd-hdac-bus-exit \
ksym-vanilla-snd-hdac-bus-exit-link-reset \
ksym-vanilla-snd-hdac-bus-free-stream-pages \
ksym-vanilla-snd-hdac-bus-get-response \
ksym-vanilla-snd-hdac-bus-handle-stream-irq \
ksym-vanilla-snd-hdac-bus-init \
ksym-vanilla-snd-hdac-bus-init-chip \
ksym-vanilla-snd-hdac-bus-init-cmd-io \
ksym-vanilla-snd-hdac-bus-link-power \
ksym-vanilla-snd-hdac-bus-parse-capabilities \
ksym-vanilla-snd-hdac-bus-reset-link \
ksym-vanilla-snd-hdac-bus-send-cmd \
ksym-vanilla-snd-hdac-bus-stop-chip \
ksym-vanilla-snd-hdac-bus-stop-cmd-io \
ksym-vanilla-snd-hdac-bus-update-rirb \
ksym-vanilla-snd-hdac-channel-allocation \
ksym-vanilla-snd-hdac-check-power-state \
ksym-vanilla-snd-hdac-chmap-to-spk-mask \
ksym-vanilla-snd-hdac-codec-link-down \
ksym-vanilla-snd-hdac-codec-link-up \
ksym-vanilla-snd-hdac-codec-modalias \
ksym-vanilla-snd-hdac-codec-read \
ksym-vanilla-snd-hdac-codec-write \
ksym-vanilla-snd-hdac-device-exit \
ksym-vanilla-snd-hdac-device-init \
ksym-vanilla-snd-hdac-device-register \
ksym-vanilla-snd-hdac-device-set-chip-name \
ksym-vanilla-snd-hdac-device-unregister \
ksym-vanilla-snd-hdac-display-power \
ksym-vanilla-snd-hdac-dsp-cleanup \
ksym-vanilla-snd-hdac-dsp-prepare \
ksym-vanilla-snd-hdac-dsp-trigger \
ksym-vanilla-snd-hdac-ext-bus-device-remove \
ksym-vanilla-snd-hdac-ext-bus-exit \
ksym-vanilla-snd-hdac-ext-bus-get-hlink-by-addr \
ksym-vanilla-snd-hdac-ext-bus-get-hlink-by-id \
ksym-vanilla-snd-hdac-ext-bus-get-hlink-by-name \
ksym-vanilla-snd-hdac-ext-bus-get-ml-capabilities \
ksym-vanilla-snd-hdac-ext-bus-init \
ksym-vanilla-snd-hdac-ext-bus-link-clear-stream-id \
ksym-vanilla-snd-hdac-ext-bus-link-get \
ksym-vanilla-snd-hdac-ext-bus-link-power \
ksym-vanilla-snd-hdac-ext-bus-link-power-down \
ksym-vanilla-snd-hdac-ext-bus-link-power-down-all \
ksym-vanilla-snd-hdac-ext-bus-link-power-up \
ksym-vanilla-snd-hdac-ext-bus-link-power-up-all \
ksym-vanilla-snd-hdac-ext-bus-link-put \
ksym-vanilla-snd-hdac-ext-bus-link-set-stream-id \
ksym-vanilla-snd-hdac-ext-bus-ppcap-enable \
ksym-vanilla-snd-hdac-ext-bus-ppcap-int-enable \
ksym-vanilla-snd-hdac-ext-cstream-assign \
ksym-vanilla-snd-hdac-ext-host-stream-setup \
ksym-vanilla-snd-hdac-ext-link-free-all \
ksym-vanilla-snd-hdac-ext-stream-assign \
ksym-vanilla-snd-hdac-ext-stream-clear \
ksym-vanilla-snd-hdac-ext-stream-decouple \
ksym-vanilla-snd-hdac-ext-stream-decouple-locked \
ksym-vanilla-snd-hdac-ext-stream-free-all \
ksym-vanilla-snd-hdac-ext-stream-init-all \
ksym-vanilla-snd-hdac-ext-stream-release \
ksym-vanilla-snd-hdac-ext-stream-reset \
ksym-vanilla-snd-hdac-ext-stream-setup \
ksym-vanilla-snd-hdac-ext-stream-start \
ksym-vanilla-snd-hdac-get-active-channels \
ksym-vanilla-snd-hdac-get-ch-alloc-from-ca \
ksym-vanilla-snd-hdac-get-connections \
ksym-vanilla-snd-hdac-get-stream \
ksym-vanilla-snd-hdac-get-stream-stripe-ctl \
ksym-vanilla-snd-hdac-get-sub-nodes \
ksym-vanilla-snd-hdac-i915-init \
ksym-vanilla-snd-hdac-i915-set-bclk \
ksym-vanilla-snd-hdac-is-supported-format \
ksym-vanilla-snd-hdac-override-parm \
ksym-vanilla-snd-hdac-power-down \
ksym-vanilla-snd-hdac-power-down-pm \
ksym-vanilla-snd-hdac-power-up \
ksym-vanilla-snd-hdac-power-up-pm \
ksym-vanilla-snd-hdac-print-channel-allocation \
ksym-vanilla-snd-hdac-query-supported-pcm \
ksym-vanilla-snd-hdac-read \
ksym-vanilla-snd-hdac-read-parm-uncached \
ksym-vanilla-snd-hdac-refresh-widgets \
ksym-vanilla-snd-hdac-register-chmap-ops \
ksym-vanilla-snd-hdac-regmap-add-vendor-verb \
ksym-vanilla-snd-hdac-regmap-exit \
ksym-vanilla-snd-hdac-regmap-init \
ksym-vanilla-snd-hdac-regmap-read-raw \
ksym-vanilla-snd-hdac-regmap-sync \
ksym-vanilla-snd-hdac-regmap-update-raw \
ksym-vanilla-snd-hdac-regmap-update-raw-once \
ksym-vanilla-snd-hdac-regmap-write-raw \
ksym-vanilla-snd-hdac-set-codec-wakeup \
ksym-vanilla-snd-hdac-setup-channel-mapping \
ksym-vanilla-snd-hdac-spdif-stream-format \
ksym-vanilla-snd-hdac-spk-to-chmap \
ksym-vanilla-snd-hdac-stop-streams \
ksym-vanilla-snd-hdac-stop-streams-and-chip \
ksym-vanilla-snd-hdac-stream-assign \
ksym-vanilla-snd-hdac-stream-cleanup \
ksym-vanilla-snd-hdac-stream-drsm-enable \
ksym-vanilla-snd-hdac-stream-format \
ksym-vanilla-snd-hdac-stream-format-bits \
ksym-vanilla-snd-hdac-stream-init \
ksym-vanilla-snd-hdac-stream-release \
ksym-vanilla-snd-hdac-stream-release-locked \
ksym-vanilla-snd-hdac-stream-reset \
ksym-vanilla-snd-hdac-stream-set-dpibr \
ksym-vanilla-snd-hdac-stream-set-lpib \
ksym-vanilla-snd-hdac-stream-set-params \
ksym-vanilla-snd-hdac-stream-set-spib \
ksym-vanilla-snd-hdac-stream-setup \
ksym-vanilla-snd-hdac-stream-setup-periods \
ksym-vanilla-snd-hdac-stream-spbcap-enable \
ksym-vanilla-snd-hdac-stream-start \
ksym-vanilla-snd-hdac-stream-stop \
ksym-vanilla-snd-hdac-stream-sync \
ksym-vanilla-snd-hdac-stream-sync-trigger \
ksym-vanilla-snd-hdac-stream-timecounter-init \
ksym-vanilla-snd-hdac-stream-wait-drsm \
ksym-vanilla-snd-hdac-sync-audio-rate \
ksym-vanilla-snd-hdac-sync-power-state \
ksym-vanilla-snd-hwdep-new \
ksym-vanilla-snd-hwparams-to-dma-slave-config \
ksym-vanilla-snd-i2c-bus-create \
ksym-vanilla-snd-i2c-device-create \
ksym-vanilla-snd-i2c-device-free \
ksym-vanilla-snd-i2c-probeaddr \
ksym-vanilla-snd-i2c-readbytes \
ksym-vanilla-snd-i2c-sendbytes \
ksym-vanilla-snd-ice1712-akm4xxx-build-controls \
ksym-vanilla-snd-ice1712-akm4xxx-free \
ksym-vanilla-snd-ice1712-akm4xxx-init \
ksym-vanilla-snd-info-create-card-entry \
ksym-vanilla-snd-info-create-module-entry \
ksym-vanilla-snd-info-free-entry \
ksym-vanilla-snd-info-get-line \
ksym-vanilla-snd-info-get-str \
ksym-vanilla-snd-info-register \
ksym-vanilla-snd-intel-acpi-dsp-driver-probe \
ksym-vanilla-snd-intel-dsp-driver-probe \
ksym-vanilla-snd-interval-list \
ksym-vanilla-snd-interval-ranges \
ksym-vanilla-snd-interval-ratnum \
ksym-vanilla-snd-interval-refine \
ksym-vanilla-snd-jack-add-new-kctl \
ksym-vanilla-snd-jack-new \
ksym-vanilla-snd-jack-report \
ksym-vanilla-snd-jack-set-key \
ksym-vanilla-snd-kill-fasync \
ksym-vanilla-snd-lookup-minor-data \
ksym-vanilla-snd-lookup-oss-minor-data \
ksym-vanilla-snd-major \
ksym-vanilla-snd-midi-channel-alloc-set \
ksym-vanilla-snd-midi-channel-free-set \
ksym-vanilla-snd-midi-channel-set-clear \
ksym-vanilla-snd-midi-event-decode \
ksym-vanilla-snd-midi-event-encode-byte \
ksym-vanilla-snd-midi-event-free \
ksym-vanilla-snd-midi-event-new \
ksym-vanilla-snd-midi-event-no-status \
ksym-vanilla-snd-midi-event-reset-decode \
ksym-vanilla-snd-midi-event-reset-encode \
ksym-vanilla-snd-midi-process-event \
ksym-vanilla-snd-mixer-oss-ioctl-card \
ksym-vanilla-snd-mixer-oss-notify-callback \
ksym-vanilla-snd-mpu401-uart-interrupt \
ksym-vanilla-snd-mpu401-uart-interrupt-tx \
ksym-vanilla-snd-mpu401-uart-new \
ksym-vanilla-snd-opl3-create \
ksym-vanilla-snd-opl3-find-patch \
ksym-vanilla-snd-opl3-hwdep-new \
ksym-vanilla-snd-opl3-init \
ksym-vanilla-snd-opl3-interrupt \
ksym-vanilla-snd-opl3-load-patch \
ksym-vanilla-snd-opl3-new \
ksym-vanilla-snd-opl3-regmap \
ksym-vanilla-snd-opl3-reset \
ksym-vanilla-snd-opl3-timer-new \
ksym-vanilla-snd-oss-info-register \
ksym-vanilla-snd-parse-eld \
ksym-vanilla-snd-pci-quirk-lookup \
ksym-vanilla-snd-pci-quirk-lookup-id \
ksym-vanilla-snd-pcm-2-1-chmaps \
ksym-vanilla-snd-pcm-add-chmap-ctls \
ksym-vanilla-snd-pcm-alt-chmaps \
ksym-vanilla-snd-pcm-create-iec958-consumer \
ksym-vanilla-snd-pcm-create-iec958-consumer-default \
ksym-vanilla-snd-pcm-create-iec958-consumer-hw-params \
ksym-vanilla-snd-pcm-debug-name \
ksym-vanilla-snd-pcm-fill-iec958-consumer \
ksym-vanilla-snd-pcm-fill-iec958-consumer-hw-params \
ksym-vanilla-snd-pcm-format-big-endian \
ksym-vanilla-snd-pcm-format-linear \
ksym-vanilla-snd-pcm-format-little-endian \
ksym-vanilla-snd-pcm-format-name \
ksym-vanilla-snd-pcm-format-physical-width \
ksym-vanilla-snd-pcm-format-set-silence \
ksym-vanilla-snd-pcm-format-signed \
ksym-vanilla-snd-pcm-format-silence-64 \
ksym-vanilla-snd-pcm-format-size \
ksym-vanilla-snd-pcm-format-unsigned \
ksym-vanilla-snd-pcm-format-width \
ksym-vanilla-snd-pcm-get-state \
ksym-vanilla-snd-pcm-hw-constraint-eld \
ksym-vanilla-snd-pcm-hw-constraint-integer \
ksym-vanilla-snd-pcm-hw-constraint-list \
ksym-vanilla-snd-pcm-hw-constraint-mask64 \
ksym-vanilla-snd-pcm-hw-constraint-minmax \
ksym-vanilla-snd-pcm-hw-constraint-msbits \
ksym-vanilla-snd-pcm-hw-constraint-pow2 \
ksym-vanilla-snd-pcm-hw-constraint-ranges \
ksym-vanilla-snd-pcm-hw-constraint-ratdens \
ksym-vanilla-snd-pcm-hw-constraint-ratnums \
ksym-vanilla-snd-pcm-hw-constraint-step \
ksym-vanilla-snd-pcm-hw-limit-rates \
ksym-vanilla-snd-pcm-hw-param-first \
ksym-vanilla-snd-pcm-hw-param-last \
ksym-vanilla-snd-pcm-hw-param-value \
ksym-vanilla-snd-pcm-hw-params-bits \
ksym-vanilla-snd-pcm-hw-refine \
ksym-vanilla-snd-pcm-hw-rule-add \
ksym-vanilla-snd-pcm-hw-rule-noresample \
ksym-vanilla-snd-pcm-kernel-ioctl \
ksym-vanilla-snd-pcm-lib-default-mmap \
ksym-vanilla-snd-pcm-lib-free-pages \
ksym-vanilla-snd-pcm-lib-ioctl \
ksym-vanilla-snd-pcm-lib-malloc-pages \
ksym-vanilla-snd-pcm-lib-preallocate-free-for-all \
ksym-vanilla-snd-pcm-lib-preallocate-pages \
ksym-vanilla-snd-pcm-lib-preallocate-pages-for-all \
ksym-vanilla-snd-pcm-mmap-data \
ksym-vanilla-snd-pcm-new \
ksym-vanilla-snd-pcm-new-internal \
ksym-vanilla-snd-pcm-new-stream \
ksym-vanilla-snd-pcm-notify \
ksym-vanilla-snd-pcm-open-substream \
ksym-vanilla-snd-pcm-period-elapsed \
ksym-vanilla-snd-pcm-period-elapsed-under-stream-lock \
ksym-vanilla-snd-pcm-rate-bit-to-rate \
ksym-vanilla-snd-pcm-rate-mask-intersect \
ksym-vanilla-snd-pcm-rate-to-rate-bit \
ksym-vanilla-snd-pcm-release-substream \
ksym-vanilla-snd-pcm-runtime-buffer-set-silence \
ksym-vanilla-snd-pcm-set-managed-buffer \
ksym-vanilla-snd-pcm-set-managed-buffer-all \
ksym-vanilla-snd-pcm-set-ops \
ksym-vanilla-snd-pcm-set-state \
ksym-vanilla-snd-pcm-set-sync-per-card \
ksym-vanilla-snd-pcm-std-chmaps \
ksym-vanilla-snd-pcm-stop \
ksym-vanilla-snd-pcm-stop-xrun \
ksym-vanilla-snd-pcm-stream-lock \
ksym-vanilla-snd-pcm-stream-lock-irq \
ksym-vanilla-snd-pcm-stream-unlock \
ksym-vanilla-snd-pcm-stream-unlock-irq \
ksym-vanilla-snd-pcm-stream-unlock-irqrestore \
ksym-vanilla-snd-pcm-suspend-all \
ksym-vanilla-snd-power-ref-and-wait \
ksym-vanilla-snd-power-wait \
ksym-vanilla-snd-print-eld-info \
ksym-vanilla-snd-print-pcm-bits \
ksym-vanilla-snd-pt2258-build-controls \
ksym-vanilla-snd-pt2258-reset \
ksym-vanilla-snd-rawmidi-drain-input \
ksym-vanilla-snd-rawmidi-drain-output \
ksym-vanilla-snd-rawmidi-drop-output \
ksym-vanilla-snd-rawmidi-free \
ksym-vanilla-snd-rawmidi-info-select \
ksym-vanilla-snd-rawmidi-init \
ksym-vanilla-snd-rawmidi-input-params \
ksym-vanilla-snd-rawmidi-kernel-open \
ksym-vanilla-snd-rawmidi-kernel-read \
ksym-vanilla-snd-rawmidi-kernel-release \
ksym-vanilla-snd-rawmidi-kernel-write \
ksym-vanilla-snd-rawmidi-new \
ksym-vanilla-snd-rawmidi-output-params \
ksym-vanilla-snd-rawmidi-proceed \
ksym-vanilla-snd-rawmidi-receive \
ksym-vanilla-snd-rawmidi-set-ops \
ksym-vanilla-snd-rawmidi-transmit \
ksym-vanilla-snd-rawmidi-transmit-ack \
ksym-vanilla-snd-rawmidi-transmit-empty \
ksym-vanilla-snd-rawmidi-transmit-peek \
ksym-vanilla-snd-refcount-init \
ksym-vanilla-snd-refcount-put \
ksym-vanilla-snd-refcount-sync \
ksym-vanilla-snd-register-device \
ksym-vanilla-snd-register-oss-device \
ksym-vanilla-snd-request-card \
ksym-vanilla-snd-seq-autoload-exit \
ksym-vanilla-snd-seq-autoload-init \
ksym-vanilla-snd-seq-create-kernel-client \
ksym-vanilla-snd-seq-delete-kernel-client \
ksym-vanilla-snd-seq-device-load-drivers \
ksym-vanilla-snd-seq-device-new \
ksym-vanilla-snd-seq-driver-unregister \
ksym-vanilla-snd-seq-dump-var-event \
ksym-vanilla-snd-seq-event-port-attach \
ksym-vanilla-snd-seq-event-port-detach \
ksym-vanilla-snd-seq-expand-var-event \
ksym-vanilla-snd-seq-expand-var-event-at \
ksym-vanilla-snd-seq-kernel-client-ctl \
ksym-vanilla-snd-seq-kernel-client-dispatch \
ksym-vanilla-snd-seq-kernel-client-enqueue \
ksym-vanilla-snd-seq-kernel-client-get \
ksym-vanilla-snd-seq-kernel-client-ioctl \
ksym-vanilla-snd-seq-kernel-client-put \
ksym-vanilla-snd-seq-kernel-client-write-poll \
ksym-vanilla-snd-seq-root \
ksym-vanilla-snd-seq-set-queue-tempo \
ksym-vanilla-snd-seq-system-broadcast \
ksym-vanilla-snd-sgbuf-get-addr \
ksym-vanilla-snd-sgbuf-get-chunk-size \
ksym-vanilla-snd-sgbuf-get-page \
ksym-vanilla-snd-show-eld \
ksym-vanilla-snd-soc-acpi-amd-acp63-sof-machines \
ksym-vanilla-snd-soc-acpi-amd-acp70-sof-machines \
ksym-vanilla-snd-soc-acpi-amd-rmb-sof-machines \
ksym-vanilla-snd-soc-acpi-amd-sof-machines \
ksym-vanilla-snd-soc-acpi-amd-vangogh-sof-machines \
ksym-vanilla-snd-soc-acpi-codec-list \
ksym-vanilla-snd-soc-acpi-find-machine \
ksym-vanilla-snd-soc-acpi-find-package-from-hid \
ksym-vanilla-snd-soc-acpi-sdw-link-slaves-found \
ksym-vanilla-snd-soc-add-card-controls \
ksym-vanilla-snd-soc-add-component \
ksym-vanilla-snd-soc-add-component-controls \
ksym-vanilla-snd-soc-add-dai-controls \
ksym-vanilla-snd-soc-add-pcm-runtimes \
ksym-vanilla-snd-soc-alloc-ac97-component \
ksym-vanilla-snd-soc-bytes-get \
ksym-vanilla-snd-soc-bytes-info \
ksym-vanilla-snd-soc-bytes-info-ext \
ksym-vanilla-snd-soc-bytes-put \
ksym-vanilla-snd-soc-bytes-tlv-callback \
ksym-vanilla-snd-soc-calc-bclk \
ksym-vanilla-snd-soc-calc-frame-size \
ksym-vanilla-snd-soc-card-add-dai-link \
ksym-vanilla-snd-soc-card-get-kcontrol \
ksym-vanilla-snd-soc-card-jack-new \
ksym-vanilla-snd-soc-card-jack-new-pins \
ksym-vanilla-snd-soc-card-remove-dai-link \
ksym-vanilla-snd-soc-card-set-topology-name \
ksym-vanilla-snd-soc-close-delayed-work \
ksym-vanilla-snd-soc-cnew \
ksym-vanilla-snd-soc-component-async-complete \
ksym-vanilla-snd-soc-component-compr-ack \
ksym-vanilla-snd-soc-component-compr-copy \
ksym-vanilla-snd-soc-component-compr-free \
ksym-vanilla-snd-soc-component-compr-get-caps \
ksym-vanilla-snd-soc-component-compr-get-codec-caps \
ksym-vanilla-snd-soc-component-compr-get-metadata \
ksym-vanilla-snd-soc-component-compr-get-params \
ksym-vanilla-snd-soc-component-compr-open \
ksym-vanilla-snd-soc-component-compr-pointer \
ksym-vanilla-snd-soc-component-compr-set-metadata \
ksym-vanilla-snd-soc-component-compr-set-params \
ksym-vanilla-snd-soc-component-compr-trigger \
ksym-vanilla-snd-soc-component-exit-regmap \
ksym-vanilla-snd-soc-component-get-jack-type \
ksym-vanilla-snd-soc-component-get-kcontrol \
ksym-vanilla-snd-soc-component-init-regmap \
ksym-vanilla-snd-soc-component-initialize \
ksym-vanilla-snd-soc-component-notify-control \
ksym-vanilla-snd-soc-component-read \
ksym-vanilla-snd-soc-component-read-field \
ksym-vanilla-snd-soc-component-regmap-val-bytes \
ksym-vanilla-snd-soc-component-set-jack \
ksym-vanilla-snd-soc-component-set-pll \
ksym-vanilla-snd-soc-component-set-sysclk \
ksym-vanilla-snd-soc-component-test-bits \
ksym-vanilla-snd-soc-component-update-bits \
ksym-vanilla-snd-soc-component-update-bits-async \
ksym-vanilla-snd-soc-component-write \
ksym-vanilla-snd-soc-component-write-field \
ksym-vanilla-snd-soc-copy-dai-args \
ksym-vanilla-snd-soc-dai-action \
ksym-vanilla-snd-soc-dai-active \
ksym-vanilla-snd-soc-dai-compr-ack \
ksym-vanilla-snd-soc-dai-compr-get-metadata \
ksym-vanilla-snd-soc-dai-compr-get-params \
ksym-vanilla-snd-soc-dai-compr-pointer \
ksym-vanilla-snd-soc-dai-compr-set-metadata \
ksym-vanilla-snd-soc-dai-compr-set-params \
ksym-vanilla-snd-soc-dai-compr-shutdown \
ksym-vanilla-snd-soc-dai-compr-startup \
ksym-vanilla-snd-soc-dai-compr-trigger \
ksym-vanilla-snd-soc-dai-digital-mute \
ksym-vanilla-snd-soc-dai-get-channel-map \
ksym-vanilla-snd-soc-dai-is-dummy \
ksym-vanilla-snd-soc-dai-name-get \
ksym-vanilla-snd-soc-dai-prepare \
ksym-vanilla-snd-soc-dai-set-bclk-clk \
ksym-vanilla-snd-soc-dai-set-bclk-ratio \
ksym-vanilla-snd-soc-dai-set-channel-map \
ksym-vanilla-snd-soc-dai-set-clkdiv \
ksym-vanilla-snd-soc-dai-set-fmt \
ksym-vanilla-snd-soc-dai-set-pll \
ksym-vanilla-snd-soc-dai-set-sysclk \
ksym-vanilla-snd-soc-dai-set-tdm-idle \
ksym-vanilla-snd-soc-dai-set-tdm-slot \
ksym-vanilla-snd-soc-dai-set-tristate \
ksym-vanilla-snd-soc-daifmt-clock-provider-flipped \
ksym-vanilla-snd-soc-daifmt-clock-provider-from-bitmap \
ksym-vanilla-snd-soc-daifmt-parse-clock-provider-raw \
ksym-vanilla-snd-soc-daifmt-parse-format \
ksym-vanilla-snd-soc-dapm-add-routes \
ksym-vanilla-snd-soc-dapm-clock-event \
ksym-vanilla-snd-soc-dapm-dai-free-widgets \
ksym-vanilla-snd-soc-dapm-dai-get-connected-widgets \
ksym-vanilla-snd-soc-dapm-del-routes \
ksym-vanilla-snd-soc-dapm-disable-pin \
ksym-vanilla-snd-soc-dapm-disable-pin-unlocked \
ksym-vanilla-snd-soc-dapm-enable-pin \
ksym-vanilla-snd-soc-dapm-enable-pin-unlocked \
ksym-vanilla-snd-soc-dapm-force-bias-level \
ksym-vanilla-snd-soc-dapm-force-enable-pin \
ksym-vanilla-snd-soc-dapm-force-enable-pin-unlocked \
ksym-vanilla-snd-soc-dapm-free-widget \
ksym-vanilla-snd-soc-dapm-get-bias-level \
ksym-vanilla-snd-soc-dapm-get-component-pin-switch \
ksym-vanilla-snd-soc-dapm-get-enum-double \
ksym-vanilla-snd-soc-dapm-get-idle-bias \
ksym-vanilla-snd-soc-dapm-get-pin-status \
ksym-vanilla-snd-soc-dapm-get-pin-switch \
ksym-vanilla-snd-soc-dapm-get-volsw \
ksym-vanilla-snd-soc-dapm-ignore-suspend \
ksym-vanilla-snd-soc-dapm-info-pin-switch \
ksym-vanilla-snd-soc-dapm-init-bias-level \
ksym-vanilla-snd-soc-dapm-kcontrol-get-value \
ksym-vanilla-snd-soc-dapm-kcontrol-to-component \
ksym-vanilla-snd-soc-dapm-kcontrol-to-dapm \
ksym-vanilla-snd-soc-dapm-kcontrol-to-widget \
ksym-vanilla-snd-soc-dapm-mixer-update-power \
ksym-vanilla-snd-soc-dapm-mux-update-power \
ksym-vanilla-snd-soc-dapm-new-control \
ksym-vanilla-snd-soc-dapm-new-controls \
ksym-vanilla-snd-soc-dapm-new-dai-widgets \
ksym-vanilla-snd-soc-dapm-new-widgets \
ksym-vanilla-snd-soc-dapm-pin-has-prefix \
ksym-vanilla-snd-soc-dapm-pinctrl-event \
ksym-vanilla-snd-soc-dapm-put-component-pin-switch \
ksym-vanilla-snd-soc-dapm-put-enum-double \
ksym-vanilla-snd-soc-dapm-put-pin-switch \
ksym-vanilla-snd-soc-dapm-put-volsw \
ksym-vanilla-snd-soc-dapm-regulator-event \
ksym-vanilla-snd-soc-dapm-set-idle-bias \
ksym-vanilla-snd-soc-dapm-stream-stop \
ksym-vanilla-snd-soc-dapm-sync \
ksym-vanilla-snd-soc-dapm-sync-unlocked \
ksym-vanilla-snd-soc-dapm-to-card \
ksym-vanilla-snd-soc-dapm-to-component \
ksym-vanilla-snd-soc-dapm-to-dev \
ksym-vanilla-snd-soc-dapm-widget-name-cmp \
ksym-vanilla-snd-soc-debugfs-root \
ksym-vanilla-snd-soc-dlc-is-dummy \
ksym-vanilla-snd-soc-dlc-use-cpu-as-platform \
ksym-vanilla-snd-soc-dpcm-get-substream \
ksym-vanilla-snd-soc-dpcm-runtime-update \
ksym-vanilla-snd-soc-dummy-dlc \
ksym-vanilla-snd-soc-find-dai \
ksym-vanilla-snd-soc-find-dai-with-mutex \
ksym-vanilla-snd-soc-free-ac97-component \
ksym-vanilla-snd-soc-get-dai-id \
ksym-vanilla-snd-soc-get-dai-name \
ksym-vanilla-snd-soc-get-dai-via-args \
ksym-vanilla-snd-soc-get-dlc \
ksym-vanilla-snd-soc-get-enum-double \
ksym-vanilla-snd-soc-get-pcm-runtime \
ksym-vanilla-snd-soc-get-stream-cpu \
ksym-vanilla-snd-soc-get-strobe \
ksym-vanilla-snd-soc-get-volsw \
ksym-vanilla-snd-soc-get-volsw-sx \
ksym-vanilla-snd-soc-get-xr-sx \
ksym-vanilla-snd-soc-hda-codec-dai-ops \
ksym-vanilla-snd-soc-info-enum-double \
ksym-vanilla-snd-soc-info-volsw \
ksym-vanilla-snd-soc-info-volsw-sx \
ksym-vanilla-snd-soc-info-xr-sx \
ksym-vanilla-snd-soc-jack-add-gpiods \
ksym-vanilla-snd-soc-jack-add-gpios \
ksym-vanilla-snd-soc-jack-add-pins \
ksym-vanilla-snd-soc-jack-add-zones \
ksym-vanilla-snd-soc-jack-free-gpios \
ksym-vanilla-snd-soc-jack-get-type \
ksym-vanilla-snd-soc-jack-notifier-register \
ksym-vanilla-snd-soc-jack-notifier-unregister \
ksym-vanilla-snd-soc-jack-report \
ksym-vanilla-snd-soc-limit-volume \
ksym-vanilla-snd-soc-link-compr-set-params \
ksym-vanilla-snd-soc-link-compr-shutdown \
ksym-vanilla-snd-soc-link-compr-startup \
ksym-vanilla-snd-soc-lookup-component \
ksym-vanilla-snd-soc-lookup-component-by-name \
ksym-vanilla-snd-soc-lookup-component-nolocked \
ksym-vanilla-snd-soc-new-ac97-component \
ksym-vanilla-snd-soc-new-compress \
ksym-vanilla-snd-soc-of-get-dai-link-codecs \
ksym-vanilla-snd-soc-of-get-dai-link-cpus \
ksym-vanilla-snd-soc-of-get-dai-name \
ksym-vanilla-snd-soc-of-get-dlc \
ksym-vanilla-snd-soc-of-get-slot-mask \
ksym-vanilla-snd-soc-of-parse-audio-routing \
ksym-vanilla-snd-soc-of-parse-audio-simple-widgets \
ksym-vanilla-snd-soc-of-parse-aux-devs \
ksym-vanilla-snd-soc-of-parse-card-name \
ksym-vanilla-snd-soc-of-parse-ignore-suspend-widgets \
ksym-vanilla-snd-soc-of-parse-node-prefix \
ksym-vanilla-snd-soc-of-parse-pin-switches \
ksym-vanilla-snd-soc-of-parse-tdm-slot \
ksym-vanilla-snd-soc-of-put-dai-link-codecs \
ksym-vanilla-snd-soc-of-put-dai-link-cpus \
ksym-vanilla-snd-soc-params-to-bclk \
ksym-vanilla-snd-soc-params-to-frame-size \
ksym-vanilla-snd-soc-pm-ops \
ksym-vanilla-snd-soc-poweroff \
ksym-vanilla-snd-soc-put-enum-double \
ksym-vanilla-snd-soc-put-strobe \
ksym-vanilla-snd-soc-put-volsw \
ksym-vanilla-snd-soc-put-volsw-sx \
ksym-vanilla-snd-soc-put-xr-sx \
ksym-vanilla-snd-soc-register-card \
ksym-vanilla-snd-soc-register-component \
ksym-vanilla-snd-soc-register-dai \
ksym-vanilla-snd-soc-remove-pcm-runtime \
ksym-vanilla-snd-soc-resume \
ksym-vanilla-snd-soc-ret \
ksym-vanilla-snd-soc-rtdcom-lookup \
ksym-vanilla-snd-soc-runtime-action \
ksym-vanilla-snd-soc-runtime-calc-hw \
ksym-vanilla-snd-soc-runtime-set-dai-fmt \
ksym-vanilla-snd-soc-set-ac97-ops \
ksym-vanilla-snd-soc-set-ac97-ops-of-reset \
ksym-vanilla-snd-soc-suspend \
ksym-vanilla-snd-soc-tdm-params-to-bclk \
ksym-vanilla-snd-soc-tplg-component-load \
ksym-vanilla-snd-soc-tplg-component-remove \
ksym-vanilla-snd-soc-tplg-widget-bind-event \
ksym-vanilla-snd-soc-unregister-card \
ksym-vanilla-snd-soc-unregister-component-by-driver \
ksym-vanilla-snd-soc-unregister-dai \
ksym-vanilla-snd-soc-usb-add-port \
ksym-vanilla-snd-soc-usb-allocate-port \
ksym-vanilla-snd-soc-usb-connect \
ksym-vanilla-snd-soc-usb-disconnect \
ksym-vanilla-snd-soc-usb-find-priv-data \
ksym-vanilla-snd-soc-usb-find-supported-format \
ksym-vanilla-snd-soc-usb-free-port \
ksym-vanilla-snd-soc-usb-remove-port \
ksym-vanilla-snd-soc-usb-setup-offload-jack \
ksym-vanilla-snd-soc-usb-update-offload-route \
ksym-vanilla-snd-sof-boot-dsp-firmware \
ksym-vanilla-snd-sof-complete \
ksym-vanilla-snd-sof-create-page-table \
ksym-vanilla-snd-sof-dbg-init \
ksym-vanilla-snd-sof-dbg-memory-info-init \
ksym-vanilla-snd-sof-debugfs-add-region-item-iomem \
ksym-vanilla-snd-sof-debugfs-buf-item \
ksym-vanilla-snd-sof-device-probe \
ksym-vanilla-snd-sof-device-probe-completed \
ksym-vanilla-snd-sof-device-remove \
ksym-vanilla-snd-sof-device-shutdown \
ksym-vanilla-snd-sof-dsp-dbg-dump \
ksym-vanilla-snd-sof-dsp-only-d0i3-compatible-stream-active \
ksym-vanilla-snd-sof-dsp-panic \
ksym-vanilla-snd-sof-dsp-update-bits \
ksym-vanilla-snd-sof-dsp-update-bits-forced \
ksym-vanilla-snd-sof-dsp-update-bits-unlocked \
ksym-vanilla-snd-sof-dsp-update-bits64 \
ksym-vanilla-snd-sof-dsp-update-bits64-unlocked \
ksym-vanilla-snd-sof-free-debug \
ksym-vanilla-snd-sof-fw-unload \
ksym-vanilla-snd-sof-handle-fw-exception \
ksym-vanilla-snd-sof-ipc-free \
ksym-vanilla-snd-sof-ipc-get-reply \
ksym-vanilla-snd-sof-ipc-init \
ksym-vanilla-snd-sof-ipc-reply \
ksym-vanilla-snd-sof-load-firmware-memcpy \
ksym-vanilla-snd-sof-load-firmware-raw \
ksym-vanilla-snd-sof-load-topology \
ksym-vanilla-snd-sof-pci-update-bits \
ksym-vanilla-snd-sof-pcm-period-elapsed \
ksym-vanilla-snd-sof-prepare \
ksym-vanilla-snd-sof-resume \
ksym-vanilla-snd-sof-run-firmware \
ksym-vanilla-snd-sof-runtime-idle \
ksym-vanilla-snd-sof-runtime-resume \
ksym-vanilla-snd-sof-runtime-suspend \
ksym-vanilla-snd-sof-suspend \
ksym-vanilla-snd-tea575x-enum-freq-bands \
ksym-vanilla-snd-tea575x-exit \
ksym-vanilla-snd-tea575x-g-tuner \
ksym-vanilla-snd-tea575x-hw-init \
ksym-vanilla-snd-tea575x-init \
ksym-vanilla-snd-tea575x-s-hw-freq-seek \
ksym-vanilla-snd-tea575x-set-freq \
ksym-vanilla-snd-timer-close \
ksym-vanilla-snd-timer-continue \
ksym-vanilla-snd-timer-global-free \
ksym-vanilla-snd-timer-global-new \
ksym-vanilla-snd-timer-global-register \
ksym-vanilla-snd-timer-instance-free \
ksym-vanilla-snd-timer-instance-new \
ksym-vanilla-snd-timer-interrupt \
ksym-vanilla-snd-timer-new \
ksym-vanilla-snd-timer-notify \
ksym-vanilla-snd-timer-open \
ksym-vanilla-snd-timer-pause \
ksym-vanilla-snd-timer-resolution \
ksym-vanilla-snd-timer-start \
ksym-vanilla-snd-timer-stop \
ksym-vanilla-snd-timeri-timer-get \
ksym-vanilla-snd-timeri-timer-put \
ksym-vanilla-snd-ump-attach-legacy-rawmidi \
ksym-vanilla-snd-ump-block-new \
ksym-vanilla-snd-ump-convert-from-ump \
ksym-vanilla-snd-ump-convert-to-ump \
ksym-vanilla-snd-ump-endpoint-new \
ksym-vanilla-snd-ump-parse-endpoint \
ksym-vanilla-snd-ump-receive \
ksym-vanilla-snd-ump-receive-ump-val \
ksym-vanilla-snd-ump-switch-protocol \
ksym-vanilla-snd-ump-transmit \
ksym-vanilla-snd-ump-update-group-attrs \
ksym-vanilla-snd-unregister-device \
ksym-vanilla-snd-unregister-oss-device \
ksym-vanilla-snd-usb-autoresume \
ksym-vanilla-snd-usb-autosuspend \
ksym-vanilla-snd-usb-endpoint-prepare \
ksym-vanilla-snd-usb-find-csint-desc \
ksym-vanilla-snd-usb-find-format \
ksym-vanilla-snd-usb-find-substream-format \
ksym-vanilla-snd-usb-find-suppported-substream \
ksym-vanilla-snd-usb-hw-free \
ksym-vanilla-snd-usb-hw-params \
ksym-vanilla-snd-usb-lock-shutdown \
ksym-vanilla-snd-usb-rediscover-devices \
ksym-vanilla-snd-usb-register-platform-ops \
ksym-vanilla-snd-usb-unlock-shutdown \
ksym-vanilla-snd-usb-unregister-platform-ops \
ksym-vanilla-snd-usbmidi-disconnect \
ksym-vanilla-snd-usbmidi-input-start \
ksym-vanilla-snd-usbmidi-input-stop \
ksym-vanilla-snd-usbmidi-resume \
ksym-vanilla-snd-usbmidi-suspend \
ksym-vanilla-snd-use-lock-sync-helper \
ksym-vanilla-snd-virmidi-new \
ksym-vanilla-snd-vx-check-reg-bit \
ksym-vanilla-snd-vx-create \
ksym-vanilla-snd-vx-dsp-boot \
ksym-vanilla-snd-vx-dsp-load \
ksym-vanilla-snd-vx-free-firmware \
ksym-vanilla-snd-vx-irq-handler \
ksym-vanilla-snd-vx-load-boot-image \
ksym-vanilla-snd-vx-resume \
ksym-vanilla-snd-vx-setup-firmware \
ksym-vanilla-snd-vx-suspend \
ksym-vanilla-snd-vx-threaded-irq-handler \
ksym-vanilla-snprintf \
ksym-vanilla-soc-ac97-ops \
ksym-vanilla-soc-attr-read-machine \
ksym-vanilla-soc-codec-dev-max98373 \
ksym-vanilla-soc-codec-dev-max98373-sdw \
ksym-vanilla-soc-device-match \
ksym-vanilla-soc-device-register \
ksym-vanilla-soc-device-unregister \
ksym-vanilla-soc-hda-ext-bus-ops \
ksym-vanilla-sock-alloc \
ksym-vanilla-sock-alloc-file \
ksym-vanilla-sock-alloc-send-pskb \
ksym-vanilla-sock-bind-add \
ksym-vanilla-sock-bindtoindex \
ksym-vanilla-sock-cmsg-send \
ksym-vanilla-sock-common-getsockopt \
ksym-vanilla-sock-common-recvmsg \
ksym-vanilla-sock-common-setsockopt \
ksym-vanilla-sock-copy-user-timeval \
ksym-vanilla-sock-create \
ksym-vanilla-sock-create-kern \
ksym-vanilla-sock-create-lite \
ksym-vanilla-sock-dequeue-err-skb \
ksym-vanilla-sock-diag-check-cookie \
ksym-vanilla-sock-diag-destroy \
ksym-vanilla-sock-diag-put-filterinfo \
ksym-vanilla-sock-diag-put-meminfo \
ksym-vanilla-sock-diag-register \
ksym-vanilla-sock-diag-register-inet-compat \
ksym-vanilla-sock-diag-save-cookie \
ksym-vanilla-sock-diag-unregister \
ksym-vanilla-sock-diag-unregister-inet-compat \
ksym-vanilla-sock-edemux \
ksym-vanilla-sock-efree \
ksym-vanilla-sock-from-file \
ksym-vanilla-sock-gen-put \
ksym-vanilla-sock-get-timeout \
ksym-vanilla-sock-gettstamp \
ksym-vanilla-sock-init-data \
ksym-vanilla-sock-init-data-uid \
ksym-vanilla-sock-inuse-get \
ksym-vanilla-sock-ioctl-inout \
ksym-vanilla-sock-kfree-s \
ksym-vanilla-sock-kmalloc \
ksym-vanilla-sock-kmemdup \
ksym-vanilla-sock-kzfree-s \
ksym-vanilla-sock-load-diag-module \
ksym-vanilla-sock-map-close \
ksym-vanilla-sock-map-destroy \
ksym-vanilla-sock-map-unhash \
ksym-vanilla-sock-no-accept \
ksym-vanilla-sock-no-bind \
ksym-vanilla-sock-no-connect \
ksym-vanilla-sock-no-getname \
ksym-vanilla-sock-no-ioctl \
ksym-vanilla-sock-no-linger \
ksym-vanilla-sock-no-listen \
ksym-vanilla-sock-no-mmap \
ksym-vanilla-sock-no-recvmsg \
ksym-vanilla-sock-no-sendmsg \
ksym-vanilla-sock-no-sendmsg-locked \
ksym-vanilla-sock-no-shutdown \
ksym-vanilla-sock-no-socketpair \
ksym-vanilla-sock-pfree \
ksym-vanilla-sock-prot-inuse-get \
ksym-vanilla-sock-queue-err-skb \
ksym-vanilla-sock-queue-rcv-skb-reason \
ksym-vanilla-sock-recv-errqueue \
ksym-vanilla-sock-recvmsg \
ksym-vanilla-sock-register \
ksym-vanilla-sock-release \
ksym-vanilla-sock-rfree \
ksym-vanilla-sock-sendmsg \
ksym-vanilla-sock-set-keepalive \
ksym-vanilla-sock-set-mark \
ksym-vanilla-sock-set-priority \
ksym-vanilla-sock-set-rcvbuf \
ksym-vanilla-sock-set-reuseaddr \
ksym-vanilla-sock-set-reuseport \
ksym-vanilla-sock-set-sndtimeo \
ksym-vanilla-sock-setsockopt \
ksym-vanilla-sock-unregister \
ksym-vanilla-sock-wake-async \
ksym-vanilla-sock-wfree \
ksym-vanilla-sock-wmalloc \
ksym-vanilla-sockaddr-to-str \
ksym-vanilla-sockfd-lookup \
ksym-vanilla-sockopt-capable \
ksym-vanilla-sockopt-lock-sock \
ksym-vanilla-sockopt-ns-capable \
ksym-vanilla-sockopt-release-sock \
ksym-vanilla-sof-block-read \
ksym-vanilla-sof-block-write \
ksym-vanilla-sof-compressed-ops \
ksym-vanilla-sof-create-ipc-file-profile \
ksym-vanilla-sof-dai-get-bclk \
ksym-vanilla-sof-dai-get-mclk \
ksym-vanilla-sof-dai-get-tdm-slots \
ksym-vanilla-sof-debug-check-flag \
ksym-vanilla-sof-imx-ops \
ksym-vanilla-sof-io-read \
ksym-vanilla-sof-io-read64 \
ksym-vanilla-sof-io-write \
ksym-vanilla-sof-io-write64 \
ksym-vanilla-sof-ipc-msg-data \
ksym-vanilla-sof-ipc-set-get-data \
ksym-vanilla-sof-ipc-tx-message \
ksym-vanilla-sof-ipc-tx-message-no-pm \
ksym-vanilla-sof-ipc3-do-rx-work \
ksym-vanilla-sof-machine-register \
ksym-vanilla-sof-machine-unregister \
ksym-vanilla-sof-mailbox-read \
ksym-vanilla-sof-mailbox-write \
ksym-vanilla-sof-of-pm \
ksym-vanilla-sof-of-probe \
ksym-vanilla-sof-of-remove \
ksym-vanilla-sof-of-shutdown \
ksym-vanilla-sof-pcm-dai-link-fixup \
ksym-vanilla-sof-print-oops-and-stack \
ksym-vanilla-sof-set-fw-state \
ksym-vanilla-sof-set-stream-data-offset \
ksym-vanilla-sof-stream-pcm-close \
ksym-vanilla-sof-stream-pcm-open \
ksym-vanilla-sof-widget-free \
ksym-vanilla-sof-widget-setup \
ksym-vanilla-sof-xtensa-arch-ops \
ksym-vanilla-softnet-data \
ksym-vanilla-software-node-find-by-name \
ksym-vanilla-software-node-fwnode \
ksym-vanilla-software-node-register \
ksym-vanilla-software-node-register-node-group \
ksym-vanilla-software-node-unregister \
ksym-vanilla-software-node-unregister-node-group \
ksym-vanilla-sonet-copy-stats \
ksym-vanilla-sonet-subtract-stats \
ksym-vanilla-sophgo-pinctrl-probe \
ksym-vanilla-sort \
ksym-vanilla-sort-nonatomic \
ksym-vanilla-sort-r \
ksym-vanilla-sort-r-nonatomic \
ksym-vanilla-sound-class \
ksym-vanilla-sound-debugfs-root \
ksym-vanilla-sp8870-attach \
ksym-vanilla-sp887x-attach \
ksym-vanilla-sparse-keymap-entry-from-keycode \
ksym-vanilla-sparse-keymap-entry-from-scancode \
ksym-vanilla-sparse-keymap-report-entry \
ksym-vanilla-sparse-keymap-report-event \
ksym-vanilla-sparse-keymap-setup \
ksym-vanilla-spc-emulate-evpd-83 \
ksym-vanilla-spc-emulate-inquiry-std \
ksym-vanilla-spc-emulate-report-luns \
ksym-vanilla-spc-parse-cdb \
ksym-vanilla-spi-add-device \
ksym-vanilla-spi-alloc-device \
ksym-vanilla-spi-async \
ksym-vanilla-spi-attach-transport \
ksym-vanilla-spi-bitbang-cleanup \
ksym-vanilla-spi-bitbang-init \
ksym-vanilla-spi-bitbang-setup \
ksym-vanilla-spi-bitbang-setup-transfer \
ksym-vanilla-spi-bitbang-start \
ksym-vanilla-spi-bitbang-stop \
ksym-vanilla-spi-bus-lock \
ksym-vanilla-spi-bus-type \
ksym-vanilla-spi-bus-unlock \
ksym-vanilla-spi-controller-dma-map-mem-op-data \
ksym-vanilla-spi-controller-dma-unmap-mem-op-data \
ksym-vanilla-spi-controller-resume \
ksym-vanilla-spi-controller-suspend \
ksym-vanilla-spi-delay-exec \
ksym-vanilla-spi-delay-to-ns \
ksym-vanilla-spi-display-xfer-agreement \
ksym-vanilla-spi-dv-device \
ksym-vanilla-spi-finalize-current-message \
ksym-vanilla-spi-finalize-current-transfer \
ksym-vanilla-spi-get-device-id \
ksym-vanilla-spi-get-device-match-data \
ksym-vanilla-spi-get-next-queued-message \
ksym-vanilla-spi-mem-adjust-op-freq \
ksym-vanilla-spi-mem-adjust-op-size \
ksym-vanilla-spi-mem-calc-op-duration \
ksym-vanilla-spi-mem-default-supports-op \
ksym-vanilla-spi-mem-dirmap-create \
ksym-vanilla-spi-mem-dirmap-destroy \
ksym-vanilla-spi-mem-dirmap-read \
ksym-vanilla-spi-mem-dirmap-write \
ksym-vanilla-spi-mem-driver-register-with-owner \
ksym-vanilla-spi-mem-driver-unregister \
ksym-vanilla-spi-mem-exec-op \
ksym-vanilla-spi-mem-get-name \
ksym-vanilla-spi-mem-poll-status \
ksym-vanilla-spi-mem-supports-op \
ksym-vanilla-spi-new-ancillary-device \
ksym-vanilla-spi-new-device \
ksym-vanilla-spi-nor-scan \
ksym-vanilla-spi-offload-trigger-disable \
ksym-vanilla-spi-offload-trigger-enable \
ksym-vanilla-spi-offload-trigger-get-priv \
ksym-vanilla-spi-offload-trigger-validate \
ksym-vanilla-spi-optimize-message \
ksym-vanilla-spi-populate-ppr-msg \
ksym-vanilla-spi-populate-sync-msg \
ksym-vanilla-spi-populate-tag-msg \
ksym-vanilla-spi-populate-width-msg \
ksym-vanilla-spi-print-msg \
ksym-vanilla-spi-register-controller \
ksym-vanilla-spi-release-transport \
ksym-vanilla-spi-schedule-dv-device \
ksym-vanilla-spi-setup \
ksym-vanilla-spi-split-transfers-maxsize \
ksym-vanilla-spi-split-transfers-maxwords \
ksym-vanilla-spi-sync \
ksym-vanilla-spi-sync-locked \
ksym-vanilla-spi-take-timestamp-post \
ksym-vanilla-spi-take-timestamp-pre \
ksym-vanilla-spi-target-abort \
ksym-vanilla-spi-test-execute-msg \
ksym-vanilla-spi-test-run-test \
ksym-vanilla-spi-test-run-tests \
ksym-vanilla-spi-transfer-cs-change-delay-exec \
ksym-vanilla-spi-unoptimize-message \
ksym-vanilla-spi-unregister-controller \
ksym-vanilla-spi-unregister-device \
ksym-vanilla-spi-write-then-read \
ksym-vanilla-splice-direct-to-actor \
ksym-vanilla-splice-file-range \
ksym-vanilla-splice-to-pipe \
ksym-vanilla-split-key-done \
ksym-vanilla-split-page \
ksym-vanilla-spmi-command-reset \
ksym-vanilla-spmi-command-shutdown \
ksym-vanilla-spmi-command-sleep \
ksym-vanilla-spmi-command-wakeup \
ksym-vanilla-spmi-controller-add \
ksym-vanilla-spmi-controller-alloc \
ksym-vanilla-spmi-controller-remove \
ksym-vanilla-spmi-device-add \
ksym-vanilla-spmi-device-alloc \
ksym-vanilla-spmi-device-remove \
ksym-vanilla-spmi-ext-register-read \
ksym-vanilla-spmi-ext-register-readl \
ksym-vanilla-spmi-ext-register-write \
ksym-vanilla-spmi-ext-register-writel \
ksym-vanilla-spmi-find-device-by-of-node \
ksym-vanilla-spmi-register-read \
ksym-vanilla-spmi-register-write \
ksym-vanilla-spmi-register-zero-write \
ksym-vanilla-sprd-clk-probe \
ksym-vanilla-sprd-clk-regmap-init \
ksym-vanilla-sprd-comp-ops \
ksym-vanilla-sprd-div-helper-recalc-rate \
ksym-vanilla-sprd-div-helper-set-rate \
ksym-vanilla-sprd-div-ops \
ksym-vanilla-sprd-gate-ops \
ksym-vanilla-sprd-mcdt-chan-dma-disable \
ksym-vanilla-sprd-mcdt-chan-dma-enable \
ksym-vanilla-sprd-mcdt-chan-int-disable \
ksym-vanilla-sprd-mcdt-chan-int-enable \
ksym-vanilla-sprd-mcdt-chan-read \
ksym-vanilla-sprd-mcdt-chan-write \
ksym-vanilla-sprd-mcdt-free-chan \
ksym-vanilla-sprd-mcdt-request-chan \
ksym-vanilla-sprd-mux-helper-get-parent \
ksym-vanilla-sprd-mux-helper-set-parent \
ksym-vanilla-sprd-mux-ops \
ksym-vanilla-sprd-pinctrl-core-probe \
ksym-vanilla-sprd-pinctrl-remove \
ksym-vanilla-sprd-pinctrl-shutdown \
ksym-vanilla-sprd-pll-ops \
ksym-vanilla-sprd-pll-sc-gate-ops \
ksym-vanilla-sprd-pmic-detect-charger-type \
ksym-vanilla-sprd-sc-gate-ops \
ksym-vanilla-sprint-oid \
ksym-vanilla-sprint-symbol \
ksym-vanilla-sprint-symbol-build-id \
ksym-vanilla-sprint-symbol-no-offset \
ksym-vanilla-sprintf \
ksym-vanilla-sps30-probe \
ksym-vanilla-srcu-barrier \
ksym-vanilla-srcu-batches-completed \
ksym-vanilla-srcu-expedite-current \
ksym-vanilla-srcu-init-notifier-head \
ksym-vanilla-srcu-notifier-call-chain \
ksym-vanilla-srcu-notifier-chain-register \
ksym-vanilla-srcu-notifier-chain-unregister \
ksym-vanilla-srcu-torture-stats-print \
ksym-vanilla-srcutorture-get-gp-data \
ksym-vanilla-srgb-eotf \
ksym-vanilla-srgb-inv-eotf \
ksym-vanilla-srp-attach-transport \
ksym-vanilla-srp-parse-tmo \
ksym-vanilla-srp-reconnect-rport \
ksym-vanilla-srp-release-transport \
ksym-vanilla-srp-remove-host \
ksym-vanilla-srp-rport-add \
ksym-vanilla-srp-rport-del \
ksym-vanilla-srp-rport-get \
ksym-vanilla-srp-rport-put \
ksym-vanilla-srp-start-tl-fail-timers \
ksym-vanilla-srp-stop-rport-timers \
ksym-vanilla-srp-timed-out \
ksym-vanilla-srp-tmo-valid \
ksym-vanilla-ssam-client-bind \
ksym-vanilla-ssam-client-link \
ksym-vanilla-ssam-controller-device \
ksym-vanilla-ssam-controller-event-disable \
ksym-vanilla-ssam-controller-event-enable \
ksym-vanilla-ssam-controller-get \
ksym-vanilla-ssam-controller-put \
ksym-vanilla-ssam-controller-statelock \
ksym-vanilla-ssam-controller-stateunlock \
ksym-vanilla-ssam-device-add \
ksym-vanilla-ssam-device-alloc \
ksym-vanilla-ssam-device-driver-unregister \
ksym-vanilla-ssam-device-get-match \
ksym-vanilla-ssam-device-get-match-data \
ksym-vanilla-ssam-device-id-match \
ksym-vanilla-ssam-device-remove \
ksym-vanilla-ssam-device-type \
ksym-vanilla-ssam-get-controller \
ksym-vanilla-ssam-notifier-register \
ksym-vanilla-ssam-remove-clients \
ksym-vanilla-ssam-request-do-sync \
ksym-vanilla-ssam-request-do-sync-with-buffer \
ksym-vanilla-ssam-request-sync-alloc \
ksym-vanilla-ssam-request-sync-free \
ksym-vanilla-ssam-request-sync-init \
ksym-vanilla-ssam-request-sync-submit \
ksym-vanilla-ssam-request-write-data \
ksym-vanilla-ssb-admatch-base \
ksym-vanilla-ssb-admatch-size \
ksym-vanilla-ssb-bus-may-powerdown \
ksym-vanilla-ssb-bus-powerup \
ksym-vanilla-ssb-bus-resume \
ksym-vanilla-ssb-bus-sdiobus-register \
ksym-vanilla-ssb-bus-suspend \
ksym-vanilla-ssb-bus-unregister \
ksym-vanilla-ssb-chipco-gpio-control \
ksym-vanilla-ssb-clockspeed \
ksym-vanilla-ssb-commit-settings \
ksym-vanilla-ssb-device-disable \
ksym-vanilla-ssb-device-enable \
ksym-vanilla-ssb-device-is-enabled \
ksym-vanilla-ssb-dma-translation \
ksym-vanilla-ssb-driver-unregister \
ksym-vanilla-ssb-pcicore-dev-irqvecs-enable \
ksym-vanilla-ssb-pcihost-register \
ksym-vanilla-ssb-pmu-set-ldo-paref \
ksym-vanilla-ssb-pmu-set-ldo-voltage \
ksym-vanilla-ssb-pmu-spuravoid-pllupdate \
ksym-vanilla-ssb-set-devtypedata \
ksym-vanilla-sscanf \
ksym-vanilla-ssd130x-probe \
ksym-vanilla-ssd130x-remove \
ksym-vanilla-ssd130x-shutdown \
ksym-vanilla-ssd130x-variants \
ksym-vanilla-ssh-packet-get \
ksym-vanilla-ssh-packet-put \
ksym-vanilla-ssm2602-probe \
ksym-vanilla-ssm2602-regmap-config \
ksym-vanilla-st-accel-common-probe \
ksym-vanilla-st-accel-get-settings \
ksym-vanilla-st-lsm6dsx-pm-ops \
ksym-vanilla-st-lsm6dsx-probe \
ksym-vanilla-st-lsm9ds0-probe \
ksym-vanilla-st-magn-common-probe \
ksym-vanilla-st-magn-get-settings \
ksym-vanilla-st-nci-disable-se \
ksym-vanilla-st-nci-discover-se \
ksym-vanilla-st-nci-enable-se \
ksym-vanilla-st-nci-hci-cmd-received \
ksym-vanilla-st-nci-hci-event-received \
ksym-vanilla-st-nci-hci-load-session \
ksym-vanilla-st-nci-probe \
ksym-vanilla-st-nci-remove \
ksym-vanilla-st-nci-se-deinit \
ksym-vanilla-st-nci-se-init \
ksym-vanilla-st-nci-se-io \
ksym-vanilla-st-nci-vendor-cmds-init \
ksym-vanilla-st-press-common-probe \
ksym-vanilla-st-press-get-settings \
ksym-vanilla-st-sensors-allocate-trigger \
ksym-vanilla-st-sensors-debugfs-reg-access \
ksym-vanilla-st-sensors-dev-name-probe \
ksym-vanilla-st-sensors-get-settings-index \
ksym-vanilla-st-sensors-i2c-configure \
ksym-vanilla-st-sensors-init-sensor \
ksym-vanilla-st-sensors-power-enable \
ksym-vanilla-st-sensors-read-info-raw \
ksym-vanilla-st-sensors-set-axis-enable \
ksym-vanilla-st-sensors-set-dataready-irq \
ksym-vanilla-st-sensors-set-enable \
ksym-vanilla-st-sensors-set-fullscale-by-gain \
ksym-vanilla-st-sensors-set-odr \
ksym-vanilla-st-sensors-spi-configure \
ksym-vanilla-st-sensors-sysfs-sampling-frequency-avail \
ksym-vanilla-st-sensors-sysfs-scale-avail \
ksym-vanilla-st-sensors-trigger-handler \
ksym-vanilla-st-sensors-validate-device \
ksym-vanilla-st-sensors-verify-id \
ksym-vanilla-st-thermal-pm-ops \
ksym-vanilla-st-thermal-register \
ksym-vanilla-st-thermal-unregister \
ksym-vanilla-st-uvis25-pm-ops \
ksym-vanilla-st-uvis25-probe \
ksym-vanilla-st21nfca-apdu-reader-event-received \
ksym-vanilla-st21nfca-connectivity-event-received \
ksym-vanilla-st21nfca-dep-deinit \
ksym-vanilla-st21nfca-dep-event-received \
ksym-vanilla-st21nfca-dep-init \
ksym-vanilla-st21nfca-hci-disable-se \
ksym-vanilla-st21nfca-hci-discover-se \
ksym-vanilla-st21nfca-hci-enable-se \
ksym-vanilla-st21nfca-hci-loopback-event-received \
ksym-vanilla-st21nfca-hci-probe \
ksym-vanilla-st21nfca-hci-remove \
ksym-vanilla-st21nfca-hci-se-io \
ksym-vanilla-st21nfca-im-send-atr-req \
ksym-vanilla-st21nfca-im-send-dep-req \
ksym-vanilla-st21nfca-se-deinit \
ksym-vanilla-st21nfca-se-init \
ksym-vanilla-st21nfca-tm-send-dep-res \
ksym-vanilla-st21nfca-vendor-cmds-init \
ksym-vanilla-st33zp24-pm-resume \
ksym-vanilla-st33zp24-pm-suspend \
ksym-vanilla-st33zp24-probe \
ksym-vanilla-st33zp24-remove \
ksym-vanilla-st7567-config \
ksym-vanilla-st7571-config \
ksym-vanilla-st7571-probe \
ksym-vanilla-st7571-remove \
ksym-vanilla-st95hf-spi-recv-echo-res \
ksym-vanilla-st95hf-spi-recv-response \
ksym-vanilla-st95hf-spi-send \
ksym-vanilla-stable-page-flags \
ksym-vanilla-stack-depot-fetch \
ksym-vanilla-stack-depot-get-extra-bits \
ksym-vanilla-stack-depot-init \
ksym-vanilla-stack-depot-print \
ksym-vanilla-stack-depot-put \
ksym-vanilla-stack-depot-save \
ksym-vanilla-stack-depot-save-flags \
ksym-vanilla-stack-depot-set-extra-bits \
ksym-vanilla-stack-depot-snprint \
ksym-vanilla-stack-trace-print \
ksym-vanilla-stack-trace-save \
ksym-vanilla-stack-trace-save-tsk \
ksym-vanilla-stack-trace-snprint \
ksym-vanilla-starget-for-each-device \
ksym-vanilla-start-creating \
ksym-vanilla-start-creating-dentry \
ksym-vanilla-start-creating-killable \
ksym-vanilla-start-creating-noperm \
ksym-vanilla-start-creating-path \
ksym-vanilla-start-creating-user-path \
ksym-vanilla-start-poll-synchronize-rcu \
ksym-vanilla-start-poll-synchronize-rcu-expedited \
ksym-vanilla-start-poll-synchronize-rcu-expedited-full \
ksym-vanilla-start-poll-synchronize-rcu-full \
ksym-vanilla-start-poll-synchronize-srcu \
ksym-vanilla-start-removing \
ksym-vanilla-start-removing-dentry \
ksym-vanilla-start-removing-killable \
ksym-vanilla-start-removing-noperm \
ksym-vanilla-start-renaming \
ksym-vanilla-start-renaming-dentry \
ksym-vanilla-start-renaming-two-dentries \
ksym-vanilla-start-tty \
ksym-vanilla-static-dev-dax \
ksym-vanilla-static-key-count \
ksym-vanilla-static-key-disable \
ksym-vanilla-static-key-disable-cpuslocked \
ksym-vanilla-static-key-enable \
ksym-vanilla-static-key-enable-cpuslocked \
ksym-vanilla-static-key-fast-inc-not-disabled \
ksym-vanilla-static-key-initialized \
ksym-vanilla-static-key-slow-dec \
ksym-vanilla-static-key-slow-inc \
ksym-vanilla-stb0899-attach \
ksym-vanilla-stb6000-attach \
ksym-vanilla-stb6100-attach \
ksym-vanilla-stm-data-write \
ksym-vanilla-stm-register-device \
ksym-vanilla-stm-register-protocol \
ksym-vanilla-stm-source-register-device \
ksym-vanilla-stm-source-unregister-device \
ksym-vanilla-stm-source-write \
ksym-vanilla-stm-unregister-device \
ksym-vanilla-stm-unregister-protocol \
ksym-vanilla-stm32-dfsdm-get-buff-cb \
ksym-vanilla-stm32-dfsdm-release-buff-cb \
ksym-vanilla-stm32-dfsdm-start-dfsdm \
ksym-vanilla-stm32-dfsdm-stop-dfsdm \
ksym-vanilla-stm32-firewall-controller-register \
ksym-vanilla-stm32-firewall-controller-unregister \
ksym-vanilla-stm32-firewall-get-firewall \
ksym-vanilla-stm32-firewall-get-grant-all-access \
ksym-vanilla-stm32-firewall-grant-access \
ksym-vanilla-stm32-firewall-grant-access-by-id \
ksym-vanilla-stm32-firewall-populate-bus \
ksym-vanilla-stm32-firewall-release-access \
ksym-vanilla-stm32-firewall-release-access-by-id \
ksym-vanilla-stm32-pctl-probe \
ksym-vanilla-stm32-pinctrl-resume \
ksym-vanilla-stm32-pinctrl-suspend \
ksym-vanilla-stm32-timers-dma-burst-read \
ksym-vanilla-stmfx-function-disable \
ksym-vanilla-stmfx-function-enable \
ksym-vanilla-stmmac-axi-blen-to-mask \
ksym-vanilla-stmmac-dvr-probe \
ksym-vanilla-stmmac-dvr-remove \
ksym-vanilla-stmmac-get-mac-addr \
ksym-vanilla-stmmac-get-phy-intf-sel \
ksym-vanilla-stmmac-get-platform-resources \
ksym-vanilla-stmmac-mdio-lock \
ksym-vanilla-stmmac-mdio-unlock \
ksym-vanilla-stmmac-pci-plat-resume \
ksym-vanilla-stmmac-pci-plat-suspend \
ksym-vanilla-stmmac-plat-dat-alloc \
ksym-vanilla-stmmac-pltfr-find-clk \
ksym-vanilla-stmmac-pltfr-pm-ops \
ksym-vanilla-stmmac-pltfr-probe \
ksym-vanilla-stmmac-pltfr-remove \
ksym-vanilla-stmmac-resume \
ksym-vanilla-stmmac-set-clk-tx-rate \
ksym-vanilla-stmmac-set-mac-addr \
ksym-vanilla-stmmac-simple-pm-ops \
ksym-vanilla-stmmac-suspend \
ksym-vanilla-stmp-reset-block \
ksym-vanilla-stop-core-cpuslocked \
ksym-vanilla-stop-machine \
ksym-vanilla-stop-tty \
ksym-vanilla-store-cdrom-address \
ksym-vanilla-stp-proto-register \
ksym-vanilla-stp-proto-unregister \
ksym-vanilla-stpcpy \
ksym-vanilla-stratix10-svc-add-async-client \
ksym-vanilla-stratix10-svc-allocate-memory \
ksym-vanilla-stratix10-svc-async-done \
ksym-vanilla-stratix10-svc-async-poll \
ksym-vanilla-stratix10-svc-async-send \
ksym-vanilla-stratix10-svc-done \
ksym-vanilla-stratix10-svc-free-channel \
ksym-vanilla-stratix10-svc-free-memory \
ksym-vanilla-stratix10-svc-remove-async-client \
ksym-vanilla-stratix10-svc-request-channel-byname \
ksym-vanilla-stratix10-svc-send \
ksym-vanilla-strcasecmp \
ksym-vanilla-strcat \
ksym-vanilla-strchr \
ksym-vanilla-strchrnul \
ksym-vanilla-strcmp \
ksym-vanilla-strcpy \
ksym-vanilla-strcspn \
ksym-vanilla-stream-open \
ksym-vanilla-strim \
ksym-vanilla-string-escape-mem \
ksym-vanilla-string-get-size \
ksym-vanilla-string-unescape \
ksym-vanilla-strlcat \
ksym-vanilla-strlen \
ksym-vanilla-strncasecmp \
ksym-vanilla-strncat \
ksym-vanilla-strnchr \
ksym-vanilla-strncmp \
ksym-vanilla-strncpy-from-user \
ksym-vanilla-strndup-user \
ksym-vanilla-strnlen \
ksym-vanilla-strnlen-user \
ksym-vanilla-strnstr \
ksym-vanilla-strp-check-rcv \
ksym-vanilla-strp-data-ready \
ksym-vanilla-strp-done \
ksym-vanilla-strp-init \
ksym-vanilla-strp-process \
ksym-vanilla-strp-stop \
ksym-vanilla-strp-unpause \
ksym-vanilla-strpbrk \
ksym-vanilla-strrchr \
ksym-vanilla-strreplace \
ksym-vanilla-strsep \
ksym-vanilla-strspn \
ksym-vanilla-strstr \
ksym-vanilla-stutter-wait \
ksym-vanilla-stv0288-attach \
ksym-vanilla-stv0297-attach \
ksym-vanilla-stv0299-attach \
ksym-vanilla-stv0367cab-attach \
ksym-vanilla-stv0367ddb-attach \
ksym-vanilla-stv0367ter-attach \
ksym-vanilla-stv0900-attach \
ksym-vanilla-stv090x-attach \
ksym-vanilla-stv0910-attach \
ksym-vanilla-stv6110-attach \
ksym-vanilla-stv6110x-attach \
ksym-vanilla-stv6111-attach \
ksym-vanilla-subdev-8255-cb-init \
ksym-vanilla-subdev-8255-io-init \
ksym-vanilla-subdev-8255-mm-init \
ksym-vanilla-subdev-8255-regbase \
ksym-vanilla-submit-bio \
ksym-vanilla-submit-bio-noacct \
ksym-vanilla-submit-bio-wait \
ksym-vanilla-subsys-interface-register \
ksym-vanilla-subsys-interface-unregister \
ksym-vanilla-subsys-system-register \
ksym-vanilla-subsys-virtual-register \
ksym-vanilla-sun4i-dclk-create \
ksym-vanilla-sun4i-dclk-free \
ksym-vanilla-sun4i-lvds-init \
ksym-vanilla-sun4i-rgb-init \
ksym-vanilla-sun4i-tcon-enable-vblank \
ksym-vanilla-sun4i-tcon-mode-set \
ksym-vanilla-sun4i-tcon-of-table \
ksym-vanilla-sun4i-usb-phy-set-squelch-detect \
ksym-vanilla-sun8i-adda-pr-regmap-init \
ksym-vanilla-sun8i-tcon-top-de-config \
ksym-vanilla-sun8i-tcon-top-of-table \
ksym-vanilla-sun8i-tcon-top-set-hdmi-src \
ksym-vanilla-sungem-phy-probe \
ksym-vanilla-sunrpc-cache-lookup-rcu \
ksym-vanilla-sunrpc-cache-notify \
ksym-vanilla-sunrpc-cache-register-pipefs \
ksym-vanilla-sunrpc-cache-requests-count \
ksym-vanilla-sunrpc-cache-requests-snapshot \
ksym-vanilla-sunrpc-cache-unhash \
ksym-vanilla-sunrpc-cache-unregister-pipefs \
ksym-vanilla-sunrpc-cache-upcall \
ksym-vanilla-sunrpc-cache-upcall-warn \
ksym-vanilla-sunrpc-cache-update \
ksym-vanilla-sunrpc-destroy-cache-detail \
ksym-vanilla-sunrpc-get-pool-mode \
ksym-vanilla-sunrpc-init-cache-detail \
ksym-vanilla-sunrpc-net-id \
ksym-vanilla-sunrpc-set-pool-mode \
ksym-vanilla-sunxi-ccu-get-mmc-timing-mode \
ksym-vanilla-sunxi-ccu-set-mmc-timing-mode \
ksym-vanilla-sunxi-rsb-driver-register \
ksym-vanilla-sunxi-sram-claim \
ksym-vanilla-sunxi-sram-release \
ksym-vanilla-super-setup-bdi \
ksym-vanilla-super-setup-bdi-name \
ksym-vanilla-surface-hid-device-add \
ksym-vanilla-surface-hid-device-destroy \
ksym-vanilla-surface-hid-pm-ops \
ksym-vanilla-suspend-set-ops \
ksym-vanilla-suspend-valid-only-mem \
ksym-vanilla-svc-addsock \
ksym-vanilla-svc-age-temp-xprts-now \
ksym-vanilla-svc-auth-flavor \
ksym-vanilla-svc-auth-register \
ksym-vanilla-svc-auth-unregister \
ksym-vanilla-svc-bind \
ksym-vanilla-svc-create \
ksym-vanilla-svc-create-pooled \
ksym-vanilla-svc-destroy \
ksym-vanilla-svc-encode-result-payload \
ksym-vanilla-svc-exit-thread \
ksym-vanilla-svc-fill-symlink-pathname \
ksym-vanilla-svc-find-listener \
ksym-vanilla-svc-find-xprt \
ksym-vanilla-svc-generic-init-request \
ksym-vanilla-svc-generic-rpcbind-set \
ksym-vanilla-svc-max-payload \
ksym-vanilla-svc-new-thread \
ksym-vanilla-svc-pool-stats-open \
ksym-vanilla-svc-pool-wake-idle-thread \
ksym-vanilla-svc-print-addr \
ksym-vanilla-svc-proc-register \
ksym-vanilla-svc-proc-unregister \
ksym-vanilla-svc-recv \
ksym-vanilla-svc-reg-xprt-class \
ksym-vanilla-svc-reserve \
ksym-vanilla-svc-rqst-replace-page \
ksym-vanilla-svc-seq-show \
ksym-vanilla-svc-set-client \
ksym-vanilla-svc-set-num-threads \
ksym-vanilla-svc-set-pool-threads \
ksym-vanilla-svc-unreg-xprt-class \
ksym-vanilla-svc-wake-up \
ksym-vanilla-svc-xprt-close \
ksym-vanilla-svc-xprt-copy-addrs \
ksym-vanilla-svc-xprt-create \
ksym-vanilla-svc-xprt-create-from-sa \
ksym-vanilla-svc-xprt-deferred-close \
ksym-vanilla-svc-xprt-destroy-all \
ksym-vanilla-svc-xprt-enqueue \
ksym-vanilla-svc-xprt-init \
ksym-vanilla-svc-xprt-names \
ksym-vanilla-svc-xprt-put \
ksym-vanilla-svc-xprt-received \
ksym-vanilla-svcauth-gss-flavor \
ksym-vanilla-svcauth-gss-register-pseudoflavor \
ksym-vanilla-svcauth-map-clnt-to-svc-cred-local \
ksym-vanilla-svcauth-unix-purge \
ksym-vanilla-svcauth-unix-set-client \
ksym-vanilla-sw842-compress \
ksym-vanilla-sw842-decompress \
ksym-vanilla-swake-up-all \
ksym-vanilla-swake-up-locked \
ksym-vanilla-swake-up-one \
ksym-vanilla-switchdev-bridge-port-offload \
ksym-vanilla-switchdev-bridge-port-replay \
ksym-vanilla-switchdev-bridge-port-unoffload \
ksym-vanilla-switchdev-deferred-process \
ksym-vanilla-switchdev-handle-fdb-event-to-device \
ksym-vanilla-switchdev-handle-port-attr-set \
ksym-vanilla-switchdev-handle-port-obj-add \
ksym-vanilla-switchdev-handle-port-obj-add-foreign \
ksym-vanilla-switchdev-handle-port-obj-del \
ksym-vanilla-switchdev-handle-port-obj-del-foreign \
ksym-vanilla-switchdev-port-attr-set \
ksym-vanilla-switchdev-port-obj-act-is-deferred \
ksym-vanilla-switchdev-port-obj-add \
ksym-vanilla-switchdev-port-obj-del \
ksym-vanilla-switchtec-class \
ksym-vanilla-swnode-gpio-undefined \
ksym-vanilla-swphy-read-reg \
ksym-vanilla-swphy-validate-state \
ksym-vanilla-sx-common-events \
ksym-vanilla-sx-common-probe \
ksym-vanilla-sx-common-read-event-config \
ksym-vanilla-sx-common-read-proximity \
ksym-vanilla-sx-common-write-event-config \
ksym-vanilla-symbol-put-addr \
ksym-vanilla-sync-blockdev \
ksym-vanilla-sync-blockdev-nowait \
ksym-vanilla-sync-blockdev-range \
ksym-vanilla-sync-dirty-buffer \
ksym-vanilla-sync-file-create \
ksym-vanilla-sync-file-get-fence \
ksym-vanilla-sync-filesystem \
ksym-vanilla-sync-inode-metadata \
ksym-vanilla-sync-inodes-sb \
ksym-vanilla-sync-page-io \
ksym-vanilla-synchronize-hardirq \
ksym-vanilla-synchronize-irq \
ksym-vanilla-synchronize-net \
ksym-vanilla-synchronize-rcu \
ksym-vanilla-synchronize-rcu-expedited \
ksym-vanilla-synchronize-rcu-tasks \
ksym-vanilla-synchronize-rcu-tasks-rude \
ksym-vanilla-synchronize-srcu \
ksym-vanilla-synchronize-srcu-expedited \
ksym-vanilla-synproxy-init-timestamp-cookie \
ksym-vanilla-synproxy-net-id \
ksym-vanilla-synproxy-parse-options \
ksym-vanilla-synproxy-recv-client-ack \
ksym-vanilla-synproxy-recv-client-ack-ipv6 \
ksym-vanilla-synproxy-send-client-synack \
ksym-vanilla-synproxy-send-client-synack-ipv6 \
ksym-vanilla-synth-event-add-field \
ksym-vanilla-synth-event-add-field-str \
ksym-vanilla-synth-event-add-fields \
ksym-vanilla-synth-event-add-next-val \
ksym-vanilla-synth-event-add-val \
ksym-vanilla-synth-event-cmd-init \
ksym-vanilla-synth-event-create \
ksym-vanilla-synth-event-delete \
ksym-vanilla-synth-event-gen-cmd-array-start \
ksym-vanilla-synth-event-trace \
ksym-vanilla-synth-event-trace-array \
ksym-vanilla-synth-event-trace-end \
ksym-vanilla-synth-event-trace-start \
ksym-vanilla-sys-copyarea \
ksym-vanilla-sys-fillrect \
ksym-vanilla-sys-imageblit \
ksym-vanilla-sys-tz \
ksym-vanilla-syscon-node-to-regmap \
ksym-vanilla-syscon-regmap-lookup-by-compatible \
ksym-vanilla-syscon-regmap-lookup-by-phandle \
ksym-vanilla-syscon-regmap-lookup-by-phandle-args \
ksym-vanilla-syscon-regmap-lookup-by-phandle-optional \
ksym-vanilla-sysconfig-probe \
ksym-vanilla-syscore-resume \
ksym-vanilla-syscore-suspend \
ksym-vanilla-sysctl-devconf-inherit-init-net \
ksym-vanilla-sysctl-fb-tunnels-only-for-init-net \
ksym-vanilla-sysctl-long-vals \
ksym-vanilla-sysctl-nf-log-all-netns \
ksym-vanilla-sysctl-rmem-max \
ksym-vanilla-sysctl-vals \
ksym-vanilla-sysctl-wmem-max \
ksym-vanilla-sysfb-disable \
ksym-vanilla-sysfb-handles-screen-info \
ksym-vanilla-sysfb-primary-display \
ksym-vanilla-sysfs-add-file-to-group \
ksym-vanilla-sysfs-add-link-to-group \
ksym-vanilla-sysfs-bin-attr-simple-read \
ksym-vanilla-sysfs-break-active-protection \
ksym-vanilla-sysfs-chmod-file \
ksym-vanilla-sysfs-create-bin-file \
ksym-vanilla-sysfs-create-file-ns \
ksym-vanilla-sysfs-create-files \
ksym-vanilla-sysfs-create-group \
ksym-vanilla-sysfs-create-groups \
ksym-vanilla-sysfs-create-link \
ksym-vanilla-sysfs-create-link-nowarn \
ksym-vanilla-sysfs-create-mount-point \
ksym-vanilla-sysfs-emit \
ksym-vanilla-sysfs-emit-at \
ksym-vanilla-sysfs-format-mac \
ksym-vanilla-sysfs-group-change-owner \
ksym-vanilla-sysfs-groups-change-owner \
ksym-vanilla-sysfs-merge-group \
ksym-vanilla-sysfs-notify \
ksym-vanilla-sysfs-remove-bin-file \
ksym-vanilla-sysfs-remove-file-from-group \
ksym-vanilla-sysfs-remove-file-ns \
ksym-vanilla-sysfs-remove-file-self \
ksym-vanilla-sysfs-remove-files \
ksym-vanilla-sysfs-remove-group \
ksym-vanilla-sysfs-remove-groups \
ksym-vanilla-sysfs-remove-link \
ksym-vanilla-sysfs-remove-link-from-group \
ksym-vanilla-sysfs-remove-mount-point \
ksym-vanilla-sysfs-rename-link-ns \
ksym-vanilla-sysfs-streq \
ksym-vanilla-sysfs-unbreak-active-protection \
ksym-vanilla-sysfs-unmerge-group \
ksym-vanilla-sysfs-update-group \
ksym-vanilla-sysfs-update-groups \
ksym-vanilla-sysrq-mask \
ksym-vanilla-sysrq-toggle-support \
ksym-vanilla-system-bh-highpri-wq \
ksym-vanilla-system-bh-wq \
ksym-vanilla-system-cpucaps \
ksym-vanilla-system-dfl-long-wq \
ksym-vanilla-system-dfl-wq \
ksym-vanilla-system-entering-hibernation \
ksym-vanilla-system-freezable-power-efficient-wq \
ksym-vanilla-system-freezable-wq \
ksym-vanilla-system-highpri-wq \
ksym-vanilla-system-long-wq \
ksym-vanilla-system-percpu-wq \
ksym-vanilla-system-power-efficient-wq \
ksym-vanilla-system-state \
ksym-vanilla-system-unbound-wq \
ksym-vanilla-system-wq \
ksym-vanilla-t3-l2e-free \
ksym-vanilla-t3-l2t-get \
ksym-vanilla-t3-l2t-send-slow \
ksym-vanilla-t3-register-cpl-handler \
ksym-vanilla-t4-cleanup-clip-tbl \
ksym-vanilla-tag-pages-for-writeback \
ksym-vanilla-take-dentry-name-snapshot \
ksym-vanilla-tap-create-cdev \
ksym-vanilla-tap-del-queues \
ksym-vanilla-tap-destroy-cdev \
ksym-vanilla-tap-free-minor \
ksym-vanilla-tap-get-minor \
ksym-vanilla-tap-get-ptr-ring \
ksym-vanilla-tap-get-socket \
ksym-vanilla-tap-handle-frame \
ksym-vanilla-tap-queue-resize \
ksym-vanilla-taprio-offload-free \
ksym-vanilla-taprio-offload-get \
ksym-vanilla-target-alloc-cmd-counter \
ksym-vanilla-target-alloc-sgl \
ksym-vanilla-target-backend-unregister \
ksym-vanilla-target-cmd-init-cdb \
ksym-vanilla-target-cmd-parse-cdb \
ksym-vanilla-target-complete-cmd \
ksym-vanilla-target-complete-cmd-with-length \
ksym-vanilla-target-complete-cmd-with-sense \
ksym-vanilla-target-configure-unmap-from-bdev \
ksym-vanilla-target-configure-write-atomic-from-bdev \
ksym-vanilla-target-depend-item \
ksym-vanilla-target-execute-cmd \
ksym-vanilla-target-free-cmd-counter \
ksym-vanilla-target-free-sgl \
ksym-vanilla-target-get-sess-cmd \
ksym-vanilla-target-init-cmd \
ksym-vanilla-target-lun-is-rdonly \
ksym-vanilla-target-nacl-find-deve \
ksym-vanilla-target-put-nacl \
ksym-vanilla-target-put-sess-cmd \
ksym-vanilla-target-register-template \
ksym-vanilla-target-remove-session \
ksym-vanilla-target-send-busy \
ksym-vanilla-target-set-cmd-data-length \
ksym-vanilla-target-setup-session \
ksym-vanilla-target-show-cmd \
ksym-vanilla-target-show-dynamic-sessions \
ksym-vanilla-target-stop-cmd-counter \
ksym-vanilla-target-stop-session \
ksym-vanilla-target-submit \
ksym-vanilla-target-submit-cmd \
ksym-vanilla-target-submit-prep \
ksym-vanilla-target-submit-tmr \
ksym-vanilla-target-to-linux-sector \
ksym-vanilla-target-tpg-has-node-acl \
ksym-vanilla-target-undepend-item \
ksym-vanilla-target-unregister-template \
ksym-vanilla-target-wait-for-cmds \
ksym-vanilla-target-wait-for-sess-cmds \
ksym-vanilla-tas2781-hda-remove \
ksym-vanilla-tas2781-load-calibration \
ksym-vanilla-tas2781-save-calibration \
ksym-vanilla-tascodec-init \
ksym-vanilla-tasdev-chn-switch \
ksym-vanilla-tasdev-fct-efi-guid \
ksym-vanilla-tasdevice-amp-getvol \
ksym-vanilla-tasdevice-amp-putvol \
ksym-vanilla-tasdevice-calbin-remove \
ksym-vanilla-tasdevice-config-get \
ksym-vanilla-tasdevice-config-info-remove \
ksym-vanilla-tasdevice-config-put \
ksym-vanilla-tasdevice-dev-bulk-read \
ksym-vanilla-tasdevice-dev-bulk-write \
ksym-vanilla-tasdevice-dev-read \
ksym-vanilla-tasdevice-dev-update-bits \
ksym-vanilla-tasdevice-dev-write \
ksym-vanilla-tasdevice-digital-getvol \
ksym-vanilla-tasdevice-digital-putvol \
ksym-vanilla-tasdevice-dsp-parser \
ksym-vanilla-tasdevice-dsp-remove \
ksym-vanilla-tasdevice-get-profile-id \
ksym-vanilla-tasdevice-info-config \
ksym-vanilla-tasdevice-info-profile \
ksym-vanilla-tasdevice-info-programs \
ksym-vanilla-tasdevice-init \
ksym-vanilla-tasdevice-kzalloc \
ksym-vanilla-tasdevice-prmg-load \
ksym-vanilla-tasdevice-program-get \
ksym-vanilla-tasdevice-program-put \
ksym-vanilla-tasdevice-rca-parser \
ksym-vanilla-tasdevice-remove \
ksym-vanilla-tasdevice-reset \
ksym-vanilla-tasdevice-select-cfg-blk \
ksym-vanilla-tasdevice-select-tuningprm-cfg \
ksym-vanilla-tasdevice-set-profile-id \
ksym-vanilla-tasdevice-tuning-switch \
ksym-vanilla-task-active-pid-ns \
ksym-vanilla-task-cls-state \
ksym-vanilla-task-cputime-adjusted \
ksym-vanilla-task-user-regset-view \
ksym-vanilla-tasklet-init \
ksym-vanilla-tasklet-kill \
ksym-vanilla-tasklet-setup \
ksym-vanilla-tasklet-unlock \
ksym-vanilla-tasklet-unlock-spin-wait \
ksym-vanilla-tasklet-unlock-wait \
ksym-vanilla-tb-configfs-register-group \
ksym-vanilla-tb-configfs-unregister-group \
ksym-vanilla-tb-property-add-data \
ksym-vanilla-tb-property-add-dir \
ksym-vanilla-tb-property-add-immediate \
ksym-vanilla-tb-property-add-text \
ksym-vanilla-tb-property-copy-dir \
ksym-vanilla-tb-property-create-dir \
ksym-vanilla-tb-property-find \
ksym-vanilla-tb-property-free-dir \
ksym-vanilla-tb-property-get-next \
ksym-vanilla-tb-property-merge-dir \
ksym-vanilla-tb-property-remove \
ksym-vanilla-tb-register-property-dir \
ksym-vanilla-tb-register-protocol-handler \
ksym-vanilla-tb-register-service-driver \
ksym-vanilla-tb-ring-alloc-rx \
ksym-vanilla-tb-ring-alloc-tx \
ksym-vanilla-tb-ring-flush \
ksym-vanilla-tb-ring-free \
ksym-vanilla-tb-ring-poll \
ksym-vanilla-tb-ring-poll-complete \
ksym-vanilla-tb-ring-start \
ksym-vanilla-tb-ring-stop \
ksym-vanilla-tb-ring-throttling \
ksym-vanilla-tb-service-properties-changed \
ksym-vanilla-tb-service-type \
ksym-vanilla-tb-unregister-property-dir \
ksym-vanilla-tb-unregister-protocol-handler \
ksym-vanilla-tb-unregister-service-driver \
ksym-vanilla-tb-xdomain-alloc-in-hopid \
ksym-vanilla-tb-xdomain-alloc-out-hopid \
ksym-vanilla-tb-xdomain-disable-paths \
ksym-vanilla-tb-xdomain-enable-paths \
ksym-vanilla-tb-xdomain-find-by-route \
ksym-vanilla-tb-xdomain-find-by-uuid \
ksym-vanilla-tb-xdomain-lane-bonding-disable \
ksym-vanilla-tb-xdomain-lane-bonding-enable \
ksym-vanilla-tb-xdomain-release-in-hopid \
ksym-vanilla-tb-xdomain-release-out-hopid \
ksym-vanilla-tb-xdomain-request \
ksym-vanilla-tb-xdomain-response \
ksym-vanilla-tb-xdomain-type \
ksym-vanilla-tc-cleanup-offload-action \
ksym-vanilla-tc-setup-cb-add \
ksym-vanilla-tc-setup-cb-call \
ksym-vanilla-tc-setup-cb-destroy \
ksym-vanilla-tc-setup-cb-reoffload \
ksym-vanilla-tc-setup-cb-replace \
ksym-vanilla-tc-setup-offload-action \
ksym-vanilla-tc-skb-ext-tc \
ksym-vanilla-tc-skb-ext-tc-disable \
ksym-vanilla-tc-skb-ext-tc-enable \
ksym-vanilla-tcf-action-check-ctrlact \
ksym-vanilla-tcf-action-exec \
ksym-vanilla-tcf-action-set-ctrlact \
ksym-vanilla-tcf-action-update-hw-stats \
ksym-vanilla-tcf-action-update-stats \
ksym-vanilla-tcf-block-get \
ksym-vanilla-tcf-block-get-ext \
ksym-vanilla-tcf-block-lookup \
ksym-vanilla-tcf-block-netif-keep-dst \
ksym-vanilla-tcf-block-put \
ksym-vanilla-tcf-block-put-ext \
ksym-vanilla-tcf-chain-get-by-act \
ksym-vanilla-tcf-chain-put-by-act \
ksym-vanilla-tcf-classify \
ksym-vanilla-tcf-dev-queue-xmit \
ksym-vanilla-tcf-em-register \
ksym-vanilla-tcf-em-tree-destroy \
ksym-vanilla-tcf-em-tree-dump \
ksym-vanilla-tcf-em-tree-validate \
ksym-vanilla-tcf-em-unregister \
ksym-vanilla-tcf-exts-change \
ksym-vanilla-tcf-exts-destroy \
ksym-vanilla-tcf-exts-dump \
ksym-vanilla-tcf-exts-dump-stats \
ksym-vanilla-tcf-exts-init-ex \
ksym-vanilla-tcf-exts-num-actions \
ksym-vanilla-tcf-exts-terse-dump \
ksym-vanilla-tcf-exts-validate \
ksym-vanilla-tcf-exts-validate-ex \
ksym-vanilla-tcf-frag-xmit-count \
ksym-vanilla-tcf-generic-walker \
ksym-vanilla-tcf-get-next-chain \
ksym-vanilla-tcf-get-next-proto \
ksym-vanilla-tcf-idr-check-alloc \
ksym-vanilla-tcf-idr-cleanup \
ksym-vanilla-tcf-idr-create \
ksym-vanilla-tcf-idr-create-from-flags \
ksym-vanilla-tcf-idr-release \
ksym-vanilla-tcf-idr-search \
ksym-vanilla-tcf-idrinfo-destroy \
ksym-vanilla-tcf-qevent-destroy \
ksym-vanilla-tcf-qevent-dump \
ksym-vanilla-tcf-qevent-handle \
ksym-vanilla-tcf-qevent-init \
ksym-vanilla-tcf-qevent-validate-change \
ksym-vanilla-tcf-queue-work \
ksym-vanilla-tcf-register-action \
ksym-vanilla-tcf-sw-enabled-key \
ksym-vanilla-tcf-unregister-action \
ksym-vanilla-tcp-abort \
ksym-vanilla-tcp-bpf-sendmsg-redir \
ksym-vanilla-tcp-bpf-update-proto \
ksym-vanilla-tcp-close \
ksym-vanilla-tcp-cong-avoid-ai \
ksym-vanilla-tcp-connect \
ksym-vanilla-tcp-enter-cwr \
ksym-vanilla-tcp-get-info \
ksym-vanilla-tcp-gro-complete \
ksym-vanilla-tcp-have-smc \
ksym-vanilla-tcp-is-ulp-esp \
ksym-vanilla-tcp-memory-per-cpu-fw-alloc \
ksym-vanilla-tcp-memory-pressure \
ksym-vanilla-tcp-mss-to-mtu \
ksym-vanilla-tcp-parse-options \
ksym-vanilla-tcp-plb-check-rehash \
ksym-vanilla-tcp-plb-update-state \
ksym-vanilla-tcp-plb-update-state-upon-rto \
ksym-vanilla-tcp-poll \
ksym-vanilla-tcp-prot \
ksym-vanilla-tcp-rate-check-app-limited \
ksym-vanilla-tcp-read-done \
ksym-vanilla-tcp-read-sock \
ksym-vanilla-tcp-recv-skb \
ksym-vanilla-tcp-register-congestion-control \
ksym-vanilla-tcp-register-ulp \
ksym-vanilla-tcp-reno-cong-avoid \
ksym-vanilla-tcp-reno-ssthresh \
ksym-vanilla-tcp-reno-undo-cwnd \
ksym-vanilla-tcp-sendmsg \
ksym-vanilla-tcp-sendmsg-locked \
ksym-vanilla-tcp-slow-start \
ksym-vanilla-tcp-sock-set-cork \
ksym-vanilla-tcp-sock-set-keepcnt \
ksym-vanilla-tcp-sock-set-keepidle \
ksym-vanilla-tcp-sock-set-keepintvl \
ksym-vanilla-tcp-sock-set-nodelay \
ksym-vanilla-tcp-sock-set-quickack \
ksym-vanilla-tcp-sock-set-syncnt \
ksym-vanilla-tcp-sock-set-user-timeout \
ksym-vanilla-tcp-stream-memory-free \
ksym-vanilla-tcp-unregister-congestion-control \
ksym-vanilla-tcp-unregister-ulp \
ksym-vanilla-tcp-vegas-cwnd-event \
ksym-vanilla-tcp-vegas-cwnd-event-tx-start \
ksym-vanilla-tcp-vegas-get-info \
ksym-vanilla-tcp-vegas-init \
ksym-vanilla-tcp-vegas-pkts-acked \
ksym-vanilla-tcp-vegas-state \
ksym-vanilla-tcp-wfree \
ksym-vanilla-tcpci-get-tcpm-port \
ksym-vanilla-tcpci-irq \
ksym-vanilla-tcpci-register-port \
ksym-vanilla-tcpci-unregister-port \
ksym-vanilla-tcpm-cc-change \
ksym-vanilla-tcpm-pd-hard-reset \
ksym-vanilla-tcpm-pd-receive \
ksym-vanilla-tcpm-pd-transmit-complete \
ksym-vanilla-tcpm-port-clean \
ksym-vanilla-tcpm-port-error-recovery \
ksym-vanilla-tcpm-port-is-toggling \
ksym-vanilla-tcpm-register-port \
ksym-vanilla-tcpm-sink-frs \
ksym-vanilla-tcpm-sourcing-vbus \
ksym-vanilla-tcpm-tcpc-reset \
ksym-vanilla-tcpm-unregister-port \
ksym-vanilla-tcpm-vbus-change \
ksym-vanilla-tcpv6-prot \
ksym-vanilla-tda10021-attach \
ksym-vanilla-tda10023-attach \
ksym-vanilla-tda10045-attach \
ksym-vanilla-tda10046-attach \
ksym-vanilla-tda10048-attach \
ksym-vanilla-tda10086-attach \
ksym-vanilla-tda18218-attach \
ksym-vanilla-tda18271-attach \
ksym-vanilla-tda18271c2dd-attach \
ksym-vanilla-tda665x-attach \
ksym-vanilla-tda8083-attach \
ksym-vanilla-tda8261-attach \
ksym-vanilla-tda826x-attach \
ksym-vanilla-tda827x-attach \
ksym-vanilla-tda829x-attach \
ksym-vanilla-tda829x-probe \
ksym-vanilla-tda9887-attach \
ksym-vanilla-tea5761-attach \
ksym-vanilla-tea5761-autodetection \
ksym-vanilla-tea5767-attach \
ksym-vanilla-tea5767-autodetection \
ksym-vanilla-team-mode-register \
ksym-vanilla-team-mode-unregister \
ksym-vanilla-team-modeop-port-change-dev-addr \
ksym-vanilla-team-modeop-port-enter \
ksym-vanilla-team-option-inst-set-change \
ksym-vanilla-team-options-change-check \
ksym-vanilla-team-options-register \
ksym-vanilla-team-options-unregister \
ksym-vanilla-tee-bnxt-copy-coredump \
ksym-vanilla-tee-bnxt-fw-load \
ksym-vanilla-tee-bus-type \
ksym-vanilla-tee-client-close-context \
ksym-vanilla-tee-client-close-session \
ksym-vanilla-tee-client-driver-unregister \
ksym-vanilla-tee-client-get-version \
ksym-vanilla-tee-client-invoke-func \
ksym-vanilla-tee-client-open-context \
ksym-vanilla-tee-client-open-session \
ksym-vanilla-tee-client-system-session \
ksym-vanilla-tee-device-alloc \
ksym-vanilla-tee-device-get \
ksym-vanilla-tee-device-put \
ksym-vanilla-tee-device-put-all-dma-heaps \
ksym-vanilla-tee-device-register \
ksym-vanilla-tee-device-register-dma-heap \
ksym-vanilla-tee-device-set-dev-groups \
ksym-vanilla-tee-device-unregister \
ksym-vanilla-tee-dyn-shm-alloc-helper \
ksym-vanilla-tee-dyn-shm-free-helper \
ksym-vanilla-tee-get-drvdata \
ksym-vanilla-tee-protmem-static-pool-alloc \
ksym-vanilla-tee-session-calc-client-uuid \
ksym-vanilla-tee-shm-alloc-dma-mem \
ksym-vanilla-tee-shm-alloc-kernel-buf \
ksym-vanilla-tee-shm-alloc-priv-buf \
ksym-vanilla-tee-shm-free \
ksym-vanilla-tee-shm-get-from-id \
ksym-vanilla-tee-shm-get-pa \
ksym-vanilla-tee-shm-get-va \
ksym-vanilla-tee-shm-pool-alloc-res-mem \
ksym-vanilla-tee-shm-put \
ksym-vanilla-tee-shm-register-fd \
ksym-vanilla-tee-shm-register-kernel-buf \
ksym-vanilla-teedev-close-context \
ksym-vanilla-teedev-ctx-get \
ksym-vanilla-teedev-ctx-put \
ksym-vanilla-teedev-open \
ksym-vanilla-tegra-ahb-enable-smmu \
ksym-vanilla-tegra-asoc-machine-init \
ksym-vanilla-tegra-asoc-machine-probe \
ksym-vanilla-tegra-bpmp-free-mrq \
ksym-vanilla-tegra-bpmp-get \
ksym-vanilla-tegra-bpmp-get-with-id \
ksym-vanilla-tegra-bpmp-mrq-is-supported \
ksym-vanilla-tegra-bpmp-mrq-return \
ksym-vanilla-tegra-bpmp-put \
ksym-vanilla-tegra-bpmp-request-mrq \
ksym-vanilla-tegra-bpmp-transfer \
ksym-vanilla-tegra-bpmp-transfer-atomic \
ksym-vanilla-tegra-dfll-register \
ksym-vanilla-tegra-dfll-resume \
ksym-vanilla-tegra-dfll-runtime-resume \
ksym-vanilla-tegra-dfll-runtime-suspend \
ksym-vanilla-tegra-dfll-suspend \
ksym-vanilla-tegra-dfll-unregister \
ksym-vanilla-tegra-fuse-readl \
ksym-vanilla-tegra-ivc-align \
ksym-vanilla-tegra-ivc-cleanup \
ksym-vanilla-tegra-ivc-init \
ksym-vanilla-tegra-ivc-notified \
ksym-vanilla-tegra-ivc-read-advance \
ksym-vanilla-tegra-ivc-read-get-next-frame \
ksym-vanilla-tegra-ivc-reset \
ksym-vanilla-tegra-ivc-total-queue-size \
ksym-vanilla-tegra-ivc-write-advance \
ksym-vanilla-tegra-ivc-write-get-next-frame \
ksym-vanilla-tegra-mc-get-carveout-info \
ksym-vanilla-tegra-mc-get-emem-device-count \
ksym-vanilla-tegra-mc-probe-device \
ksym-vanilla-tegra-mc-write-emem-configuration \
ksym-vanilla-tegra-mipi-disable \
ksym-vanilla-tegra-mipi-enable \
ksym-vanilla-tegra-mipi-finish-calibration \
ksym-vanilla-tegra-mipi-free \
ksym-vanilla-tegra-mipi-request \
ksym-vanilla-tegra-mipi-start-calibration \
ksym-vanilla-tegra-pcm-close \
ksym-vanilla-tegra-pcm-hw-params \
ksym-vanilla-tegra-pcm-new \
ksym-vanilla-tegra-pcm-open \
ksym-vanilla-tegra-pcm-platform-register \
ksym-vanilla-tegra-pcm-platform-register-with-chan-names \
ksym-vanilla-tegra-pcm-platform-unregister \
ksym-vanilla-tegra-pcm-pointer \
ksym-vanilla-tegra-phy-xusb-utmi-pad-power-down \
ksym-vanilla-tegra-phy-xusb-utmi-pad-power-on \
ksym-vanilla-tegra-phy-xusb-utmi-port-reset \
ksym-vanilla-tegra-pinctrl-probe \
ksym-vanilla-tegra-pmc-io-pad-power-disable \
ksym-vanilla-tegra-pmc-io-pad-power-enable \
ksym-vanilla-tegra-pmc-powergate-power-off \
ksym-vanilla-tegra-pmc-powergate-power-on \
ksym-vanilla-tegra-pmc-powergate-remove-clamping \
ksym-vanilla-tegra-pmc-powergate-sequence-power-up \
ksym-vanilla-tegra-read-ram-code \
ksym-vanilla-tegra-sku-info \
ksym-vanilla-tegra-xusb-padctl-disable-phy-sleepwalk \
ksym-vanilla-tegra-xusb-padctl-disable-phy-wake \
ksym-vanilla-tegra-xusb-padctl-enable-phy-sleepwalk \
ksym-vanilla-tegra-xusb-padctl-enable-phy-wake \
ksym-vanilla-tegra-xusb-padctl-get \
ksym-vanilla-tegra-xusb-padctl-get-port-number \
ksym-vanilla-tegra-xusb-padctl-get-usb3-companion \
ksym-vanilla-tegra-xusb-padctl-hsic-set-idle \
ksym-vanilla-tegra-xusb-padctl-legacy-probe \
ksym-vanilla-tegra-xusb-padctl-legacy-remove \
ksym-vanilla-tegra-xusb-padctl-put \
ksym-vanilla-tegra-xusb-padctl-remote-wake-detected \
ksym-vanilla-tegra-xusb-padctl-set-vbus-override \
ksym-vanilla-tegra-xusb-padctl-usb3-save-context \
ksym-vanilla-tegra-xusb-padctl-usb3-set-lfps-detect \
ksym-vanilla-tegra124-xusb-padctl-soc \
ksym-vanilla-tegra186-xusb-padctl-soc \
ksym-vanilla-tegra194-miscreg-mask-serror \
ksym-vanilla-tegra194-xusb-padctl-soc \
ksym-vanilla-tegra210-clk-emc-attach \
ksym-vanilla-tegra210-clk-emc-detach \
ksym-vanilla-tegra210-clk-emc-dll-enable \
ksym-vanilla-tegra210-clk-emc-dll-update-setting \
ksym-vanilla-tegra210-clk-emc-update-setting \
ksym-vanilla-tegra210-plle-hw-sequence-is-enabled \
ksym-vanilla-tegra210-plle-hw-sequence-start \
ksym-vanilla-tegra210-put-utmipll-in-iddq \
ksym-vanilla-tegra210-put-utmipll-out-iddq \
ksym-vanilla-tegra210-sata-pll-hw-control-enable \
ksym-vanilla-tegra210-sata-pll-hw-sequence-start \
ksym-vanilla-tegra210-set-sata-pll-seq-sw \
ksym-vanilla-tegra210-xusb-padctl-soc \
ksym-vanilla-tegra210-xusb-pll-hw-control-enable \
ksym-vanilla-tegra210-xusb-pll-hw-sequence-start \
ksym-vanilla-tegra234-xusb-padctl-soc \
ksym-vanilla-test-taint \
ksym-vanilla-textsearch-destroy \
ksym-vanilla-textsearch-find-continuous \
ksym-vanilla-textsearch-prepare \
ksym-vanilla-textsearch-register \
ksym-vanilla-textsearch-unregister \
ksym-vanilla-thaw-super \
ksym-vanilla-thermal-acpi-active-trip-temp \
ksym-vanilla-thermal-acpi-critical-trip-temp \
ksym-vanilla-thermal-acpi-hot-trip-temp \
ksym-vanilla-thermal-acpi-passive-trip-temp \
ksym-vanilla-thermal-add-hwmon-sysfs \
ksym-vanilla-thermal-cooling-device-register \
ksym-vanilla-thermal-cooling-device-unregister \
ksym-vanilla-thermal-cooling-device-update \
ksym-vanilla-thermal-genl-cpu-capability-event \
ksym-vanilla-thermal-of-cooling-device-register \
ksym-vanilla-thermal-remove-hwmon-sysfs \
ksym-vanilla-thermal-trip-is-bound-to-cdev \
ksym-vanilla-thermal-tripless-zone-device-register \
ksym-vanilla-thermal-zone-device \
ksym-vanilla-thermal-zone-device-critical \
ksym-vanilla-thermal-zone-device-disable \
ksym-vanilla-thermal-zone-device-enable \
ksym-vanilla-thermal-zone-device-id \
ksym-vanilla-thermal-zone-device-priv \
ksym-vanilla-thermal-zone-device-register-with-trips \
ksym-vanilla-thermal-zone-device-type \
ksym-vanilla-thermal-zone-device-unregister \
ksym-vanilla-thermal-zone-device-update \
ksym-vanilla-thermal-zone-for-each-trip \
ksym-vanilla-thermal-zone-get-crit-temp \
ksym-vanilla-thermal-zone-get-offset \
ksym-vanilla-thermal-zone-get-slope \
ksym-vanilla-thermal-zone-get-temp \
ksym-vanilla-thermal-zone-get-zone-by-name \
ksym-vanilla-thermal-zone-set-trip-temp \
ksym-vanilla-this-cpu-has-cap \
ksym-vanilla-thp-get-unmapped-area \
ksym-vanilla-ti-lmu-common-get-brt-res \
ksym-vanilla-ti-lmu-common-get-ramp-params \
ksym-vanilla-ti-lmu-common-set-brightness \
ksym-vanilla-ti-lmu-common-set-ramp \
ksym-vanilla-tick-broadcast-control \
ksym-vanilla-tick-broadcast-oneshot-control \
ksym-vanilla-tick-nohz-dep-clear-cpu \
ksym-vanilla-tick-nohz-dep-clear-task \
ksym-vanilla-tick-nohz-dep-set-cpu \
ksym-vanilla-tick-nohz-dep-set-task \
ksym-vanilla-tick-nohz-full-mask \
ksym-vanilla-tick-nohz-full-running \
ksym-vanilla-tick-nohz-is-active \
ksym-vanilla-tifm-add-adapter \
ksym-vanilla-tifm-alloc-adapter \
ksym-vanilla-tifm-alloc-device \
ksym-vanilla-tifm-eject \
ksym-vanilla-tifm-free-adapter \
ksym-vanilla-tifm-free-device \
ksym-vanilla-tifm-has-ms-pif \
ksym-vanilla-tifm-map-sg \
ksym-vanilla-tifm-queue-work \
ksym-vanilla-tifm-register-driver \
ksym-vanilla-tifm-remove-adapter \
ksym-vanilla-tifm-unmap-sg \
ksym-vanilla-tifm-unregister-driver \
ksym-vanilla-time64-to-tm \
ksym-vanilla-timecounter-init \
ksym-vanilla-timecounter-read \
ksym-vanilla-timekeeping-clocksource-has-base \
ksym-vanilla-timer-delete \
ksym-vanilla-timer-delete-sync \
ksym-vanilla-timer-delete-sync-try \
ksym-vanilla-timer-init-key \
ksym-vanilla-timer-of-cleanup \
ksym-vanilla-timer-of-init \
ksym-vanilla-timer-reduce \
ksym-vanilla-timer-shutdown \
ksym-vanilla-timer-shutdown-sync \
ksym-vanilla-timer-unstable-counter-workaround \
ksym-vanilla-timerqueue-add \
ksym-vanilla-timerqueue-del \
ksym-vanilla-timerqueue-iterate-next \
ksym-vanilla-timerqueue-linked-add \
ksym-vanilla-timespec64-add-safe \
ksym-vanilla-timespec64-to-jiffies \
ksym-vanilla-timestamp-truncate \
ksym-vanilla-tipc-dump-done \
ksym-vanilla-tipc-dump-start \
ksym-vanilla-tipc-nl-sk-walk \
ksym-vanilla-tipc-sk-fill-sock-diag \
ksym-vanilla-tls-alert-recv \
ksym-vanilla-tls-client-hello-anon \
ksym-vanilla-tls-client-hello-psk \
ksym-vanilla-tls-client-hello-x509 \
ksym-vanilla-tls-device-sk-destruct \
ksym-vanilla-tls-encrypt-skb \
ksym-vanilla-tls-get-record \
ksym-vanilla-tls-get-record-type \
ksym-vanilla-tls-handshake-cancel \
ksym-vanilla-tls-handshake-close \
ksym-vanilla-tls-offload-tx-resync-request \
ksym-vanilla-tls-server-hello-psk \
ksym-vanilla-tls-server-hello-x509 \
ksym-vanilla-tls-validate-xmit-skb \
ksym-vanilla-tlv320aic23-probe \
ksym-vanilla-tlv320aic23-regmap \
ksym-vanilla-tmc-alloc-sg-table \
ksym-vanilla-tmc-etr-get-buffer \
ksym-vanilla-tmc-etr-get-catu-device \
ksym-vanilla-tmc-etr-remove-catu-ops \
ksym-vanilla-tmc-etr-set-catu-ops \
ksym-vanilla-tmc-free-sg-table \
ksym-vanilla-tmc-sg-table-get-data \
ksym-vanilla-tmc-sg-table-sync-data-range \
ksym-vanilla-tmc-sg-table-sync-table \
ksym-vanilla-tmio-mmc-disable-mmc-irqs \
ksym-vanilla-tmio-mmc-do-data-irq \
ksym-vanilla-tmio-mmc-enable-mmc-irqs \
ksym-vanilla-tmio-mmc-host-alloc \
ksym-vanilla-tmio-mmc-host-probe \
ksym-vanilla-tmio-mmc-host-remove \
ksym-vanilla-tmio-mmc-host-runtime-resume \
ksym-vanilla-tmio-mmc-host-runtime-suspend \
ksym-vanilla-tmio-mmc-irq \
ksym-vanilla-tnum-strn \
ksym-vanilla-to-cxl-dax-region \
ksym-vanilla-to-cxl-decoder \
ksym-vanilla-to-cxl-endpoint-decoder \
ksym-vanilla-to-cxl-nvdimm \
ksym-vanilla-to-cxl-nvdimm-bridge \
ksym-vanilla-to-cxl-pmem-region \
ksym-vanilla-to-cxl-port \
ksym-vanilla-to-cxl-root-decoder \
ksym-vanilla-to-cxl-switch-decoder \
ksym-vanilla-to-cxlfs \
ksym-vanilla-to-drm-sched-fence \
ksym-vanilla-to-hisi-sas-port \
ksym-vanilla-to-nd-btt \
ksym-vanilla-to-nd-dax \
ksym-vanilla-to-nd-desc \
ksym-vanilla-to-nd-pfn \
ksym-vanilla-to-nd-region \
ksym-vanilla-to-ndd \
ksym-vanilla-to-nfit-uuid \
ksym-vanilla-to-nvdimm \
ksym-vanilla-to-nvdimm-bus \
ksym-vanilla-to-nvdimm-bus-dev \
ksym-vanilla-to-of-pinfo \
ksym-vanilla-to-pdrv-policy-node \
ksym-vanilla-to-software-node \
ksym-vanilla-topology-clear-scale-freq-source \
ksym-vanilla-topology-set-scale-freq-source \
ksym-vanilla-topology-update-hw-pressure \
ksym-vanilla-torture-cleanup-begin \
ksym-vanilla-torture-cleanup-end \
ksym-vanilla-torture-hrtimeout-jiffies \
ksym-vanilla-torture-hrtimeout-ms \
ksym-vanilla-torture-hrtimeout-ns \
ksym-vanilla-torture-hrtimeout-s \
ksym-vanilla-torture-hrtimeout-us \
ksym-vanilla-torture-init-begin \
ksym-vanilla-torture-init-end \
ksym-vanilla-torture-kthread-stopping \
ksym-vanilla-torture-must-stop \
ksym-vanilla-torture-must-stop-irq \
ksym-vanilla-torture-num-online-cpus \
ksym-vanilla-torture-offline \
ksym-vanilla-torture-online \
ksym-vanilla-torture-onoff-failures \
ksym-vanilla-torture-onoff-init \
ksym-vanilla-torture-onoff-stats \
ksym-vanilla-torture-random \
ksym-vanilla-torture-sched-set-normal \
ksym-vanilla-torture-sched-setaffinity \
ksym-vanilla-torture-shuffle-init \
ksym-vanilla-torture-shuffle-task-register \
ksym-vanilla-torture-shutdown-absorb \
ksym-vanilla-torture-shutdown-init \
ksym-vanilla-torture-stutter-init \
ksym-vanilla-touch-atime \
ksym-vanilla-touch-buffer \
ksym-vanilla-touch-overlay-get-touchscreen-abs \
ksym-vanilla-touch-overlay-map \
ksym-vanilla-touch-overlay-mapped-touchscreen \
ksym-vanilla-touch-overlay-process-contact \
ksym-vanilla-touch-overlay-sync-frame \
ksym-vanilla-touch-softlockup-watchdog \
ksym-vanilla-touchscreen-parse-properties \
ksym-vanilla-touchscreen-report-pos \
ksym-vanilla-touchscreen-set-mt-pos \
ksym-vanilla-tpm-buf-append \
ksym-vanilla-tpm-buf-append-hmac-session \
ksym-vanilla-tpm-buf-append-name \
ksym-vanilla-tpm-buf-append-u16 \
ksym-vanilla-tpm-buf-append-u32 \
ksym-vanilla-tpm-buf-append-u8 \
ksym-vanilla-tpm-buf-destroy \
ksym-vanilla-tpm-buf-init \
ksym-vanilla-tpm-buf-init-sized \
ksym-vanilla-tpm-buf-length \
ksym-vanilla-tpm-buf-read-u16 \
ksym-vanilla-tpm-buf-read-u32 \
ksym-vanilla-tpm-buf-read-u8 \
ksym-vanilla-tpm-buf-reset \
ksym-vanilla-tpm-buf-reset-sized \
ksym-vanilla-tpm-calc-ordinal-duration \
ksym-vanilla-tpm-chip-alloc \
ksym-vanilla-tpm-chip-bootstrap \
ksym-vanilla-tpm-chip-register \
ksym-vanilla-tpm-chip-start \
ksym-vanilla-tpm-chip-stop \
ksym-vanilla-tpm-chip-unregister \
ksym-vanilla-tpm-crb-ffa-init \
ksym-vanilla-tpm-crb-ffa-start \
ksym-vanilla-tpm-default-chip \
ksym-vanilla-tpm-get-random \
ksym-vanilla-tpm-get-timeouts \
ksym-vanilla-tpm-is-tpm2 \
ksym-vanilla-tpm-pcr-extend \
ksym-vanilla-tpm-pcr-read \
ksym-vanilla-tpm-pm-resume \
ksym-vanilla-tpm-pm-suspend \
ksym-vanilla-tpm-put-ops \
ksym-vanilla-tpm-tis-core-init \
ksym-vanilla-tpm-tis-remove \
ksym-vanilla-tpm-tis-resume \
ksym-vanilla-tpm-transmit-cmd \
ksym-vanilla-tpm-try-get-ops \
ksym-vanilla-tpm1-do-selftest \
ksym-vanilla-tpm1-getcap \
ksym-vanilla-tpm2-find-hash-alg \
ksym-vanilla-tpm2-flush-context \
ksym-vanilla-tpm2-get-cc-attrs-tbl \
ksym-vanilla-tpm2-get-tpm-pt \
ksym-vanilla-tpm2-probe \
ksym-vanilla-tpmm-chip-alloc \
ksym-vanilla-tps65010-config-vdcdc2 \
ksym-vanilla-tps65010-config-vregs1 \
ksym-vanilla-tps65010-set-gpio-out-value \
ksym-vanilla-tps65010-set-led \
ksym-vanilla-tps65010-set-low-pwr \
ksym-vanilla-tps65010-set-vbus-draw \
ksym-vanilla-tps65010-set-vib \
ksym-vanilla-tps65013-set-low-pwr \
ksym-vanilla-tps65224-volatile-table \
ksym-vanilla-tps6594-device-init \
ksym-vanilla-tps6594-volatile-table \
ksym-vanilla-trace-add-event-call \
ksym-vanilla-trace-array-destroy \
ksym-vanilla-trace-array-get-by-name \
ksym-vanilla-trace-array-init-printk \
ksym-vanilla-trace-array-printk \
ksym-vanilla-trace-array-put \
ksym-vanilla-trace-array-set-clr-event \
ksym-vanilla-trace-clock \
ksym-vanilla-trace-clock-global \
ksym-vanilla-trace-clock-jiffies \
ksym-vanilla-trace-clock-local \
ksym-vanilla-trace-define-field \
ksym-vanilla-trace-dump-stack \
ksym-vanilla-trace-event-buffer-commit \
ksym-vanilla-trace-event-buffer-lock-reserve \
ksym-vanilla-trace-event-buffer-reserve \
ksym-vanilla-trace-event-ignore-this-pid \
ksym-vanilla-trace-event-printf \
ksym-vanilla-trace-event-raw-init \
ksym-vanilla-trace-event-reg \
ksym-vanilla-trace-get-event-file \
ksym-vanilla-trace-handle-return \
ksym-vanilla-trace-output-call \
ksym-vanilla-trace-print-array-seq \
ksym-vanilla-trace-print-bitmask-seq \
ksym-vanilla-trace-print-flags-seq \
ksym-vanilla-trace-print-hex-dump-seq \
ksym-vanilla-trace-print-hex-seq \
ksym-vanilla-trace-print-symbols-seq \
ksym-vanilla-trace-printk-init-buffers \
ksym-vanilla-trace-put-event-file \
ksym-vanilla-trace-raw-output-prep \
ksym-vanilla-trace-remove-event-call \
ksym-vanilla-trace-seq-acquire \
ksym-vanilla-trace-seq-bitmask \
ksym-vanilla-trace-seq-bitmask-list \
ksym-vanilla-trace-seq-bprintf \
ksym-vanilla-trace-seq-hex-dump \
ksym-vanilla-trace-seq-path \
ksym-vanilla-trace-seq-printf \
ksym-vanilla-trace-seq-putc \
ksym-vanilla-trace-seq-putmem \
ksym-vanilla-trace-seq-putmem-hex \
ksym-vanilla-trace-seq-puts \
ksym-vanilla-trace-seq-to-user \
ksym-vanilla-trace-seq-vprintf \
ksym-vanilla-trace-set-clr-event \
ksym-vanilla-trace-vbprintk \
ksym-vanilla-trace-vprintk \
ksym-vanilla-tracefs-create-file \
ksym-vanilla-tracepoint-probe-register \
ksym-vanilla-tracepoint-probe-register-prio \
ksym-vanilla-tracepoint-probe-register-prio-may-exist \
ksym-vanilla-tracepoint-probe-unregister \
ksym-vanilla-tracepoint-srcu \
ksym-vanilla-tracing-cond-snapshot-data \
ksym-vanilla-tracing-is-on \
ksym-vanilla-tracing-off \
ksym-vanilla-tracing-on \
ksym-vanilla-tracing-snapshot \
ksym-vanilla-tracing-snapshot-alloc \
ksym-vanilla-tracing-snapshot-cond \
ksym-vanilla-tracing-snapshot-cond-disable \
ksym-vanilla-tracing-snapshot-cond-enable \
ksym-vanilla-transport-add-device \
ksym-vanilla-transport-alloc-session \
ksym-vanilla-transport-alloc-session-tags \
ksym-vanilla-transport-backend-register \
ksym-vanilla-transport-class-register \
ksym-vanilla-transport-class-unregister \
ksym-vanilla-transport-configure-device \
ksym-vanilla-transport-copy-sense-to-cmd \
ksym-vanilla-transport-deregister-session \
ksym-vanilla-transport-deregister-session-configfs \
ksym-vanilla-transport-destroy-device \
ksym-vanilla-transport-free-session \
ksym-vanilla-transport-generic-free-cmd \
ksym-vanilla-transport-generic-handle-tmr \
ksym-vanilla-transport-generic-new-cmd \
ksym-vanilla-transport-generic-request-failure \
ksym-vanilla-transport-init-session \
ksym-vanilla-transport-kmap-data-sg \
ksym-vanilla-transport-kunmap-data-sg \
ksym-vanilla-transport-lookup-cmd-lun \
ksym-vanilla-transport-lookup-tmr-lun \
ksym-vanilla-transport-register-session \
ksym-vanilla-transport-remove-device \
ksym-vanilla-transport-send-check-condition-and-sense \
ksym-vanilla-transport-set-vpd-assoc \
ksym-vanilla-transport-set-vpd-ident \
ksym-vanilla-transport-set-vpd-ident-type \
ksym-vanilla-transport-set-vpd-proto-id \
ksym-vanilla-transport-setup-device \
ksym-vanilla-transport-wait-for-tasks \
ksym-vanilla-truncate-inode-pages \
ksym-vanilla-truncate-inode-pages-final \
ksym-vanilla-truncate-inode-pages-range \
ksym-vanilla-truncate-pagecache \
ksym-vanilla-truncate-pagecache-range \
ksym-vanilla-truncate-setsize \
ksym-vanilla-try-lookup-noperm \
ksym-vanilla-try-module-get \
ksym-vanilla-try-offline-node \
ksym-vanilla-try-test-sas-gpio-gp-bit \
ksym-vanilla-try-to-free-buffers \
ksym-vanilla-try-to-writeback-inodes-sb \
ksym-vanilla-try-wait-for-completion \
ksym-vanilla-ts2020-attach \
ksym-vanilla-ts3a227e-enable-jack-detect \
ksym-vanilla-tsa-serial-connect \
ksym-vanilla-tsa-serial-disconnect \
ksym-vanilla-tsa-serial-get-byphandle \
ksym-vanilla-tsa-serial-get-info \
ksym-vanilla-tsa-serial-get-num \
ksym-vanilla-tsa-serial-put \
ksym-vanilla-tsc200x-groups \
ksym-vanilla-tsc200x-pm-ops \
ksym-vanilla-tsc200x-probe \
ksym-vanilla-tsc200x-regmap-config \
ksym-vanilla-tsm-register \
ksym-vanilla-tsm-report-register \
ksym-vanilla-tsm-report-unregister \
ksym-vanilla-tsm-unregister \
ksym-vanilla-tso-build-data \
ksym-vanilla-tso-build-hdr \
ksym-vanilla-tso-dma-map-cleanup \
ksym-vanilla-tso-dma-map-count \
ksym-vanilla-tso-dma-map-init \
ksym-vanilla-tso-dma-map-next \
ksym-vanilla-tso-start \
ksym-vanilla-ttm-backup-bytes-avail \
ksym-vanilla-ttm-bo-access \
ksym-vanilla-ttm-bo-eviction-valuable \
ksym-vanilla-ttm-bo-fini \
ksym-vanilla-ttm-bo-init-reserved \
ksym-vanilla-ttm-bo-init-validate \
ksym-vanilla-ttm-bo-kmap \
ksym-vanilla-ttm-bo-kmap-try-from-panic \
ksym-vanilla-ttm-bo-kunmap \
ksym-vanilla-ttm-bo-lru-cursor-fini \
ksym-vanilla-ttm-bo-lru-cursor-first \
ksym-vanilla-ttm-bo-lru-cursor-init \
ksym-vanilla-ttm-bo-lru-cursor-next \
ksym-vanilla-ttm-bo-mem-space \
ksym-vanilla-ttm-bo-mmap-obj \
ksym-vanilla-ttm-bo-move-accel-cleanup \
ksym-vanilla-ttm-bo-move-memcpy \
ksym-vanilla-ttm-bo-move-sync-cleanup \
ksym-vanilla-ttm-bo-move-to-lru-tail \
ksym-vanilla-ttm-bo-pin \
ksym-vanilla-ttm-bo-populate \
ksym-vanilla-ttm-bo-set-bulk-move \
ksym-vanilla-ttm-bo-setup-export \
ksym-vanilla-ttm-bo-shrink \
ksym-vanilla-ttm-bo-shrink-avoid-wait \
ksym-vanilla-ttm-bo-shrink-suitable \
ksym-vanilla-ttm-bo-unmap-virtual \
ksym-vanilla-ttm-bo-unpin \
ksym-vanilla-ttm-bo-validate \
ksym-vanilla-ttm-bo-vm-access \
ksym-vanilla-ttm-bo-vm-close \
ksym-vanilla-ttm-bo-vm-dummy-page \
ksym-vanilla-ttm-bo-vm-fault \
ksym-vanilla-ttm-bo-vm-fault-reserved \
ksym-vanilla-ttm-bo-vm-open \
ksym-vanilla-ttm-bo-vm-reserve \
ksym-vanilla-ttm-bo-vmap \
ksym-vanilla-ttm-bo-vunmap \
ksym-vanilla-ttm-bo-wait-ctx \
ksym-vanilla-ttm-device-clear-dma-mappings \
ksym-vanilla-ttm-device-fini \
ksym-vanilla-ttm-device-init \
ksym-vanilla-ttm-device-prepare-hibernation \
ksym-vanilla-ttm-device-swapout \
ksym-vanilla-ttm-eu-backoff-reservation \
ksym-vanilla-ttm-eu-fence-buffer-objects \
ksym-vanilla-ttm-eu-reserve-buffers \
ksym-vanilla-ttm-glob \
ksym-vanilla-ttm-io-prot \
ksym-vanilla-ttm-kmap-iter-iomap-init \
ksym-vanilla-ttm-kmap-iter-tt-init \
ksym-vanilla-ttm-lru-bulk-move-fini \
ksym-vanilla-ttm-lru-bulk-move-init \
ksym-vanilla-ttm-lru-bulk-move-tail \
ksym-vanilla-ttm-lru-walk-for-evict \
ksym-vanilla-ttm-move-memcpy \
ksym-vanilla-ttm-pool-alloc \
ksym-vanilla-ttm-pool-debugfs \
ksym-vanilla-ttm-pool-fini \
ksym-vanilla-ttm-pool-free \
ksym-vanilla-ttm-pool-init \
ksym-vanilla-ttm-range-man-fini-nocheck \
ksym-vanilla-ttm-range-man-init-nocheck \
ksym-vanilla-ttm-resource-fini \
ksym-vanilla-ttm-resource-free \
ksym-vanilla-ttm-resource-init \
ksym-vanilla-ttm-resource-manager-create-debugfs \
ksym-vanilla-ttm-resource-manager-debug \
ksym-vanilla-ttm-resource-manager-evict-all \
ksym-vanilla-ttm-resource-manager-init \
ksym-vanilla-ttm-resource-manager-usage \
ksym-vanilla-ttm-sg-tt-init \
ksym-vanilla-ttm-tt-fini \
ksym-vanilla-ttm-tt-init \
ksym-vanilla-ttm-tt-pages-limit \
ksym-vanilla-ttm-tt-restore \
ksym-vanilla-ttm-tt-setup-backup \
ksym-vanilla-ttpci-budget-debiread \
ksym-vanilla-ttpci-budget-debiwrite \
ksym-vanilla-ttpci-budget-deinit \
ksym-vanilla-ttpci-budget-init \
ksym-vanilla-ttpci-budget-init-hooks \
ksym-vanilla-ttpci-budget-irq10-handler \
ksym-vanilla-ttpci-budget-set-video-port \
ksym-vanilla-ttpci-eeprom-decode-mac \
ksym-vanilla-ttpci-eeprom-parse-mac \
ksym-vanilla-ttusbdecfe-dvbs-attach \
ksym-vanilla-ttusbdecfe-dvbt-attach \
ksym-vanilla-tty-buffer-lock-exclusive \
ksym-vanilla-tty-buffer-request-room \
ksym-vanilla-tty-buffer-set-limit \
ksym-vanilla-tty-buffer-space-avail \
ksym-vanilla-tty-buffer-unlock-exclusive \
ksym-vanilla-tty-chars-in-buffer \
ksym-vanilla-tty-check-change \
ksym-vanilla-tty-dev-name-to-number \
ksym-vanilla-tty-devnum \
ksym-vanilla-tty-do-resize \
ksym-vanilla-tty-driver-flush-buffer \
ksym-vanilla-tty-driver-kref-put \
ksym-vanilla-tty-encode-baud-rate \
ksym-vanilla-tty-find-polling-driver \
ksym-vanilla-tty-flip-buffer-push \
ksym-vanilla-tty-get-char-size \
ksym-vanilla-tty-get-frame-size \
ksym-vanilla-tty-get-icount \
ksym-vanilla-tty-get-pgrp \
ksym-vanilla-tty-get-tiocm \
ksym-vanilla-tty-hangup \
ksym-vanilla-tty-hung-up-p \
ksym-vanilla-tty-init-termios \
ksym-vanilla-tty-kclose \
ksym-vanilla-tty-kopen-exclusive \
ksym-vanilla-tty-kopen-shared \
ksym-vanilla-tty-kref-put \
ksym-vanilla-tty-ldisc-deref \
ksym-vanilla-tty-ldisc-flush \
ksym-vanilla-tty-ldisc-receive-buf \
ksym-vanilla-tty-ldisc-ref \
ksym-vanilla-tty-ldisc-ref-wait \
ksym-vanilla-tty-lock \
ksym-vanilla-tty-mode-ioctl \
ksym-vanilla-tty-name \
ksym-vanilla-tty-perform-flush \
ksym-vanilla-tty-port-alloc-xmit-buf \
ksym-vanilla-tty-port-block-til-ready \
ksym-vanilla-tty-port-carrier-raised \
ksym-vanilla-tty-port-close \
ksym-vanilla-tty-port-close-end \
ksym-vanilla-tty-port-close-start \
ksym-vanilla-tty-port-default-client-ops \
ksym-vanilla-tty-port-destroy \
ksym-vanilla-tty-port-free-xmit-buf \
ksym-vanilla-tty-port-hangup \
ksym-vanilla-tty-port-init \
ksym-vanilla-tty-port-install \
ksym-vanilla-tty-port-link-device \
ksym-vanilla-tty-port-link-wq \
ksym-vanilla-tty-port-lower-dtr-rts \
ksym-vanilla-tty-port-open \
ksym-vanilla-tty-port-put \
ksym-vanilla-tty-port-raise-dtr-rts \
ksym-vanilla-tty-port-register-device \
ksym-vanilla-tty-port-register-device-attr \
ksym-vanilla-tty-port-register-device-attr-serdev \
ksym-vanilla-tty-port-tty-get \
ksym-vanilla-tty-port-tty-set \
ksym-vanilla-tty-port-tty-wakeup \
ksym-vanilla-tty-port-unregister-device \
ksym-vanilla-tty-prepare-flip-string \
ksym-vanilla-tty-put-char \
ksym-vanilla-tty-register-device \
ksym-vanilla-tty-register-device-attr \
ksym-vanilla-tty-register-driver \
ksym-vanilla-tty-register-ldisc \
ksym-vanilla-tty-release-struct \
ksym-vanilla-tty-save-termios \
ksym-vanilla-tty-set-ldisc \
ksym-vanilla-tty-set-termios \
ksym-vanilla-tty-standard-install \
ksym-vanilla-tty-std-termios \
ksym-vanilla-tty-termios-baud-rate \
ksym-vanilla-tty-termios-copy-hw \
ksym-vanilla-tty-termios-encode-baud-rate \
ksym-vanilla-tty-termios-hw-change \
ksym-vanilla-tty-termios-input-baud-rate \
ksym-vanilla-tty-unlock \
ksym-vanilla-tty-unregister-device \
ksym-vanilla-tty-unregister-driver \
ksym-vanilla-tty-unregister-ldisc \
ksym-vanilla-tty-unthrottle \
ksym-vanilla-tty-vhangup \
ksym-vanilla-tty-wait-until-sent \
ksym-vanilla-tty-wakeup \
ksym-vanilla-tty-write-room \
ksym-vanilla-tua6100-attach \
ksym-vanilla-tun-get-socket \
ksym-vanilla-tun-get-tx-ring \
ksym-vanilla-tun-ptr-free \
ksym-vanilla-tuner-count \
ksym-vanilla-tuners \
ksym-vanilla-tveeprom-hauppauge-analog \
ksym-vanilla-tveeprom-read \
ksym-vanilla-twofish-setkey \
ksym-vanilla-typec-altmode-attention \
ksym-vanilla-typec-altmode-enter \
ksym-vanilla-typec-altmode-exit \
ksym-vanilla-typec-altmode-get-partner \
ksym-vanilla-typec-altmode-get-plug \
ksym-vanilla-typec-altmode-notify \
ksym-vanilla-typec-altmode-put-plug \
ksym-vanilla-typec-altmode-set-ops \
ksym-vanilla-typec-altmode-state-update \
ksym-vanilla-typec-altmode-unregister-driver \
ksym-vanilla-typec-altmode-update-active \
ksym-vanilla-typec-altmode-vdm \
ksym-vanilla-typec-altmode2port \
ksym-vanilla-typec-bus \
ksym-vanilla-typec-cable-altmode-enter \
ksym-vanilla-typec-cable-altmode-exit \
ksym-vanilla-typec-cable-altmode-vdm \
ksym-vanilla-typec-cable-get \
ksym-vanilla-typec-cable-is-active \
ksym-vanilla-typec-cable-put \
ksym-vanilla-typec-cable-set-identity \
ksym-vanilla-typec-cable-set-svdm-version \
ksym-vanilla-typec-find-orientation \
ksym-vanilla-typec-find-port-data-role \
ksym-vanilla-typec-find-port-power-role \
ksym-vanilla-typec-find-power-role \
ksym-vanilla-typec-find-pwr-opmode \
ksym-vanilla-typec-get-cable-svdm-version \
ksym-vanilla-typec-get-data-role \
ksym-vanilla-typec-get-drvdata \
ksym-vanilla-typec-get-fw-cap \
ksym-vanilla-typec-get-negotiated-svdm-version \
ksym-vanilla-typec-get-orientation \
ksym-vanilla-typec-match-altmode \
ksym-vanilla-typec-mode-selection-delete \
ksym-vanilla-typec-mode-selection-start \
ksym-vanilla-typec-mux-get-drvdata \
ksym-vanilla-typec-mux-put \
ksym-vanilla-typec-mux-register \
ksym-vanilla-typec-mux-set \
ksym-vanilla-typec-mux-set-drvdata \
ksym-vanilla-typec-mux-unregister \
ksym-vanilla-typec-partner-altmode-dev-type \
ksym-vanilla-typec-partner-register-altmode \
ksym-vanilla-typec-partner-set-identity \
ksym-vanilla-typec-partner-set-num-altmodes \
ksym-vanilla-typec-partner-set-pd-revision \
ksym-vanilla-typec-partner-set-svdm-version \
ksym-vanilla-typec-partner-set-usb-mode \
ksym-vanilla-typec-partner-set-usb-power-delivery \
ksym-vanilla-typec-partner-usb-power-delivery-register \
ksym-vanilla-typec-plug-altmode-dev-type \
ksym-vanilla-typec-plug-register-altmode \
ksym-vanilla-typec-plug-set-num-altmodes \
ksym-vanilla-typec-port-altmode-dev-type \
ksym-vanilla-typec-port-register-altmode \
ksym-vanilla-typec-port-register-altmodes \
ksym-vanilla-typec-port-register-cable-ops \
ksym-vanilla-typec-port-set-usb-mode \
ksym-vanilla-typec-port-set-usb-power-delivery \
ksym-vanilla-typec-register-cable \
ksym-vanilla-typec-register-partner \
ksym-vanilla-typec-register-plug \
ksym-vanilla-typec-register-port \
ksym-vanilla-typec-retimer-get-drvdata \
ksym-vanilla-typec-retimer-put \
ksym-vanilla-typec-retimer-register \
ksym-vanilla-typec-retimer-set \
ksym-vanilla-typec-retimer-unregister \
ksym-vanilla-typec-set-data-role \
ksym-vanilla-typec-set-mode \
ksym-vanilla-typec-set-orientation \
ksym-vanilla-typec-set-pwr-opmode \
ksym-vanilla-typec-set-pwr-role \
ksym-vanilla-typec-set-vconn-role \
ksym-vanilla-typec-switch-get-drvdata \
ksym-vanilla-typec-switch-put \
ksym-vanilla-typec-switch-register \
ksym-vanilla-typec-switch-set \
ksym-vanilla-typec-switch-set-drvdata \
ksym-vanilla-typec-switch-unregister \
ksym-vanilla-typec-unregister-altmode \
ksym-vanilla-typec-unregister-cable \
ksym-vanilla-typec-unregister-partner \
ksym-vanilla-typec-unregister-plug \
ksym-vanilla-typec-unregister-port \
ksym-vanilla-u-audio-get-capture-srate \
ksym-vanilla-u-audio-get-mute \
ksym-vanilla-u-audio-get-playback-srate \
ksym-vanilla-u-audio-get-volume \
ksym-vanilla-u-audio-set-capture-srate \
ksym-vanilla-u-audio-set-mute \
ksym-vanilla-u-audio-set-playback-srate \
ksym-vanilla-u-audio-set-volume \
ksym-vanilla-u-audio-start-capture \
ksym-vanilla-u-audio-start-playback \
ksym-vanilla-u-audio-stop-capture \
ksym-vanilla-u-audio-stop-playback \
ksym-vanilla-u-audio-suspend \
ksym-vanilla-u-boot-env-parse \
ksym-vanilla-uacce-alloc \
ksym-vanilla-uacce-register \
ksym-vanilla-uacce-remove \
ksym-vanilla-uart-add-one-port \
ksym-vanilla-uart-console-device \
ksym-vanilla-uart-console-write \
ksym-vanilla-uart-get-baud-rate \
ksym-vanilla-uart-get-divisor \
ksym-vanilla-uart-get-rs485-mode \
ksym-vanilla-uart-handle-cts-change \
ksym-vanilla-uart-handle-dcd-change \
ksym-vanilla-uart-insert-char \
ksym-vanilla-uart-match-port \
ksym-vanilla-uart-parse-earlycon \
ksym-vanilla-uart-parse-options \
ksym-vanilla-uart-read-and-validate-port-properties \
ksym-vanilla-uart-read-port-properties \
ksym-vanilla-uart-register-driver \
ksym-vanilla-uart-remove-one-port \
ksym-vanilla-uart-resume-port \
ksym-vanilla-uart-set-options \
ksym-vanilla-uart-suspend-port \
ksym-vanilla-uart-try-toggle-sysrq \
ksym-vanilla-uart-unregister-driver \
ksym-vanilla-uart-update-timeout \
ksym-vanilla-uart-write-wakeup \
ksym-vanilla-uart-xchar-out \
ksym-vanilla-ubi-close-volume \
ksym-vanilla-ubi-do-get-device-info \
ksym-vanilla-ubi-get-device-info \
ksym-vanilla-ubi-get-volume-info \
ksym-vanilla-ubi-is-mapped \
ksym-vanilla-ubi-leb-change \
ksym-vanilla-ubi-leb-erase \
ksym-vanilla-ubi-leb-map \
ksym-vanilla-ubi-leb-read \
ksym-vanilla-ubi-leb-read-sg \
ksym-vanilla-ubi-leb-unmap \
ksym-vanilla-ubi-leb-write \
ksym-vanilla-ubi-open-volume \
ksym-vanilla-ubi-open-volume-nm \
ksym-vanilla-ubi-open-volume-path \
ksym-vanilla-ubi-register-volume-notifier \
ksym-vanilla-ubi-sync \
ksym-vanilla-ubi-unregister-volume-notifier \
ksym-vanilla-ucc-fast-disable \
ksym-vanilla-ucc-fast-dump-regs \
ksym-vanilla-ucc-fast-enable \
ksym-vanilla-ucc-fast-free \
ksym-vanilla-ucc-fast-get-qe-cr-subblock \
ksym-vanilla-ucc-fast-init \
ksym-vanilla-ucc-fast-transmit-on-demand \
ksym-vanilla-ucc-mux-set-grant-tsa-bkpt \
ksym-vanilla-ucc-of-parse-tdm \
ksym-vanilla-ucc-set-qe-mux-mii-mng \
ksym-vanilla-ucc-tdm-init \
ksym-vanilla-ucs2-as-utf8 \
ksym-vanilla-ucs2-strlen \
ksym-vanilla-ucs2-strncmp \
ksym-vanilla-ucs2-strnlen \
ksym-vanilla-ucs2-strscpy \
ksym-vanilla-ucs2-strsize \
ksym-vanilla-ucs2-utf8size \
ksym-vanilla-ucsi-connector-change \
ksym-vanilla-ucsi-create \
ksym-vanilla-ucsi-destroy \
ksym-vanilla-ucsi-get-drvdata \
ksym-vanilla-ucsi-notify-common \
ksym-vanilla-ucsi-register \
ksym-vanilla-ucsi-resume \
ksym-vanilla-ucsi-send-command \
ksym-vanilla-ucsi-set-drvdata \
ksym-vanilla-ucsi-suspend \
ksym-vanilla-ucsi-sync-control-common \
ksym-vanilla-ucsi-unregister \
ksym-vanilla-ucsi-write-message-out-command \
ksym-vanilla-udc-basic-init \
ksym-vanilla-udc-enable-dev-setup-interrupts \
ksym-vanilla-udc-irq \
ksym-vanilla-udc-mask-unused-interrupts \
ksym-vanilla-udc-probe \
ksym-vanilla-udc-remove \
ksym-vanilla-udp-bpf-update-proto \
ksym-vanilla-udp-encap-disable \
ksym-vanilla-udp-encap-enable \
ksym-vanilla-udp-flow-hashrnd \
ksym-vanilla-udp-memory-per-cpu-fw-alloc \
ksym-vanilla-udp-prot \
ksym-vanilla-udp-sendmsg \
ksym-vanilla-udp-set-csum \
ksym-vanilla-udp-sock-create4 \
ksym-vanilla-udp-sock-create6 \
ksym-vanilla-udp-tun-rx-dst \
ksym-vanilla-udp-tunnel-drop-rx-port \
ksym-vanilla-udp-tunnel-dst-lookup \
ksym-vanilla-udp-tunnel-nic-ops \
ksym-vanilla-udp-tunnel-notify-add-rx-port \
ksym-vanilla-udp-tunnel-notify-del-rx-port \
ksym-vanilla-udp-tunnel-push-rx-port \
ksym-vanilla-udp-tunnel-sock-release \
ksym-vanilla-udp-tunnel-update-gro-lookup \
ksym-vanilla-udp-tunnel-update-gro-rcv \
ksym-vanilla-udp-tunnel-xmit-skb \
ksym-vanilla-udp-tunnel6-dst-lookup \
ksym-vanilla-udp-tunnel6-xmit-skb \
ksym-vanilla-udp4-hwcsum \
ksym-vanilla-udp4-lib-lookup \
ksym-vanilla-udp6-lib-lookup \
ksym-vanilla-udp6-set-csum \
ksym-vanilla-udpv6-encap-enable \
ksym-vanilla-udpv6-sendmsg \
ksym-vanilla-ufshcd-alloc-host \
ksym-vanilla-ufshcd-apply-tx-eq-settings \
ksym-vanilla-ufshcd-auto-hibern8-update \
ksym-vanilla-ufshcd-change-power-mode \
ksym-vanilla-ufshcd-clkgate-delay-set \
ksym-vanilla-ufshcd-config-pwr-mode \
ksym-vanilla-ufshcd-delay-us \
ksym-vanilla-ufshcd-disable-irq \
ksym-vanilla-ufshcd-dme-configure-adapt \
ksym-vanilla-ufshcd-dme-enable \
ksym-vanilla-ufshcd-dme-get-attr \
ksym-vanilla-ufshcd-dme-reset \
ksym-vanilla-ufshcd-dme-rmw \
ksym-vanilla-ufshcd-dme-set-attr \
ksym-vanilla-ufshcd-dump-regs \
ksym-vanilla-ufshcd-dwc-dme-set-attrs \
ksym-vanilla-ufshcd-dwc-link-startup-notify \
ksym-vanilla-ufshcd-enable-irq \
ksym-vanilla-ufshcd-fixup-dev-quirks \
ksym-vanilla-ufshcd-force-error-recovery \
ksym-vanilla-ufshcd-get-vreg \
ksym-vanilla-ufshcd-hba-enable \
ksym-vanilla-ufshcd-hba-stop \
ksym-vanilla-ufshcd-hold \
ksym-vanilla-ufshcd-init \
ksym-vanilla-ufshcd-init-host-params \
ksym-vanilla-ufshcd-is-hba-active \
ksym-vanilla-ufshcd-link-recovery \
ksym-vanilla-ufshcd-make-hba-operational \
ksym-vanilla-ufshcd-mcq-config-esi \
ksym-vanilla-ufshcd-mcq-config-mac \
ksym-vanilla-ufshcd-mcq-enable \
ksym-vanilla-ufshcd-mcq-enable-esi \
ksym-vanilla-ufshcd-mcq-make-queues-operational \
ksym-vanilla-ufshcd-mcq-poll-cqe-lock \
ksym-vanilla-ufshcd-mcq-queue-cfg-addr \
ksym-vanilla-ufshcd-mcq-read-cqis \
ksym-vanilla-ufshcd-mcq-write-cqis \
ksym-vanilla-ufshcd-negotiate-pwr-params \
ksym-vanilla-ufshcd-opp-config-clks \
ksym-vanilla-ufshcd-parse-gear-limits \
ksym-vanilla-ufshcd-pltfrm-init \
ksym-vanilla-ufshcd-pltfrm-remove \
ksym-vanilla-ufshcd-pm-qos-update \
ksym-vanilla-ufshcd-populate-vreg \
ksym-vanilla-ufshcd-release \
ksym-vanilla-ufshcd-remove \
ksym-vanilla-ufshcd-resume-complete \
ksym-vanilla-ufshcd-runtime-resume \
ksym-vanilla-ufshcd-runtime-suspend \
ksym-vanilla-ufshcd-suspend-prepare \
ksym-vanilla-ufshcd-system-freeze \
ksym-vanilla-ufshcd-system-restore \
ksym-vanilla-ufshcd-system-resume \
ksym-vanilla-ufshcd-system-suspend \
ksym-vanilla-ufshcd-system-thaw \
ksym-vanilla-ufshcd-uic-change-pwr-mode \
ksym-vanilla-ufshcd-uic-hibern8-enter \
ksym-vanilla-ufshcd-uic-hibern8-exit \
ksym-vanilla-ufshcd-update-evt-hist \
ksym-vanilla-ufshcd-us-to-ahit \
ksym-vanilla-uhci-check-and-reset-hc \
ksym-vanilla-uhci-reset-hc \
ksym-vanilla-uio-event-notify \
ksym-vanilla-uio-unregister-device \
ksym-vanilla-ulpi-read \
ksym-vanilla-ulpi-register-interface \
ksym-vanilla-ulpi-unregister-driver \
ksym-vanilla-ulpi-unregister-interface \
ksym-vanilla-ulpi-viewport-access-ops \
ksym-vanilla-ulpi-write \
ksym-vanilla-unix-domain-find \
ksym-vanilla-unix-inq-len \
ksym-vanilla-unix-outq-len \
ksym-vanilla-unix-peer-get \
ksym-vanilla-unload-nls \
ksym-vanilla-unlock-buffer \
ksym-vanilla-unlock-new-inode \
ksym-vanilla-unlock-page \
ksym-vanilla-unlock-system-sleep \
ksym-vanilla-unlock-two-nondirectories \
ksym-vanilla-unmap-mapping-pages \
ksym-vanilla-unmap-mapping-range \
ksym-vanilla-unpack \
ksym-vanilla-unpack-fields-u16 \
ksym-vanilla-unpack-fields-u8 \
ksym-vanilla-unpin-folio \
ksym-vanilla-unpin-folios \
ksym-vanilla-unpin-user-folio \
ksym-vanilla-unpin-user-page \
ksym-vanilla-unpin-user-page-range-dirty-lock \
ksym-vanilla-unpin-user-pages \
ksym-vanilla-unpin-user-pages-dirty-lock \
ksym-vanilla-unpoison-memory \
ksym-vanilla-unregister-acpi-bus-type \
ksym-vanilla-unregister-acpi-hed-notifier \
ksym-vanilla-unregister-acpi-notifier \
ksym-vanilla-unregister-asymmetric-key-parser \
ksym-vanilla-unregister-atmdevice-notifier \
ksym-vanilla-unregister-binfmt \
ksym-vanilla-unregister-blkdev \
ksym-vanilla-unregister-blocking-lsm-notifier \
ksym-vanilla-unregister-c-can-dev \
ksym-vanilla-unregister-candev \
ksym-vanilla-unregister-cdrom \
ksym-vanilla-unregister-chrdev-region \
ksym-vanilla-unregister-console \
ksym-vanilla-unregister-dcbevent-notifier \
ksym-vanilla-unregister-die-notifier \
ksym-vanilla-unregister-dpll-notifier \
ksym-vanilla-unregister-fib-notifier \
ksym-vanilla-unregister-filesystem \
ksym-vanilla-unregister-firmware-config-sysctl \
ksym-vanilla-unregister-framebuffer \
ksym-vanilla-unregister-ftrace-direct \
ksym-vanilla-unregister-ftrace-export \
ksym-vanilla-unregister-ftrace-function \
ksym-vanilla-unregister-gadget-item \
ksym-vanilla-unregister-hdlc-device \
ksym-vanilla-unregister-hdlc-protocol \
ksym-vanilla-unregister-hw-breakpoint \
ksym-vanilla-unregister-ife-op \
ksym-vanilla-unregister-inet6addr-notifier \
ksym-vanilla-unregister-inet6addr-validator-notifier \
ksym-vanilla-unregister-inetaddr-notifier \
ksym-vanilla-unregister-inetaddr-validator-notifier \
ksym-vanilla-unregister-ip-vs-app \
ksym-vanilla-unregister-ip-vs-pe \
ksym-vanilla-unregister-ip-vs-scheduler \
ksym-vanilla-unregister-key-type \
ksym-vanilla-unregister-keyboard-notifier \
ksym-vanilla-unregister-kprobe \
ksym-vanilla-unregister-kprobes \
ksym-vanilla-unregister-kretprobe \
ksym-vanilla-unregister-kretprobes \
ksym-vanilla-unregister-md-submodule \
ksym-vanilla-unregister-memory-notifier \
ksym-vanilla-unregister-module-notifier \
ksym-vanilla-unregister-mt-adistance-algorithm \
ksym-vanilla-unregister-mtd-chip-driver \
ksym-vanilla-unregister-mtd-user \
ksym-vanilla-unregister-net-sysctl-table \
ksym-vanilla-unregister-netdev \
ksym-vanilla-unregister-netdevice-many \
ksym-vanilla-unregister-netdevice-notifier \
ksym-vanilla-unregister-netdevice-notifier-dev-net \
ksym-vanilla-unregister-netdevice-notifier-net \
ksym-vanilla-unregister-netdevice-queue \
ksym-vanilla-unregister-netevent-notifier \
ksym-vanilla-unregister-nexthop-notifier \
ksym-vanilla-unregister-nfs-version \
ksym-vanilla-unregister-nls \
ksym-vanilla-unregister-node-notifier \
ksym-vanilla-unregister-nvdimm-pmu \
ksym-vanilla-unregister-oom-notifier \
ksym-vanilla-unregister-pernet-device \
ksym-vanilla-unregister-pernet-subsys \
ksym-vanilla-unregister-pfn-address-space \
ksym-vanilla-unregister-platform-power-off \
ksym-vanilla-unregister-pm-notifier \
ksym-vanilla-unregister-pppox-proto \
ksym-vanilla-unregister-pstore-device \
ksym-vanilla-unregister-pstore-zone \
ksym-vanilla-unregister-qdisc \
ksym-vanilla-unregister-quota-format \
ksym-vanilla-unregister-random-vmfork-notifier \
ksym-vanilla-unregister-reboot-notifier \
ksym-vanilla-unregister-restart-handler \
ksym-vanilla-unregister-rpmsg-driver \
ksym-vanilla-unregister-sja1000dev \
ksym-vanilla-unregister-snap-client \
ksym-vanilla-unregister-sound-dsp \
ksym-vanilla-unregister-sound-mixer \
ksym-vanilla-unregister-sound-special \
ksym-vanilla-unregister-switchdev-blocking-notifier \
ksym-vanilla-unregister-switchdev-notifier \
ksym-vanilla-unregister-sys-off-handler \
ksym-vanilla-unregister-syscore \
ksym-vanilla-unregister-sysctl-table \
ksym-vanilla-unregister-sysrq-key \
ksym-vanilla-unregister-tcf-proto-ops \
ksym-vanilla-unregister-trace-event \
ksym-vanilla-unregister-tracepoint-module-notifier \
ksym-vanilla-unregister-virtio-device \
ksym-vanilla-unregister-virtio-driver \
ksym-vanilla-unregister-vmap-purge-notifier \
ksym-vanilla-unregister-vmcore-cb \
ksym-vanilla-unregister-vt-notifier \
ksym-vanilla-unregister-wide-hw-breakpoint \
ksym-vanilla-unshare-fs-struct \
ksym-vanilla-uobj-destroy \
ksym-vanilla-up \
ksym-vanilla-up-read \
ksym-vanilla-up-write \
ksym-vanilla-update-devfreq \
ksym-vanilla-update-region \
ksym-vanilla-uprobe-register \
ksym-vanilla-uprobe-unregister-nosync \
ksym-vanilla-uprobe-unregister-sync \
ksym-vanilla-usb-acpi-port-lpm-incapable \
ksym-vanilla-usb-acpi-power-manageable \
ksym-vanilla-usb-acpi-set-power-state \
ksym-vanilla-usb-add-config \
ksym-vanilla-usb-add-config-only \
ksym-vanilla-usb-add-function \
ksym-vanilla-usb-add-gadget \
ksym-vanilla-usb-add-gadget-udc \
ksym-vanilla-usb-add-gadget-udc-release \
ksym-vanilla-usb-add-hcd \
ksym-vanilla-usb-add-phy \
ksym-vanilla-usb-add-phy-dev \
ksym-vanilla-usb-alloc-coherent \
ksym-vanilla-usb-alloc-dev \
ksym-vanilla-usb-alloc-noncoherent \
ksym-vanilla-usb-alloc-streams \
ksym-vanilla-usb-alloc-urb \
ksym-vanilla-usb-altnum-to-altsetting \
ksym-vanilla-usb-amd-dev-put \
ksym-vanilla-usb-amd-hang-symptom-quirk \
ksym-vanilla-usb-amd-prefetch-quirk \
ksym-vanilla-usb-amd-pt-check-port \
ksym-vanilla-usb-amd-quirk-pll-check \
ksym-vanilla-usb-amd-quirk-pll-disable \
ksym-vanilla-usb-amd-quirk-pll-enable \
ksym-vanilla-usb-anchor-empty \
ksym-vanilla-usb-anchor-resume-wakeups \
ksym-vanilla-usb-anchor-suspend-wakeups \
ksym-vanilla-usb-anchor-urb \
ksym-vanilla-usb-asmedia-modifyflowcontrol \
ksym-vanilla-usb-assign-descriptors \
ksym-vanilla-usb-autopm-get-interface \
ksym-vanilla-usb-autopm-get-interface-async \
ksym-vanilla-usb-autopm-get-interface-no-resume \
ksym-vanilla-usb-autopm-put-interface \
ksym-vanilla-usb-autopm-put-interface-async \
ksym-vanilla-usb-autopm-put-interface-no-suspend \
ksym-vanilla-usb-block-urb \
ksym-vanilla-usb-bulk-msg \
ksym-vanilla-usb-bulk-msg-killable \
ksym-vanilla-usb-bus-idr \
ksym-vanilla-usb-bus-idr-lock \
ksym-vanilla-usb-bus-start-enum \
ksym-vanilla-usb-cache-string \
ksym-vanilla-usb-calc-bus-time \
ksym-vanilla-usb-cdc-wdm-register \
ksym-vanilla-usb-check-bulk-endpoints \
ksym-vanilla-usb-check-int-endpoints \
ksym-vanilla-usb-choose-configuration \
ksym-vanilla-usb-clear-halt \
ksym-vanilla-usb-composite-overwrite-options \
ksym-vanilla-usb-composite-probe \
ksym-vanilla-usb-composite-setup-continue \
ksym-vanilla-usb-composite-unregister \
ksym-vanilla-usb-control-msg \
ksym-vanilla-usb-control-msg-recv \
ksym-vanilla-usb-control-msg-send \
ksym-vanilla-usb-copy-descriptors \
ksym-vanilla-usb-create-hcd \
ksym-vanilla-usb-create-shared-hcd \
ksym-vanilla-usb-cypress-load-firmware \
ksym-vanilla-usb-debug-root \
ksym-vanilla-usb-decode-ctrl \
ksym-vanilla-usb-decode-interval \
ksym-vanilla-usb-del-gadget \
ksym-vanilla-usb-del-gadget-udc \
ksym-vanilla-usb-deregister \
ksym-vanilla-usb-deregister-dev \
ksym-vanilla-usb-deregister-device-driver \
ksym-vanilla-usb-descriptor-fillbuf \
ksym-vanilla-usb-device-match-id \
ksym-vanilla-usb-disable-autosuspend \
ksym-vanilla-usb-disable-lpm \
ksym-vanilla-usb-disable-ltm \
ksym-vanilla-usb-disable-xhci-ports \
ksym-vanilla-usb-disabled \
ksym-vanilla-usb-driver-claim-interface \
ksym-vanilla-usb-driver-release-interface \
ksym-vanilla-usb-driver-set-configuration \
ksym-vanilla-usb-dynids-lock \
ksym-vanilla-usb-enable-autosuspend \
ksym-vanilla-usb-enable-intel-xhci-ports \
ksym-vanilla-usb-enable-lpm \
ksym-vanilla-usb-enable-ltm \
ksym-vanilla-usb-endpoint-is-hs-isoc-double \
ksym-vanilla-usb-endpoint-max-periodic-payload \
ksym-vanilla-usb-ep-alloc-request \
ksym-vanilla-usb-ep-autoconfig \
ksym-vanilla-usb-ep-autoconfig-release \
ksym-vanilla-usb-ep-autoconfig-reset \
ksym-vanilla-usb-ep-autoconfig-ss \
ksym-vanilla-usb-ep-clear-halt \
ksym-vanilla-usb-ep-dequeue \
ksym-vanilla-usb-ep-disable \
ksym-vanilla-usb-ep-enable \
ksym-vanilla-usb-ep-fifo-flush \
ksym-vanilla-usb-ep-fifo-status \
ksym-vanilla-usb-ep-free-request \
ksym-vanilla-usb-ep-queue \
ksym-vanilla-usb-ep-set-halt \
ksym-vanilla-usb-ep-set-maxpacket-limit \
ksym-vanilla-usb-ep-set-wedge \
ksym-vanilla-usb-ep-type-string \
ksym-vanilla-usb-ep0-reinit \
ksym-vanilla-usb-find-alt-setting \
ksym-vanilla-usb-find-common-endpoints \
ksym-vanilla-usb-find-common-endpoints-reverse \
ksym-vanilla-usb-find-interface \
ksym-vanilla-usb-for-each-dev \
ksym-vanilla-usb-free-all-descriptors \
ksym-vanilla-usb-free-coherent \
ksym-vanilla-usb-free-noncoherent \
ksym-vanilla-usb-free-streams \
ksym-vanilla-usb-free-urb \
ksym-vanilla-usb-func-wakeup \
ksym-vanilla-usb-function-activate \
ksym-vanilla-usb-function-deactivate \
ksym-vanilla-usb-function-register \
ksym-vanilla-usb-function-unregister \
ksym-vanilla-usb-gadget-activate \
ksym-vanilla-usb-gadget-check-config \
ksym-vanilla-usb-gadget-clear-selfpowered \
ksym-vanilla-usb-gadget-connect \
ksym-vanilla-usb-gadget-deactivate \
ksym-vanilla-usb-gadget-disconnect \
ksym-vanilla-usb-gadget-ep-match-desc \
ksym-vanilla-usb-gadget-frame-number \
ksym-vanilla-usb-gadget-get-string \
ksym-vanilla-usb-gadget-giveback-request \
ksym-vanilla-usb-gadget-map-request \
ksym-vanilla-usb-gadget-map-request-by-dev \
ksym-vanilla-usb-gadget-register-driver-owner \
ksym-vanilla-usb-gadget-set-remote-wakeup \
ksym-vanilla-usb-gadget-set-selfpowered \
ksym-vanilla-usb-gadget-set-state \
ksym-vanilla-usb-gadget-udc-reset \
ksym-vanilla-usb-gadget-unmap-request \
ksym-vanilla-usb-gadget-unmap-request-by-dev \
ksym-vanilla-usb-gadget-unregister-driver \
ksym-vanilla-usb-gadget-vbus-connect \
ksym-vanilla-usb-gadget-vbus-disconnect \
ksym-vanilla-usb-gadget-vbus-draw \
ksym-vanilla-usb-gadget-wakeup \
ksym-vanilla-usb-gen-phy-init \
ksym-vanilla-usb-gen-phy-shutdown \
ksym-vanilla-usb-get-current-frame-number \
ksym-vanilla-usb-get-descriptor \
ksym-vanilla-usb-get-dev \
ksym-vanilla-usb-get-dr-mode \
ksym-vanilla-usb-get-from-anchor \
ksym-vanilla-usb-get-function \
ksym-vanilla-usb-get-function-instance \
ksym-vanilla-usb-get-gadget-udc-name \
ksym-vanilla-usb-get-hcd \
ksym-vanilla-usb-get-intf \
ksym-vanilla-usb-get-maximum-speed \
ksym-vanilla-usb-get-maximum-ssp-rate \
ksym-vanilla-usb-get-phy \
ksym-vanilla-usb-get-role-switch-default-mode \
ksym-vanilla-usb-get-status \
ksym-vanilla-usb-get-urb \
ksym-vanilla-usb-gstrings-attach \
ksym-vanilla-usb-hc-died \
ksym-vanilla-usb-hcd-amd-remote-wakeup-quirk \
ksym-vanilla-usb-hcd-check-unlink-urb \
ksym-vanilla-usb-hcd-end-port-resume \
ksym-vanilla-usb-hcd-giveback-urb \
ksym-vanilla-usb-hcd-irq \
ksym-vanilla-usb-hcd-is-primary-hcd \
ksym-vanilla-usb-hcd-link-urb-to-ep \
ksym-vanilla-usb-hcd-map-urb-for-dma \
ksym-vanilla-usb-hcd-pci-pm-ops \
ksym-vanilla-usb-hcd-pci-probe \
ksym-vanilla-usb-hcd-pci-remove \
ksym-vanilla-usb-hcd-pci-shutdown \
ksym-vanilla-usb-hcd-platform-shutdown \
ksym-vanilla-usb-hcd-poll-rh-status \
ksym-vanilla-usb-hcd-resume-root-hub \
ksym-vanilla-usb-hcd-setup-local-mem \
ksym-vanilla-usb-hcd-start-port-resume \
ksym-vanilla-usb-hcd-unlink-urb-from-ep \
ksym-vanilla-usb-hcd-unmap-urb-for-dma \
ksym-vanilla-usb-hcd-unmap-urb-setup-for-dma \
ksym-vanilla-usb-hub-claim-port \
ksym-vanilla-usb-hub-clear-tt-buffer \
ksym-vanilla-usb-hub-find-child \
ksym-vanilla-usb-hub-release-port \
ksym-vanilla-usb-ifnum-to-if \
ksym-vanilla-usb-init-urb \
ksym-vanilla-usb-initialize-gadget \
ksym-vanilla-usb-interface-id \
ksym-vanilla-usb-interrupt-msg \
ksym-vanilla-usb-intf-get-dma-device \
ksym-vanilla-usb-kill-anchored-urbs \
ksym-vanilla-usb-kill-urb \
ksym-vanilla-usb-led-activity \
ksym-vanilla-usb-lock-device-for-reset \
ksym-vanilla-usb-match-id \
ksym-vanilla-usb-match-one-id \
ksym-vanilla-usb-mon-deregister \
ksym-vanilla-usb-mon-register \
ksym-vanilla-usb-of-get-companion-dev \
ksym-vanilla-usb-of-get-connect-type \
ksym-vanilla-usb-of-get-device-node \
ksym-vanilla-usb-of-get-interface-node \
ksym-vanilla-usb-of-has-combined-node \
ksym-vanilla-usb-offload-check \
ksym-vanilla-usb-offload-get \
ksym-vanilla-usb-offload-put \
ksym-vanilla-usb-offload-set-pm-locked \
ksym-vanilla-usb-os-desc-prepare-interf-dir \
ksym-vanilla-usb-otg-descriptor-alloc \
ksym-vanilla-usb-otg-descriptor-init \
ksym-vanilla-usb-otg-state-string \
ksym-vanilla-usb-phy-gen-create-phy \
ksym-vanilla-usb-phy-generic-register \
ksym-vanilla-usb-phy-generic-unregister \
ksym-vanilla-usb-phy-get-charger-current \
ksym-vanilla-usb-phy-roothub-alloc \
ksym-vanilla-usb-phy-roothub-alloc-usb3-phy \
ksym-vanilla-usb-phy-roothub-calibrate \
ksym-vanilla-usb-phy-roothub-exit \
ksym-vanilla-usb-phy-roothub-init \
ksym-vanilla-usb-phy-roothub-notify-connect \
ksym-vanilla-usb-phy-roothub-notify-disconnect \
ksym-vanilla-usb-phy-roothub-power-off \
ksym-vanilla-usb-phy-roothub-power-on \
ksym-vanilla-usb-phy-roothub-resume \
ksym-vanilla-usb-phy-roothub-set-mode \
ksym-vanilla-usb-phy-roothub-suspend \
ksym-vanilla-usb-phy-set-charger-current \
ksym-vanilla-usb-phy-set-charger-state \
ksym-vanilla-usb-phy-set-event \
ksym-vanilla-usb-pipe-type-check \
ksym-vanilla-usb-poison-anchored-urbs \
ksym-vanilla-usb-poison-urb \
ksym-vanilla-usb-power-delivery-link-device \
ksym-vanilla-usb-power-delivery-register \
ksym-vanilla-usb-power-delivery-register-capabilities \
ksym-vanilla-usb-power-delivery-unlink-device \
ksym-vanilla-usb-power-delivery-unregister \
ksym-vanilla-usb-power-delivery-unregister-capabilities \
ksym-vanilla-usb-put-dev \
ksym-vanilla-usb-put-function \
ksym-vanilla-usb-put-function-instance \
ksym-vanilla-usb-put-hcd \
ksym-vanilla-usb-put-intf \
ksym-vanilla-usb-put-phy \
ksym-vanilla-usb-queue-reset-device \
ksym-vanilla-usb-register-dev \
ksym-vanilla-usb-register-device-driver \
ksym-vanilla-usb-register-driver \
ksym-vanilla-usb-register-notify \
ksym-vanilla-usb-remove-function \
ksym-vanilla-usb-remove-hcd \
ksym-vanilla-usb-remove-phy \
ksym-vanilla-usb-reset-configuration \
ksym-vanilla-usb-reset-device \
ksym-vanilla-usb-reset-endpoint \
ksym-vanilla-usb-role-string \
ksym-vanilla-usb-role-switch-find-by-fwnode \
ksym-vanilla-usb-role-switch-get \
ksym-vanilla-usb-role-switch-get-drvdata \
ksym-vanilla-usb-role-switch-get-role \
ksym-vanilla-usb-role-switch-put \
ksym-vanilla-usb-role-switch-register \
ksym-vanilla-usb-role-switch-set-drvdata \
ksym-vanilla-usb-role-switch-set-role \
ksym-vanilla-usb-role-switch-unregister \
ksym-vanilla-usb-root-hub-lost-power \
ksym-vanilla-usb-scuttle-anchored-urbs \
ksym-vanilla-usb-serial-claim-interface \
ksym-vanilla-usb-serial-deregister-drivers \
ksym-vanilla-usb-serial-generic-chars-in-buffer \
ksym-vanilla-usb-serial-generic-close \
ksym-vanilla-usb-serial-generic-get-icount \
ksym-vanilla-usb-serial-generic-open \
ksym-vanilla-usb-serial-generic-process-read-urb \
ksym-vanilla-usb-serial-generic-read-bulk-callback \
ksym-vanilla-usb-serial-generic-resume \
ksym-vanilla-usb-serial-generic-submit-read-urbs \
ksym-vanilla-usb-serial-generic-throttle \
ksym-vanilla-usb-serial-generic-tiocmiwait \
ksym-vanilla-usb-serial-generic-unthrottle \
ksym-vanilla-usb-serial-generic-wait-until-sent \
ksym-vanilla-usb-serial-generic-write \
ksym-vanilla-usb-serial-generic-write-bulk-callback \
ksym-vanilla-usb-serial-generic-write-start \
ksym-vanilla-usb-serial-handle-dcd-change \
ksym-vanilla-usb-serial-port-softint \
ksym-vanilla-usb-serial-resume \
ksym-vanilla-usb-serial-suspend \
ksym-vanilla-usb-set-configuration \
ksym-vanilla-usb-set-device-state \
ksym-vanilla-usb-set-interface \
ksym-vanilla-usb-set-wireless-status \
ksym-vanilla-usb-sg-cancel \
ksym-vanilla-usb-sg-init \
ksym-vanilla-usb-sg-wait \
ksym-vanilla-usb-show-dynids \
ksym-vanilla-usb-speed-string \
ksym-vanilla-usb-state-string \
ksym-vanilla-usb-stor-Bulk-reset \
ksym-vanilla-usb-stor-Bulk-transport \
ksym-vanilla-usb-stor-CB-reset \
ksym-vanilla-usb-stor-CB-transport \
ksym-vanilla-usb-stor-access-xfer-buf \
ksym-vanilla-usb-stor-adjust-quirks \
ksym-vanilla-usb-stor-bulk-srb \
ksym-vanilla-usb-stor-bulk-transfer-buf \
ksym-vanilla-usb-stor-bulk-transfer-sg \
ksym-vanilla-usb-stor-clear-halt \
ksym-vanilla-usb-stor-control-msg \
ksym-vanilla-usb-stor-ctrl-transfer \
ksym-vanilla-usb-stor-disconnect \
ksym-vanilla-usb-stor-host-template-init \
ksym-vanilla-usb-stor-post-reset \
ksym-vanilla-usb-stor-pre-reset \
ksym-vanilla-usb-stor-probe1 \
ksym-vanilla-usb-stor-probe2 \
ksym-vanilla-usb-stor-reset-resume \
ksym-vanilla-usb-stor-resume \
ksym-vanilla-usb-stor-sense-invalidCDB \
ksym-vanilla-usb-stor-set-xfer-buf \
ksym-vanilla-usb-stor-suspend \
ksym-vanilla-usb-stor-transparent-scsi-command \
ksym-vanilla-usb-store-new-id \
ksym-vanilla-usb-string \
ksym-vanilla-usb-string-id \
ksym-vanilla-usb-string-ids-n \
ksym-vanilla-usb-string-ids-tab \
ksym-vanilla-usb-submit-urb \
ksym-vanilla-usb-udc-vbus-handler \
ksym-vanilla-usb-unanchor-urb \
ksym-vanilla-usb-unlink-urb \
ksym-vanilla-usb-unlocked-disable-lpm \
ksym-vanilla-usb-unlocked-enable-lpm \
ksym-vanilla-usb-unpoison-anchored-urbs \
ksym-vanilla-usb-unpoison-urb \
ksym-vanilla-usb-unregister-notify \
ksym-vanilla-usb-urb-ep-type-check \
ksym-vanilla-usb-validate-langid \
ksym-vanilla-usb-wait-anchor-empty-timeout \
ksym-vanilla-usb-wakeup-enabled-descendants \
ksym-vanilla-usb-wakeup-notification \
ksym-vanilla-usb-wwan-chars-in-buffer \
ksym-vanilla-usb-wwan-close \
ksym-vanilla-usb-wwan-dtr-rts \
ksym-vanilla-usb-wwan-open \
ksym-vanilla-usb-wwan-port-probe \
ksym-vanilla-usb-wwan-port-remove \
ksym-vanilla-usb-wwan-resume \
ksym-vanilla-usb-wwan-suspend \
ksym-vanilla-usb-wwan-tiocmget \
ksym-vanilla-usb-wwan-tiocmset \
ksym-vanilla-usb-wwan-write \
ksym-vanilla-usb-wwan-write-room \
ksym-vanilla-usb4-usb3-port-match \
ksym-vanilla-usbatm-usb-disconnect \
ksym-vanilla-usbatm-usb-probe \
ksym-vanilla-usbip-alloc-iso-desc-pdu \
ksym-vanilla-usbip-debug-flag \
ksym-vanilla-usbip-dump-header \
ksym-vanilla-usbip-dump-urb \
ksym-vanilla-usbip-event-add \
ksym-vanilla-usbip-event-happened \
ksym-vanilla-usbip-header-correct-endian \
ksym-vanilla-usbip-in-eh \
ksym-vanilla-usbip-pack-pdu \
ksym-vanilla-usbip-pad-iso \
ksym-vanilla-usbip-recv \
ksym-vanilla-usbip-recv-iso \
ksym-vanilla-usbip-recv-xbuff \
ksym-vanilla-usbip-start-eh \
ksym-vanilla-usbip-stop-eh \
ksym-vanilla-usbnet-cdc-bind \
ksym-vanilla-usbnet-cdc-status \
ksym-vanilla-usbnet-cdc-unbind \
ksym-vanilla-usbnet-cdc-update-filter \
ksym-vanilla-usbnet-cdc-zte-rx-fixup \
ksym-vanilla-usbnet-change-mtu \
ksym-vanilla-usbnet-defer-kevent \
ksym-vanilla-usbnet-device-suggests-idle \
ksym-vanilla-usbnet-disconnect \
ksym-vanilla-usbnet-ether-cdc-bind \
ksym-vanilla-usbnet-generic-cdc-bind \
ksym-vanilla-usbnet-get-drvinfo \
ksym-vanilla-usbnet-get-endpoints \
ksym-vanilla-usbnet-get-ethernet-addr \
ksym-vanilla-usbnet-get-link \
ksym-vanilla-usbnet-get-link-ksettings-internal \
ksym-vanilla-usbnet-get-link-ksettings-mii \
ksym-vanilla-usbnet-get-msglevel \
ksym-vanilla-usbnet-link-change \
ksym-vanilla-usbnet-manage-power \
ksym-vanilla-usbnet-mii-ioctl \
ksym-vanilla-usbnet-nway-reset \
ksym-vanilla-usbnet-open \
ksym-vanilla-usbnet-pause-rx \
ksym-vanilla-usbnet-probe \
ksym-vanilla-usbnet-purge-paused-rxq \
ksym-vanilla-usbnet-read-cmd \
ksym-vanilla-usbnet-read-cmd-nopm \
ksym-vanilla-usbnet-resume \
ksym-vanilla-usbnet-resume-rx \
ksym-vanilla-usbnet-set-link-ksettings-mii \
ksym-vanilla-usbnet-set-msglevel \
ksym-vanilla-usbnet-set-rx-mode \
ksym-vanilla-usbnet-skb-return \
ksym-vanilla-usbnet-start-xmit \
ksym-vanilla-usbnet-status-start \
ksym-vanilla-usbnet-status-stop \
ksym-vanilla-usbnet-stop \
ksym-vanilla-usbnet-suspend \
ksym-vanilla-usbnet-tx-timeout \
ksym-vanilla-usbnet-unlink-rx-urbs \
ksym-vanilla-usbnet-update-max-qlen \
ksym-vanilla-usbnet-write-cmd \
ksym-vanilla-usbnet-write-cmd-async \
ksym-vanilla-usbnet-write-cmd-nopm \
ksym-vanilla-user-describe \
ksym-vanilla-user-destroy \
ksym-vanilla-user-free-preparse \
ksym-vanilla-user-path-at \
ksym-vanilla-user-preparse \
ksym-vanilla-user-read \
ksym-vanilla-user-revoke \
ksym-vanilla-user-update \
ksym-vanilla-usermodehelper-read-lock-wait \
ksym-vanilla-usermodehelper-read-trylock \
ksym-vanilla-usermodehelper-read-unlock \
ksym-vanilla-usleep-range-state \
ksym-vanilla-utf16s-to-utf8s \
ksym-vanilla-utf32-to-utf8 \
ksym-vanilla-utf8-casefold \
ksym-vanilla-utf8-casefold-hash \
ksym-vanilla-utf8-data-table \
ksym-vanilla-utf8-load \
ksym-vanilla-utf8-normalize \
ksym-vanilla-utf8-parse-version \
ksym-vanilla-utf8-strncasecmp \
ksym-vanilla-utf8-strncasecmp-folded \
ksym-vanilla-utf8-strncmp \
ksym-vanilla-utf8-to-utf32 \
ksym-vanilla-utf8-unload \
ksym-vanilla-utf8-validate \
ksym-vanilla-utf8s-to-utf16s \
ksym-vanilla-uuid-gen \
ksym-vanilla-uuid-is-valid \
ksym-vanilla-uuid-null \
ksym-vanilla-uuid-parse \
ksym-vanilla-uvc-format-by-guid \
ksym-vanilla-uverbs-copy-to \
ksym-vanilla-uverbs-copy-to-struct-or-zero \
ksym-vanilla-uverbs-destroy-def-handler \
ksym-vanilla-uverbs-fd-class \
ksym-vanilla-uverbs-finalize-object \
ksym-vanilla-uverbs-finalize-uobj-create \
ksym-vanilla-uverbs-get-buffer-desc \
ksym-vanilla-uverbs-get-cleared-udata \
ksym-vanilla-uverbs-get-flags32 \
ksym-vanilla-uverbs-get-flags64 \
ksym-vanilla-uverbs-get-uobject-from-file \
ksym-vanilla-uverbs-idr-class \
ksym-vanilla-uverbs-try-lock-object \
ksym-vanilla-uverbs-uobject-fd-release \
ksym-vanilla-uverbs-uobject-put \
ksym-vanilla-uverbs-uobject-release \
ksym-vanilla-v4l-bound-align-image \
ksym-vanilla-v4l-disable-media-source \
ksym-vanilla-v4l-enable-media-source \
ksym-vanilla-v4l-printk-ioctl \
ksym-vanilla-v4l-vb2q-enable-media-source \
ksym-vanilla-v4l2-apply-frmsize-constraints \
ksym-vanilla-v4l2-async-connection-unique \
ksym-vanilla-v4l2-async-nf-cleanup \
ksym-vanilla-v4l2-async-nf-init \
ksym-vanilla-v4l2-async-nf-register \
ksym-vanilla-v4l2-async-nf-unregister \
ksym-vanilla-v4l2-async-subdev-endpoint-add \
ksym-vanilla-v4l2-async-subdev-nf-init \
ksym-vanilla-v4l2-async-unregister-subdev \
ksym-vanilla-v4l2-calc-aspect-ratio \
ksym-vanilla-v4l2-calc-timeperframe \
ksym-vanilla-v4l2-compat-ioctl32 \
ksym-vanilla-v4l2-create-fwnode-links \
ksym-vanilla-v4l2-create-fwnode-links-to-pad \
ksym-vanilla-v4l2-ctrl-activate \
ksym-vanilla-v4l2-ctrl-add-handler \
ksym-vanilla-v4l2-ctrl-auto-cluster \
ksym-vanilla-v4l2-ctrl-cluster \
ksym-vanilla-v4l2-ctrl-fill \
ksym-vanilla-v4l2-ctrl-find \
ksym-vanilla-v4l2-ctrl-g-ctrl \
ksym-vanilla-v4l2-ctrl-g-ctrl-int64 \
ksym-vanilla-v4l2-ctrl-get-int-menu \
ksym-vanilla-v4l2-ctrl-get-menu \
ksym-vanilla-v4l2-ctrl-get-name \
ksym-vanilla-v4l2-ctrl-handler-free \
ksym-vanilla-v4l2-ctrl-handler-init-class \
ksym-vanilla-v4l2-ctrl-handler-log-status \
ksym-vanilla-v4l2-ctrl-handler-setup \
ksym-vanilla-v4l2-ctrl-log-status \
ksym-vanilla-v4l2-ctrl-merge \
ksym-vanilla-v4l2-ctrl-new-custom \
ksym-vanilla-v4l2-ctrl-new-fwnode-properties \
ksym-vanilla-v4l2-ctrl-new-int-menu \
ksym-vanilla-v4l2-ctrl-new-std \
ksym-vanilla-v4l2-ctrl-new-std-compound \
ksym-vanilla-v4l2-ctrl-new-std-menu \
ksym-vanilla-v4l2-ctrl-new-std-menu-items \
ksym-vanilla-v4l2-ctrl-notify \
ksym-vanilla-v4l2-ctrl-poll \
ksym-vanilla-v4l2-ctrl-query-fill \
ksym-vanilla-v4l2-ctrl-radio-filter \
ksym-vanilla-v4l2-ctrl-replace \
ksym-vanilla-v4l2-ctrl-request-complete \
ksym-vanilla-v4l2-ctrl-request-hdl-ctrl-find \
ksym-vanilla-v4l2-ctrl-request-hdl-find \
ksym-vanilla-v4l2-ctrl-request-setup \
ksym-vanilla-v4l2-ctrl-sub-ev-ops \
ksym-vanilla-v4l2-ctrl-subdev-log-status \
ksym-vanilla-v4l2-ctrl-subdev-subscribe-event \
ksym-vanilla-v4l2-ctrl-subscribe-event \
ksym-vanilla-v4l2-ctrl-type-op-equal \
ksym-vanilla-v4l2-ctrl-type-op-init \
ksym-vanilla-v4l2-ctrl-type-op-log \
ksym-vanilla-v4l2-ctrl-type-op-validate \
ksym-vanilla-v4l2-debugfs-if-alloc \
ksym-vanilla-v4l2-debugfs-if-free \
ksym-vanilla-v4l2-debugfs-root \
ksym-vanilla-v4l2-detect-cvt \
ksym-vanilla-v4l2-detect-gtf \
ksym-vanilla-v4l2-device-disconnect \
ksym-vanilla-v4l2-device-put \
ksym-vanilla-v4l2-device-register \
ksym-vanilla-v4l2-device-set-name \
ksym-vanilla-v4l2-device-unregister \
ksym-vanilla-v4l2-device-unregister-subdev \
ksym-vanilla-v4l2-dv-timings-aspect-ratio \
ksym-vanilla-v4l2-dv-timings-presets \
ksym-vanilla-v4l2-enum-dv-timings-cap \
ksym-vanilla-v4l2-event-dequeue \
ksym-vanilla-v4l2-event-pending \
ksym-vanilla-v4l2-event-queue \
ksym-vanilla-v4l2-event-queue-fh \
ksym-vanilla-v4l2-event-subdev-unsubscribe \
ksym-vanilla-v4l2-event-subscribe \
ksym-vanilla-v4l2-event-unsubscribe \
ksym-vanilla-v4l2-event-unsubscribe-all \
ksym-vanilla-v4l2-event-wake-all \
ksym-vanilla-v4l2-fh-add \
ksym-vanilla-v4l2-fh-del \
ksym-vanilla-v4l2-fh-exit \
ksym-vanilla-v4l2-fh-init \
ksym-vanilla-v4l2-fh-is-singular \
ksym-vanilla-v4l2-fh-open \
ksym-vanilla-v4l2-fh-release \
ksym-vanilla-v4l2-field-names \
ksym-vanilla-v4l2-fill-pixfmt \
ksym-vanilla-v4l2-fill-pixfmt-mp \
ksym-vanilla-v4l2-fill-pixfmt-mp-aligned \
ksym-vanilla-v4l2-find-dv-timings-cap \
ksym-vanilla-v4l2-find-dv-timings-cea861-vic \
ksym-vanilla-v4l2-format-info \
ksym-vanilla-v4l2-fraction-to-interval \
ksym-vanilla-v4l2-fwnode-connector-add-link \
ksym-vanilla-v4l2-fwnode-connector-free \
ksym-vanilla-v4l2-fwnode-connector-parse \
ksym-vanilla-v4l2-fwnode-device-parse \
ksym-vanilla-v4l2-fwnode-endpoint-alloc-parse \
ksym-vanilla-v4l2-fwnode-endpoint-free \
ksym-vanilla-v4l2-fwnode-endpoint-parse \
ksym-vanilla-v4l2-fwnode-parse-link \
ksym-vanilla-v4l2-fwnode-put-link \
ksym-vanilla-v4l2-g-ctrl \
ksym-vanilla-v4l2-g-ext-ctrls \
ksym-vanilla-v4l2-g-parm-cap \
ksym-vanilla-v4l2-get-active-data-lanes \
ksym-vanilla-v4l2-get-edid-phys-addr \
ksym-vanilla-v4l2-get-link-freq \
ksym-vanilla-v4l2-h264-build-b-ref-lists \
ksym-vanilla-v4l2-h264-build-p-ref-list \
ksym-vanilla-v4l2-h264-init-reflist-builder \
ksym-vanilla-v4l2-hdmi-rx-colorimetry \
ksym-vanilla-v4l2-i2c-new-subdev \
ksym-vanilla-v4l2-i2c-new-subdev-board \
ksym-vanilla-v4l2-i2c-subdev-addr \
ksym-vanilla-v4l2-i2c-subdev-init \
ksym-vanilla-v4l2-i2c-subdev-set-name \
ksym-vanilla-v4l2-i2c-tuner-addrs \
ksym-vanilla-v4l2-isp-params-validate-buffer \
ksym-vanilla-v4l2-isp-params-validate-buffer-size \
ksym-vanilla-v4l2-jpeg-parse-header \
ksym-vanilla-v4l2-jpeg-ref-table-chroma-ac-ht \
ksym-vanilla-v4l2-jpeg-ref-table-chroma-dc-ht \
ksym-vanilla-v4l2-jpeg-ref-table-chroma-qt \
ksym-vanilla-v4l2-jpeg-ref-table-luma-ac-ht \
ksym-vanilla-v4l2-jpeg-ref-table-luma-dc-ht \
ksym-vanilla-v4l2-jpeg-ref-table-luma-qt \
ksym-vanilla-v4l2-jpeg-zigzag-scan-index \
ksym-vanilla-v4l2-link-freq-to-bitmap \
ksym-vanilla-v4l2-m2m-buf-copy-metadata \
ksym-vanilla-v4l2-m2m-buf-done-and-job-finish \
ksym-vanilla-v4l2-m2m-buf-queue \
ksym-vanilla-v4l2-m2m-buf-remove \
ksym-vanilla-v4l2-m2m-buf-remove-by-buf \
ksym-vanilla-v4l2-m2m-buf-remove-by-idx \
ksym-vanilla-v4l2-m2m-create-bufs \
ksym-vanilla-v4l2-m2m-ctx-init \
ksym-vanilla-v4l2-m2m-ctx-release \
ksym-vanilla-v4l2-m2m-decoder-cmd \
ksym-vanilla-v4l2-m2m-dqbuf \
ksym-vanilla-v4l2-m2m-encoder-cmd \
ksym-vanilla-v4l2-m2m-expbuf \
ksym-vanilla-v4l2-m2m-fop-mmap \
ksym-vanilla-v4l2-m2m-fop-poll \
ksym-vanilla-v4l2-m2m-get \
ksym-vanilla-v4l2-m2m-get-curr-priv \
ksym-vanilla-v4l2-m2m-get-vq \
ksym-vanilla-v4l2-m2m-init \
ksym-vanilla-v4l2-m2m-ioctl-create-bufs \
ksym-vanilla-v4l2-m2m-ioctl-decoder-cmd \
ksym-vanilla-v4l2-m2m-ioctl-dqbuf \
ksym-vanilla-v4l2-m2m-ioctl-encoder-cmd \
ksym-vanilla-v4l2-m2m-ioctl-expbuf \
ksym-vanilla-v4l2-m2m-ioctl-prepare-buf \
ksym-vanilla-v4l2-m2m-ioctl-qbuf \
ksym-vanilla-v4l2-m2m-ioctl-querybuf \
ksym-vanilla-v4l2-m2m-ioctl-remove-bufs \
ksym-vanilla-v4l2-m2m-ioctl-reqbufs \
ksym-vanilla-v4l2-m2m-ioctl-stateless-decoder-cmd \
ksym-vanilla-v4l2-m2m-ioctl-stateless-try-decoder-cmd \
ksym-vanilla-v4l2-m2m-ioctl-streamoff \
ksym-vanilla-v4l2-m2m-ioctl-streamon \
ksym-vanilla-v4l2-m2m-ioctl-try-decoder-cmd \
ksym-vanilla-v4l2-m2m-ioctl-try-encoder-cmd \
ksym-vanilla-v4l2-m2m-job-finish \
ksym-vanilla-v4l2-m2m-last-buf \
ksym-vanilla-v4l2-m2m-last-buffer-done \
ksym-vanilla-v4l2-m2m-mmap \
ksym-vanilla-v4l2-m2m-next-buf \
ksym-vanilla-v4l2-m2m-poll \
ksym-vanilla-v4l2-m2m-prepare-buf \
ksym-vanilla-v4l2-m2m-put \
ksym-vanilla-v4l2-m2m-qbuf \
ksym-vanilla-v4l2-m2m-querybuf \
ksym-vanilla-v4l2-m2m-register-media-controller \
ksym-vanilla-v4l2-m2m-release \
ksym-vanilla-v4l2-m2m-reqbufs \
ksym-vanilla-v4l2-m2m-request-queue \
ksym-vanilla-v4l2-m2m-resume \
ksym-vanilla-v4l2-m2m-streamoff \
ksym-vanilla-v4l2-m2m-streamon \
ksym-vanilla-v4l2-m2m-suspend \
ksym-vanilla-v4l2-m2m-try-schedule \
ksym-vanilla-v4l2-m2m-unregister-media-controller \
ksym-vanilla-v4l2-m2m-update-start-streaming-state \
ksym-vanilla-v4l2-m2m-update-stop-streaming-state \
ksym-vanilla-v4l2-match-dv-timings \
ksym-vanilla-v4l2-mc-create-media-graph \
ksym-vanilla-v4l2-norm-to-name \
ksym-vanilla-v4l2-num-edid-blocks \
ksym-vanilla-v4l2-phys-addr-for-input \
ksym-vanilla-v4l2-phys-addr-validate \
ksym-vanilla-v4l2-pipeline-link-notify \
ksym-vanilla-v4l2-pipeline-pm-get \
ksym-vanilla-v4l2-pipeline-pm-put \
ksym-vanilla-v4l2-print-dv-timings \
ksym-vanilla-v4l2-prio-change \
ksym-vanilla-v4l2-prio-check \
ksym-vanilla-v4l2-prio-close \
ksym-vanilla-v4l2-prio-init \
ksym-vanilla-v4l2-prio-max \
ksym-vanilla-v4l2-prio-open \
ksym-vanilla-v4l2-query-ext-ctrl \
ksym-vanilla-v4l2-query-ext-ctrl-to-v4l2-queryctrl \
ksym-vanilla-v4l2-queryctrl \
ksym-vanilla-v4l2-querymenu \
ksym-vanilla-v4l2-s-ctrl \
ksym-vanilla-v4l2-s-ext-ctrls \
ksym-vanilla-v4l2-s-parm-cap \
ksym-vanilla-v4l2-set-edid-phys-addr \
ksym-vanilla-v4l2-simplify-fraction \
ksym-vanilla-v4l2-spi-new-subdev \
ksym-vanilla-v4l2-spi-subdev-init \
ksym-vanilla-v4l2-src-change-event-subdev-subscribe \
ksym-vanilla-v4l2-src-change-event-subscribe \
ksym-vanilla-v4l2-subdev-call-wrappers \
ksym-vanilla-v4l2-subdev-cleanup \
ksym-vanilla-v4l2-subdev-disable-streams \
ksym-vanilla-v4l2-subdev-enable-streams \
ksym-vanilla-v4l2-subdev-get-fmt \
ksym-vanilla-v4l2-subdev-get-frame-desc-passthrough \
ksym-vanilla-v4l2-subdev-get-frame-interval \
ksym-vanilla-v4l2-subdev-get-fwnode-pad-1-to-1 \
ksym-vanilla-v4l2-subdev-get-privacy-led \
ksym-vanilla-v4l2-subdev-has-pad-interdep \
ksym-vanilla-v4l2-subdev-init \
ksym-vanilla-v4l2-subdev-is-streaming \
ksym-vanilla-v4l2-subdev-link-validate \
ksym-vanilla-v4l2-subdev-link-validate-default \
ksym-vanilla-v4l2-subdev-notify-event \
ksym-vanilla-v4l2-subdev-put-privacy-led \
ksym-vanilla-v4l2-subdev-routing-find-opposite-end \
ksym-vanilla-v4l2-subdev-routing-validate \
ksym-vanilla-v4l2-subdev-s-stream-helper \
ksym-vanilla-v4l2-subdev-set-routing \
ksym-vanilla-v4l2-subdev-set-routing-with-fmt \
ksym-vanilla-v4l2-subdev-state-get-opposite-stream-format \
ksym-vanilla-v4l2-subdev-state-xlate-streams \
ksym-vanilla-v4l2-translate-cmd \
ksym-vanilla-v4l2-try-ext-ctrls \
ksym-vanilla-v4l2-type-names \
ksym-vanilla-v4l2-valid-dv-timings \
ksym-vanilla-v4l2-video-std-construct \
ksym-vanilla-v4l2-video-std-frame-period \
ksym-vanilla-v4l2-vp9-adapt-coef-probs \
ksym-vanilla-v4l2-vp9-adapt-noncoef-probs \
ksym-vanilla-v4l2-vp9-default-probs \
ksym-vanilla-v4l2-vp9-fw-update-probs \
ksym-vanilla-v4l2-vp9-kf-partition-probs \
ksym-vanilla-v4l2-vp9-kf-uv-mode-prob \
ksym-vanilla-v4l2-vp9-kf-y-mode-prob \
ksym-vanilla-v4l2-vp9-reset-frame-ctx \
ksym-vanilla-v4l2-vp9-seg-feat-enabled \
ksym-vanilla-v9fs-get-default-trans \
ksym-vanilla-v9fs-get-trans-by-name \
ksym-vanilla-v9fs-put-trans \
ksym-vanilla-v9fs-register-trans \
ksym-vanilla-v9fs-unregister-trans \
ksym-vanilla-validate-slab-cache \
ksym-vanilla-validate-usercopy-range \
ksym-vanilla-validate-xmit-skb-list \
ksym-vanilla-validate-xmit-xfrm \
ksym-vanilla-vb2-buffer-done \
ksym-vanilla-vb2-buffer-in-use \
ksym-vanilla-vb2-common-vm-ops \
ksym-vanilla-vb2-core-create-bufs \
ksym-vanilla-vb2-core-dqbuf \
ksym-vanilla-vb2-core-expbuf \
ksym-vanilla-vb2-core-poll \
ksym-vanilla-vb2-core-prepare-buf \
ksym-vanilla-vb2-core-qbuf \
ksym-vanilla-vb2-core-querybuf \
ksym-vanilla-vb2-core-queue-init \
ksym-vanilla-vb2-core-queue-release \
ksym-vanilla-vb2-core-remove-bufs \
ksym-vanilla-vb2-core-reqbufs \
ksym-vanilla-vb2-core-streamoff \
ksym-vanilla-vb2-core-streamon \
ksym-vanilla-vb2-create-bufs \
ksym-vanilla-vb2-create-framevec \
ksym-vanilla-vb2-destroy-framevec \
ksym-vanilla-vb2-discard-done \
ksym-vanilla-vb2-dma-contig-memops \
ksym-vanilla-vb2-dma-contig-set-max-seg-size \
ksym-vanilla-vb2-dma-sg-memops \
ksym-vanilla-vb2-dqbuf \
ksym-vanilla-vb2-dvb-alloc-frontend \
ksym-vanilla-vb2-dvb-dealloc-frontends \
ksym-vanilla-vb2-dvb-find-frontend \
ksym-vanilla-vb2-dvb-get-frontend \
ksym-vanilla-vb2-dvb-register-bus \
ksym-vanilla-vb2-dvb-unregister-bus \
ksym-vanilla-vb2-expbuf \
ksym-vanilla-vb2-find-buffer \
ksym-vanilla-vb2-fop-mmap \
ksym-vanilla-vb2-fop-poll \
ksym-vanilla-vb2-fop-read \
ksym-vanilla-vb2-fop-release \
ksym-vanilla-vb2-fop-write \
ksym-vanilla-vb2-ioctl-create-bufs \
ksym-vanilla-vb2-ioctl-dqbuf \
ksym-vanilla-vb2-ioctl-expbuf \
ksym-vanilla-vb2-ioctl-prepare-buf \
ksym-vanilla-vb2-ioctl-qbuf \
ksym-vanilla-vb2-ioctl-querybuf \
ksym-vanilla-vb2-ioctl-remove-bufs \
ksym-vanilla-vb2-ioctl-reqbufs \
ksym-vanilla-vb2-ioctl-streamoff \
ksym-vanilla-vb2-ioctl-streamon \
ksym-vanilla-vb2-mmap \
ksym-vanilla-vb2-plane-cookie \
ksym-vanilla-vb2-plane-vaddr \
ksym-vanilla-vb2-poll \
ksym-vanilla-vb2-prepare-buf \
ksym-vanilla-vb2-qbuf \
ksym-vanilla-vb2-querybuf \
ksym-vanilla-vb2-queue-change-type \
ksym-vanilla-vb2-queue-error \
ksym-vanilla-vb2-queue-init \
ksym-vanilla-vb2-queue-init-name \
ksym-vanilla-vb2-queue-release \
ksym-vanilla-vb2-read \
ksym-vanilla-vb2-reqbufs \
ksym-vanilla-vb2-request-buffer-cnt \
ksym-vanilla-vb2-request-object-is-buffer \
ksym-vanilla-vb2-request-queue \
ksym-vanilla-vb2-request-validate \
ksym-vanilla-vb2-streamoff \
ksym-vanilla-vb2-streamon \
ksym-vanilla-vb2-thread-start \
ksym-vanilla-vb2-thread-stop \
ksym-vanilla-vb2-verify-memory-type \
ksym-vanilla-vb2-video-unregister-device \
ksym-vanilla-vb2-vmalloc-memops \
ksym-vanilla-vb2-wait-for-all-buffers \
ksym-vanilla-vb2-write \
ksym-vanilla-vbg-err \
ksym-vanilla-vbg-err-ratelimited \
ksym-vanilla-vbg-get-gdev \
ksym-vanilla-vbg-hgcm-call \
ksym-vanilla-vbg-hgcm-connect \
ksym-vanilla-vbg-hgcm-disconnect \
ksym-vanilla-vbg-info \
ksym-vanilla-vbg-put-gdev \
ksym-vanilla-vbg-status-code-to-errno \
ksym-vanilla-vbg-warn \
ksym-vanilla-vbin-printf \
ksym-vanilla-vc-cons \
ksym-vanilla-vc-font-pitch \
ksym-vanilla-vc-font-size \
ksym-vanilla-vcalloc-noprof \
ksym-vanilla-vcap-add-rule \
ksym-vanilla-vcap-addr-keysets \
ksym-vanilla-vcap-admin-rule-count \
ksym-vanilla-vcap-alloc-rule \
ksym-vanilla-vcap-chain-id-to-lookup \
ksym-vanilla-vcap-chain-offset \
ksym-vanilla-vcap-copy-rule \
ksym-vanilla-vcap-debugfs \
ksym-vanilla-vcap-del-rule \
ksym-vanilla-vcap-del-rules \
ksym-vanilla-vcap-enable-lookups \
ksym-vanilla-vcap-filter-rule-keys \
ksym-vanilla-vcap-find-actionfield \
ksym-vanilla-vcap-find-admin \
ksym-vanilla-vcap-find-keystream-keysets \
ksym-vanilla-vcap-free-rule \
ksym-vanilla-vcap-get-rule \
ksym-vanilla-vcap-get-rule-count-by-cookie \
ksym-vanilla-vcap-is-last-chain \
ksym-vanilla-vcap-is-next-lookup \
ksym-vanilla-vcap-keyfield-name \
ksym-vanilla-vcap-keyfieldset \
ksym-vanilla-vcap-keyset-list-add \
ksym-vanilla-vcap-keyset-name \
ksym-vanilla-vcap-lookup-keyfield \
ksym-vanilla-vcap-lookup-rule-by-cookie \
ksym-vanilla-vcap-mod-rule \
ksym-vanilla-vcap-netbytes-copy \
ksym-vanilla-vcap-port-debugfs \
ksym-vanilla-vcap-rule-add-action-bit \
ksym-vanilla-vcap-rule-add-action-u32 \
ksym-vanilla-vcap-rule-add-action-u72 \
ksym-vanilla-vcap-rule-add-key-bit \
ksym-vanilla-vcap-rule-add-key-u128 \
ksym-vanilla-vcap-rule-add-key-u32 \
ksym-vanilla-vcap-rule-add-key-u48 \
ksym-vanilla-vcap-rule-add-key-u72 \
ksym-vanilla-vcap-rule-find-keysets \
ksym-vanilla-vcap-rule-get-counter \
ksym-vanilla-vcap-rule-get-key-u32 \
ksym-vanilla-vcap-rule-mod-action-u32 \
ksym-vanilla-vcap-rule-mod-key-u32 \
ksym-vanilla-vcap-rule-rem-key \
ksym-vanilla-vcap-rule-set-counter \
ksym-vanilla-vcap-rule-set-counter-id \
ksym-vanilla-vcap-select-min-rule-keyset \
ksym-vanilla-vcap-set-rule-set-actionset \
ksym-vanilla-vcap-set-rule-set-keyset \
ksym-vanilla-vcap-set-tc-exterr \
ksym-vanilla-vcap-tc-flower-handler-arp-usage \
ksym-vanilla-vcap-tc-flower-handler-cvlan-usage \
ksym-vanilla-vcap-tc-flower-handler-ethaddr-usage \
ksym-vanilla-vcap-tc-flower-handler-ip-usage \
ksym-vanilla-vcap-tc-flower-handler-ipv4-usage \
ksym-vanilla-vcap-tc-flower-handler-ipv6-usage \
ksym-vanilla-vcap-tc-flower-handler-portnum-usage \
ksym-vanilla-vcap-tc-flower-handler-tcp-usage \
ksym-vanilla-vcap-tc-flower-handler-vlan-usage \
ksym-vanilla-vcap-val-rule \
ksym-vanilla-vcc-hash \
ksym-vanilla-vcc-insert-socket \
ksym-vanilla-vcc-process-recv-queue \
ksym-vanilla-vcc-release-async \
ksym-vanilla-vcc-sklist-lock \
ksym-vanilla-vchan-dma-desc-free-list \
ksym-vanilla-vchan-find-desc \
ksym-vanilla-vchan-init \
ksym-vanilla-vchan-tx-desc-free \
ksym-vanilla-vchan-tx-submit \
ksym-vanilla-vchiq-add-connected-callback \
ksym-vanilla-vchiq-bulk-receive \
ksym-vanilla-vchiq-bulk-transmit \
ksym-vanilla-vchiq-close-service \
ksym-vanilla-vchiq-connect \
ksym-vanilla-vchiq-driver-register \
ksym-vanilla-vchiq-driver-unregister \
ksym-vanilla-vchiq-get-peer-version \
ksym-vanilla-vchiq-get-service-userdata \
ksym-vanilla-vchiq-initialise \
ksym-vanilla-vchiq-mmal-component-disable \
ksym-vanilla-vchiq-mmal-component-enable \
ksym-vanilla-vchiq-mmal-component-finalise \
ksym-vanilla-vchiq-mmal-component-init \
ksym-vanilla-vchiq-mmal-finalise \
ksym-vanilla-vchiq-mmal-init \
ksym-vanilla-vchiq-mmal-port-connect-tunnel \
ksym-vanilla-vchiq-mmal-port-disable \
ksym-vanilla-vchiq-mmal-port-enable \
ksym-vanilla-vchiq-mmal-port-parameter-get \
ksym-vanilla-vchiq-mmal-port-parameter-set \
ksym-vanilla-vchiq-mmal-port-set-format \
ksym-vanilla-vchiq-mmal-submit-buffer \
ksym-vanilla-vchiq-mmal-version \
ksym-vanilla-vchiq-msg-hold \
ksym-vanilla-vchiq-msg-queue-push \
ksym-vanilla-vchiq-open-service \
ksym-vanilla-vchiq-queue-kernel-message \
ksym-vanilla-vchiq-release-message \
ksym-vanilla-vchiq-release-service \
ksym-vanilla-vchiq-shutdown \
ksym-vanilla-vchiq-use-service \
ksym-vanilla-vdpa-get-config \
ksym-vanilla-vdpa-mgmtdev-register \
ksym-vanilla-vdpa-mgmtdev-unregister \
ksym-vanilla-vdpa-register-device \
ksym-vanilla-vdpa-set-config \
ksym-vanilla-vdpa-set-status \
ksym-vanilla-vdpa-unregister-device \
ksym-vanilla-vdpa-unregister-driver \
ksym-vanilla-vdpasim-create \
ksym-vanilla-vdpasim-schedule-work \
ksym-vanilla-venus-close-common \
ksym-vanilla-venus-helper-acquire-buf-ref \
ksym-vanilla-venus-helper-alloc-dpb-bufs \
ksym-vanilla-venus-helper-buffers-done \
ksym-vanilla-venus-helper-change-dpb-owner \
ksym-vanilla-venus-helper-check-codec \
ksym-vanilla-venus-helper-check-format \
ksym-vanilla-venus-helper-find-buf \
ksym-vanilla-venus-helper-free-dpb-bufs \
ksym-vanilla-venus-helper-get-bufreq \
ksym-vanilla-venus-helper-get-framesz \
ksym-vanilla-venus-helper-get-framesz-raw \
ksym-vanilla-venus-helper-get-opb-size \
ksym-vanilla-venus-helper-get-out-fmts \
ksym-vanilla-venus-helper-get-profile-level \
ksym-vanilla-venus-helper-get-ts-metadata \
ksym-vanilla-venus-helper-init-instance \
ksym-vanilla-venus-helper-intbufs-alloc \
ksym-vanilla-venus-helper-intbufs-free \
ksym-vanilla-venus-helper-intbufs-realloc \
ksym-vanilla-venus-helper-m2m-device-run \
ksym-vanilla-venus-helper-m2m-job-abort \
ksym-vanilla-venus-helper-process-initial-cap-bufs \
ksym-vanilla-venus-helper-process-initial-out-bufs \
ksym-vanilla-venus-helper-queue-dpb-bufs \
ksym-vanilla-venus-helper-release-buf-ref \
ksym-vanilla-venus-helper-session-init \
ksym-vanilla-venus-helper-set-bufsize \
ksym-vanilla-venus-helper-set-color-format \
ksym-vanilla-venus-helper-set-dyn-bufmode \
ksym-vanilla-venus-helper-set-format-constraints \
ksym-vanilla-venus-helper-set-input-resolution \
ksym-vanilla-venus-helper-set-multistream \
ksym-vanilla-venus-helper-set-num-bufs \
ksym-vanilla-venus-helper-set-output-resolution \
ksym-vanilla-venus-helper-set-profile-level \
ksym-vanilla-venus-helper-set-raw-format \
ksym-vanilla-venus-helper-set-stride \
ksym-vanilla-venus-helper-set-work-mode \
ksym-vanilla-venus-helper-unregister-bufs \
ksym-vanilla-venus-helper-vb2-buf-init \
ksym-vanilla-venus-helper-vb2-buf-prepare \
ksym-vanilla-venus-helper-vb2-buf-queue \
ksym-vanilla-venus-helper-vb2-queue-error \
ksym-vanilla-venus-helper-vb2-start-streaming \
ksym-vanilla-venus-helper-vb2-stop-streaming \
ksym-vanilla-verbose-torout-sleep \
ksym-vanilla-verify-pkcs7-signature \
ksym-vanilla-verify-signature \
ksym-vanilla-verify-spi-info \
ksym-vanilla-versal-pm-aes-dec-final \
ksym-vanilla-versal-pm-aes-dec-update \
ksym-vanilla-versal-pm-aes-enc-final \
ksym-vanilla-versal-pm-aes-enc-update \
ksym-vanilla-versal-pm-aes-init \
ksym-vanilla-versal-pm-aes-key-write \
ksym-vanilla-versal-pm-aes-key-zero \
ksym-vanilla-versal-pm-aes-op-init \
ksym-vanilla-versal-pm-aes-update-aad \
ksym-vanilla-ves1820-attach \
ksym-vanilla-ves1x93-attach \
ksym-vanilla-vesa-modes \
ksym-vanilla-vfio-assign-device-set \
ksym-vanilla-vfio-combine-iova-ranges \
ksym-vanilla-vfio-device-put-registration \
ksym-vanilla-vfio-device-set-open-count \
ksym-vanilla-vfio-device-try-get-registration \
ksym-vanilla-vfio-dma-rw \
ksym-vanilla-vfio-file-enforced-coherent \
ksym-vanilla-vfio-file-has-dev \
ksym-vanilla-vfio-file-iommu-group \
ksym-vanilla-vfio-file-is-group \
ksym-vanilla-vfio-file-is-valid \
ksym-vanilla-vfio-file-set-kvm \
ksym-vanilla-vfio-find-device-in-devset \
ksym-vanilla-vfio-info-add-capability \
ksym-vanilla-vfio-info-cap-add \
ksym-vanilla-vfio-info-cap-shift \
ksym-vanilla-vfio-mig-get-next-state \
ksym-vanilla-vfio-pci-config-rw-single \
ksym-vanilla-vfio-pci-core-aer-err-detected \
ksym-vanilla-vfio-pci-core-close-device \
ksym-vanilla-vfio-pci-core-disable \
ksym-vanilla-vfio-pci-core-do-io-rw \
ksym-vanilla-vfio-pci-core-enable \
ksym-vanilla-vfio-pci-core-err-handlers \
ksym-vanilla-vfio-pci-core-fill-phys-vec \
ksym-vanilla-vfio-pci-core-finish-enable \
ksym-vanilla-vfio-pci-core-get-dmabuf-phys \
ksym-vanilla-vfio-pci-core-init-dev \
ksym-vanilla-vfio-pci-core-ioctl \
ksym-vanilla-vfio-pci-core-ioctl-feature \
ksym-vanilla-vfio-pci-core-ioread16 \
ksym-vanilla-vfio-pci-core-ioread32 \
ksym-vanilla-vfio-pci-core-ioread64 \
ksym-vanilla-vfio-pci-core-ioread8 \
ksym-vanilla-vfio-pci-core-iowrite16 \
ksym-vanilla-vfio-pci-core-iowrite32 \
ksym-vanilla-vfio-pci-core-iowrite64 \
ksym-vanilla-vfio-pci-core-iowrite8 \
ksym-vanilla-vfio-pci-core-match \
ksym-vanilla-vfio-pci-core-match-token-uuid \
ksym-vanilla-vfio-pci-core-mmap \
ksym-vanilla-vfio-pci-core-range-intersect-range \
ksym-vanilla-vfio-pci-core-read \
ksym-vanilla-vfio-pci-core-register-dev-region \
ksym-vanilla-vfio-pci-core-register-device \
ksym-vanilla-vfio-pci-core-release-dev \
ksym-vanilla-vfio-pci-core-request \
ksym-vanilla-vfio-pci-core-sriov-configure \
ksym-vanilla-vfio-pci-core-unregister-device \
ksym-vanilla-vfio-pci-core-write \
ksym-vanilla-vfio-pci-dma-buf-iommufd-map \
ksym-vanilla-vfio-pci-ioctl-get-region-info \
ksym-vanilla-vfio-pci-vmf-insert-pfn \
ksym-vanilla-vfio-pin-pages \
ksym-vanilla-vfio-platform-close-device \
ksym-vanilla-vfio-platform-init-common \
ksym-vanilla-vfio-platform-ioctl \
ksym-vanilla-vfio-platform-ioctl-get-region-info \
ksym-vanilla-vfio-platform-mmap \
ksym-vanilla-vfio-platform-open-device \
ksym-vanilla-vfio-platform-read \
ksym-vanilla-vfio-platform-release-common \
ksym-vanilla-vfio-platform-unregister-reset \
ksym-vanilla-vfio-platform-write \
ksym-vanilla-vfio-register-emulated-iommu-dev \
ksym-vanilla-vfio-register-group-dev \
ksym-vanilla-vfio-register-iommu-driver \
ksym-vanilla-vfio-set-irqs-validate-and-prepare \
ksym-vanilla-vfio-unpin-pages \
ksym-vanilla-vfio-unregister-group-dev \
ksym-vanilla-vfio-unregister-iommu-driver \
ksym-vanilla-vfio-virqfd-disable \
ksym-vanilla-vfio-virqfd-enable \
ksym-vanilla-vfio-virqfd-flush-thread \
ksym-vanilla-vfree \
ksym-vanilla-vfs-cancel-lock \
ksym-vanilla-vfs-clone-file-range \
ksym-vanilla-vfs-copy-file-range \
ksym-vanilla-vfs-create \
ksym-vanilla-vfs-create-mount \
ksym-vanilla-vfs-dedupe-file-range \
ksym-vanilla-vfs-dedupe-file-range-one \
ksym-vanilla-vfs-dup-fs-context \
ksym-vanilla-vfs-fadvise \
ksym-vanilla-vfs-fallocate \
ksym-vanilla-vfs-fileattr-get \
ksym-vanilla-vfs-fileattr-set \
ksym-vanilla-vfs-fsync \
ksym-vanilla-vfs-fsync-range \
ksym-vanilla-vfs-get-acl \
ksym-vanilla-vfs-get-fsid \
ksym-vanilla-vfs-get-link \
ksym-vanilla-vfs-get-tree \
ksym-vanilla-vfs-getattr \
ksym-vanilla-vfs-getattr-nosec \
ksym-vanilla-vfs-getxattr \
ksym-vanilla-vfs-inode-has-locks \
ksym-vanilla-vfs-iocb-iter-read \
ksym-vanilla-vfs-iocb-iter-write \
ksym-vanilla-vfs-iter-read \
ksym-vanilla-vfs-iter-write \
ksym-vanilla-vfs-kern-mount \
ksym-vanilla-vfs-link \
ksym-vanilla-vfs-listxattr \
ksym-vanilla-vfs-llseek \
ksym-vanilla-vfs-lock-file \
ksym-vanilla-vfs-mkdir \
ksym-vanilla-vfs-mknod \
ksym-vanilla-vfs-mkobj \
ksym-vanilla-vfs-parse-fs-param \
ksym-vanilla-vfs-parse-fs-param-source \
ksym-vanilla-vfs-parse-fs-qstr \
ksym-vanilla-vfs-parse-monolithic-sep \
ksym-vanilla-vfs-path-lookup \
ksym-vanilla-vfs-path-parent-lookup \
ksym-vanilla-vfs-pressure-ratio \
ksym-vanilla-vfs-readlink \
ksym-vanilla-vfs-remove-acl \
ksym-vanilla-vfs-removexattr \
ksym-vanilla-vfs-rename \
ksym-vanilla-vfs-rmdir \
ksym-vanilla-vfs-set-acl \
ksym-vanilla-vfs-setlease \
ksym-vanilla-vfs-setpos \
ksym-vanilla-vfs-setxattr \
ksym-vanilla-vfs-splice-read \
ksym-vanilla-vfs-statfs \
ksym-vanilla-vfs-symlink \
ksym-vanilla-vfs-test-lock \
ksym-vanilla-vfs-truncate \
ksym-vanilla-vfs-unlink \
ksym-vanilla-vfs-utimes \
ksym-vanilla-vfsgid-in-group-p \
ksym-vanilla-vfsmount-to-propagation-flags \
ksym-vanilla-vga-client-register \
ksym-vanilla-vga-default-device \
ksym-vanilla-vga-get \
ksym-vanilla-vga-put \
ksym-vanilla-vga-remove-vgacon \
ksym-vanilla-vga-set-legacy-decoding \
ksym-vanilla-vhost-add-used \
ksym-vanilla-vhost-add-used-and-signal \
ksym-vanilla-vhost-add-used-and-signal-n \
ksym-vanilla-vhost-add-used-n \
ksym-vanilla-vhost-chr-poll \
ksym-vanilla-vhost-chr-read-iter \
ksym-vanilla-vhost-chr-write-iter \
ksym-vanilla-vhost-clear-msg \
ksym-vanilla-vhost-dequeue-msg \
ksym-vanilla-vhost-dev-check-owner \
ksym-vanilla-vhost-dev-cleanup \
ksym-vanilla-vhost-dev-flush \
ksym-vanilla-vhost-dev-has-owner \
ksym-vanilla-vhost-dev-init \
ksym-vanilla-vhost-dev-ioctl \
ksym-vanilla-vhost-dev-reset-owner \
ksym-vanilla-vhost-dev-reset-owner-prepare \
ksym-vanilla-vhost-dev-set-owner \
ksym-vanilla-vhost-dev-stop \
ksym-vanilla-vhost-disable-notify \
ksym-vanilla-vhost-discard-vq-desc \
ksym-vanilla-vhost-enable-notify \
ksym-vanilla-vhost-enqueue-msg \
ksym-vanilla-vhost-exceeds-weight \
ksym-vanilla-vhost-get-vq-desc \
ksym-vanilla-vhost-get-vq-desc-n \
ksym-vanilla-vhost-init-device-iotlb \
ksym-vanilla-vhost-iotlb-add-range \
ksym-vanilla-vhost-iotlb-add-range-ctx \
ksym-vanilla-vhost-iotlb-alloc \
ksym-vanilla-vhost-iotlb-del-range \
ksym-vanilla-vhost-iotlb-free \
ksym-vanilla-vhost-iotlb-init \
ksym-vanilla-vhost-iotlb-itree-first \
ksym-vanilla-vhost-iotlb-itree-next \
ksym-vanilla-vhost-iotlb-map-free \
ksym-vanilla-vhost-iotlb-reset \
ksym-vanilla-vhost-log-access-ok \
ksym-vanilla-vhost-log-write \
ksym-vanilla-vhost-new-msg \
ksym-vanilla-vhost-poll-init \
ksym-vanilla-vhost-poll-queue \
ksym-vanilla-vhost-poll-start \
ksym-vanilla-vhost-poll-stop \
ksym-vanilla-vhost-set-backend-features \
ksym-vanilla-vhost-signal \
ksym-vanilla-vhost-task-create \
ksym-vanilla-vhost-task-start \
ksym-vanilla-vhost-task-stop \
ksym-vanilla-vhost-task-wake \
ksym-vanilla-vhost-vq-access-ok \
ksym-vanilla-vhost-vq-avail-empty \
ksym-vanilla-vhost-vq-has-work \
ksym-vanilla-vhost-vq-init-access \
ksym-vanilla-vhost-vq-is-setup \
ksym-vanilla-vhost-vq-work-queue \
ksym-vanilla-vhost-vring-ioctl \
ksym-vanilla-vhost-work-init \
ksym-vanilla-vhost-worker-ioctl \
ksym-vanilla-viai2c-init \
ksym-vanilla-viai2c-irq-xfer \
ksym-vanilla-viai2c-wait-bus-not-busy \
ksym-vanilla-viai2c-xfer \
ksym-vanilla-vid-from-reg \
ksym-vanilla-vid-is-dsa-8021q \
ksym-vanilla-vid-which-vrm \
ksym-vanilla-video-devdata \
ksym-vanilla-video-device-alloc \
ksym-vanilla-video-device-pipeline \
ksym-vanilla-video-device-pipeline-alloc-start \
ksym-vanilla-video-device-pipeline-start \
ksym-vanilla-video-device-pipeline-stop \
ksym-vanilla-video-device-release \
ksym-vanilla-video-device-release-empty \
ksym-vanilla-video-firmware-drivers-only \
ksym-vanilla-video-get-options \
ksym-vanilla-video-ioctl2 \
ksym-vanilla-video-unregister-device \
ksym-vanilla-videomode-from-timing \
ksym-vanilla-videomode-from-timings \
ksym-vanilla-virtio-add-status \
ksym-vanilla-virtio-break-device \
ksym-vanilla-virtio-check-driver-offered-feature \
ksym-vanilla-virtio-check-mem-acc-cb \
ksym-vanilla-virtio-config-changed \
ksym-vanilla-virtio-config-driver-disable \
ksym-vanilla-virtio-config-driver-enable \
ksym-vanilla-virtio-device-freeze \
ksym-vanilla-virtio-device-reset-done \
ksym-vanilla-virtio-device-reset-prepare \
ksym-vanilla-virtio-device-restore \
ksym-vanilla-virtio-dma-buf-attach \
ksym-vanilla-virtio-dma-buf-export \
ksym-vanilla-virtio-dma-buf-get-uuid \
ksym-vanilla-virtio-max-dma-size \
ksym-vanilla-virtio-pci-admin-dev-parts-get \
ksym-vanilla-virtio-pci-admin-dev-parts-metadata-get \
ksym-vanilla-virtio-pci-admin-dev-parts-set \
ksym-vanilla-virtio-pci-admin-has-dev-parts \
ksym-vanilla-virtio-pci-admin-mode-set \
ksym-vanilla-virtio-pci-admin-obj-create \
ksym-vanilla-virtio-pci-admin-obj-destroy \
ksym-vanilla-virtio-pmem-host-ack \
ksym-vanilla-virtio-require-restricted-mem-acc \
ksym-vanilla-virtio-reset-device \
ksym-vanilla-virtio-transport-connect \
ksym-vanilla-virtio-transport-consume-skb-sent \
ksym-vanilla-virtio-transport-deliver-tap-pkt \
ksym-vanilla-virtio-transport-destruct \
ksym-vanilla-virtio-transport-dgram-allow \
ksym-vanilla-virtio-transport-dgram-bind \
ksym-vanilla-virtio-transport-dgram-dequeue \
ksym-vanilla-virtio-transport-dgram-enqueue \
ksym-vanilla-virtio-transport-do-socket-init \
ksym-vanilla-virtio-transport-get-credit \
ksym-vanilla-virtio-transport-inc-tx-pkt \
ksym-vanilla-virtio-transport-notify-buffer-size \
ksym-vanilla-virtio-transport-notify-poll-in \
ksym-vanilla-virtio-transport-notify-poll-out \
ksym-vanilla-virtio-transport-notify-recv-init \
ksym-vanilla-virtio-transport-notify-recv-post-dequeue \
ksym-vanilla-virtio-transport-notify-recv-pre-block \
ksym-vanilla-virtio-transport-notify-recv-pre-dequeue \
ksym-vanilla-virtio-transport-notify-send-init \
ksym-vanilla-virtio-transport-notify-send-post-enqueue \
ksym-vanilla-virtio-transport-notify-send-pre-block \
ksym-vanilla-virtio-transport-notify-send-pre-enqueue \
ksym-vanilla-virtio-transport-notify-set-rcvlowat \
ksym-vanilla-virtio-transport-purge-skbs \
ksym-vanilla-virtio-transport-put-credit \
ksym-vanilla-virtio-transport-read-skb \
ksym-vanilla-virtio-transport-recv-pkt \
ksym-vanilla-virtio-transport-release \
ksym-vanilla-virtio-transport-seqpacket-dequeue \
ksym-vanilla-virtio-transport-seqpacket-enqueue \
ksym-vanilla-virtio-transport-seqpacket-has-data \
ksym-vanilla-virtio-transport-shutdown \
ksym-vanilla-virtio-transport-stream-dequeue \
ksym-vanilla-virtio-transport-stream-enqueue \
ksym-vanilla-virtio-transport-stream-has-data \
ksym-vanilla-virtio-transport-stream-has-space \
ksym-vanilla-virtio-transport-stream-is-active \
ksym-vanilla-virtio-transport-stream-rcvhiwat \
ksym-vanilla-virtio-transport-unsent-bytes \
ksym-vanilla-virtqueue-add-inbuf \
ksym-vanilla-virtqueue-add-inbuf-cache-clean \
ksym-vanilla-virtqueue-add-inbuf-ctx \
ksym-vanilla-virtqueue-add-inbuf-premapped \
ksym-vanilla-virtqueue-add-outbuf \
ksym-vanilla-virtqueue-add-outbuf-premapped \
ksym-vanilla-virtqueue-add-sgs \
ksym-vanilla-virtqueue-detach-unused-buf \
ksym-vanilla-virtqueue-disable-cb \
ksym-vanilla-virtqueue-dma-dev \
ksym-vanilla-virtqueue-enable-cb \
ksym-vanilla-virtqueue-enable-cb-delayed \
ksym-vanilla-virtqueue-enable-cb-prepare \
ksym-vanilla-virtqueue-get-avail-addr \
ksym-vanilla-virtqueue-get-buf \
ksym-vanilla-virtqueue-get-buf-ctx \
ksym-vanilla-virtqueue-get-desc-addr \
ksym-vanilla-virtqueue-get-used-addr \
ksym-vanilla-virtqueue-get-vring \
ksym-vanilla-virtqueue-get-vring-size \
ksym-vanilla-virtqueue-is-broken \
ksym-vanilla-virtqueue-kick \
ksym-vanilla-virtqueue-kick-prepare \
ksym-vanilla-virtqueue-map-alloc-coherent \
ksym-vanilla-virtqueue-map-free-coherent \
ksym-vanilla-virtqueue-map-mapping-error \
ksym-vanilla-virtqueue-map-need-sync \
ksym-vanilla-virtqueue-map-page-attrs \
ksym-vanilla-virtqueue-map-single-attrs \
ksym-vanilla-virtqueue-map-sync-single-range-for-cpu \
ksym-vanilla-virtqueue-map-sync-single-range-for-device \
ksym-vanilla-virtqueue-notify \
ksym-vanilla-virtqueue-poll \
ksym-vanilla-virtqueue-reset \
ksym-vanilla-virtqueue-resize \
ksym-vanilla-virtqueue-unmap-page-attrs \
ksym-vanilla-virtqueue-unmap-single-attrs \
ksym-vanilla-visitor128 \
ksym-vanilla-visitor32 \
ksym-vanilla-visitor64 \
ksym-vanilla-visitorl \
ksym-vanilla-vivaldi-attribute-groups \
ksym-vanilla-vivaldi-feature-mapping \
ksym-vanilla-vivaldi-function-row-physmap-show \
ksym-vanilla-vlan-dev-real-dev \
ksym-vanilla-vlan-dev-vlan-id \
ksym-vanilla-vlan-dev-vlan-proto \
ksym-vanilla-vlan-filter-drop-vids \
ksym-vanilla-vlan-filter-push-vids \
ksym-vanilla-vlan-for-each \
ksym-vanilla-vlan-ioctl-set \
ksym-vanilla-vlan-uses-dev \
ksym-vanilla-vlan-vid-add \
ksym-vanilla-vlan-vid-del \
ksym-vanilla-vlan-vids-add-by-dev \
ksym-vanilla-vlan-vids-del-by-dev \
ksym-vanilla-vli-cmp \
ksym-vanilla-vli-from-be64 \
ksym-vanilla-vli-from-le64 \
ksym-vanilla-vli-is-zero \
ksym-vanilla-vli-mod-inv \
ksym-vanilla-vli-mod-mult-slow \
ksym-vanilla-vli-num-bits \
ksym-vanilla-vli-sub \
ksym-vanilla-vm-event-states \
ksym-vanilla-vm-get-page-prot \
ksym-vanilla-vm-insert-page \
ksym-vanilla-vm-insert-pages \
ksym-vanilla-vm-iomap-memory \
ksym-vanilla-vm-map-pages \
ksym-vanilla-vm-map-pages-zero \
ksym-vanilla-vm-map-ram \
ksym-vanilla-vm-memory-committed \
ksym-vanilla-vm-mmap \
ksym-vanilla-vm-munmap \
ksym-vanilla-vm-node-stat \
ksym-vanilla-vm-unmap-aliases \
ksym-vanilla-vm-unmap-ram \
ksym-vanilla-vm-zone-stat \
ksym-vanilla-vma-alloc-folio-noprof \
ksym-vanilla-vma-set-file \
ksym-vanilla-vmalloc-32-noprof \
ksym-vanilla-vmalloc-32-user-noprof \
ksym-vanilla-vmalloc-array-noprof \
ksym-vanilla-vmalloc-huge-node-noprof \
ksym-vanilla-vmalloc-node-noprof \
ksym-vanilla-vmalloc-noprof \
ksym-vanilla-vmalloc-to-page \
ksym-vanilla-vmalloc-to-pfn \
ksym-vanilla-vmalloc-user-noprof \
ksym-vanilla-vmap \
ksym-vanilla-vmap-pfn \
ksym-vanilla-vmbus-alloc-ring \
ksym-vanilla-vmbus-allocate-mmio \
ksym-vanilla-vmbus-close \
ksym-vanilla-vmbus-connect-ring \
ksym-vanilla-vmbus-connection \
ksym-vanilla-vmbus-device-unregister \
ksym-vanilla-vmbus-devs \
ksym-vanilla-vmbus-disconnect-ring \
ksym-vanilla-vmbus-driver-unregister \
ksym-vanilla-vmbus-establish-gpadl \
ksym-vanilla-vmbus-free-mmio \
ksym-vanilla-vmbus-free-ring \
ksym-vanilla-vmbus-hvsock-device-unregister \
ksym-vanilla-vmbus-initiate-unload \
ksym-vanilla-vmbus-is-confidential \
ksym-vanilla-vmbus-isr \
ksym-vanilla-vmbus-next-request-id \
ksym-vanilla-vmbus-open \
ksym-vanilla-vmbus-prep-negotiate-resp \
ksym-vanilla-vmbus-proto-version \
ksym-vanilla-vmbus-recvpacket \
ksym-vanilla-vmbus-recvpacket-raw \
ksym-vanilla-vmbus-request-addr \
ksym-vanilla-vmbus-request-addr-match \
ksym-vanilla-vmbus-send-modifychannel \
ksym-vanilla-vmbus-send-tl-connect-request \
ksym-vanilla-vmbus-sendpacket \
ksym-vanilla-vmbus-sendpacket-getid \
ksym-vanilla-vmbus-sendpacket-mpb-desc \
ksym-vanilla-vmbus-set-chn-rescind-callback \
ksym-vanilla-vmbus-set-event \
ksym-vanilla-vmbus-set-sc-create-callback \
ksym-vanilla-vmbus-set-skip-unload \
ksym-vanilla-vmbus-setevent \
ksym-vanilla-vmbus-teardown-gpadl \
ksym-vanilla-vmci-context-get-priv-flags \
ksym-vanilla-vmci-datagram-create-handle \
ksym-vanilla-vmci-datagram-create-handle-priv \
ksym-vanilla-vmci-datagram-destroy-handle \
ksym-vanilla-vmci-datagram-send \
ksym-vanilla-vmci-doorbell-create \
ksym-vanilla-vmci-doorbell-destroy \
ksym-vanilla-vmci-event-subscribe \
ksym-vanilla-vmci-event-unsubscribe \
ksym-vanilla-vmci-get-context-id \
ksym-vanilla-vmci-is-context-owner \
ksym-vanilla-vmci-qpair-alloc \
ksym-vanilla-vmci-qpair-consume-buf-ready \
ksym-vanilla-vmci-qpair-consume-free-space \
ksym-vanilla-vmci-qpair-dequev \
ksym-vanilla-vmci-qpair-detach \
ksym-vanilla-vmci-qpair-enquev \
ksym-vanilla-vmci-qpair-get-consume-indexes \
ksym-vanilla-vmci-qpair-get-produce-indexes \
ksym-vanilla-vmci-qpair-peekv \
ksym-vanilla-vmci-qpair-produce-buf-ready \
ksym-vanilla-vmci-qpair-produce-free-space \
ksym-vanilla-vmci-register-vsock-callback \
ksym-vanilla-vmci-send-datagram \
ksym-vanilla-vmcore-add-device-dump \
ksym-vanilla-vmemdup-user \
ksym-vanilla-vmf-insert-folio-pmd \
ksym-vanilla-vmf-insert-mixed \
ksym-vanilla-vmf-insert-page-mkwrite \
ksym-vanilla-vmf-insert-pfn \
ksym-vanilla-vmf-insert-pfn-pmd \
ksym-vanilla-vmf-insert-pfn-prot \
ksym-vanilla-vnic-dev-get-pdev \
ksym-vanilla-vnic-dev-get-res \
ksym-vanilla-vnic-dev-get-res-count \
ksym-vanilla-vnic-dev-register \
ksym-vanilla-vnic-dev-unregister \
ksym-vanilla-vop-component-ops \
ksym-vanilla-vop2-component-ops \
ksym-vanilla-vp-legacy-config-vector \
ksym-vanilla-vp-legacy-get-driver-features \
ksym-vanilla-vp-legacy-get-features \
ksym-vanilla-vp-legacy-get-queue-enable \
ksym-vanilla-vp-legacy-get-queue-size \
ksym-vanilla-vp-legacy-get-status \
ksym-vanilla-vp-legacy-probe \
ksym-vanilla-vp-legacy-queue-vector \
ksym-vanilla-vp-legacy-remove \
ksym-vanilla-vp-legacy-set-features \
ksym-vanilla-vp-legacy-set-queue-address \
ksym-vanilla-vp-legacy-set-status \
ksym-vanilla-vp-modern-avq-index \
ksym-vanilla-vp-modern-avq-num \
ksym-vanilla-vp-modern-config-vector \
ksym-vanilla-vp-modern-generation \
ksym-vanilla-vp-modern-get-driver-extended-features \
ksym-vanilla-vp-modern-get-extended-features \
ksym-vanilla-vp-modern-get-num-queues \
ksym-vanilla-vp-modern-get-queue-enable \
ksym-vanilla-vp-modern-get-queue-reset \
ksym-vanilla-vp-modern-get-queue-size \
ksym-vanilla-vp-modern-get-status \
ksym-vanilla-vp-modern-map-vq-notify \
ksym-vanilla-vp-modern-probe \
ksym-vanilla-vp-modern-queue-address \
ksym-vanilla-vp-modern-queue-vector \
ksym-vanilla-vp-modern-remove \
ksym-vanilla-vp-modern-set-extended-features \
ksym-vanilla-vp-modern-set-queue-enable \
ksym-vanilla-vp-modern-set-queue-reset \
ksym-vanilla-vp-modern-set-queue-size \
ksym-vanilla-vp-modern-set-status \
ksym-vanilla-vp3054-i2c-probe \
ksym-vanilla-vp3054-i2c-remove \
ksym-vanilla-vpanic \
ksym-vanilla-vprintk \
ksym-vanilla-vprintk-default \
ksym-vanilla-vprintk-emit \
ksym-vanilla-vpu-get-plat-device \
ksym-vanilla-vpu-get-vdec-hw-capa \
ksym-vanilla-vpu-get-venc-hw-capa \
ksym-vanilla-vpu-ipi-register \
ksym-vanilla-vpu-ipi-send \
ksym-vanilla-vpu-load-firmware \
ksym-vanilla-vpu-mapping-dm-addr \
ksym-vanilla-vpu-wdt-reg-handler \
ksym-vanilla-vq-meta-prefetch \
ksym-vanilla-vrealloc-node-align-noprof \
ksym-vanilla-vring-create-virtqueue \
ksym-vanilla-vring-create-virtqueue-map \
ksym-vanilla-vring-del-virtqueue \
ksym-vanilla-vring-interrupt \
ksym-vanilla-vring-new-virtqueue \
ksym-vanilla-vring-notification-data \
ksym-vanilla-vring-transport-features \
ksym-vanilla-vringh-complete-iotlb \
ksym-vanilla-vringh-complete-kern \
ksym-vanilla-vringh-complete-multi-user \
ksym-vanilla-vringh-complete-user \
ksym-vanilla-vringh-getdesc-iotlb \
ksym-vanilla-vringh-getdesc-kern \
ksym-vanilla-vringh-getdesc-user \
ksym-vanilla-vringh-init-iotlb \
ksym-vanilla-vringh-init-iotlb-va \
ksym-vanilla-vringh-init-kern \
ksym-vanilla-vringh-init-user \
ksym-vanilla-vringh-iov-pull-iotlb \
ksym-vanilla-vringh-iov-pull-user \
ksym-vanilla-vringh-iov-push-iotlb \
ksym-vanilla-vringh-iov-push-user \
ksym-vanilla-vringh-kiov-advance \
ksym-vanilla-vringh-need-notify-iotlb \
ksym-vanilla-vringh-need-notify-kern \
ksym-vanilla-vringh-need-notify-user \
ksym-vanilla-vringh-notify-disable-kern \
ksym-vanilla-vringh-notify-disable-user \
ksym-vanilla-vringh-notify-enable-kern \
ksym-vanilla-vringh-notify-enable-user \
ksym-vanilla-vringh-set-iotlb \
ksym-vanilla-vsc73xx-is-addr-valid \
ksym-vanilla-vsc73xx-probe \
ksym-vanilla-vsc73xx-remove \
ksym-vanilla-vsc73xx-shutdown \
ksym-vanilla-vsc7514-regfields \
ksym-vanilla-vsc7514-regmap \
ksym-vanilla-vsc7514-vcap-props \
ksym-vanilla-vscnprintf \
ksym-vanilla-vsnprintf \
ksym-vanilla-vsock-add-pending \
ksym-vanilla-vsock-add-tap \
ksym-vanilla-vsock-addr-bound \
ksym-vanilla-vsock-addr-cast \
ksym-vanilla-vsock-addr-equals-addr \
ksym-vanilla-vsock-addr-init \
ksym-vanilla-vsock-addr-unbind \
ksym-vanilla-vsock-addr-validate \
ksym-vanilla-vsock-assign-transport \
ksym-vanilla-vsock-bind-table \
ksym-vanilla-vsock-connected-table \
ksym-vanilla-vsock-connectible-has-data \
ksym-vanilla-vsock-connectible-recvmsg \
ksym-vanilla-vsock-core-get-transport \
ksym-vanilla-vsock-core-register \
ksym-vanilla-vsock-core-unregister \
ksym-vanilla-vsock-create-connected \
ksym-vanilla-vsock-data-ready \
ksym-vanilla-vsock-deliver-tap \
ksym-vanilla-vsock-dgram-recvmsg \
ksym-vanilla-vsock-enqueue-accept \
ksym-vanilla-vsock-find-bound-socket \
ksym-vanilla-vsock-find-bound-socket-net \
ksym-vanilla-vsock-find-cid \
ksym-vanilla-vsock-find-connected-socket \
ksym-vanilla-vsock-find-connected-socket-net \
ksym-vanilla-vsock-for-each-connected-socket \
ksym-vanilla-vsock-insert-connected \
ksym-vanilla-vsock-linger \
ksym-vanilla-vsock-pending-to-accept \
ksym-vanilla-vsock-remove-bound \
ksym-vanilla-vsock-remove-connected \
ksym-vanilla-vsock-remove-pending \
ksym-vanilla-vsock-remove-sock \
ksym-vanilla-vsock-remove-tap \
ksym-vanilla-vsock-stream-has-data \
ksym-vanilla-vsock-stream-has-space \
ksym-vanilla-vsock-table-lock \
ksym-vanilla-vsp1-du-atomic-begin \
ksym-vanilla-vsp1-du-atomic-flush \
ksym-vanilla-vsp1-du-atomic-update \
ksym-vanilla-vsp1-du-disable \
ksym-vanilla-vsp1-du-enable \
ksym-vanilla-vsp1-du-init \
ksym-vanilla-vsp1-du-map-sg \
ksym-vanilla-vsp1-du-unmap-sg \
ksym-vanilla-vsp1-isp-alloc-buffer \
ksym-vanilla-vsp1-isp-free-buffer \
ksym-vanilla-vsp1-isp-get-bus-master \
ksym-vanilla-vsp1-isp-init \
ksym-vanilla-vsp1-isp-job-prepare \
ksym-vanilla-vsp1-isp-job-release \
ksym-vanilla-vsp1-isp-job-run \
ksym-vanilla-vsp1-isp-start-streaming \
ksym-vanilla-vsp1-isp-stop-streaming \
ksym-vanilla-vsprintf \
ksym-vanilla-vsscanf \
ksym-vanilla-vt-get-leds \
ksym-vanilla-vtime-guest-enter \
ksym-vanilla-vtime-guest-exit \
ksym-vanilla-vunmap \
ksym-vanilla-vxlan-dev-create \
ksym-vanilla-vxlan-fdb-clear-offload \
ksym-vanilla-vxlan-fdb-find-uc \
ksym-vanilla-vxlan-fdb-replay \
ksym-vanilla-vzalloc-node-noprof \
ksym-vanilla-vzalloc-noprof \
ksym-vanilla-w1-add-master-device \
ksym-vanilla-w1-calc-crc8 \
ksym-vanilla-w1-ds2780-eeprom-cmd \
ksym-vanilla-w1-ds2780-io \
ksym-vanilla-w1-ds2781-eeprom-cmd \
ksym-vanilla-w1-ds2781-io \
ksym-vanilla-w1-next-pullup \
ksym-vanilla-w1-read-8 \
ksym-vanilla-w1-read-block \
ksym-vanilla-w1-register-family \
ksym-vanilla-w1-remove-master-device \
ksym-vanilla-w1-reset-bus \
ksym-vanilla-w1-reset-resume-command \
ksym-vanilla-w1-reset-select-slave \
ksym-vanilla-w1-touch-bit \
ksym-vanilla-w1-touch-block \
ksym-vanilla-w1-triplet \
ksym-vanilla-w1-unregister-family \
ksym-vanilla-w1-write-8 \
ksym-vanilla-w1-write-block \
ksym-vanilla-w5100-ops-priv \
ksym-vanilla-w5100-pm-ops \
ksym-vanilla-w5100-probe \
ksym-vanilla-w5100-remove \
ksym-vanilla-wait-for-completion \
ksym-vanilla-wait-for-completion-interruptible \
ksym-vanilla-wait-for-completion-interruptible-timeout \
ksym-vanilla-wait-for-completion-io \
ksym-vanilla-wait-for-completion-io-timeout \
ksym-vanilla-wait-for-completion-killable \
ksym-vanilla-wait-for-completion-killable-timeout \
ksym-vanilla-wait-for-completion-state \
ksym-vanilla-wait-for-completion-timeout \
ksym-vanilla-wait-for-device-probe \
ksym-vanilla-wait-for-initramfs \
ksym-vanilla-wait-for-key-construction \
ksym-vanilla-wait-for-random-bytes \
ksym-vanilla-wait-on-new-inode \
ksym-vanilla-wait-on-page-writeback \
ksym-vanilla-wait-woken \
ksym-vanilla-wake-bit-function \
ksym-vanilla-wake-up-all-idle-cpus \
ksym-vanilla-wake-up-bit \
ksym-vanilla-wake-up-process \
ksym-vanilla-wake-up-var \
ksym-vanilla-wakeme-after-rcu \
ksym-vanilla-wakeup-source-register \
ksym-vanilla-wakeup-source-unregister \
ksym-vanilla-wakeup-sources-read-lock \
ksym-vanilla-wakeup-sources-read-unlock \
ksym-vanilla-wakeup-sources-walk-next \
ksym-vanilla-wakeup-sources-walk-start \
ksym-vanilla-walk-hmem-resources \
ksym-vanilla-walk-iomem-res-desc \
ksym-vanilla-walk-soft-reserve-res \
ksym-vanilla-watchdog-hardlockup-miss-thresh \
ksym-vanilla-watchdog-init-timeout \
ksym-vanilla-watchdog-notify-pretimeout \
ksym-vanilla-watchdog-register-device \
ksym-vanilla-watchdog-register-governor \
ksym-vanilla-watchdog-set-last-hw-keepalive \
ksym-vanilla-watchdog-set-restart-priority \
ksym-vanilla-watchdog-unregister-device \
ksym-vanilla-watchdog-unregister-governor \
ksym-vanilla-wb-writeout-inc \
ksym-vanilla-wbc-account-cgroup-owner \
ksym-vanilla-wbc-attach-fdatawrite-inode \
ksym-vanilla-wbc-detach-inode \
ksym-vanilla-wbt-disable-default \
ksym-vanilla-wbt-enable-default \
ksym-vanilla-wcd-bus-config \
ksym-vanilla-wcd-clsh-ctrl-alloc \
ksym-vanilla-wcd-clsh-ctrl-free \
ksym-vanilla-wcd-clsh-ctrl-get-state \
ksym-vanilla-wcd-clsh-ctrl-set-state \
ksym-vanilla-wcd-clsh-set-hph-mode \
ksym-vanilla-wcd-dt-parse-mbhc-data \
ksym-vanilla-wcd-dt-parse-micbias-info \
ksym-vanilla-wcd-get-micb-vout-ctl-val \
ksym-vanilla-wcd-interrupt-callback \
ksym-vanilla-wcd-mbhc-deinit \
ksym-vanilla-wcd-mbhc-event-notify \
ksym-vanilla-wcd-mbhc-get-hph-type \
ksym-vanilla-wcd-mbhc-get-impedance \
ksym-vanilla-wcd-mbhc-init \
ksym-vanilla-wcd-mbhc-set-hph-type \
ksym-vanilla-wcd-mbhc-start \
ksym-vanilla-wcd-mbhc-stop \
ksym-vanilla-wcd-mbhc-typec-report-plug \
ksym-vanilla-wcd-mbhc-typec-report-unplug \
ksym-vanilla-wcd-sdw-component-ops \
ksym-vanilla-wcd-update-status \
ksym-vanilla-wcd938x-sdw-free \
ksym-vanilla-wcd938x-sdw-hw-params \
ksym-vanilla-wcd938x-sdw-set-sdw-stream \
ksym-vanilla-wcd939x-sdw-free \
ksym-vanilla-wcd939x-sdw-hw-params \
ksym-vanilla-wcd939x-sdw-set-sdw-stream \
ksym-vanilla-wdev-chandef \
ksym-vanilla-wdev-to-ieee80211-vif \
ksym-vanilla-widget-in-list \
ksym-vanilla-wiphy-apply-custom-regulatory \
ksym-vanilla-wiphy-delayed-work-cancel \
ksym-vanilla-wiphy-delayed-work-flush \
ksym-vanilla-wiphy-delayed-work-pending \
ksym-vanilla-wiphy-delayed-work-queue \
ksym-vanilla-wiphy-delayed-work-timer \
ksym-vanilla-wiphy-free \
ksym-vanilla-wiphy-hrtimer-work-cancel \
ksym-vanilla-wiphy-hrtimer-work-flush \
ksym-vanilla-wiphy-hrtimer-work-pending \
ksym-vanilla-wiphy-hrtimer-work-queue \
ksym-vanilla-wiphy-hrtimer-work-timer \
ksym-vanilla-wiphy-new-nm \
ksym-vanilla-wiphy-read-of-freq-limits \
ksym-vanilla-wiphy-register \
ksym-vanilla-wiphy-rfkill-set-hw-state-reason \
ksym-vanilla-wiphy-rfkill-start-polling \
ksym-vanilla-wiphy-to-ieee80211-hw \
ksym-vanilla-wiphy-unregister \
ksym-vanilla-wiphy-work-cancel \
ksym-vanilla-wiphy-work-flush \
ksym-vanilla-wiphy-work-queue \
ksym-vanilla-wireless-nlevent-flush \
ksym-vanilla-wireless-send-event \
ksym-vanilla-wl1251-alloc-hw \
ksym-vanilla-wl1251-free-hw \
ksym-vanilla-wl1251-init-ieee80211 \
ksym-vanilla-wl1271-acx-init-mem-config \
ksym-vanilla-wl1271-acx-pm-config \
ksym-vanilla-wl1271-acx-set-ht-capabilities \
ksym-vanilla-wl1271-acx-sleep-auth \
ksym-vanilla-wl1271-cmd-configure \
ksym-vanilla-wl1271-cmd-data-path \
ksym-vanilla-wl1271-cmd-send \
ksym-vanilla-wl1271-cmd-test \
ksym-vanilla-wl1271-debugfs-update-stats \
ksym-vanilla-wl1271-format-buffer \
ksym-vanilla-wl1271-free-tx-id \
ksym-vanilla-wl1271-tx-flush \
ksym-vanilla-wl1271-tx-min-rate-get \
ksym-vanilla-wl12xx-acx-mem-cfg \
ksym-vanilla-wl12xx-cmd-build-probe-req \
ksym-vanilla-wl12xx-debug-level \
ksym-vanilla-wl12xx-is-dummy-packet \
ksym-vanilla-wlcore-alloc-hw \
ksym-vanilla-wlcore-boot-run-firmware \
ksym-vanilla-wlcore-boot-upload-firmware \
ksym-vanilla-wlcore-boot-upload-nvs \
ksym-vanilla-wlcore-calc-packet-alignment \
ksym-vanilla-wlcore-cmd-generic-cfg \
ksym-vanilla-wlcore-cmd-wait-for-event-or-timeout \
ksym-vanilla-wlcore-disable-interrupts \
ksym-vanilla-wlcore-disable-interrupts-nosync \
ksym-vanilla-wlcore-enable-interrupts \
ksym-vanilla-wlcore-event-ba-rx-constraint \
ksym-vanilla-wlcore-event-beacon-loss \
ksym-vanilla-wlcore-event-channel-switch \
ksym-vanilla-wlcore-event-dummy-packet \
ksym-vanilla-wlcore-event-fw-logger \
ksym-vanilla-wlcore-event-inactive-sta \
ksym-vanilla-wlcore-event-max-tx-failure \
ksym-vanilla-wlcore-event-roc-complete \
ksym-vanilla-wlcore-event-rssi-trigger \
ksym-vanilla-wlcore-event-sched-scan-completed \
ksym-vanilla-wlcore-event-soft-gemini-sense \
ksym-vanilla-wlcore-free-hw \
ksym-vanilla-wlcore-get-native-channel-type \
ksym-vanilla-wlcore-probe \
ksym-vanilla-wlcore-remove \
ksym-vanilla-wlcore-scan-sched-scan-results \
ksym-vanilla-wlcore-scan-sched-scan-ssid-list \
ksym-vanilla-wlcore-set-key \
ksym-vanilla-wlcore-set-partition \
ksym-vanilla-wlcore-set-scan-chan-params \
ksym-vanilla-wlcore-synchronize-interrupts \
ksym-vanilla-wlcore-translate-addr \
ksym-vanilla-wlcore-tx-complete \
ksym-vanilla-wm-adsp-compr-copy \
ksym-vanilla-wm-adsp-compr-free \
ksym-vanilla-wm-adsp-compr-get-caps \
ksym-vanilla-wm-adsp-compr-handle-irq \
ksym-vanilla-wm-adsp-compr-open \
ksym-vanilla-wm-adsp-compr-pointer \
ksym-vanilla-wm-adsp-compr-set-params \
ksym-vanilla-wm-adsp-compr-trigger \
ksym-vanilla-wm-adsp-control-add \
ksym-vanilla-wm-adsp-early-event \
ksym-vanilla-wm-adsp-event \
ksym-vanilla-wm-adsp-fw-enum \
ksym-vanilla-wm-adsp-fw-get \
ksym-vanilla-wm-adsp-fw-put \
ksym-vanilla-wm-adsp-hibernate \
ksym-vanilla-wm-adsp-power-down \
ksym-vanilla-wm-adsp-power-up \
ksym-vanilla-wm-adsp-read-ctl \
ksym-vanilla-wm-adsp-run \
ksym-vanilla-wm-adsp-stop \
ksym-vanilla-wm-adsp-write-ctl \
ksym-vanilla-wm-adsp1-event \
ksym-vanilla-wm-adsp1-init \
ksym-vanilla-wm-adsp2-bus-error \
ksym-vanilla-wm-adsp2-component-probe \
ksym-vanilla-wm-adsp2-component-remove \
ksym-vanilla-wm-adsp2-init \
ksym-vanilla-wm-adsp2-preloader-get \
ksym-vanilla-wm-adsp2-preloader-put \
ksym-vanilla-wm-adsp2-remove \
ksym-vanilla-wm-adsp2-set-dspclk \
ksym-vanilla-wm-halo-bus-error \
ksym-vanilla-wm-halo-init \
ksym-vanilla-wm-halo-wdt-expire \
ksym-vanilla-wm-hubs-add-analogue-controls \
ksym-vanilla-wm-hubs-add-analogue-routes \
ksym-vanilla-wm-hubs-dcs-done \
ksym-vanilla-wm-hubs-handle-analogue-pdata \
ksym-vanilla-wm-hubs-hpl-mux \
ksym-vanilla-wm-hubs-hpr-mux \
ksym-vanilla-wm-hubs-set-bias-level \
ksym-vanilla-wm-hubs-spkmix-tlv \
ksym-vanilla-wm-hubs-update-class-w \
ksym-vanilla-wm-hubs-vmid-ena \
ksym-vanilla-wm1811-regmap-config \
ksym-vanilla-wm8804-pm \
ksym-vanilla-wm8804-probe \
ksym-vanilla-wm8804-regmap-config \
ksym-vanilla-wm8804-remove \
ksym-vanilla-wm8903-mic-detect \
ksym-vanilla-wm8958-mic-detect \
ksym-vanilla-wm8958-regmap-config \
ksym-vanilla-wm8962-mic-detect \
ksym-vanilla-wm8994-base-regmap-config \
ksym-vanilla-wm8994-irq-exit \
ksym-vanilla-wm8994-irq-init \
ksym-vanilla-wm8994-mic-detect \
ksym-vanilla-wm8994-regmap-config \
ksym-vanilla-wm9705-codec \
ksym-vanilla-wm9712-codec \
ksym-vanilla-wm9713-codec \
ksym-vanilla-wm97xx-config-gpio \
ksym-vanilla-wm97xx-get-gpio \
ksym-vanilla-wm97xx-read-aux-adc \
ksym-vanilla-wm97xx-reg-read \
ksym-vanilla-wm97xx-reg-write \
ksym-vanilla-wm97xx-register-mach-ops \
ksym-vanilla-wm97xx-set-gpio \
ksym-vanilla-wm97xx-set-suspend-mode \
ksym-vanilla-wm97xx-unregister-mach-ops \
ksym-vanilla-woken-wake-bit-function \
ksym-vanilla-woken-wake-function \
ksym-vanilla-work-busy \
ksym-vanilla-work-on-cpu-key \
ksym-vanilla-workqueue-congested \
ksym-vanilla-workqueue-set-max-active \
ksym-vanilla-would-dump \
ksym-vanilla-wp-shared-mapping-range \
ksym-vanilla-wpan-phy-find \
ksym-vanilla-wpan-phy-for-each \
ksym-vanilla-wpan-phy-free \
ksym-vanilla-wpan-phy-new \
ksym-vanilla-wpan-phy-register \
ksym-vanilla-wpan-phy-unregister \
ksym-vanilla-wrap-directory-iterator \
ksym-vanilla-write-bytes-to-xdr-buf \
ksym-vanilla-write-dirty-buffer \
ksym-vanilla-write-dst \
ksym-vanilla-write-inode-now \
ksym-vanilla-writeback-inodes-sb \
ksym-vanilla-writeback-inodes-sb-nr \
ksym-vanilla-writeback-iter \
ksym-vanilla-wsa-macro-set-spkr-mode \
ksym-vanilla-ww-mutex-lock \
ksym-vanilla-ww-mutex-lock-interruptible \
ksym-vanilla-ww-mutex-trylock \
ksym-vanilla-ww-mutex-unlock \
ksym-vanilla-wwan-create-port \
ksym-vanilla-wwan-port-get-drvdata \
ksym-vanilla-wwan-port-rx \
ksym-vanilla-wwan-port-txoff \
ksym-vanilla-wwan-port-txon \
ksym-vanilla-wwan-register-ops \
ksym-vanilla-wwan-remove-port \
ksym-vanilla-wwan-unregister-ops \
ksym-vanilla-wx-change-mtu \
ksym-vanilla-wx-check-flash-load \
ksym-vanilla-wx-clean-all-rx-rings \
ksym-vanilla-wx-clean-all-tx-rings \
ksym-vanilla-wx-clear-hw-cntrs \
ksym-vanilla-wx-clear-interrupt-scheme \
ksym-vanilla-wx-configure \
ksym-vanilla-wx-configure-rx \
ksym-vanilla-wx-configure-vectors \
ksym-vanilla-wx-configure-vf \
ksym-vanilla-wx-control-hw \
ksym-vanilla-wx-decode-ptype \
ksym-vanilla-wx-disable-pcie-master \
ksym-vanilla-wx-disable-rx \
ksym-vanilla-wx-disable-rx-queue \
ksym-vanilla-wx-disable-sec-rx-path \
ksym-vanilla-wx-disable-sriov \
ksym-vanilla-wx-disable-vf-rx-tx \
ksym-vanilla-wx-enable-rx-queue \
ksym-vanilla-wx-enable-sec-rx-path \
ksym-vanilla-wx-fc-enable \
ksym-vanilla-wx-features-check \
ksym-vanilla-wx-fix-features \
ksym-vanilla-wx-flush-sw-mac-table \
ksym-vanilla-wx-free-irq \
ksym-vanilla-wx-free-isb-resources \
ksym-vanilla-wx-free-resources \
ksym-vanilla-wx-get-channels \
ksym-vanilla-wx-get-coalesce \
ksym-vanilla-wx-get-drvinfo \
ksym-vanilla-wx-get-ethtool-stats \
ksym-vanilla-wx-get-fw-version-vf \
ksym-vanilla-wx-get-link-ksettings \
ksym-vanilla-wx-get-link-state-vf \
ksym-vanilla-wx-get-mac-addr \
ksym-vanilla-wx-get-mac-addr-vf \
ksym-vanilla-wx-get-mac-stats \
ksym-vanilla-wx-get-msglevel \
ksym-vanilla-wx-get-pause-stats \
ksym-vanilla-wx-get-pauseparam \
ksym-vanilla-wx-get-pcie-msix-counts \
ksym-vanilla-wx-get-ptp-stats \
ksym-vanilla-wx-get-queues-vf \
ksym-vanilla-wx-get-ringparam \
ksym-vanilla-wx-get-rxfh \
ksym-vanilla-wx-get-rxfh-fields \
ksym-vanilla-wx-get-rxfh-key-size \
ksym-vanilla-wx-get-sset-count \
ksym-vanilla-wx-get-stats64 \
ksym-vanilla-wx-get-strings \
ksym-vanilla-wx-get-ts-info \
ksym-vanilla-wx-get-wol \
ksym-vanilla-wx-host-interface-command \
ksym-vanilla-wx-hwtstamp-get \
ksym-vanilla-wx-hwtstamp-set \
ksym-vanilla-wx-init-eeprom-params \
ksym-vanilla-wx-init-hw-vf \
ksym-vanilla-wx-init-interrupt-scheme \
ksym-vanilla-wx-init-mbx-params-vf \
ksym-vanilla-wx-init-rx-addrs \
ksym-vanilla-wx-intr-enable \
ksym-vanilla-wx-irq-disable \
ksym-vanilla-wx-mac-set-default-filter \
ksym-vanilla-wx-misc-isb \
ksym-vanilla-wx-mng-present \
ksym-vanilla-wx-msg-task \
ksym-vanilla-wx-msix-clean-rings \
ksym-vanilla-wx-napi-disable-all \
ksym-vanilla-wx-napi-enable-all \
ksym-vanilla-wx-negotiate-api-version \
ksym-vanilla-wx-negotiate-api-vf \
ksym-vanilla-wx-nway-reset \
ksym-vanilla-wx-pci-sriov-configure \
ksym-vanilla-wx-phy-read-reg-mdi-c22 \
ksym-vanilla-wx-phy-read-reg-mdi-c45 \
ksym-vanilla-wx-phy-write-reg-mdi-c22 \
ksym-vanilla-wx-phy-write-reg-mdi-c45 \
ksym-vanilla-wx-ping-all-vfs-with-link-status \
ksym-vanilla-wx-ptp-check-pps-event \
ksym-vanilla-wx-ptp-init \
ksym-vanilla-wx-ptp-reset \
ksym-vanilla-wx-ptp-reset-cyclecounter \
ksym-vanilla-wx-ptp-stop \
ksym-vanilla-wx-ptp-suspend \
ksym-vanilla-wx-read-ee-hostif \
ksym-vanilla-wx-read-ee-hostif-buffer \
ksym-vanilla-wx-request-msix-irqs-vf \
ksym-vanilla-wx-reset-hw-vf \
ksym-vanilla-wx-reset-interrupt-capability \
ksym-vanilla-wx-reset-mac \
ksym-vanilla-wx-reset-misc \
ksym-vanilla-wx-reset-vf \
ksym-vanilla-wx-rlpml-set-vf \
ksym-vanilla-wx-rss-indir-size \
ksym-vanilla-wx-service-event-complete \
ksym-vanilla-wx-service-event-schedule \
ksym-vanilla-wx-service-timer \
ksym-vanilla-wx-set-all-vfs \
ksym-vanilla-wx-set-channels \
ksym-vanilla-wx-set-coalesce \
ksym-vanilla-wx-set-ethtool-ops-vf \
ksym-vanilla-wx-set-features \
ksym-vanilla-wx-set-link-ksettings \
ksym-vanilla-wx-set-mac \
ksym-vanilla-wx-set-mac-vf \
ksym-vanilla-wx-set-msglevel \
ksym-vanilla-wx-set-pauseparam \
ksym-vanilla-wx-set-rar-vf \
ksym-vanilla-wx-set-ring \
ksym-vanilla-wx-set-rx-mode \
ksym-vanilla-wx-set-rx-mode-vf \
ksym-vanilla-wx-set-rxfh \
ksym-vanilla-wx-set-rxfh-fields \
ksym-vanilla-wx-set-uc-addr-vf \
ksym-vanilla-wx-set-vfta-vf \
ksym-vanilla-wx-set-wol \
ksym-vanilla-wx-setup-isb-resources \
ksym-vanilla-wx-setup-resources \
ksym-vanilla-wx-start-hw \
ksym-vanilla-wx-stop-adapter \
ksym-vanilla-wx-stop-adapter-vf \
ksym-vanilla-wx-sw-init \
ksym-vanilla-wx-update-mc-addr-list-vf \
ksym-vanilla-wx-update-stats \
ksym-vanilla-wx-update-xcast-mode-vf \
ksym-vanilla-wx-vlan-rx-add-vid \
ksym-vanilla-wx-vlan-rx-kill-vid \
ksym-vanilla-wx-xmit-frame \
ksym-vanilla-wxvf-close \
ksym-vanilla-wxvf-init-service \
ksym-vanilla-wxvf-open \
ksym-vanilla-wxvf-remove \
ksym-vanilla-wxvf-resume \
ksym-vanilla-wxvf-shutdown \
ksym-vanilla-wxvf-suspend \
ksym-vanilla-wxvf-watchdog-update-link \
ksym-vanilla-x509-cert-parse \
ksym-vanilla-x509-decode-time \
ksym-vanilla-x509-free-certificate \
ksym-vanilla-x509-load-certificate-list \
ksym-vanilla-xa-clear-mark \
ksym-vanilla-xa-delete-node \
ksym-vanilla-xa-destroy \
ksym-vanilla-xa-erase \
ksym-vanilla-xa-extract \
ksym-vanilla-xa-find \
ksym-vanilla-xa-find-after \
ksym-vanilla-xa-get-mark \
ksym-vanilla-xa-get-order \
ksym-vanilla-xa-load \
ksym-vanilla-xa-set-mark \
ksym-vanilla-xa-store \
ksym-vanilla-xa-store-range \
ksym-vanilla-xas-clear-mark \
ksym-vanilla-xas-create-range \
ksym-vanilla-xas-destroy \
ksym-vanilla-xas-find \
ksym-vanilla-xas-find-conflict \
ksym-vanilla-xas-find-marked \
ksym-vanilla-xas-get-mark \
ksym-vanilla-xas-get-order \
ksym-vanilla-xas-init-marks \
ksym-vanilla-xas-load \
ksym-vanilla-xas-nomem \
ksym-vanilla-xas-pause \
ksym-vanilla-xas-set-mark \
ksym-vanilla-xas-split \
ksym-vanilla-xas-split-alloc \
ksym-vanilla-xas-store \
ksym-vanilla-xas-try-split \
ksym-vanilla-xas-try-split-min-order \
ksym-vanilla-xattr-full-name \
ksym-vanilla-xattr-supports-user-prefix \
ksym-vanilla-xc2028-attach \
ksym-vanilla-xc4000-attach \
ksym-vanilla-xc5000-attach \
ksym-vanilla-xchacha20poly1305-decrypt \
ksym-vanilla-xchacha20poly1305-encrypt \
ksym-vanilla-xcv-init-hw \
ksym-vanilla-xcv-setup-link \
ksym-vanilla-xdma-disable-user-irq \
ksym-vanilla-xdma-enable-user-irq \
ksym-vanilla-xdma-get-user-irq \
ksym-vanilla-xdp-attachment-setup \
ksym-vanilla-xdp-build-skb-from-buff \
ksym-vanilla-xdp-build-skb-from-frame \
ksym-vanilla-xdp-build-skb-from-zc \
ksym-vanilla-xdp-convert-zc-to-xdp-frame \
ksym-vanilla-xdp-do-flush \
ksym-vanilla-xdp-do-redirect \
ksym-vanilla-xdp-do-redirect-frame \
ksym-vanilla-xdp-features-clear-redirect-target \
ksym-vanilla-xdp-features-clear-redirect-target-locked \
ksym-vanilla-xdp-features-set-redirect-target \
ksym-vanilla-xdp-features-set-redirect-target-locked \
ksym-vanilla-xdp-master-redirect \
ksym-vanilla-xdp-reg-mem-model \
ksym-vanilla-xdp-reg-page-pool \
ksym-vanilla-xdp-return-buff \
ksym-vanilla-xdp-return-frag \
ksym-vanilla-xdp-return-frame \
ksym-vanilla-xdp-return-frame-bulk \
ksym-vanilla-xdp-return-frame-rx-napi \
ksym-vanilla-xdp-rxq-info-attach-page-pool \
ksym-vanilla-xdp-rxq-info-is-reg \
ksym-vanilla-xdp-rxq-info-reg-mem-model \
ksym-vanilla-xdp-rxq-info-unreg \
ksym-vanilla-xdp-rxq-info-unreg-mem-model \
ksym-vanilla-xdp-rxq-info-unused \
ksym-vanilla-xdp-set-features-flag \
ksym-vanilla-xdp-set-features-flag-locked \
ksym-vanilla-xdp-unreg-mem-model \
ksym-vanilla-xdp-unreg-page-pool \
ksym-vanilla-xdp-warn \
ksym-vanilla-xdr-buf-from-iov \
ksym-vanilla-xdr-buf-subsegment \
ksym-vanilla-xdr-buf-to-bvec \
ksym-vanilla-xdr-buf-to-sg \
ksym-vanilla-xdr-buf-to-sg-alloc \
ksym-vanilla-xdr-buf-trim \
ksym-vanilla-xdr-decode-array2 \
ksym-vanilla-xdr-decode-word \
ksym-vanilla-xdr-encode-array2 \
ksym-vanilla-xdr-encode-netobj \
ksym-vanilla-xdr-encode-opaque \
ksym-vanilla-xdr-encode-opaque-fixed \
ksym-vanilla-xdr-encode-string \
ksym-vanilla-xdr-encode-word \
ksym-vanilla-xdr-enter-page \
ksym-vanilla-xdr-finish-decode \
ksym-vanilla-xdr-init-decode \
ksym-vanilla-xdr-init-decode-pages \
ksym-vanilla-xdr-init-encode \
ksym-vanilla-xdr-init-encode-pages \
ksym-vanilla-xdr-inline-decode \
ksym-vanilla-xdr-inline-pages \
ksym-vanilla-xdr-page-pos \
ksym-vanilla-xdr-read-pages \
ksym-vanilla-xdr-reserve-space \
ksym-vanilla-xdr-reserve-space-vec \
ksym-vanilla-xdr-restrict-buflen \
ksym-vanilla-xdr-set-pagelen \
ksym-vanilla-xdr-stream-decode-opaque-auth \
ksym-vanilla-xdr-stream-decode-string-dup \
ksym-vanilla-xdr-stream-encode-opaque-auth \
ksym-vanilla-xdr-stream-move-subsegment \
ksym-vanilla-xdr-stream-pos \
ksym-vanilla-xdr-stream-subsegment \
ksym-vanilla-xdr-stream-zero \
ksym-vanilla-xdr-terminate-string \
ksym-vanilla-xdr-truncate-decode \
ksym-vanilla-xdr-truncate-encode \
ksym-vanilla-xdr-write-pages \
ksym-vanilla-xe-sriov-vfio-data-read \
ksym-vanilla-xe-sriov-vfio-data-write \
ksym-vanilla-xe-sriov-vfio-error \
ksym-vanilla-xe-sriov-vfio-flr-prepare \
ksym-vanilla-xe-sriov-vfio-get-pf \
ksym-vanilla-xe-sriov-vfio-migration-supported \
ksym-vanilla-xe-sriov-vfio-resume-data-enter \
ksym-vanilla-xe-sriov-vfio-resume-data-exit \
ksym-vanilla-xe-sriov-vfio-resume-device \
ksym-vanilla-xe-sriov-vfio-stop-copy-enter \
ksym-vanilla-xe-sriov-vfio-stop-copy-exit \
ksym-vanilla-xe-sriov-vfio-stop-copy-size \
ksym-vanilla-xe-sriov-vfio-suspend-device \
ksym-vanilla-xe-sriov-vfio-wait-flr-done \
ksym-vanilla-xfer-to-guest-mode-handle-work \
ksym-vanilla-xfrm-aalg-get-byid \
ksym-vanilla-xfrm-aalg-get-byidx \
ksym-vanilla-xfrm-aalg-get-byname \
ksym-vanilla-xfrm-aead-get-byname \
ksym-vanilla-xfrm-alloc-spi \
ksym-vanilla-xfrm-audit-policy-add \
ksym-vanilla-xfrm-audit-policy-delete \
ksym-vanilla-xfrm-audit-state-add \
ksym-vanilla-xfrm-audit-state-delete \
ksym-vanilla-xfrm-audit-state-icvfail \
ksym-vanilla-xfrm-audit-state-notfound \
ksym-vanilla-xfrm-audit-state-notfound-simple \
ksym-vanilla-xfrm-audit-state-replay \
ksym-vanilla-xfrm-audit-state-replay-overflow \
ksym-vanilla-xfrm-bpf-md-dst \
ksym-vanilla-xfrm-calg-get-byid \
ksym-vanilla-xfrm-calg-get-byname \
ksym-vanilla-xfrm-count-pfkey-auth-supported \
ksym-vanilla-xfrm-count-pfkey-enc-supported \
ksym-vanilla-xfrm-dev-offload-ok \
ksym-vanilla-xfrm-dev-policy-add \
ksym-vanilla-xfrm-dev-policy-flush \
ksym-vanilla-xfrm-dev-resume \
ksym-vanilla-xfrm-dev-state-add \
ksym-vanilla-xfrm-dev-state-delete \
ksym-vanilla-xfrm-dev-state-flush \
ksym-vanilla-xfrm-dst-ifdown \
ksym-vanilla-xfrm-ealg-get-byid \
ksym-vanilla-xfrm-ealg-get-byidx \
ksym-vanilla-xfrm-ealg-get-byname \
ksym-vanilla-xfrm-find-acq \
ksym-vanilla-xfrm-find-acq-byseq \
ksym-vanilla-xfrm-flush-gc \
ksym-vanilla-xfrm-get-acqseq \
ksym-vanilla-xfrm-if-register-cb \
ksym-vanilla-xfrm-if-unregister-cb \
ksym-vanilla-xfrm-init-replay \
ksym-vanilla-xfrm-init-state \
ksym-vanilla-xfrm-input \
ksym-vanilla-xfrm-input-register-afinfo \
ksym-vanilla-xfrm-input-resume \
ksym-vanilla-xfrm-input-state-lookup \
ksym-vanilla-xfrm-input-unregister-afinfo \
ksym-vanilla-xfrm-local-error \
ksym-vanilla-xfrm-lookup \
ksym-vanilla-xfrm-lookup-route \
ksym-vanilla-xfrm-lookup-with-ifid \
ksym-vanilla-xfrm-migrate \
ksym-vanilla-xfrm-migrate-state-find \
ksym-vanilla-xfrm-msg-min \
ksym-vanilla-xfrm-nat-keepalive-fini \
ksym-vanilla-xfrm-nat-keepalive-init \
ksym-vanilla-xfrm-output \
ksym-vanilla-xfrm-output-resume \
ksym-vanilla-xfrm-parse-spi \
ksym-vanilla-xfrm-policy-alloc \
ksym-vanilla-xfrm-policy-byid \
ksym-vanilla-xfrm-policy-bysel-ctx \
ksym-vanilla-xfrm-policy-delete \
ksym-vanilla-xfrm-policy-destroy \
ksym-vanilla-xfrm-policy-flush \
ksym-vanilla-xfrm-policy-hash-rebuild \
ksym-vanilla-xfrm-policy-insert \
ksym-vanilla-xfrm-policy-register-afinfo \
ksym-vanilla-xfrm-policy-unregister-afinfo \
ksym-vanilla-xfrm-policy-walk \
ksym-vanilla-xfrm-policy-walk-done \
ksym-vanilla-xfrm-policy-walk-init \
ksym-vanilla-xfrm-probe-algs \
ksym-vanilla-xfrm-register-km \
ksym-vanilla-xfrm-register-mode-cbs \
ksym-vanilla-xfrm-register-type \
ksym-vanilla-xfrm-register-type-offload \
ksym-vanilla-xfrm-replay-seqhi \
ksym-vanilla-xfrm-sad-getinfo \
ksym-vanilla-xfrm-set-type-offload \
ksym-vanilla-xfrm-spd-getinfo \
ksym-vanilla-xfrm-state-add \
ksym-vanilla-xfrm-state-afinfo-get-rcu \
ksym-vanilla-xfrm-state-alloc \
ksym-vanilla-xfrm-state-check-expire \
ksym-vanilla-xfrm-state-delete \
ksym-vanilla-xfrm-state-flush \
ksym-vanilla-xfrm-state-free \
ksym-vanilla-xfrm-state-insert \
ksym-vanilla-xfrm-state-lookup \
ksym-vanilla-xfrm-state-lookup-byaddr \
ksym-vanilla-xfrm-state-lookup-byspi \
ksym-vanilla-xfrm-state-migrate \
ksym-vanilla-xfrm-state-migrate-create \
ksym-vanilla-xfrm-state-migrate-install \
ksym-vanilla-xfrm-state-mtu \
ksym-vanilla-xfrm-state-register-afinfo \
ksym-vanilla-xfrm-state-unregister-afinfo \
ksym-vanilla-xfrm-state-update \
ksym-vanilla-xfrm-state-walk \
ksym-vanilla-xfrm-state-walk-done \
ksym-vanilla-xfrm-state-walk-init \
ksym-vanilla-xfrm-stateonly-find \
ksym-vanilla-xfrm-trans-queue \
ksym-vanilla-xfrm-trans-queue-net \
ksym-vanilla-xfrm-unregister-km \
ksym-vanilla-xfrm-unregister-mode-cbs \
ksym-vanilla-xfrm-unregister-type \
ksym-vanilla-xfrm-unregister-type-offload \
ksym-vanilla-xfrm-user-policy \
ksym-vanilla-xfrm4-gro-udp-encap-rcv \
ksym-vanilla-xfrm4-protocol-deregister \
ksym-vanilla-xfrm4-protocol-register \
ksym-vanilla-xfrm4-rcv \
ksym-vanilla-xfrm4-rcv-encap \
ksym-vanilla-xfrm4-tunnel-check-size \
ksym-vanilla-xfrm4-tunnel-deregister \
ksym-vanilla-xfrm4-tunnel-register \
ksym-vanilla-xfrm4-udp-encap-rcv \
ksym-vanilla-xfrm6-input-addr \
ksym-vanilla-xfrm6-protocol-deregister \
ksym-vanilla-xfrm6-protocol-register \
ksym-vanilla-xfrm6-rcv \
ksym-vanilla-xfrm6-rcv-encap \
ksym-vanilla-xfrm6-rcv-spi \
ksym-vanilla-xfrm6-rcv-tnl \
ksym-vanilla-xfrm6-tunnel-alloc-spi \
ksym-vanilla-xfrm6-tunnel-check-size \
ksym-vanilla-xfrm6-tunnel-deregister \
ksym-vanilla-xfrm6-tunnel-register \
ksym-vanilla-xfrm6-tunnel-spi-lookup \
ksym-vanilla-xfrma-policy \
ksym-vanilla-xgene-enet-phy-register \
ksym-vanilla-xgene-mdio-rd-mac \
ksym-vanilla-xgene-mdio-rgmii-read \
ksym-vanilla-xgene-mdio-rgmii-write \
ksym-vanilla-xgene-mdio-wr-mac \
ksym-vanilla-xhci-add-endpoint \
ksym-vanilla-xhci-check-bandwidth \
ksym-vanilla-xhci-create-secondary-interrupter \
ksym-vanilla-xhci-dbg-trace \
ksym-vanilla-xhci-drop-endpoint \
ksym-vanilla-xhci-ext-cap-init \
ksym-vanilla-xhci-gen-setup \
ksym-vanilla-xhci-get-endpoint-index \
ksym-vanilla-xhci-get-ep-ctx \
ksym-vanilla-xhci-hub-control \
ksym-vanilla-xhci-init-driver \
ksym-vanilla-xhci-initialize-ring-info \
ksym-vanilla-xhci-msi-irq \
ksym-vanilla-xhci-pci-common-probe \
ksym-vanilla-xhci-pci-remove \
ksym-vanilla-xhci-plat-pm-ops \
ksym-vanilla-xhci-plat-probe \
ksym-vanilla-xhci-plat-remove \
ksym-vanilla-xhci-port-state-to-neutral \
ksym-vanilla-xhci-portsc-readl \
ksym-vanilla-xhci-portsc-writel \
ksym-vanilla-xhci-remove-secondary-interrupter \
ksym-vanilla-xhci-reset-bandwidth \
ksym-vanilla-xhci-resume \
ksym-vanilla-xhci-run \
ksym-vanilla-xhci-shutdown \
ksym-vanilla-xhci-sideband-add-endpoint \
ksym-vanilla-xhci-sideband-check \
ksym-vanilla-xhci-sideband-create-interrupter \
ksym-vanilla-xhci-sideband-get-endpoint-buffer \
ksym-vanilla-xhci-sideband-get-event-buffer \
ksym-vanilla-xhci-sideband-interrupter-id \
ksym-vanilla-xhci-sideband-notify-ep-ring-free \
ksym-vanilla-xhci-sideband-register \
ksym-vanilla-xhci-sideband-remove-endpoint \
ksym-vanilla-xhci-sideband-remove-interrupter \
ksym-vanilla-xhci-sideband-stop-endpoint \
ksym-vanilla-xhci-sideband-unregister \
ksym-vanilla-xhci-stop \
ksym-vanilla-xhci-stop-endpoint-sync \
ksym-vanilla-xhci-suspend \
ksym-vanilla-xhci-update-hub-device \
ksym-vanilla-xilinx-core-probe \
ksym-vanilla-xilinx-vdma-channel-set-config \
ksym-vanilla-xillybus-cleanup-chrdev \
ksym-vanilla-xillybus-endpoint-discovery \
ksym-vanilla-xillybus-endpoint-remove \
ksym-vanilla-xillybus-find-inode \
ksym-vanilla-xillybus-init-chrdev \
ksym-vanilla-xillybus-init-endpoint \
ksym-vanilla-xillybus-isr \
ksym-vanilla-xlnx-get-crypto-dev-data \
ksym-vanilla-xlnx-register-event \
ksym-vanilla-xlnx-unregister-event \
ksym-vanilla-xor-gen \
ksym-vanilla-xp-alloc \
ksym-vanilla-xp-alloc-batch \
ksym-vanilla-xp-can-alloc \
ksym-vanilla-xp-dma-map \
ksym-vanilla-xp-dma-unmap \
ksym-vanilla-xp-fill-cb \
ksym-vanilla-xp-free \
ksym-vanilla-xp-raw-get-ctx \
ksym-vanilla-xp-raw-get-data \
ksym-vanilla-xp-raw-get-dma \
ksym-vanilla-xp-set-rxq-info \
ksym-vanilla-xpcs-config-eee-mult-fact \
ksym-vanilla-xpcs-create-fwnode \
ksym-vanilla-xpcs-create-mdiodev \
ksym-vanilla-xpcs-create-pcs-mdiodev \
ksym-vanilla-xpcs-destroy \
ksym-vanilla-xpcs-destroy-pcs \
ksym-vanilla-xpcs-get-an-mode \
ksym-vanilla-xpcs-to-phylink-pcs \
ksym-vanilla-xprt-add-backlog \
ksym-vanilla-xprt-add-backlog-noncongested \
ksym-vanilla-xprt-adjust-cwnd \
ksym-vanilla-xprt-alloc \
ksym-vanilla-xprt-alloc-slot \
ksym-vanilla-xprt-complete-rqst \
ksym-vanilla-xprt-destroy-backchannel \
ksym-vanilla-xprt-disconnect-done \
ksym-vanilla-xprt-enqueue-bc-request \
ksym-vanilla-xprt-find-transport-ident \
ksym-vanilla-xprt-force-disconnect \
ksym-vanilla-xprt-free \
ksym-vanilla-xprt-free-slot \
ksym-vanilla-xprt-get \
ksym-vanilla-xprt-lock-connect \
ksym-vanilla-xprt-lookup-rqst \
ksym-vanilla-xprt-pin-rqst \
ksym-vanilla-xprt-put \
ksym-vanilla-xprt-reconnect-backoff \
ksym-vanilla-xprt-reconnect-delay \
ksym-vanilla-xprt-register-transport \
ksym-vanilla-xprt-release-rqst-cong \
ksym-vanilla-xprt-release-xprt \
ksym-vanilla-xprt-release-xprt-cong \
ksym-vanilla-xprt-request-get-cong \
ksym-vanilla-xprt-reserve-xprt \
ksym-vanilla-xprt-reserve-xprt-cong \
ksym-vanilla-xprt-setup-backchannel \
ksym-vanilla-xprt-svc-destroy-nullify-bc \
ksym-vanilla-xprt-svc-shutdown-bc \
ksym-vanilla-xprt-unlock-connect \
ksym-vanilla-xprt-unpin-rqst \
ksym-vanilla-xprt-unregister-transport \
ksym-vanilla-xprt-update-rtt \
ksym-vanilla-xprt-wait-for-buffer-space \
ksym-vanilla-xprt-wait-for-reply-request-def \
ksym-vanilla-xprt-wait-for-reply-request-rtt \
ksym-vanilla-xprt-wake-pending-tasks \
ksym-vanilla-xprt-wake-up-backlog \
ksym-vanilla-xprt-write-space \
ksym-vanilla-xprtiod-workqueue \
ksym-vanilla-xrs7003e-info \
ksym-vanilla-xrs7003f-info \
ksym-vanilla-xrs7004e-info \
ksym-vanilla-xrs7004f-info \
ksym-vanilla-xrs700x-switch-alloc \
ksym-vanilla-xrs700x-switch-register \
ksym-vanilla-xrs700x-switch-remove \
ksym-vanilla-xrs700x-switch-shutdown \
ksym-vanilla-xsk-clear-rx-need-wakeup \
ksym-vanilla-xsk-clear-tx-need-wakeup \
ksym-vanilla-xsk-get-pool-from-qid \
ksym-vanilla-xsk-set-rx-need-wakeup \
ksym-vanilla-xsk-set-tx-need-wakeup \
ksym-vanilla-xsk-tx-completed \
ksym-vanilla-xsk-tx-peek-desc \
ksym-vanilla-xsk-tx-peek-release-desc-batch \
ksym-vanilla-xsk-tx-release \
ksym-vanilla-xsk-uses-need-wakeup \
ksym-vanilla-xspi-dirmap-write \
ksym-vanilla-xt-alloc-entry-offsets \
ksym-vanilla-xt-alloc-table-info \
ksym-vanilla-xt-check-entry-offsets \
ksym-vanilla-xt-check-hooks-match \
ksym-vanilla-xt-check-hooks-target \
ksym-vanilla-xt-check-match \
ksym-vanilla-xt-check-proc-name \
ksym-vanilla-xt-check-table-hooks \
ksym-vanilla-xt-check-target \
ksym-vanilla-xt-compat-add-offset \
ksym-vanilla-xt-compat-calc-jump \
ksym-vanilla-xt-compat-check-entry-offsets \
ksym-vanilla-xt-compat-flush-offsets \
ksym-vanilla-xt-compat-init-offsets \
ksym-vanilla-xt-compat-lock \
ksym-vanilla-xt-compat-match-from-user \
ksym-vanilla-xt-compat-match-offset \
ksym-vanilla-xt-compat-match-to-user \
ksym-vanilla-xt-compat-target-from-user \
ksym-vanilla-xt-compat-target-offset \
ksym-vanilla-xt-compat-target-to-user \
ksym-vanilla-xt-compat-unlock \
ksym-vanilla-xt-copy-counters \
ksym-vanilla-xt-counters-alloc \
ksym-vanilla-xt-data-to-user \
ksym-vanilla-xt-find-jump-offset \
ksym-vanilla-xt-find-match \
ksym-vanilla-xt-find-revision \
ksym-vanilla-xt-find-table \
ksym-vanilla-xt-find-table-lock \
ksym-vanilla-xt-free-table-info \
ksym-vanilla-xt-hook-ops-alloc \
ksym-vanilla-xt-match-to-user \
ksym-vanilla-xt-percpu-counter-alloc \
ksym-vanilla-xt-percpu-counter-free \
ksym-vanilla-xt-proto-fini \
ksym-vanilla-xt-proto-init \
ksym-vanilla-xt-rateest-lookup \
ksym-vanilla-xt-rateest-put \
ksym-vanilla-xt-recseq \
ksym-vanilla-xt-register-match \
ksym-vanilla-xt-register-matches \
ksym-vanilla-xt-register-table \
ksym-vanilla-xt-register-target \
ksym-vanilla-xt-register-targets \
ksym-vanilla-xt-register-template \
ksym-vanilla-xt-replace-table \
ksym-vanilla-xt-request-find-match \
ksym-vanilla-xt-request-find-table-lock \
ksym-vanilla-xt-request-find-target \
ksym-vanilla-xt-table-unlock \
ksym-vanilla-xt-target-to-user \
ksym-vanilla-xt-tee-enabled \
ksym-vanilla-xt-unregister-match \
ksym-vanilla-xt-unregister-matches \
ksym-vanilla-xt-unregister-table-exit \
ksym-vanilla-xt-unregister-table-pre-exit \
ksym-vanilla-xt-unregister-target \
ksym-vanilla-xt-unregister-targets \
ksym-vanilla-xt-unregister-template \
ksym-vanilla-xvip-cleanup-resources \
ksym-vanilla-xvip-clr-and-set \
ksym-vanilla-xvip-clr-or-set \
ksym-vanilla-xvip-enum-frame-size \
ksym-vanilla-xvip-enum-mbus-code \
ksym-vanilla-xvip-get-format-by-code \
ksym-vanilla-xvip-get-format-by-fourcc \
ksym-vanilla-xvip-init-resources \
ksym-vanilla-xvip-of-get-format \
ksym-vanilla-xvip-set-format-size \
ksym-vanilla-xvtc-generator-start \
ksym-vanilla-xvtc-generator-stop \
ksym-vanilla-xvtc-of-get \
ksym-vanilla-xvtc-put \
ksym-vanilla-xxh32 \
ksym-vanilla-xxh64 \
ksym-vanilla-xxh64-digest \
ksym-vanilla-xxh64-reset \
ksym-vanilla-xxh64-update \
ksym-vanilla-xz-dec-end \
ksym-vanilla-xz-dec-init \
ksym-vanilla-xz-dec-microlzma-alloc \
ksym-vanilla-xz-dec-microlzma-end \
ksym-vanilla-xz-dec-microlzma-reset \
ksym-vanilla-xz-dec-microlzma-run \
ksym-vanilla-xz-dec-reset \
ksym-vanilla-xz-dec-run \
ksym-vanilla-yield \
ksym-vanilla-yield-to \
ksym-vanilla-yoga-c630-ec-read16 \
ksym-vanilla-yoga-c630-ec-read8 \
ksym-vanilla-yoga-c630-ec-register-notify \
ksym-vanilla-yoga-c630-ec-ucsi-get-version \
ksym-vanilla-yoga-c630-ec-ucsi-read \
ksym-vanilla-yoga-c630-ec-ucsi-write \
ksym-vanilla-yoga-c630-ec-unregister-notify \
ksym-vanilla-zap-special-vma-range \
ksym-vanilla-zd1301-demod-get-dvb-frontend \
ksym-vanilla-zd1301-demod-get-i2c-adapter \
ksym-vanilla-zero-fill-bio \
ksym-vanilla-zero-page-pfn \
ksym-vanilla-zerocopy-sg-from-iter \
ksym-vanilla-zgid \
ksym-vanilla-zl10036-attach \
ksym-vanilla-zl10039-attach \
ksym-vanilla-zl10353-attach \
ksym-vanilla-zl3073x-dev-probe \
ksym-vanilla-zl3073x-devm-alloc \
ksym-vanilla-zl3073x-regmap-config \
ksym-vanilla-zlib-deflate \
ksym-vanilla-zlib-deflate-dfltcc-enabled \
ksym-vanilla-zlib-deflate-workspacesize \
ksym-vanilla-zlib-deflateEnd \
ksym-vanilla-zlib-deflateInit2 \
ksym-vanilla-zlib-deflateReset \
ksym-vanilla-zlib-inflate \
ksym-vanilla-zlib-inflate-blob \
ksym-vanilla-zlib-inflate-workspacesize \
ksym-vanilla-zlib-inflateEnd \
ksym-vanilla-zlib-inflateIncomp \
ksym-vanilla-zlib-inflateInit2 \
ksym-vanilla-zlib-inflateReset \
ksym-vanilla-zone-device-page-init \
ksym-vanilla-zpa2326-isreg-precious \
ksym-vanilla-zpa2326-isreg-readable \
ksym-vanilla-zpa2326-isreg-writeable \
ksym-vanilla-zpa2326-pm-ops \
ksym-vanilla-zpa2326-probe \
ksym-vanilla-zpa2326-remove \
ksym-vanilla-zs-compact \
ksym-vanilla-zs-create-pool \
ksym-vanilla-zs-destroy-pool \
ksym-vanilla-zs-free \
ksym-vanilla-zs-get-total-pages \
ksym-vanilla-zs-huge-class-size \
ksym-vanilla-zs-lookup-class-index \
ksym-vanilla-zs-malloc \
ksym-vanilla-zs-obj-read-begin \
ksym-vanilla-zs-obj-read-end \
ksym-vanilla-zs-obj-read-sg-begin \
ksym-vanilla-zs-obj-read-sg-end \
ksym-vanilla-zs-obj-write \
ksym-vanilla-zs-pool-stats \
ksym-vanilla-zstd-cctx-set-param \
ksym-vanilla-zstd-cctx-workspace-bound \
ksym-vanilla-zstd-cctx-workspace-bound-with-ext-seq-prod \
ksym-vanilla-zstd-compress-bound \
ksym-vanilla-zstd-compress-cctx \
ksym-vanilla-zstd-compress-sequences-and-literals \
ksym-vanilla-zstd-compress-stream \
ksym-vanilla-zstd-compress-using-cdict \
ksym-vanilla-zstd-create-cctx-advanced \
ksym-vanilla-zstd-create-cdict-byreference \
ksym-vanilla-zstd-create-dctx-advanced \
ksym-vanilla-zstd-create-ddict-byreference \
ksym-vanilla-zstd-cstream-workspace-bound \
ksym-vanilla-zstd-cstream-workspace-bound-with-ext-seq-prod \
ksym-vanilla-zstd-dctx-workspace-bound \
ksym-vanilla-zstd-decompress-dctx \
ksym-vanilla-zstd-decompress-stream \
ksym-vanilla-zstd-decompress-using-ddict \
ksym-vanilla-zstd-default-clevel \
ksym-vanilla-zstd-dstream-workspace-bound \
ksym-vanilla-zstd-end-stream \
ksym-vanilla-zstd-find-frame-compressed-size \
ksym-vanilla-zstd-flush-stream \
ksym-vanilla-zstd-free-cctx \
ksym-vanilla-zstd-free-cdict \
ksym-vanilla-zstd-free-dctx \
ksym-vanilla-zstd-free-ddict \
ksym-vanilla-zstd-get-cparams \
ksym-vanilla-zstd-get-error-code \
ksym-vanilla-zstd-get-error-name \
ksym-vanilla-zstd-get-frame-header \
ksym-vanilla-zstd-get-params \
ksym-vanilla-zstd-init-cctx \
ksym-vanilla-zstd-init-cstream \
ksym-vanilla-zstd-init-dctx \
ksym-vanilla-zstd-init-dstream \
ksym-vanilla-zstd-is-error \
ksym-vanilla-zstd-max-clevel \
ksym-vanilla-zstd-min-clevel \
ksym-vanilla-zstd-register-sequence-producer \
ksym-vanilla-zstd-reset-cstream \
ksym-vanilla-zstd-reset-dstream \
ksym-vanilla-zynqmp-pm-aes-engine \
ksym-vanilla-zynqmp-pm-bootmode-read \
ksym-vanilla-zynqmp-pm-bootmode-write \
ksym-vanilla-zynqmp-pm-clock-disable \
ksym-vanilla-zynqmp-pm-clock-enable \
ksym-vanilla-zynqmp-pm-clock-getdivider \
ksym-vanilla-zynqmp-pm-clock-getparent \
ksym-vanilla-zynqmp-pm-clock-getstate \
ksym-vanilla-zynqmp-pm-clock-setdivider \
ksym-vanilla-zynqmp-pm-clock-setparent \
ksym-vanilla-zynqmp-pm-efuse-access \
ksym-vanilla-zynqmp-pm-feature \
ksym-vanilla-zynqmp-pm-force-pwrdwn \
ksym-vanilla-zynqmp-pm-fpga-get-config-status \
ksym-vanilla-zynqmp-pm-fpga-get-status \
ksym-vanilla-zynqmp-pm-fpga-load \
ksym-vanilla-zynqmp-pm-get-api-version \
ksym-vanilla-zynqmp-pm-get-chipid \
ksym-vanilla-zynqmp-pm-get-family-info \
ksym-vanilla-zynqmp-pm-get-node-status \
ksym-vanilla-zynqmp-pm-get-pll-frac-data \
ksym-vanilla-zynqmp-pm-get-pll-frac-mode \
ksym-vanilla-zynqmp-pm-get-rpu-mode \
ksym-vanilla-zynqmp-pm-get-rpu-node-status \
ksym-vanilla-zynqmp-pm-get-ufs-calibration-values \
ksym-vanilla-zynqmp-pm-is-function-supported \
ksym-vanilla-zynqmp-pm-is-mphy-tx-rx-config-ready \
ksym-vanilla-zynqmp-pm-is-sram-init-done \
ksym-vanilla-zynqmp-pm-load-pdi \
ksym-vanilla-zynqmp-pm-ospi-mux-select \
ksym-vanilla-zynqmp-pm-pinctrl-get-config \
ksym-vanilla-zynqmp-pm-pinctrl-release \
ksym-vanilla-zynqmp-pm-pinctrl-request \
ksym-vanilla-zynqmp-pm-pinctrl-set-config \
ksym-vanilla-zynqmp-pm-pinctrl-set-function \
ksym-vanilla-zynqmp-pm-query-data \
ksym-vanilla-zynqmp-pm-read-ggs \
ksym-vanilla-zynqmp-pm-read-pggs \
ksym-vanilla-zynqmp-pm-register-notifier \
ksym-vanilla-zynqmp-pm-release-node \
ksym-vanilla-zynqmp-pm-request-node \
ksym-vanilla-zynqmp-pm-request-wake \
ksym-vanilla-zynqmp-pm-reset-assert \
ksym-vanilla-zynqmp-pm-reset-get-status \
ksym-vanilla-zynqmp-pm-sd-dll-reset \
ksym-vanilla-zynqmp-pm-sec-mask-write-reg \
ksym-vanilla-zynqmp-pm-sec-read-reg \
ksym-vanilla-zynqmp-pm-set-gem-config \
ksym-vanilla-zynqmp-pm-set-pll-frac-data \
ksym-vanilla-zynqmp-pm-set-pll-frac-mode \
ksym-vanilla-zynqmp-pm-set-requirement \
ksym-vanilla-zynqmp-pm-set-rpu-mode \
ksym-vanilla-zynqmp-pm-set-sd-config \
ksym-vanilla-zynqmp-pm-set-sd-tapdelay \
ksym-vanilla-zynqmp-pm-set-sram-bypass \
ksym-vanilla-zynqmp-pm-set-suspend-mode \
ksym-vanilla-zynqmp-pm-set-tapdelay-bypass \
ksym-vanilla-zynqmp-pm-set-tcm-config \
ksym-vanilla-zynqmp-pm-sha-hash \
ksym-vanilla-zynqmp-pm-write-ggs \
ksym-vanilla-zynqmp-pm-write-pggs \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
awk \
coreutils \
distribution-release \
kmod-zstd \
modutils \
suse-kernel-rpm-scriptlets \
suse-module-tools"

inherit rpm
