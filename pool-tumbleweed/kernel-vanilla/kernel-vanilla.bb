SUMMARY = "The Standard Kernel - without any SUSE patches"
DESCRIPTION = "The standard kernel - without any SUSE patches \
 \
 \
Source Timestamp: 2026-09-12 06:50:42 +0000 \
GIT Revision: 6b7e8a968cce3b45e63d59e1d4981c9b7c5bc6b5 \
GIT Branch: stable"
LICENSE = "GPL-2.0-only"

PV = "7.2.5"

RPM_NAME = "kernel-vanilla-7.2.5-1.1.aarch64.rpm"
RPM_HASH = "ab7a176e03ef052de7e5705bf6c1f668a13b9e05077578c85ed1116ea07f2df4f77ddb77edf0e4effd4cd1efb41c5287d38ab1c3bbef6d3e7b38b0aca1833a68"

RPROVIDES:${PN} += "kernel \
kernel-base \
kernel-srchash-6b7e8a968cce3b45e63d59e1d4981c9b7c5bc6b5 \
kernel-uname-r \
kernel-vanilla \
kernel-vanilla-7.2.5-1 \
kernel-vanilla-aarch64 \
kernel-vanilla-base-srchash-6b7e8a968cce3b45e63d59e1d4981c9b7c5bc6b5 \
kernel-vanilla-srchash-6b7e8a968cce3b45e63d59e1d4981c9b7c5bc6b5 \
kmod-3c59x.ko \
kmod-3w-9xxx.ko \
kmod-3w-sas.ko \
kmod-3w-xxxx.ko \
kmod-6lowpan.ko \
kmod-8021q.ko \
kmod-8139cp.ko \
kmod-8139too.ko \
kmod-8250-aspeed-vuart.ko \
kmod-8250-base.ko \
kmod-8250-bcm2835aux.ko \
kmod-8250-bcm7271.ko \
kmod-8250-dfl.ko \
kmod-8250-dw.ko \
kmod-8250-em.ko \
kmod-8250-exar.ko \
kmod-8250-fsl.ko \
kmod-8250-keba.ko \
kmod-8250-mtk.ko \
kmod-8250-of.ko \
kmod-8250-pci.ko \
kmod-8250-pci1xxxx.ko \
kmod-8250-pericom.ko \
kmod-8250-pxa.ko \
kmod-8250-tegra.ko \
kmod-8250.ko \
kmod-8255.ko \
kmod-8390.ko \
kmod-842-compress.ko \
kmod-842-decompress.ko \
kmod-88pg86x.ko \
kmod-9p.ko \
kmod-9pnet-fd.ko \
kmod-9pnet-rdma.ko \
kmod-9pnet-virtio.ko \
kmod-9pnet.ko \
kmod-BusLogic.ko \
kmod-a1-peripherals.ko \
kmod-a1-pll.ko \
kmod-a100u2w.ko \
kmod-a53-pll.ko \
kmod-a7-pll.ko \
kmod-a72-edac.ko \
kmod-a8293.ko \
kmod-aacraid.ko \
kmod-abp060mg.ko \
kmod-abp2030pa-i2c.ko \
kmod-abp2030pa-spi.ko \
kmod-abp2030pa.ko \
kmod-ac.ko \
kmod-ac100.ko \
kmod-ac97-bus.ko \
kmod-acard-ahci.ko \
kmod-acbel-fsg032.ko \
kmod-acecad.ko \
kmod-acer-aspire1-ec.ko \
kmod-acp-audio-dma.ko \
kmod-acpi-configfs.ko \
kmod-acpi-ipmi.ko \
kmod-acpi-mdio.ko \
kmod-acpi-tad.ko \
kmod-acpiphp-ampere-altra.ko \
kmod-act-bpf.ko \
kmod-act-connmark.ko \
kmod-act-csum.ko \
kmod-act-ct.ko \
kmod-act-ctinfo.ko \
kmod-act-gact.ko \
kmod-act-gate.ko \
kmod-act-ife.ko \
kmod-act-meta-mark.ko \
kmod-act-meta-skbprio.ko \
kmod-act-meta-skbtcindex.ko \
kmod-act-mirred.ko \
kmod-act-mpls.ko \
kmod-act-nat.ko \
kmod-act-pedit.ko \
kmod-act-police.ko \
kmod-act-sample.ko \
kmod-act-simple.ko \
kmod-act-skbedit.ko \
kmod-act-skbmod.ko \
kmod-act-tunnel-key.ko \
kmod-act-vlan.ko \
kmod-ad-sigma-delta.ko \
kmod-ad3530r.ko \
kmod-ad3552r-common.ko \
kmod-ad3552r-hs.ko \
kmod-ad4000.ko \
kmod-ad4030.ko \
kmod-ad4062.ko \
kmod-ad4080.ko \
kmod-ad4134.ko \
kmod-ad4170-4.ko \
kmod-ad4691.ko \
kmod-ad4695.ko \
kmod-ad4851.ko \
kmod-ad525x-dpot-i2c.ko \
kmod-ad525x-dpot.ko \
kmod-ad5272.ko \
kmod-ad5592r-base.ko \
kmod-ad5592r.ko \
kmod-ad5686-spi.ko \
kmod-ad5686.ko \
kmod-ad5696-i2c.ko \
kmod-ad5706r.ko \
kmod-ad5758.ko \
kmod-ad5761.ko \
kmod-ad5766.ko \
kmod-ad5770r.ko \
kmod-ad5820.ko \
kmod-ad7091r-base.ko \
kmod-ad7091r5.ko \
kmod-ad7124.ko \
kmod-ad714x-i2c.ko \
kmod-ad714x.ko \
kmod-ad7173.ko \
kmod-ad7191.ko \
kmod-ad7292.ko \
kmod-ad7405.ko \
kmod-ad7414.ko \
kmod-ad7418.ko \
kmod-ad7606-par.ko \
kmod-ad7606-spi.ko \
kmod-ad7606.ko \
kmod-ad7625.ko \
kmod-ad7766.ko \
kmod-ad7768-1.ko \
kmod-ad7779.ko \
kmod-ad7879-i2c.ko \
kmod-ad7879.ko \
kmod-ad7944.ko \
kmod-ad7949.ko \
kmod-ad8460.ko \
kmod-ad8801.ko \
kmod-ad9467.ko \
kmod-ad9739a.ko \
kmod-ada4250.ko \
kmod-adafruit-seesaw.ko \
kmod-adc-battery-helper.ko \
kmod-adc-joystick.ko \
kmod-adc128d818.ko \
kmod-ade9000.ko \
kmod-adf4371.ko \
kmod-adf7242.ko \
kmod-adfs.ko \
kmod-adi-axi-adc.ko \
kmod-adi-axi-dac.ko \
kmod-adi-i3c-master.ko \
kmod-adiantum.ko \
kmod-adin.ko \
kmod-adin1100.ko \
kmod-adin1110.ko \
kmod-adis-lib.ko \
kmod-adis16460.ko \
kmod-adis16475.ko \
kmod-adis16550.ko \
kmod-adl8113.ko \
kmod-adm1025.ko \
kmod-adm1026.ko \
kmod-adm1029.ko \
kmod-adm1031.ko \
kmod-adm1177.ko \
kmod-adm1266.ko \
kmod-adm1275.ko \
kmod-adm8211.ko \
kmod-adm9240.ko \
kmod-admfm2000.ko \
kmod-admv1014.ko \
kmod-admv4420.ko \
kmod-adp1050.ko \
kmod-adp1653.ko \
kmod-adp5055-regulator.ko \
kmod-adp5061.ko \
kmod-adp5585-keys.ko \
kmod-adp5585.ko \
kmod-adp5588-keys.ko \
kmod-adp8860-bl.ko \
kmod-adp8870-bl.ko \
kmod-adpdrm-mipi.ko \
kmod-adpdrm.ko \
kmod-adrf6780.ko \
kmod-ads7828.ko \
kmod-ads7846.ko \
kmod-adt7410.ko \
kmod-adt7411.ko \
kmod-adt7462.ko \
kmod-adt7470.ko \
kmod-adt7475.ko \
kmod-adt7x10.ko \
kmod-adutux.ko \
kmod-adux1020.ko \
kmod-adv7170.ko \
kmod-adv7175.ko \
kmod-adv7180.ko \
kmod-adv7183.ko \
kmod-adv7343.ko \
kmod-adv7393.ko \
kmod-adv748x.ko \
kmod-adv7511.ko \
kmod-adv7604.ko \
kmod-adv7842.ko \
kmod-advansys.ko \
kmod-adxl313-core.ko \
kmod-adxl313-i2c.ko \
kmod-adxl313-spi.ko \
kmod-adxl345-core.ko \
kmod-adxl345-i2c.ko \
kmod-adxl345-spi.ko \
kmod-adxl34x-i2c.ko \
kmod-adxl34x-spi.ko \
kmod-adxl34x.ko \
kmod-adxl355-core.ko \
kmod-adxl355-i2c.ko \
kmod-adxl355-spi.ko \
kmod-adxl367-i2c.ko \
kmod-adxl367-spi.ko \
kmod-adxl367.ko \
kmod-adxl372-i2c.ko \
kmod-adxl372-spi.ko \
kmod-adxl372.ko \
kmod-adxl380-i2c.ko \
kmod-adxl380-spi.ko \
kmod-adxl380.ko \
kmod-aead.ko \
kmod-aegis128.ko \
kmod-aer-inject.ko \
kmod-aes-ce-blk.ko \
kmod-aes-ce-ccm.ko \
kmod-aes-neon-blk.ko \
kmod-aes-neon-bs.ko \
kmod-aes.ko \
kmod-af-alg.ko \
kmod-af-key.ko \
kmod-af-packet-diag.ko \
kmod-af-packet.ko \
kmod-af9013.ko \
kmod-af9033.ko \
kmod-afe4403.ko \
kmod-afe4404.ko \
kmod-affs.ko \
kmod-afs.ko \
kmod-ah4.ko \
kmod-ah6.ko \
kmod-ahci-brcm.ko \
kmod-ahci-ceva.ko \
kmod-ahci-dwc.ko \
kmod-ahci-imx.ko \
kmod-ahci-mtk.ko \
kmod-ahci-mvebu.ko \
kmod-ahci-platform.ko \
kmod-ahci-qoriq.ko \
kmod-ahci-seattle.ko \
kmod-ahci-sunxi.ko \
kmod-ahci-tegra.ko \
kmod-ahci-xgene.ko \
kmod-ahci.ko \
kmod-aht10.ko \
kmod-aic79xx.ko \
kmod-aic7xxx.ko \
kmod-aic94xx.ko \
kmod-aiptek.ko \
kmod-air-an8801.ko \
kmod-air-en8811h.ko \
kmod-air-phy-lib.ko \
kmod-aircable.ko \
kmod-airoha-cpu-pmdomain.ko \
kmod-airoha-cpufreq.ko \
kmod-airoha-thermal.ko \
kmod-airoha-trng.ko \
kmod-airspy.ko \
kmod-ak7375.ko \
kmod-ak881x.ko \
kmod-ak8974.ko \
kmod-akcipher.ko \
kmod-al-mc-edac.ko \
kmod-al3000a.ko \
kmod-al3010.ko \
kmod-alcor-pci.ko \
kmod-alcor.ko \
kmod-algif-aead.ko \
kmod-algif-hash.ko \
kmod-algif-rng.ko \
kmod-algif-skcipher.ko \
kmod-alibaba-uncore-drw-pmu.ko \
kmod-alim7101-wdt.ko \
kmod-allegro.ko \
kmod-als31300.ko \
kmod-altera-ci.ko \
kmod-altera-cvp.ko \
kmod-altera-fpga2sdram.ko \
kmod-altera-freeze-bridge.ko \
kmod-altera-hps2fpga.ko \
kmod-altera-msgdma.ko \
kmod-altera-pr-ip-core-plat.ko \
kmod-altera-pr-ip-core.ko \
kmod-altera-ps-spi.ko \
kmod-altera-ps2.ko \
kmod-altera-stapl.ko \
kmod-alvium-csi2.ko \
kmod-alx.ko \
kmod-am2315.ko \
kmod-am53c974.ko \
kmod-amba-pl010.ko \
kmod-amba-pl011.ko \
kmod-amc6821.ko \
kmod-amd-axi-w1.ko \
kmod-amd-isp4-capture.ko \
kmod-amd-xgbe.ko \
kmod-amd.ko \
kmod-amd8111e.ko \
kmod-amdgpu.ko \
kmod-amdxcp.ko \
kmod-amlogic-gxl-crypto.ko \
kmod-amlogic-thermal.ko \
kmod-amphion-vpu.ko \
kmod-ams-iaq-core.ko \
kmod-amt.ko \
kmod-analogix-anx6345.ko \
kmod-analogix-anx78xx.ko \
kmod-analogix-dp.ko \
kmod-anx7411.ko \
kmod-anx7625.ko \
kmod-ao-cec-g12a.ko \
kmod-ao-cec.ko \
kmod-aoe.ko \
kmod-apbps2.ko \
kmod-apcs-msm8916.ko \
kmod-apcs-msm8996.ko \
kmod-apds9160.ko \
kmod-apds9306.ko \
kmod-apds9960.ko \
kmod-apds9999.ko \
kmod-apple-admac.ko \
kmod-apple-dart.ko \
kmod-apple-dwi-bl.ko \
kmod-apple-mailbox.ko \
kmod-apple-mfi-fastcharge.ko \
kmod-apple-nvmem-spmi.ko \
kmod-apple-rtkit.ko \
kmod-apple-sart.ko \
kmod-apple-soc-cpufreq.ko \
kmod-apple-tunable.ko \
kmod-apple-wdt.ko \
kmod-apple-z2.ko \
kmod-appledisplay.ko \
kmod-appletouch.ko \
kmod-apr.ko \
kmod-aps-379.ko \
kmod-apss-ipq-pll.ko \
kmod-apss-ipq5424.ko \
kmod-apss-ipq6018.ko \
kmod-aptina-pll.ko \
kmod-aqc111.ko \
kmod-aquacomputer-d5next.ko \
kmod-aquantia.ko \
kmod-ar0521.ko \
kmod-ar1021-i2c.ko \
kmod-ar5523.ko \
kmod-arasan-nand-controller.ko \
kmod-arcmsr.ko \
kmod-arctic-fan-controller.ko \
kmod-arcxcnn-bl.ko \
kmod-aria-generic.ko \
kmod-arizona-ldo1.ko \
kmod-arizona-micsupp.ko \
kmod-ark3116.ko \
kmod-arm-cca-guest.ko \
kmod-arm-cci.ko \
kmod-arm-ccn.ko \
kmod-arm-cmn.ko \
kmod-arm-dma350.ko \
kmod-arm-dmc620-pmu.ko \
kmod-arm-dsu-pmu.ko \
kmod-arm-mhuv2.ko \
kmod-arm-mhuv3.ko \
kmod-arm-ni.ko \
kmod-arm-scpi.ko \
kmod-arm-smc-wdt.ko \
kmod-arm-smccc-trng.ko \
kmod-arm-smmu-v3.ko \
kmod-arm-smmu.ko \
kmod-arm-smmuv3-pmu.ko \
kmod-arm-spe-pmu.ko \
kmod-arm-tstee.ko \
kmod-arm64-reloc-test.ko \
kmod-armada-37xx-cpufreq.ko \
kmod-armada-37xx-rwtm-mailbox.ko \
kmod-armada-37xx-wdt.ko \
kmod-armada-8k-cpufreq.ko \
kmod-armada-thermal.ko \
kmod-armmmci.ko \
kmod-arp-tables.ko \
kmod-arpt-mangle.ko \
kmod-arptable-filter.ko \
kmod-as102-fe.ko \
kmod-as21xxx.ko \
kmod-as370-hwmon.ko \
kmod-as5011.ko \
kmod-asc7621.ko \
kmod-ascot2e.ko \
kmod-asix.ko \
kmod-asn1-decoder.ko \
kmod-asn1-encoder.ko \
kmod-aspeed-acry.ko \
kmod-aspeed-adc.ko \
kmod-aspeed-crypto.ko \
kmod-aspeed-edac.ko \
kmod-aspeed-g6-pwm-tach.ko \
kmod-aspeed-gfx.ko \
kmod-aspeed-lpc-ctrl.ko \
kmod-aspeed-lpc-snoop.ko \
kmod-aspeed-p2a-ctrl.ko \
kmod-aspeed-pwm-tacho.ko \
kmod-aspeed-uart-routing.ko \
kmod-aspeed-udc.ko \
kmod-aspeed-vhub.ko \
kmod-aspeed-video.ko \
kmod-aspeed-wdt.ko \
kmod-ast.ko \
kmod-ast2600-i3c-master.ko \
kmod-ast2700-mailbox.ko \
kmod-asus-rog-ryujin.ko \
kmod-async-memcpy.ko \
kmod-async-pq.ko \
kmod-async-raid6-recov.ko \
kmod-async-tx.ko \
kmod-async-xor.ko \
kmod-at-xdmac.ko \
kmod-at24.ko \
kmod-at76c50x-usb.ko \
kmod-at803x.ko \
kmod-at91-usart.ko \
kmod-ata-generic.ko \
kmod-ata-piix.ko \
kmod-atbm8830.ko \
kmod-atc260x-core.ko \
kmod-atc260x-i2c.ko \
kmod-atc260x-onkey.ko \
kmod-atc260x-poweroff.ko \
kmod-atc260x-regulator.ko \
kmod-aten.ko \
kmod-ath.ko \
kmod-ath10k-core.ko \
kmod-ath10k-pci.ko \
kmod-ath10k-sdio.ko \
kmod-ath10k-snoc.ko \
kmod-ath10k-usb.ko \
kmod-ath11k-ahb.ko \
kmod-ath11k-pci.ko \
kmod-ath11k.ko \
kmod-ath12k-wifi7.ko \
kmod-ath12k.ko \
kmod-ath3k.ko \
kmod-ath5k.ko \
kmod-ath6kl-core.ko \
kmod-ath6kl-sdio.ko \
kmod-ath6kl-usb.ko \
kmod-ath9k-common.ko \
kmod-ath9k-htc.ko \
kmod-ath9k-hw.ko \
kmod-ath9k-pci-owl-loader.ko \
kmod-ath9k.ko \
kmod-ati-remote.ko \
kmod-ati-remote2.ko \
kmod-atkbd.ko \
kmod-atl1.ko \
kmod-atl1c.ko \
kmod-atl1e.ko \
kmod-atl2.ko \
kmod-atlantic.ko \
kmod-atlas-ezo-sensor.ko \
kmod-atlas-sensor.ko \
kmod-atm.ko \
kmod-atmel-aes.ko \
kmod-atmel-captouch.ko \
kmod-atmel-ecc.ko \
kmod-atmel-hlcdc.ko \
kmod-atmel-i2c.ko \
kmod-atmel-mxt-ts.ko \
kmod-atmel-rng.ko \
kmod-atmel-sha204a.ko \
kmod-atp870u.ko \
kmod-atxp1.ko \
kmod-au0828.ko \
kmod-au8522-common.ko \
kmod-au8522-decoder.ko \
kmod-au8522-dig.ko \
kmod-auo-pixcir-ts.ko \
kmod-auth-rpcgss.ko \
kmod-authenc.ko \
kmod-authencesn.ko \
kmod-autofs4.ko \
kmod-aux-bridge.ko \
kmod-aux-hpd-bridge.ko \
kmod-auxadc-thermal.ko \
kmod-aw37503-regulator.ko \
kmod-aw86927.ko \
kmod-aw96103.ko \
kmod-aw99706.ko \
kmod-ax88179-178a.ko \
kmod-ax88796b.ko \
kmod-ax88796c.ko \
kmod-axg-aoclk.ko \
kmod-axg-audio.ko \
kmod-axg.ko \
kmod-axi-fan-control.ko \
kmod-axis-fifo.ko \
kmod-axp20x-ac-power.ko \
kmod-axp20x-adc.ko \
kmod-axp20x-battery.ko \
kmod-axp20x-i2c.ko \
kmod-axp20x-pek.ko \
kmod-axp20x-regulator.ko \
kmod-axp20x-rsb.ko \
kmod-axp20x-usb-power.ko \
kmod-axp20x.ko \
kmod-axp288-adc.ko \
kmod-b2c2-flexcop-pci.ko \
kmod-b2c2-flexcop-usb.ko \
kmod-b2c2-flexcop.ko \
kmod-b43.ko \
kmod-b43legacy.ko \
kmod-b44.ko \
kmod-b53-common.ko \
kmod-b53-mdio.ko \
kmod-b53-mmap.ko \
kmod-b53-serdes.ko \
kmod-b53-spi.ko \
kmod-b53-srab.ko \
kmod-ba431-rng.ko \
kmod-backlight.ko \
kmod-bam-dma.ko \
kmod-bareudp.ko \
kmod-battery.ko \
kmod-bcache.ko \
kmod-bch.ko \
kmod-bcm-asp.ko \
kmod-bcm-crypto-spu.ko \
kmod-bcm-flexrm-mailbox.ko \
kmod-bcm-iproc-adc.ko \
kmod-bcm-iproc-tsc.ko \
kmod-bcm-pdc-mailbox.ko \
kmod-bcm-phy-lib.ko \
kmod-bcm-sba-raid.ko \
kmod-bcm-sf2.ko \
kmod-bcm-vk.ko \
kmod-bcm203x.ko \
kmod-bcm2711-thermal.ko \
kmod-bcm2835-dma.ko \
kmod-bcm2835-mailbox.ko \
kmod-bcm2835-mmal-vchiq.ko \
kmod-bcm2835-rng.ko \
kmod-bcm2835-thermal.ko \
kmod-bcm2835-unicam.ko \
kmod-bcm2835-wdt.ko \
kmod-bcm2835.ko \
kmod-bcm3510.ko \
kmod-bcm4908-enet.ko \
kmod-bcm54140.ko \
kmod-bcm5974.ko \
kmod-bcm63xx-uart.ko \
kmod-bcm7038-wdt.ko \
kmod-bcm74110-mailbox.ko \
kmod-bcm74110-rng.ko \
kmod-bcm7xxx.ko \
kmod-bcm84881.ko \
kmod-bcm87xx.ko \
kmod-bcma-hcd.ko \
kmod-bcma.ko \
kmod-bcmsysport.ko \
kmod-bd6107.ko \
kmod-bd71815-regulator.ko \
kmod-bd71828-power.ko \
kmod-bd71828-regulator.ko \
kmod-bd718x7-regulator.ko \
kmod-bd9571mwv-regulator.ko \
kmod-bd9571mwv.ko \
kmod-bd9576-regulator.ko \
kmod-bd9576-wdt.ko \
kmod-bd99954-charger.ko \
kmod-bdc.ko \
kmod-be2iscsi.ko \
kmod-be2net.ko \
kmod-befs.ko \
kmod-bel-pfe.ko \
kmod-belkin-sa.ko \
kmod-bfa.ko \
kmod-bfq.ko \
kmod-bfs.ko \
kmod-bfusb.ko \
kmod-bgmac-platform.ko \
kmod-bgmac.ko \
kmod-bh1745.ko \
kmod-bh1770glc.ko \
kmod-binfmt-misc.ko \
kmod-binfmt-script.ko \
kmod-blake2b.ko \
kmod-block2mtd.ko \
kmod-blocklayoutdriver.ko \
kmod-blowfish-common.ko \
kmod-blowfish-generic.ko \
kmod-bluefield-edac.ko \
kmod-bluetooth-6lowpan.ko \
kmod-bluetooth.ko \
kmod-bma150.ko \
kmod-bma220-core.ko \
kmod-bma220-i2c.ko \
kmod-bma220-spi.ko \
kmod-bma400-core.ko \
kmod-bma400-i2c.ko \
kmod-bma400-spi.ko \
kmod-bmc150-accel-core.ko \
kmod-bmc150-accel-i2c.ko \
kmod-bmc150-accel-spi.ko \
kmod-bme680-core.ko \
kmod-bme680-i2c.ko \
kmod-bme680-spi.ko \
kmod-bmi088-accel-core.ko \
kmod-bmi088-accel-i2c.ko \
kmod-bmi088-accel-spi.ko \
kmod-bmi160-core.ko \
kmod-bmi160-i2c.ko \
kmod-bmi160-spi.ko \
kmod-bmi270-core.ko \
kmod-bmi270-i2c.ko \
kmod-bmi270-spi.ko \
kmod-bmi323-core.ko \
kmod-bmi323-i2c.ko \
kmod-bmi323-spi.ko \
kmod-bmp280-i2c.ko \
kmod-bmp280-spi.ko \
kmod-bmp280.ko \
kmod-bna.ko \
kmod-bnep.ko \
kmod-bng-en.ko \
kmod-bng-re.ko \
kmod-bnx2.ko \
kmod-bnx2fc.ko \
kmod-bnx2i.ko \
kmod-bnx2x.ko \
kmod-bnxt-en.ko \
kmod-bnxt-fwctl.ko \
kmod-bnxt-re.ko \
kmod-bochs.ko \
kmod-bonding.ko \
kmod-bpa-rs600.ko \
kmod-bpa10x.ko \
kmod-bpck.ko \
kmod-bpck6.ko \
kmod-bpf-crypto-skcipher.ko \
kmod-bq24190-charger.ko \
kmod-bq24257-charger.ko \
kmod-bq24735-charger.ko \
kmod-bq2515x-charger.ko \
kmod-bq256xx-charger.ko \
kmod-bq257xx-charger.ko \
kmod-bq257xx-regulator.ko \
kmod-bq257xx.ko \
kmod-bq25890-charger.ko \
kmod-bq25980-charger.ko \
kmod-bq27xxx-battery-hdq.ko \
kmod-bq27xxx-battery-i2c.ko \
kmod-bq27xxx-battery.ko \
kmod-br-netfilter.ko \
kmod-br2684.ko \
kmod-brcmfmac-bca.ko \
kmod-brcmfmac-cyw.ko \
kmod-brcmfmac-wcc.ko \
kmod-brcmfmac.ko \
kmod-brcmsmac.ko \
kmod-brcmstb-avs-cpufreq.ko \
kmod-brcmstb-dpfe.ko \
kmod-brcmstb-gisb.ko \
kmod-brcmstb-memc.ko \
kmod-brcmstb-thermal.ko \
kmod-brcmstb-usb-pinmap.ko \
kmod-brcmutil.ko \
kmod-brd.ko \
kmod-bridge.ko \
kmod-broadcom.ko \
kmod-bsd-comp.ko \
kmod-bsg.ko \
kmod-bt-bmc.ko \
kmod-bt819.ko \
kmod-bt856.ko \
kmod-bt866.ko \
kmod-bt878.ko \
kmod-btbcm.ko \
kmod-btcoexist.ko \
kmod-btintel-pcie.ko \
kmod-btintel.ko \
kmod-btmrvl-sdio.ko \
kmod-btmrvl.ko \
kmod-btmtk.ko \
kmod-btmtksdio.ko \
kmod-btmtkuart.ko \
kmod-btnxpuart.ko \
kmod-btqca.ko \
kmod-btqcomsmd.ko \
kmod-btrfs.ko \
kmod-btrsi.ko \
kmod-btrtl.ko \
kmod-btsdio.ko \
kmod-bttv.ko \
kmod-btusb.ko \
kmod-bu21013-ts.ko \
kmod-bu21029-ts.ko \
kmod-buddy.ko \
kmod-budget-ci.ko \
kmod-budget-core.ko \
kmod-budget.ko \
kmod-button.ko \
kmod-bxcan.ko \
kmod-c-can-pci.ko \
kmod-c-can.ko \
kmod-c3-isp.ko \
kmod-c3-mipi-adap.ko \
kmod-c3-mipi-csi2.ko \
kmod-c3-peripherals.ko \
kmod-c3-pll.ko \
kmod-c67x00.ko \
kmod-ca8210.ko \
kmod-caam-jr.ko \
kmod-caam.ko \
kmod-caamalg-desc.ko \
kmod-caamhash-desc.ko \
kmod-cachefiles.ko \
kmod-cadence-nand-controller.ko \
kmod-cadence-wdt.ko \
kmod-cafe-ccic.ko \
kmod-cafe-nand.ko \
kmod-cambistmclkcc-kaanapali.ko \
kmod-cambistmclkcc-sm8750.ko \
kmod-camcc-kaanapali.ko \
kmod-camcc-milos.ko \
kmod-camcc-qcs615.ko \
kmod-camcc-sa8775p.ko \
kmod-camcc-sc7180.ko \
kmod-camcc-sc7280.ko \
kmod-camcc-sc8180x.ko \
kmod-camcc-sc8280xp.ko \
kmod-camcc-sdm845.ko \
kmod-camcc-sm4450.ko \
kmod-camcc-sm6350.ko \
kmod-camcc-sm7150.ko \
kmod-camcc-sm8150.ko \
kmod-camcc-sm8250.ko \
kmod-camcc-sm8450.ko \
kmod-camcc-sm8650.ko \
kmod-camcc-sm8750.ko \
kmod-camcc-x1e80100.ko \
kmod-camcc-x1p42100.ko \
kmod-camellia-generic.ko \
kmod-can-bcm.ko \
kmod-can-dev.ko \
kmod-can-gw.ko \
kmod-can-isotp.ko \
kmod-can-j1939.ko \
kmod-can-raw.ko \
kmod-can.ko \
kmod-can327.ko \
kmod-cap11xx.ko \
kmod-capsule-loader.ko \
kmod-carl9170.ko \
kmod-cassini.ko \
kmod-cast-common.ko \
kmod-cast5-generic.ko \
kmod-cast6-generic.ko \
kmod-catc.ko \
kmod-cavium-ptp.ko \
kmod-cavium-rng-vf.ko \
kmod-cavium-rng.ko \
kmod-cb710-mmc.ko \
kmod-cb710.ko \
kmod-cbc.ko \
kmod-cbmem.ko \
kmod-ccm.ko \
kmod-ccp-crypto.ko \
kmod-ccp.ko \
kmod-ccree.ko \
kmod-ccs-pll.ko \
kmod-ccs.ko \
kmod-ccs811.ko \
kmod-cctrng.ko \
kmod-cdc-acm.ko \
kmod-cdc-eem.ko \
kmod-cdc-ether.ko \
kmod-cdc-mbim.ko \
kmod-cdc-ncm.ko \
kmod-cdc-phonet.ko \
kmod-cdc-subset.ko \
kmod-cdc-wdm.ko \
kmod-cdns-csi2rx.ko \
kmod-cdns-csi2tx.ko \
kmod-cdns-dphy-rx.ko \
kmod-cdns-dphy.ko \
kmod-cdns-dsi.ko \
kmod-cdns-mhdp8546.ko \
kmod-cdns-pltfrm.ko \
kmod-cdns.ko \
kmod-cdns2-udc-pci.ko \
kmod-cdns3-imx.ko \
kmod-cdns3-pci-wrap.ko \
kmod-cdnsp-pci.ko \
kmod-cdrom.ko \
kmod-cdx-controller.ko \
kmod-cec-gpio.ko \
kmod-cec.ko \
kmod-ceph.ko \
kmod-cfbcopyarea.ko \
kmod-cfbfillrect.ko \
kmod-cfbimgblt.ko \
kmod-cfg80211.ko \
kmod-cfi-cmdset-0001.ko \
kmod-cfi-cmdset-0002.ko \
kmod-cfi-cmdset-0020.ko \
kmod-cfi-probe.ko \
kmod-cfi-util.ko \
kmod-ch-ipsec.ko \
kmod-ch-ktls.ko \
kmod-ch.ko \
kmod-ch341.ko \
kmod-ch7006.ko \
kmod-ch7322.ko \
kmod-ch9200.ko \
kmod-chacha.ko \
kmod-chacha20poly1305.ko \
kmod-chagall-battery.ko \
kmod-chaoskey.ko \
kmod-charlcd.ko \
kmod-charlieplex-keypad.ko \
kmod-chcr.ko \
kmod-chipcap2.ko \
kmod-chipone-icn6211.ko \
kmod-chipone-icn8318.ko \
kmod-chipone-icn8505.ko \
kmod-chipreg.ko \
kmod-chromeos-acpi.ko \
kmod-chromeos-of-hw-prober.ko \
kmod-chromeos-privacy-screen.ko \
kmod-chromeos-tbmc.ko \
kmod-chrontel-ch7033.ko \
kmod-chv3-i2s.ko \
kmod-ci-hdrc-imx.ko \
kmod-ci-hdrc-msm.ko \
kmod-ci-hdrc-npcm.ko \
kmod-ci-hdrc-pci.ko \
kmod-ci-hdrc-tegra.ko \
kmod-ci-hdrc-usb2.ko \
kmod-ci-hdrc.ko \
kmod-cicada.ko \
kmod-cifs-md4.ko \
kmod-cifs.ko \
kmod-cirrus-qemu.ko \
kmod-cix-mailbox.ko \
kmod-clk-apmixed.ko \
kmod-clk-apple-nco.ko \
kmod-clk-axi-clkgen.ko \
kmod-clk-bcm2711-dvp.ko \
kmod-clk-bd718x7.ko \
kmod-clk-cbf-8996.ko \
kmod-clk-cdce706.ko \
kmod-clk-cdce925.ko \
kmod-clk-cpu-8996.ko \
kmod-clk-cpu-dyndiv.ko \
kmod-clk-cpumux.ko \
kmod-clk-cs2000-cp.ko \
kmod-clk-dualdiv.ko \
kmod-clk-exynos-audss.ko \
kmod-clk-exynos-clkout.ko \
kmod-clk-fsl-flexspi.ko \
kmod-clk-gate.ko \
kmod-clk-hi3519.ko \
kmod-clk-hi655x.ko \
kmod-clk-imx-acm.ko \
kmod-clk-imx-lpcg-scu.ko \
kmod-clk-imx-scu.ko \
kmod-clk-imx8mm.ko \
kmod-clk-imx8mn.ko \
kmod-clk-imx8mp-audiomix.ko \
kmod-clk-imx8mp.ko \
kmod-clk-imx8mq.ko \
kmod-clk-imx8ulp-sim-lpav.ko \
kmod-clk-imx8ulp.ko \
kmod-clk-imx93.ko \
kmod-clk-imx95-blk-ctl.ko \
kmod-clk-lan966x.ko \
kmod-clk-lmk04832.ko \
kmod-clk-lochnagar.ko \
kmod-clk-ma35d1.ko \
kmod-clk-max77686.ko \
kmod-clk-max9485.ko \
kmod-clk-mpll.ko \
kmod-clk-mt2712-apmixedsys.ko \
kmod-clk-mt2712-bdp.ko \
kmod-clk-mt2712-img.ko \
kmod-clk-mt2712-jpgdec.ko \
kmod-clk-mt2712-mfg.ko \
kmod-clk-mt2712-mm.ko \
kmod-clk-mt2712-vdec.ko \
kmod-clk-mt2712-venc.ko \
kmod-clk-mt2712.ko \
kmod-clk-mt6735-apmixedsys.ko \
kmod-clk-mt6735-imgsys.ko \
kmod-clk-mt6735-infracfg.ko \
kmod-clk-mt6735-mfgcfg.ko \
kmod-clk-mt6735-pericfg.ko \
kmod-clk-mt6735-topckgen.ko \
kmod-clk-mt6735-vdecsys.ko \
kmod-clk-mt6735-vencsys.ko \
kmod-clk-mt6765-audio.ko \
kmod-clk-mt6765-cam.ko \
kmod-clk-mt6765-img.ko \
kmod-clk-mt6765-mipi0a.ko \
kmod-clk-mt6765-mm.ko \
kmod-clk-mt6765-vcodec.ko \
kmod-clk-mt6765.ko \
kmod-clk-mt6779-aud.ko \
kmod-clk-mt6779-cam.ko \
kmod-clk-mt6779-img.ko \
kmod-clk-mt6779-ipe.ko \
kmod-clk-mt6779-mfg.ko \
kmod-clk-mt6779-mm.ko \
kmod-clk-mt6779-vdec.ko \
kmod-clk-mt6779-venc.ko \
kmod-clk-mt6779.ko \
kmod-clk-mt6795-apmixedsys.ko \
kmod-clk-mt6795-infracfg.ko \
kmod-clk-mt6795-mfg.ko \
kmod-clk-mt6795-mm.ko \
kmod-clk-mt6795-pericfg.ko \
kmod-clk-mt6795-topckgen.ko \
kmod-clk-mt6795-vdecsys.ko \
kmod-clk-mt6795-vencsys.ko \
kmod-clk-mt6797-img.ko \
kmod-clk-mt6797-mm.ko \
kmod-clk-mt6797-vdec.ko \
kmod-clk-mt6797-venc.ko \
kmod-clk-mt6797.ko \
kmod-clk-mt7622-apmixedsys.ko \
kmod-clk-mt7622-aud.ko \
kmod-clk-mt7622-eth.ko \
kmod-clk-mt7622-hif.ko \
kmod-clk-mt7622-infracfg.ko \
kmod-clk-mt7622.ko \
kmod-clk-mt7981-apmixed.ko \
kmod-clk-mt7981-eth.ko \
kmod-clk-mt7981-infracfg.ko \
kmod-clk-mt7981-topckgen.ko \
kmod-clk-mt7986-apmixed.ko \
kmod-clk-mt7986-eth.ko \
kmod-clk-mt7986-infracfg.ko \
kmod-clk-mt7986-topckgen.ko \
kmod-clk-mt7988-apmixed.ko \
kmod-clk-mt7988-eth.ko \
kmod-clk-mt7988-infracfg.ko \
kmod-clk-mt7988-topckgen.ko \
kmod-clk-mt7988-xfipll.ko \
kmod-clk-mt8167-apmixedsys.ko \
kmod-clk-mt8167-aud.ko \
kmod-clk-mt8167-img.ko \
kmod-clk-mt8167-mfgcfg.ko \
kmod-clk-mt8167-mm.ko \
kmod-clk-mt8167-vdec.ko \
kmod-clk-mt8167.ko \
kmod-clk-mt8173-apmixedsys.ko \
kmod-clk-mt8173-img.ko \
kmod-clk-mt8173-infracfg.ko \
kmod-clk-mt8173-mm.ko \
kmod-clk-mt8173-pericfg.ko \
kmod-clk-mt8173-topckgen.ko \
kmod-clk-mt8173-vdecsys.ko \
kmod-clk-mt8173-vencsys.ko \
kmod-clk-mt8183-apmixedsys.ko \
kmod-clk-mt8183-audio.ko \
kmod-clk-mt8183-cam.ko \
kmod-clk-mt8183-img.ko \
kmod-clk-mt8183-ipu-adl.ko \
kmod-clk-mt8183-ipu-conn.ko \
kmod-clk-mt8183-ipu0.ko \
kmod-clk-mt8183-ipu1.ko \
kmod-clk-mt8183-mfgcfg.ko \
kmod-clk-mt8183-mm.ko \
kmod-clk-mt8183-vdec.ko \
kmod-clk-mt8183-venc.ko \
kmod-clk-mt8183.ko \
kmod-clk-mt8186-apmixedsys.ko \
kmod-clk-mt8186-cam.ko \
kmod-clk-mt8186-img.ko \
kmod-clk-mt8186-imp-iic-wrap.ko \
kmod-clk-mt8186-infra-ao.ko \
kmod-clk-mt8186-ipe.ko \
kmod-clk-mt8186-mcu.ko \
kmod-clk-mt8186-mdp.ko \
kmod-clk-mt8186-mfg.ko \
kmod-clk-mt8186-mm.ko \
kmod-clk-mt8186-topckgen.ko \
kmod-clk-mt8186-vdec.ko \
kmod-clk-mt8186-venc.ko \
kmod-clk-mt8186-wpe.ko \
kmod-clk-mt8188-adsp-audio26m.ko \
kmod-clk-mt8188-apmixedsys.ko \
kmod-clk-mt8188-cam.ko \
kmod-clk-mt8188-ccu.ko \
kmod-clk-mt8188-img.ko \
kmod-clk-mt8188-imp-iic-wrap.ko \
kmod-clk-mt8188-infra-ao.ko \
kmod-clk-mt8188-ipe.ko \
kmod-clk-mt8188-mfg.ko \
kmod-clk-mt8188-peri-ao.ko \
kmod-clk-mt8188-topckgen.ko \
kmod-clk-mt8188-vdec.ko \
kmod-clk-mt8188-vdo0.ko \
kmod-clk-mt8188-vdo1.ko \
kmod-clk-mt8188-venc.ko \
kmod-clk-mt8188-vpp0.ko \
kmod-clk-mt8188-vpp1.ko \
kmod-clk-mt8188-wpe.ko \
kmod-clk-mt8192-apmixedsys.ko \
kmod-clk-mt8192-aud.ko \
kmod-clk-mt8192-cam.ko \
kmod-clk-mt8192-img.ko \
kmod-clk-mt8192-imp-iic-wrap.ko \
kmod-clk-mt8192-ipe.ko \
kmod-clk-mt8192-mdp.ko \
kmod-clk-mt8192-mfg.ko \
kmod-clk-mt8192-mm.ko \
kmod-clk-mt8192-msdc.ko \
kmod-clk-mt8192-scp-adsp.ko \
kmod-clk-mt8192-vdec.ko \
kmod-clk-mt8192-venc.ko \
kmod-clk-mt8192.ko \
kmod-clk-mt8195-apmixedsys.ko \
kmod-clk-mt8195-apusys-pll.ko \
kmod-clk-mt8195-cam.ko \
kmod-clk-mt8195-ccu.ko \
kmod-clk-mt8195-img.ko \
kmod-clk-mt8195-imp-iic-wrap.ko \
kmod-clk-mt8195-infra-ao.ko \
kmod-clk-mt8195-ipe.ko \
kmod-clk-mt8195-mfg.ko \
kmod-clk-mt8195-peri-ao.ko \
kmod-clk-mt8195-scp-adsp.ko \
kmod-clk-mt8195-topckgen.ko \
kmod-clk-mt8195-vdec.ko \
kmod-clk-mt8195-vdo0.ko \
kmod-clk-mt8195-vdo1.ko \
kmod-clk-mt8195-venc.ko \
kmod-clk-mt8195-vpp0.ko \
kmod-clk-mt8195-vpp1.ko \
kmod-clk-mt8195-wpe.ko \
kmod-clk-mt8196-apmixedsys.ko \
kmod-clk-mt8196-disp0.ko \
kmod-clk-mt8196-disp1.ko \
kmod-clk-mt8196-imp-iic-wrap.ko \
kmod-clk-mt8196-mcu.ko \
kmod-clk-mt8196-mdpsys.ko \
kmod-clk-mt8196-mfg.ko \
kmod-clk-mt8196-ovl0.ko \
kmod-clk-mt8196-ovl1.ko \
kmod-clk-mt8196-peri-ao.ko \
kmod-clk-mt8196-pextp.ko \
kmod-clk-mt8196-topckgen.ko \
kmod-clk-mt8196-topckgen2.ko \
kmod-clk-mt8196-ufs-ao.ko \
kmod-clk-mt8196-vdec.ko \
kmod-clk-mt8196-vdisp-ao.ko \
kmod-clk-mt8196-venc.ko \
kmod-clk-mt8196-vlpckgen.ko \
kmod-clk-mt8365-apmixedsys.ko \
kmod-clk-mt8365-apu.ko \
kmod-clk-mt8365-cam.ko \
kmod-clk-mt8365-mfg.ko \
kmod-clk-mt8365-mm.ko \
kmod-clk-mt8365-vdec.ko \
kmod-clk-mt8365-venc.ko \
kmod-clk-mt8365.ko \
kmod-clk-mt8516-apmixedsys.ko \
kmod-clk-mt8516-aud.ko \
kmod-clk-mt8516.ko \
kmod-clk-mtk.ko \
kmod-clk-mux.ko \
kmod-clk-npcm8xx.ko \
kmod-clk-phase.ko \
kmod-clk-pll.ko \
kmod-clk-plldig.ko \
kmod-clk-pwm.ko \
kmod-clk-pxa1908-apbc.ko \
kmod-clk-pxa1908-apbcp.ko \
kmod-clk-pxa1908-apmu.ko \
kmod-clk-pxa1908-mpmu.ko \
kmod-clk-qcom.ko \
kmod-clk-raspberrypi.ko \
kmod-clk-regmap.ko \
kmod-clk-renesas-pcie.ko \
kmod-clk-rk808.ko \
kmod-clk-rp1.ko \
kmod-clk-rpm.ko \
kmod-clk-rpmh.ko \
kmod-clk-s2mps11.ko \
kmod-clk-scmi.ko \
kmod-clk-scpi.ko \
kmod-clk-sg2042-clkgen.ko \
kmod-clk-sg2042-pll.ko \
kmod-clk-sg2042-rpgate.ko \
kmod-clk-sg2044-pll.ko \
kmod-clk-sg2044.ko \
kmod-clk-si514.ko \
kmod-clk-si521xx.ko \
kmod-clk-si5341.ko \
kmod-clk-si544.ko \
kmod-clk-smd-rpm.ko \
kmod-clk-sophgo-cv1800.ko \
kmod-clk-spmi-pmic-div.ko \
kmod-clk-sprd.ko \
kmod-clk-vbattb.ko \
kmod-clk-versaclock3.ko \
kmod-clk-versaclock5.ko \
kmod-clk-versaclock7.ko \
kmod-clk-vexpress-osc.ko \
kmod-clk-xlnx-clock-wizard.ko \
kmod-cls-basic.ko \
kmod-cls-bpf.ko \
kmod-cls-cgroup.ko \
kmod-cls-flow.ko \
kmod-cls-flower.ko \
kmod-cls-fw.ko \
kmod-cls-matchall.ko \
kmod-cls-route.ko \
kmod-cls-u32.ko \
kmod-cm109.ko \
kmod-cm3232.ko \
kmod-cm3323.ko \
kmod-cm3605.ko \
kmod-cma3000-d0x-i2c.ko \
kmod-cma3000-d0x.ko \
kmod-cmac.ko \
kmod-cmd-db.ko \
kmod-cmdlinepart.ko \
kmod-cn.ko \
kmod-cn10k-rng.ko \
kmod-cnic.ko \
kmod-coda-vpu.ko \
kmod-coda.ko \
kmod-colibri-vf50-ts.ko \
kmod-comedi-8255.ko \
kmod-comedi-usb.ko \
kmod-comedi.ko \
kmod-comm.ko \
kmod-configfs.ko \
kmod-configs.ko \
kmod-cordic.ko \
kmod-core.ko \
kmod-coreboot-table.ko \
kmod-corebootdrm.ko \
kmod-coresight-catu.ko \
kmod-coresight-cpu-debug.ko \
kmod-coresight-ctcu.ko \
kmod-coresight-cti.ko \
kmod-coresight-dummy.ko \
kmod-coresight-etb10.ko \
kmod-coresight-etm4x.ko \
kmod-coresight-funnel.ko \
kmod-coresight-replicator.ko \
kmod-coresight-stm.ko \
kmod-coresight-tmc.ko \
kmod-coresight-tnoc.ko \
kmod-coresight-tpda.ko \
kmod-coresight-tpdm.ko \
kmod-coresight-tpiu.ko \
kmod-coresight-trbe.ko \
kmod-coresight.ko \
kmod-corsair-cpro.ko \
kmod-corsair-psu.ko \
kmod-cortina.ko \
kmod-counter.ko \
kmod-cp210x.ko \
kmod-cp500.ko \
kmod-cpcap-adc.ko \
kmod-cpcap-battery.ko \
kmod-cpcap-pwrbutton.ko \
kmod-cpcap-regulator.ko \
kmod-cppc-cpufreq.ko \
kmod-cpr.ko \
kmod-cptpf.ko \
kmod-cptvf.ko \
kmod-cpufreq-conservative.ko \
kmod-cpufreq-dt.ko \
kmod-cpufreq-ondemand.ko \
kmod-cpufreq-performance.ko \
kmod-cpufreq-powersave.ko \
kmod-cpufreq-userspace.ko \
kmod-cqhci.ko \
kmod-cramfs.ko \
kmod-crc-ccitt.ko \
kmod-crc-itu-t.ko \
kmod-crc-t10dif.ko \
kmod-crc16.ko \
kmod-crc32-cryptoapi.ko \
kmod-crc32.ko \
kmod-crc32c-cryptoapi.ko \
kmod-crc64.ko \
kmod-crc7.ko \
kmod-crc8.ko \
kmod-crg-hi3798cv200.ko \
kmod-cros-charge-control.ko \
kmod-cros-ec-accel-legacy.ko \
kmod-cros-ec-activity.ko \
kmod-cros-ec-anx7688.ko \
kmod-cros-ec-baro.ko \
kmod-cros-ec-cec.ko \
kmod-cros-ec-chardev.ko \
kmod-cros-ec-dev.ko \
kmod-cros-ec-hwmon.ko \
kmod-cros-ec-i2c.ko \
kmod-cros-ec-keyb.ko \
kmod-cros-ec-lid-angle.ko \
kmod-cros-ec-light-prox.ko \
kmod-cros-ec-lightbar.ko \
kmod-cros-ec-mkbp-proximity.ko \
kmod-cros-ec-proto.ko \
kmod-cros-ec-regulator.ko \
kmod-cros-ec-rpmsg.ko \
kmod-cros-ec-sensorhub.ko \
kmod-cros-ec-sensors-core.ko \
kmod-cros-ec-sensors.ko \
kmod-cros-ec-spi.ko \
kmod-cros-ec-sysfs.ko \
kmod-cros-ec-typec.ko \
kmod-cros-ec-uart.ko \
kmod-cros-ec-ucsi.ko \
kmod-cros-ec-vbc.ko \
kmod-cros-ec-wdt.ko \
kmod-cros-ec.ko \
kmod-cros-hps-i2c.ko \
kmod-cros-kbd-led-backlight.ko \
kmod-cros-peripheral-charger.ko \
kmod-cros-typec-switch.ko \
kmod-cros-usbpd-charger.ko \
kmod-cros-usbpd-logger.ko \
kmod-cros-usbpd-notify.ko \
kmod-crps.ko \
kmod-cryptd.ko \
kmod-crypto-acompress.ko \
kmod-crypto-algapi.ko \
kmod-crypto-engine.ko \
kmod-crypto-hash.ko \
kmod-crypto-hw-eip93.ko \
kmod-crypto-null.ko \
kmod-crypto-safexcel.ko \
kmod-crypto-skcipher.ko \
kmod-crypto-user.ko \
kmod-crypto.ko \
kmod-cryptomgr.ko \
kmod-cs-dsp.ko \
kmod-cs3308.ko \
kmod-cs42l43-i2c.ko \
kmod-cs42l43-sdw.ko \
kmod-cs42l43.ko \
kmod-cs5345.ko \
kmod-cs53l32a.ko \
kmod-csiostor.ko \
kmod-ctr.ko \
kmod-cts.ko \
kmod-ctucanfd-pci.ko \
kmod-ctucanfd-platform.ko \
kmod-ctucanfd.ko \
kmod-cuse.ko \
kmod-cv1800-mailbox.ko \
kmod-cv1800-rtcsys.ko \
kmod-cv1800b-dmamux.ko \
kmod-cv1800b-sound-adc.ko \
kmod-cv1800b-sound-dac.ko \
kmod-cv1800b-tdm.ko \
kmod-cw1200-core.ko \
kmod-cw1200-wlan-sdio.ko \
kmod-cw2015-battery.ko \
kmod-cx18-alsa.ko \
kmod-cx18.ko \
kmod-cx22700.ko \
kmod-cx22702.ko \
kmod-cx231xx-alsa.ko \
kmod-cx231xx-dvb.ko \
kmod-cx231xx.ko \
kmod-cx2341x.ko \
kmod-cx23885.ko \
kmod-cx24110.ko \
kmod-cx24113.ko \
kmod-cx24116.ko \
kmod-cx24117.ko \
kmod-cx24120.ko \
kmod-cx24123.ko \
kmod-cx25821-alsa.ko \
kmod-cx25821.ko \
kmod-cx25840.ko \
kmod-cx82310-eth.ko \
kmod-cx88-alsa.ko \
kmod-cx88-blackbird.ko \
kmod-cx88-dvb.ko \
kmod-cx88-vp3054-i2c.ko \
kmod-cx8800.ko \
kmod-cx8802.ko \
kmod-cx88xx.ko \
kmod-cxacru.ko \
kmod-cxd2099.ko \
kmod-cxd2820r.ko \
kmod-cxd2841er.ko \
kmod-cxd2880-spi.ko \
kmod-cxd2880.ko \
kmod-cxgb.ko \
kmod-cxgb3.ko \
kmod-cxgb3i.ko \
kmod-cxgb4.ko \
kmod-cxgb4i.ko \
kmod-cxgb4vf.ko \
kmod-cxgbit.ko \
kmod-cxl-acpi.ko \
kmod-cxl-core.ko \
kmod-cxl-mem.ko \
kmod-cxl-pci.ko \
kmod-cxl-pmem.ko \
kmod-cxl-pmu.ko \
kmod-cxl-port.ko \
kmod-cy8ctma140.ko \
kmod-cy8ctmg110-ts.ko \
kmod-cyapatp.ko \
kmod-cyberjack.ko \
kmod-cypress-cy7c63.ko \
kmod-cypress-firmware.ko \
kmod-cypress-m8.ko \
kmod-cypress-sf.ko \
kmod-cytherm.ko \
kmod-cyttsp-core.ko \
kmod-cyttsp-i2c.ko \
kmod-cyttsp5.ko \
kmod-d1u74t.ko \
kmod-d3323aa.ko \
kmod-da280.ko \
kmod-da311.ko \
kmod-da7280.ko \
kmod-da9121-regulator.ko \
kmod-davicom.ko \
kmod-dax-cxl.ko \
kmod-dax-hmem.ko \
kmod-dax-pmem.ko \
kmod-dax.ko \
kmod-db9.ko \
kmod-dc395x.ko \
kmod-ddbridge-dummy-fe.ko \
kmod-ddbridge.ko \
kmod-de2104x.ko \
kmod-deflate.ko \
kmod-defxx.ko \
kmod-delta-ahe50dc-fan.ko \
kmod-denali-dt.ko \
kmod-denali.ko \
kmod-des-generic.ko \
kmod-designware-i2s.ko \
kmod-device-dax.ko \
kmod-dfl-afu.ko \
kmod-dfl-emif.ko \
kmod-dfl-fme-br.ko \
kmod-dfl-fme-mgr.ko \
kmod-dfl-fme-region.ko \
kmod-dfl-fme.ko \
kmod-dfl-n3000-nios.ko \
kmod-dfl-pci.ko \
kmod-dfl.ko \
kmod-dh-generic.ko \
kmod-dib0070.ko \
kmod-dib0090.ko \
kmod-dib3000mb.ko \
kmod-dib3000mc.ko \
kmod-dib7000m.ko \
kmod-dib7000p.ko \
kmod-dib8000.ko \
kmod-dib9000.ko \
kmod-dibs.ko \
kmod-dibx000-common.ko \
kmod-digi-acceleport.ko \
kmod-digsig.ko \
kmod-dimlib.ko \
kmod-diskonchip.ko \
kmod-dispcc-eliza.ko \
kmod-dispcc-glymur.ko \
kmod-dispcc-kaanapali.ko \
kmod-dispcc-milos.ko \
kmod-dispcc-qcm2290.ko \
kmod-dispcc-qcs615.ko \
kmod-dispcc-sc7180.ko \
kmod-dispcc-sc7280.ko \
kmod-dispcc-sc8280xp.ko \
kmod-dispcc-sdm845.ko \
kmod-dispcc-sm4450.ko \
kmod-dispcc-sm6115.ko \
kmod-dispcc-sm6125.ko \
kmod-dispcc-sm6350.ko \
kmod-dispcc-sm6375.ko \
kmod-dispcc-sm7150.ko \
kmod-dispcc-sm8250.ko \
kmod-dispcc-sm8450.ko \
kmod-dispcc-sm8550.ko \
kmod-dispcc-sm8750.ko \
kmod-dispcc-x1e80100.ko \
kmod-dispcc0-sa8775p.ko \
kmod-dispcc1-sa8775p.ko \
kmod-display-connector.ko \
kmod-dl2k.ko \
kmod-dlhl60d.ko \
kmod-dlink-dir685-touchkeys.ko \
kmod-dlm.ko \
kmod-dln2-adc.ko \
kmod-dln2.ko \
kmod-dm-bio-prison.ko \
kmod-dm-bufio.ko \
kmod-dm-cache-smq.ko \
kmod-dm-cache.ko \
kmod-dm-clone.ko \
kmod-dm-crypt.ko \
kmod-dm-delay.ko \
kmod-dm-dust.ko \
kmod-dm-ebs.ko \
kmod-dm-era.ko \
kmod-dm-flakey.ko \
kmod-dm-historical-service-time.ko \
kmod-dm-inlinecrypt.ko \
kmod-dm-integrity.ko \
kmod-dm-io-affinity.ko \
kmod-dm-log-userspace.ko \
kmod-dm-log-writes.ko \
kmod-dm-log.ko \
kmod-dm-mirror.ko \
kmod-dm-mod.ko \
kmod-dm-multipath.ko \
kmod-dm-persistent-data.ko \
kmod-dm-queue-length.ko \
kmod-dm-raid.ko \
kmod-dm-region-hash.ko \
kmod-dm-round-robin.ko \
kmod-dm-service-time.ko \
kmod-dm-snapshot.ko \
kmod-dm-switch.ko \
kmod-dm-thin-pool.ko \
kmod-dm-unstripe.ko \
kmod-dm-vdo.ko \
kmod-dm-verity.ko \
kmod-dm-writecache.ko \
kmod-dm-zero.ko \
kmod-dm-zoned.ko \
kmod-dm1105.ko \
kmod-dm9601.ko \
kmod-dma-axi-dmac.ko \
kmod-dmard06.ko \
kmod-dmard09.ko \
kmod-dmard10.ko \
kmod-dmc520-edac.ko \
kmod-dme1737.ko \
kmod-dmfe.ko \
kmod-dmi-sysfs.ko \
kmod-dmx3191d.ko \
kmod-dns-resolver.ko \
kmod-dp83822.ko \
kmod-dp83848.ko \
kmod-dp83867.ko \
kmod-dp83869.ko \
kmod-dp83tc811.ko \
kmod-dp83td510.ko \
kmod-dp83tg720.ko \
kmod-dpaa2-caam.ko \
kmod-dpaa2-console.ko \
kmod-dpaa2-qdma.ko \
kmod-dpdmai.ko \
kmod-dpot-dac.ko \
kmod-dps310.ko \
kmod-dps920ab.ko \
kmod-drbd.ko \
kmod-drbg.ko \
kmod-drivetemp.ko \
kmod-drm-buddy.ko \
kmod-drm-client-lib.ko \
kmod-drm-display-helper.ko \
kmod-drm-dma-helper.ko \
kmod-drm-dp-aux-bus.ko \
kmod-drm-exec.ko \
kmod-drm-gpusvm-helper.ko \
kmod-drm-gpuvm.ko \
kmod-drm-kms-helper.ko \
kmod-drm-mipi-dbi.ko \
kmod-drm-mipi-dsi.ko \
kmod-drm-panel-backlight-quirks.ko \
kmod-drm-panel-orientation-quirks.ko \
kmod-drm-shmem-helper.ko \
kmod-drm-suballoc-helper.ko \
kmod-drm-sysfb-helper.ko \
kmod-drm-ttm-helper.ko \
kmod-drm-vram-helper.ko \
kmod-drm.ko \
kmod-drop-monitor.ko \
kmod-drv260x.ko \
kmod-drv2665.ko \
kmod-drv2667.ko \
kmod-drx39xyj.ko \
kmod-drxd.ko \
kmod-drxk.ko \
kmod-ds1621.ko \
kmod-ds1682.ko \
kmod-ds2482.ko \
kmod-ds2490.ko \
kmod-ds2760-battery.ko \
kmod-ds2780-battery.ko \
kmod-ds2781-battery.ko \
kmod-ds2782-battery.ko \
kmod-ds3000.ko \
kmod-ds4424.ko \
kmod-ds620.ko \
kmod-ds90ub913.ko \
kmod-ds90ub953.ko \
kmod-ds90ub960.ko \
kmod-dsa-core.ko \
kmod-dsa-loop.ko \
kmod-dsbr100.ko \
kmod-dst-ca.ko \
kmod-dst.ko \
kmod-dstr.ko \
kmod-dt3155.ko \
kmod-dt9812.ko \
kmod-dummy-irq.ko \
kmod-dummy.ko \
kmod-dvb-as102.ko \
kmod-dvb-bt8xx.ko \
kmod-dvb-core.ko \
kmod-dvb-pll.ko \
kmod-dvb-ttpci.ko \
kmod-dvb-ttusb-budget.ko \
kmod-dvb-usb-a800.ko \
kmod-dvb-usb-af9005-remote.ko \
kmod-dvb-usb-af9005.ko \
kmod-dvb-usb-af9015.ko \
kmod-dvb-usb-af9035.ko \
kmod-dvb-usb-anysee.ko \
kmod-dvb-usb-au6610.ko \
kmod-dvb-usb-az6007.ko \
kmod-dvb-usb-az6027.ko \
kmod-dvb-usb-ce6230.ko \
kmod-dvb-usb-cinergyT2.ko \
kmod-dvb-usb-cxusb.ko \
kmod-dvb-usb-dib0700.ko \
kmod-dvb-usb-dibusb-common.ko \
kmod-dvb-usb-dibusb-mb.ko \
kmod-dvb-usb-dibusb-mc-common.ko \
kmod-dvb-usb-dibusb-mc.ko \
kmod-dvb-usb-digitv.ko \
kmod-dvb-usb-dtt200u.ko \
kmod-dvb-usb-dtv5100.ko \
kmod-dvb-usb-dvbsky.ko \
kmod-dvb-usb-dw2102.ko \
kmod-dvb-usb-ec168.ko \
kmod-dvb-usb-gl861.ko \
kmod-dvb-usb-gp8psk.ko \
kmod-dvb-usb-lmedm04.ko \
kmod-dvb-usb-m920x.ko \
kmod-dvb-usb-mxl111sf.ko \
kmod-dvb-usb-nova-t-usb2.ko \
kmod-dvb-usb-opera.ko \
kmod-dvb-usb-pctv452e.ko \
kmod-dvb-usb-rtl28xxu.ko \
kmod-dvb-usb-technisat-usb2.ko \
kmod-dvb-usb-ttusb2.ko \
kmod-dvb-usb-umt-010.ko \
kmod-dvb-usb-v2.ko \
kmod-dvb-usb-vp702x.ko \
kmod-dvb-usb-vp7045.ko \
kmod-dvb-usb.ko \
kmod-dw-axi-dmac-platform.ko \
kmod-dw-dmac-core.ko \
kmod-dw-dmac-pci.ko \
kmod-dw-dp.ko \
kmod-dw-drm-dsi.ko \
kmod-dw-edma-pcie.ko \
kmod-dw-edma.ko \
kmod-dw-hdmi-ahb-audio.ko \
kmod-dw-hdmi-cec.ko \
kmod-dw-hdmi-gp-audio.ko \
kmod-dw-hdmi-i2s-audio.ko \
kmod-dw-hdmi-qp.ko \
kmod-dw-hdmi.ko \
kmod-dw-i3c-master.ko \
kmod-dw-mipi-csi2rx.ko \
kmod-dw-mipi-dsi-stm.ko \
kmod-dw-mipi-dsi.ko \
kmod-dw-mipi-dsi2.ko \
kmod-dw-mmc-bluefield.ko \
kmod-dw-mmc-exynos.ko \
kmod-dw-mmc-hi3798cv200.ko \
kmod-dw-mmc-hi3798mv200.ko \
kmod-dw-mmc-k3.ko \
kmod-dw-mmc-pci.ko \
kmod-dw-mmc-pltfm.ko \
kmod-dw-mmc-rockchip.ko \
kmod-dw-mmc.ko \
kmod-dw-wdt.ko \
kmod-dw-xdata-pcie.ko \
kmod-dw100.ko \
kmod-dw9714.ko \
kmod-dw9719.ko \
kmod-dw9768.ko \
kmod-dw9807-vcm.ko \
kmod-dwc-pcie-pmu.ko \
kmod-dwc-xlgmac.ko \
kmod-dwc2-pci.ko \
kmod-dwc2.ko \
kmod-dwc3-apple.ko \
kmod-dwc3-exynos.ko \
kmod-dwc3-generic-plat.ko \
kmod-dwc3-google.ko \
kmod-dwc3-haps.ko \
kmod-dwc3-imx.ko \
kmod-dwc3-imx8mp.ko \
kmod-dwc3-meson-g12a.ko \
kmod-dwc3-of-simple.ko \
kmod-dwc3-pci.ko \
kmod-dwc3-qcom-legacy.ko \
kmod-dwc3-qcom.ko \
kmod-dwc3-rtk.ko \
kmod-dwc3-xilinx.ko \
kmod-dwc3.ko \
kmod-dwmac-altr-socfpga.ko \
kmod-dwmac-dwc-qos-eth.ko \
kmod-dwmac-generic.ko \
kmod-dwmac-imx.ko \
kmod-dwmac-ipq806x.ko \
kmod-dwmac-mediatek.ko \
kmod-dwmac-meson.ko \
kmod-dwmac-meson8b.ko \
kmod-dwmac-motorcomm.ko \
kmod-dwmac-nuvoton.ko \
kmod-dwmac-qcom-ethqos.ko \
kmod-dwmac-renesas-gbeth.ko \
kmod-dwmac-rk.ko \
kmod-dwmac-s32.ko \
kmod-dwmac-sophgo.ko \
kmod-dwmac-stm32.ko \
kmod-dwmac-sun55i.ko \
kmod-dwmac-sun8i.ko \
kmod-dwmac-sunxi.ko \
kmod-dwmac-visconti.ko \
kmod-dynapro.ko \
kmod-e100.ko \
kmod-e1000.ko \
kmod-e1000e.ko \
kmod-e4000.ko \
kmod-e50sn12051.ko \
kmod-earth-pt1.ko \
kmod-earth-pt3.ko \
kmod-ebt-802-3.ko \
kmod-ebt-among.ko \
kmod-ebt-arp.ko \
kmod-ebt-arpreply.ko \
kmod-ebt-dnat.ko \
kmod-ebt-ip.ko \
kmod-ebt-ip6.ko \
kmod-ebt-limit.ko \
kmod-ebt-log.ko \
kmod-ebt-mark-m.ko \
kmod-ebt-mark.ko \
kmod-ebt-nflog.ko \
kmod-ebt-pkttype.ko \
kmod-ebt-redirect.ko \
kmod-ebt-snat.ko \
kmod-ebt-stp.ko \
kmod-ebt-vlan.ko \
kmod-ebtable-broute.ko \
kmod-ebtable-filter.ko \
kmod-ebtable-nat.ko \
kmod-ebtables.ko \
kmod-ec100.ko \
kmod-ecb.ko \
kmod-ecc-mtk.ko \
kmod-ecc.ko \
kmod-ecdh-generic.ko \
kmod-ecdsa-generic.ko \
kmod-echainiv.ko \
kmod-ecpricc-qdu1000.ko \
kmod-ecrdsa-generic.ko \
kmod-ecryptfs.ko \
kmod-edac-core.ko \
kmod-edt-ft5x06.ko \
kmod-ee1004.ko \
kmod-eeprom-93cx6.ko \
kmod-eeti-ts.ko \
kmod-efa.ko \
kmod-efct.ko \
kmod-efi-pstore.ko \
kmod-efi-secret.ko \
kmod-efibc.ko \
kmod-efidrm.ko \
kmod-efinix-spi.ko \
kmod-efivarfs.ko \
kmod-efs.ko \
kmod-egalax-ts-serial.ko \
kmod-ehci-exynos.ko \
kmod-ehci-fsl.ko \
kmod-ehci-hcd.ko \
kmod-ehci-mv.ko \
kmod-ehci-npcm7xx.ko \
kmod-ehci-orion.ko \
kmod-ehci-pci.ko \
kmod-ehci-platform.ko \
kmod-ehset.ko \
kmod-ektf2127.ko \
kmod-elan-i2c.ko \
kmod-elants-i2c.ko \
kmod-elo.ko \
kmod-em-canid.ko \
kmod-em-cmp.ko \
kmod-em-ipset.ko \
kmod-em-ipt.ko \
kmod-em-meta.ko \
kmod-em-nbyte.ko \
kmod-em-text.ko \
kmod-em-u32.ko \
kmod-em28xx-alsa.ko \
kmod-em28xx-dvb.ko \
kmod-em28xx-rc.ko \
kmod-em28xx-v4l.ko \
kmod-em28xx.ko \
kmod-emc1403.ko \
kmod-emc1812.ko \
kmod-emc2103.ko \
kmod-emc2305.ko \
kmod-emc6w201.ko \
kmod-emi26.ko \
kmod-emi62.ko \
kmod-empeg.ko \
kmod-ems-pci.ko \
kmod-ems-usb.ko \
kmod-ena.ko \
kmod-enc28j60.ko \
kmod-enclosure.ko \
kmod-encrypted-keys.ko \
kmod-encx24j600-regmap.ko \
kmod-encx24j600.ko \
kmod-enic.ko \
kmod-ens210.ko \
kmod-epat.ko \
kmod-epia.ko \
kmod-epic100.ko \
kmod-eql.ko \
kmod-erdma.ko \
kmod-erofs.ko \
kmod-error.ko \
kmod-erst-dbg.ko \
kmod-esas2r.ko \
kmod-esd-402-pci.ko \
kmod-esd-usb.ko \
kmod-esp-scsi.ko \
kmod-esp4-offload.ko \
kmod-esp4.ko \
kmod-esp6-offload.ko \
kmod-esp6.ko \
kmod-essiv.ko \
kmod-et1011c.ko \
kmod-et131x.ko \
kmod-et8ek8.ko \
kmod-etas-es58x.ko \
kmod-ethoc.ko \
kmod-ethosu.ko \
kmod-etnaviv.ko \
kmod-evdev.ko \
kmod-exc3000.ko \
kmod-exfat.ko \
kmod-exportfs.ko \
kmod-ext4.ko \
kmod-extcon-core.ko \
kmod-extcon-fsa9480.ko \
kmod-extcon-gpio.ko \
kmod-extcon-lc824206xa.ko \
kmod-extcon-max14526.ko \
kmod-extcon-max3355.ko \
kmod-extcon-ptn5150.ko \
kmod-extcon-qcom-spmi-misc.ko \
kmod-extcon-rtk-type-c.ko \
kmod-extcon-sm5502.ko \
kmod-extcon-usbc-cros-ec.ko \
kmod-extcon-usbc-tusb320.ko \
kmod-extron-da-hd-4k-plus-cec.ko \
kmod-exynos-bus.ko \
kmod-exynos-chipid.ko \
kmod-exynos-gsc.ko \
kmod-exynos-interconnect.ko \
kmod-exynos-lpass.ko \
kmod-exynos-mailbox.ko \
kmod-exynos-nocp.ko \
kmod-exynos-ppmu.ko \
kmod-exynos-thermal.ko \
kmod-exynos-trng.ko \
kmod-exynos-usi.ko \
kmod-ezusb.ko \
kmod-f2fs.ko \
kmod-f71805f.ko \
kmod-f71882fg.ko \
kmod-f75375s.ko \
kmod-f81232.ko \
kmod-f81534.ko \
kmod-f81601.ko \
kmod-f81604.ko \
kmod-failover.ko \
kmod-fakelb.ko \
kmod-fan.ko \
kmod-fan53555.ko \
kmod-fan53880.ko \
kmod-farsync.ko \
kmod-fastrpc.ko \
kmod-fat.ko \
kmod-fb-agm1264k-fl.ko \
kmod-fb-bd663474.ko \
kmod-fb-hx8340bn.ko \
kmod-fb-hx8347d.ko \
kmod-fb-hx8353d.ko \
kmod-fb-hx8357d.ko \
kmod-fb-ili9163.ko \
kmod-fb-ili9320.ko \
kmod-fb-ili9325.ko \
kmod-fb-ili9340.ko \
kmod-fb-ili9341.ko \
kmod-fb-ili9481.ko \
kmod-fb-ili9486.ko \
kmod-fb-io-fops.ko \
kmod-fb-pcd8544.ko \
kmod-fb-ra8875.ko \
kmod-fb-s6d02a1.ko \
kmod-fb-s6d1121.ko \
kmod-fb-seps525.ko \
kmod-fb-sh1106.ko \
kmod-fb-ssd1289.ko \
kmod-fb-ssd1305.ko \
kmod-fb-ssd1306.ko \
kmod-fb-ssd1325.ko \
kmod-fb-ssd1331.ko \
kmod-fb-ssd1351.ko \
kmod-fb-st7735r.ko \
kmod-fb-st7789v.ko \
kmod-fb-sys-fops.ko \
kmod-fb-tinylcd.ko \
kmod-fb-tls8204.ko \
kmod-fb-uc1611.ko \
kmod-fb-uc1701.ko \
kmod-fb-upd161704.ko \
kmod-fb.ko \
kmod-fbnic.ko \
kmod-fbtft.ko \
kmod-fc0011.ko \
kmod-fc0012.ko \
kmod-fc0013.ko \
kmod-fc2580.ko \
kmod-fcoe.ko \
kmod-fddi.ko \
kmod-fdomain-pci.ko \
kmod-fdomain.ko \
kmod-fealnx.ko \
kmod-fec.ko \
kmod-ff-memless.ko \
kmod-ffa-core.ko \
kmod-ffa-module.ko \
kmod-firedtv.ko \
kmod-firewire-core.ko \
kmod-firewire-net.ko \
kmod-firewire-ohci.ko \
kmod-firewire-sbp2.ko \
kmod-firmware-class.ko \
kmod-fit2.ko \
kmod-fit3.ko \
kmod-fixed-layout.ko \
kmod-fixed-phy.ko \
kmod-fixed.ko \
kmod-flexcan.ko \
kmod-fm10k.ko \
kmod-font.ko \
kmod-forcedeth.ko \
kmod-fou.ko \
kmod-fou6.ko \
kmod-fp9931.ko \
kmod-fpga-bridge.ko \
kmod-fpga-mgr.ko \
kmod-fpga-region.ko \
kmod-framebuffer-coreboot.ko \
kmod-framer-pef2256.ko \
kmod-freevxfs.ko \
kmod-friq.ko \
kmod-frpw.ko \
kmod-fsa4480.ko \
kmod-fsdev-dax.ko \
kmod-fsia6b.ko \
kmod-fsl-dpa.ko \
kmod-fsl-dpaa-fman-port.ko \
kmod-fsl-dpaa-fman.ko \
kmod-fsl-dpaa-mac.ko \
kmod-fsl-dpaa2-eth.ko \
kmod-fsl-dpaa2-mac.ko \
kmod-fsl-dpaa2-ptp.ko \
kmod-fsl-dpaa2-switch.ko \
kmod-fsl-edma.ko \
kmod-fsl-enetc-core.ko \
kmod-fsl-enetc-ierb.ko \
kmod-fsl-enetc-mdio.ko \
kmod-fsl-enetc-ptp.ko \
kmod-fsl-enetc-vf.ko \
kmod-fsl-enetc.ko \
kmod-fsl-ifc-nand.ko \
kmod-fsl-imx8-ddr-perf.ko \
kmod-fsl-imx9-ddr-perf.ko \
kmod-fsl-ldb.ko \
kmod-fsl-linflexuart.ko \
kmod-fsl-lpuart.ko \
kmod-fsl-mc-dpio.ko \
kmod-fsl-mph-dr-of.ko \
kmod-fsl-pq-mdio.ko \
kmod-fsl-qdma.ko \
kmod-fsl-ucc-hdlc.ko \
kmod-fsp-3y.ko \
kmod-ftdi-sio.ko \
kmod-ftl.ko \
kmod-ftsteutates.ko \
kmod-fujitsu-ts.ko \
kmod-fujitsu-uncore-pmu.ko \
kmod-funcore.ko \
kmod-funeth.ko \
kmod-fusb302.ko \
kmod-fuse.ko \
kmod-fwctl.ko \
kmod-fwnode-mdio.ko \
kmod-fxas21002c-core.ko \
kmod-fxas21002c-i2c.ko \
kmod-fxas21002c-spi.ko \
kmod-fxls8962af-core.ko \
kmod-fxls8962af-i2c.ko \
kmod-fxls8962af-spi.ko \
kmod-fxos8700-core.ko \
kmod-fxos8700-i2c.ko \
kmod-fxos8700-spi.ko \
kmod-g-acm-ms.ko \
kmod-g-audio.ko \
kmod-g-cdc.ko \
kmod-g-dbgp.ko \
kmod-g-ether.ko \
kmod-g-ffs.ko \
kmod-g-hid.ko \
kmod-g-mass-storage.ko \
kmod-g-midi.ko \
kmod-g-multi.ko \
kmod-g-ncm.ko \
kmod-g-nokia.ko \
kmod-g-printer.ko \
kmod-g-serial.ko \
kmod-g-webcam.ko \
kmod-g12a-aoclk.ko \
kmod-g12a.ko \
kmod-g760a.ko \
kmod-g762.ko \
kmod-gadgetfs.ko \
kmod-gamecon.ko \
kmod-garmin-gps.ko \
kmod-garp.ko \
kmod-gateworks-gsc.ko \
kmod-gc0308.ko \
kmod-gc0310.ko \
kmod-gc05a2.ko \
kmod-gc08a3.ko \
kmod-gc2145.ko \
kmod-gcc-eliza.ko \
kmod-gcc-glymur.ko \
kmod-gcc-hawi.ko \
kmod-gcc-ipq5018.ko \
kmod-gcc-ipq5210.ko \
kmod-gcc-ipq5424.ko \
kmod-gcc-ipq6018.ko \
kmod-gcc-ipq9650.ko \
kmod-gcc-kaanapali.ko \
kmod-gcc-milos.ko \
kmod-gcc-msm8916.ko \
kmod-gcc-msm8939.ko \
kmod-gcc-msm8953.ko \
kmod-gcc-msm8976.ko \
kmod-gcc-msm8994.ko \
kmod-gcc-msm8998.ko \
kmod-gcc-nord.ko \
kmod-gcc-qcm2290.ko \
kmod-gcc-qcs404.ko \
kmod-gcc-qcs615.ko \
kmod-gcc-qcs8300.ko \
kmod-gcc-qdu1000.ko \
kmod-gcc-sa8775p.ko \
kmod-gcc-sar2130p.ko \
kmod-gcc-sc7180.ko \
kmod-gcc-sc7280.ko \
kmod-gcc-sc8180x.ko \
kmod-gcc-sc8280xp.ko \
kmod-gcc-sdm660.ko \
kmod-gcc-sdm845.ko \
kmod-gcc-sdx75.ko \
kmod-gcc-sm4450.ko \
kmod-gcc-sm6115.ko \
kmod-gcc-sm6125.ko \
kmod-gcc-sm6350.ko \
kmod-gcc-sm6375.ko \
kmod-gcc-sm7150.ko \
kmod-gcc-sm8150.ko \
kmod-gcc-sm8250.ko \
kmod-gcc-sm8350.ko \
kmod-gcc-sm8450.ko \
kmod-gcc-sm8550.ko \
kmod-gcc-sm8650.ko \
kmod-gcc-sm8750.ko \
kmod-gcc-x1e80100.ko \
kmod-gcm.ko \
kmod-ge2d.ko \
kmod-gehc-pmc-adc.ko \
kmod-gemini.ko \
kmod-gen-probe.ko \
kmod-generic.ko \
kmod-genet.ko \
kmod-geneve.ko \
kmod-geniv.ko \
kmod-genwqe-card.ko \
kmod-gf128mul.ko \
kmod-gfs2.ko \
kmod-ghash-ce.ko \
kmod-ghes-edac.ko \
kmod-ghes-nvidia.ko \
kmod-gianfar-driver.ko \
kmod-gigabyte-waterforce.ko \
kmod-gl518sm.ko \
kmod-gl520sm.ko \
kmod-gl620a.ko \
kmod-glob.ko \
kmod-gluebi.ko \
kmod-gm12u320.ko \
kmod-gnss-mtk.ko \
kmod-gnss-serial.ko \
kmod-gnss-sirf.ko \
kmod-gnss-ubx.ko \
kmod-gnss-usb.ko \
kmod-gnss.ko \
kmod-go7007-loader.ko \
kmod-go7007-usb.ko \
kmod-go7007.ko \
kmod-goodix-berlin-core.ko \
kmod-goodix-berlin-i2c.ko \
kmod-goodix-berlin-spi.ko \
kmod-goodix-ts.ko \
kmod-governor-passive.ko \
kmod-governor-performance.ko \
kmod-governor-powersave.ko \
kmod-governor-simpleondemand.ko \
kmod-governor-userspace.ko \
kmod-gp2ap002.ko \
kmod-gp8psk-fe.ko \
kmod-gpi.ko \
kmod-gpio-74xx-mmio.ko \
kmod-gpio-adp5585.ko \
kmod-gpio-aggregator.ko \
kmod-gpio-altera-a10sr.ko \
kmod-gpio-aspeed.ko \
kmod-gpio-backlight.ko \
kmod-gpio-bd71815.ko \
kmod-gpio-bd71828.ko \
kmod-gpio-bd72720.ko \
kmod-gpio-bd9571mwv.ko \
kmod-gpio-blzp1600.ko \
kmod-gpio-brcmstb.ko \
kmod-gpio-by-pinctrl.ko \
kmod-gpio-cadence.ko \
kmod-gpio-charger.ko \
kmod-gpio-cros-ec.ko \
kmod-gpio-decoder.ko \
kmod-gpio-dln2.ko \
kmod-gpio-ds4520.ko \
kmod-gpio-dwapb.ko \
kmod-gpio-eic-sprd.ko \
kmod-gpio-en7523.ko \
kmod-gpio-fan.ko \
kmod-gpio-fxl6408.ko \
kmod-gpio-generic.ko \
kmod-gpio-grgpio.ko \
kmod-gpio-gw-pld.ko \
kmod-gpio-hisi.ko \
kmod-gpio-idio-16.ko \
kmod-gpio-ir-recv.ko \
kmod-gpio-ir-tx.ko \
kmod-gpio-kempld.ko \
kmod-gpio-keys-polled.ko \
kmod-gpio-keys.ko \
kmod-gpio-latch.ko \
kmod-gpio-line-mux.ko \
kmod-gpio-ljca.ko \
kmod-gpio-lp3943.ko \
kmod-gpio-lp873x.ko \
kmod-gpio-lp87565.ko \
kmod-gpio-ltc4283.ko \
kmod-gpio-macsmc.ko \
kmod-gpio-madera.ko \
kmod-gpio-max3191x.ko \
kmod-gpio-max7300.ko \
kmod-gpio-max730x.ko \
kmod-gpio-max732x.ko \
kmod-gpio-max7360.ko \
kmod-gpio-max77620.ko \
kmod-gpio-max77650.ko \
kmod-gpio-max77759.ko \
kmod-gpio-mb86s7x.ko \
kmod-gpio-mlxbf.ko \
kmod-gpio-mlxbf2.ko \
kmod-gpio-mlxbf3.ko \
kmod-gpio-mockup.ko \
kmod-gpio-mouse.ko \
kmod-gpio-moxtet.ko \
kmod-gpio-mpsse.ko \
kmod-gpio-mxc.ko \
kmod-gpio-nct6694.ko \
kmod-gpio-npcm-sgpio.ko \
kmod-gpio-pca953x.ko \
kmod-gpio-pca9570.ko \
kmod-gpio-pcf857x.ko \
kmod-gpio-pci-idio-16.ko \
kmod-gpio-pcie-idio-24.ko \
kmod-gpio-pisosr.ko \
kmod-gpio-pl061.ko \
kmod-gpio-pmic-eic-sprd.ko \
kmod-gpio-qixis-fpga.ko \
kmod-gpio-raspberrypi-exp.ko \
kmod-gpio-rcar.ko \
kmod-gpio-regmap.ko \
kmod-gpio-regulator.ko \
kmod-gpio-rockchip.ko \
kmod-gpio-rtd.ko \
kmod-gpio-sbu-mux.ko \
kmod-gpio-shared-proxy.ko \
kmod-gpio-sim.ko \
kmod-gpio-sprd.ko \
kmod-gpio-syscon.ko \
kmod-gpio-tegra.ko \
kmod-gpio-tegra186.ko \
kmod-gpio-thunderx.ko \
kmod-gpio-tn48m.ko \
kmod-gpio-tpic2810.ko \
kmod-gpio-tqmx86.ko \
kmod-gpio-vf610.ko \
kmod-gpio-vibra.ko \
kmod-gpio-viperboard.ko \
kmod-gpio-virtio.ko \
kmod-gpio-virtuser.ko \
kmod-gpio-visconti.ko \
kmod-gpio-waveshare-dsi.ko \
kmod-gpio-wcd934x.ko \
kmod-gpio-xgene-sb.ko \
kmod-gpio-xgs-iproc.ko \
kmod-gpio-xilinx.ko \
kmod-gpio-xlp.ko \
kmod-gpio-xra1403.ko \
kmod-gpio-zynq.ko \
kmod-gpio-zynqmp-modepin.ko \
kmod-gpio.ko \
kmod-gpmi-nand.ko \
kmod-gpu-sched.ko \
kmod-gpucc-glymur.ko \
kmod-gpucc-kaanapali.ko \
kmod-gpucc-milos.ko \
kmod-gpucc-msm8998.ko \
kmod-gpucc-qcm2290.ko \
kmod-gpucc-qcs615.ko \
kmod-gpucc-sar2130p.ko \
kmod-gpucc-sc7180.ko \
kmod-gpucc-sc7280.ko \
kmod-gpucc-sc8280xp.ko \
kmod-gpucc-sdm660.ko \
kmod-gpucc-sdm845.ko \
kmod-gpucc-sm4450.ko \
kmod-gpucc-sm6115.ko \
kmod-gpucc-sm6125.ko \
kmod-gpucc-sm6350.ko \
kmod-gpucc-sm6375.ko \
kmod-gpucc-sm8150.ko \
kmod-gpucc-sm8250.ko \
kmod-gpucc-sm8350.ko \
kmod-gpucc-sm8450.ko \
kmod-gpucc-sm8550.ko \
kmod-gpucc-sm8650.ko \
kmod-gpucc-sm8750.ko \
kmod-gpucc-x1e80100.ko \
kmod-gpucc-x1p42100.ko \
kmod-grace.ko \
kmod-gre.ko \
kmod-gs-usb.ko \
kmod-gs1662.ko \
kmod-gsc-hwmon.ko \
kmod-gspca-benq.ko \
kmod-gspca-conex.ko \
kmod-gspca-cpia1.ko \
kmod-gspca-dtcs033.ko \
kmod-gspca-etoms.ko \
kmod-gspca-finepix.ko \
kmod-gspca-gl860.ko \
kmod-gspca-jeilinj.ko \
kmod-gspca-jl2005bcd.ko \
kmod-gspca-kinect.ko \
kmod-gspca-konica.ko \
kmod-gspca-m5602.ko \
kmod-gspca-main.ko \
kmod-gspca-mars.ko \
kmod-gspca-mr97310a.ko \
kmod-gspca-nw80x.ko \
kmod-gspca-ov519.ko \
kmod-gspca-ov534-9.ko \
kmod-gspca-ov534.ko \
kmod-gspca-pac207.ko \
kmod-gspca-pac7302.ko \
kmod-gspca-pac7311.ko \
kmod-gspca-se401.ko \
kmod-gspca-sn9c2028.ko \
kmod-gspca-sn9c20x.ko \
kmod-gspca-sonixb.ko \
kmod-gspca-sonixj.ko \
kmod-gspca-spca1528.ko \
kmod-gspca-spca500.ko \
kmod-gspca-spca501.ko \
kmod-gspca-spca505.ko \
kmod-gspca-spca506.ko \
kmod-gspca-spca508.ko \
kmod-gspca-spca561.ko \
kmod-gspca-sq905.ko \
kmod-gspca-sq905c.ko \
kmod-gspca-sq930x.ko \
kmod-gspca-stk014.ko \
kmod-gspca-stk1135.ko \
kmod-gspca-stv0680.ko \
kmod-gspca-stv06xx.ko \
kmod-gspca-sunplus.ko \
kmod-gspca-t613.ko \
kmod-gspca-topro.ko \
kmod-gspca-touptek.ko \
kmod-gspca-tv8532.ko \
kmod-gspca-vc032x.ko \
kmod-gspca-vicam.ko \
kmod-gspca-xirlink-cit.ko \
kmod-gspca-zc3xx.ko \
kmod-gtp.ko \
kmod-gud.ko \
kmod-gunyah-wdt.ko \
kmod-gunze.ko \
kmod-gve.ko \
kmod-gxbb-aoclk.ko \
kmod-gxbb.ko \
kmod-gxclkctl-kaanapali.ko \
kmod-hac300s.ko \
kmod-hackrf.ko \
kmod-hampshire.ko \
kmod-hantro-vpu.ko \
kmod-hanwang.ko \
kmod-hci-bcm4377.ko \
kmod-hci-nokia.ko \
kmod-hci-uart.ko \
kmod-hci-vhci.ko \
kmod-hci.ko \
kmod-hclge-common.ko \
kmod-hclge.ko \
kmod-hclgevf.ko \
kmod-hctr2.ko \
kmod-hd3ss3220.ko \
kmod-hd44780-common.ko \
kmod-hd44780.ko \
kmod-hdc100x.ko \
kmod-hdlc-cisco.ko \
kmod-hdlc-fr.ko \
kmod-hdlc-ppp.ko \
kmod-hdlc-raw-eth.ko \
kmod-hdlc-raw.ko \
kmod-hdlc-x25.ko \
kmod-hdlc.ko \
kmod-hdlcd.ko \
kmod-hdma-mgmt.ko \
kmod-hdma.ko \
kmod-hdpvr.ko \
kmod-hed.ko \
kmod-helene.ko \
kmod-hellcreek-sw.ko \
kmod-hfpll.ko \
kmod-hfsplus.ko \
kmod-hi311x.ko \
kmod-hi3660-mailbox.ko \
kmod-hi556.ko \
kmod-hi6210-i2s.ko \
kmod-hi6220-mailbox.ko \
kmod-hi6220-reset.ko \
kmod-hi6421-pmic-core.ko \
kmod-hi6421-regulator.ko \
kmod-hi6421-spmi-pmic.ko \
kmod-hi6421v530-regulator.ko \
kmod-hi6421v600-irq.ko \
kmod-hi6421v600-regulator.ko \
kmod-hi655x-pmic.ko \
kmod-hi655x-regulator.ko \
kmod-hi8435.ko \
kmod-hi846.ko \
kmod-hi847.ko \
kmod-hibmc-drm.ko \
kmod-hibmcge.ko \
kmod-hid-a4tech.ko \
kmod-hid-accutouch.ko \
kmod-hid-alps.ko \
kmod-hid-apple.ko \
kmod-hid-appleir.ko \
kmod-hid-asus.ko \
kmod-hid-aureal.ko \
kmod-hid-axff.ko \
kmod-hid-belkin.ko \
kmod-hid-betopff.ko \
kmod-hid-bigbenff.ko \
kmod-hid-bpf.ko \
kmod-hid-cherry.ko \
kmod-hid-chicony.ko \
kmod-hid-corsair-void.ko \
kmod-hid-corsair.ko \
kmod-hid-cougar.ko \
kmod-hid-cp2112.ko \
kmod-hid-creative-sb0540.ko \
kmod-hid-cypress.ko \
kmod-hid-dr.ko \
kmod-hid-elan.ko \
kmod-hid-elecom.ko \
kmod-hid-elo.ko \
kmod-hid-emsff.ko \
kmod-hid-evision.ko \
kmod-hid-ezkey.ko \
kmod-hid-ft260.ko \
kmod-hid-gaff.ko \
kmod-hid-gembird.ko \
kmod-hid-generic.ko \
kmod-hid-gfrm.ko \
kmod-hid-glorious.ko \
kmod-hid-goodix-spi.ko \
kmod-hid-google-hammer.ko \
kmod-hid-google-stadiaff.ko \
kmod-hid-gt683r.ko \
kmod-hid-gyration.ko \
kmod-hid-holtek-kbd.ko \
kmod-hid-holtek-mouse.ko \
kmod-hid-holtekff.ko \
kmod-hid-huawei.ko \
kmod-hid-hyperv.ko \
kmod-hid-icade.ko \
kmod-hid-ite.ko \
kmod-hid-jabra.ko \
kmod-hid-kensington.ko \
kmod-hid-keytouch.ko \
kmod-hid-kye.ko \
kmod-hid-kysona.ko \
kmod-hid-lcpower.ko \
kmod-hid-led.ko \
kmod-hid-lenovo-go-s.ko \
kmod-hid-lenovo-go.ko \
kmod-hid-lenovo.ko \
kmod-hid-letsketch.ko \
kmod-hid-lg-g15.ko \
kmod-hid-logitech-dj.ko \
kmod-hid-logitech-hidpp.ko \
kmod-hid-logitech.ko \
kmod-hid-macally.ko \
kmod-hid-magicmouse.ko \
kmod-hid-maltron.ko \
kmod-hid-mcp2200.ko \
kmod-hid-mcp2221.ko \
kmod-hid-megaworld.ko \
kmod-hid-mf.ko \
kmod-hid-microsoft.ko \
kmod-hid-monterey.ko \
kmod-hid-multitouch.ko \
kmod-hid-nintendo.ko \
kmod-hid-nti.ko \
kmod-hid-ntrig.ko \
kmod-hid-nvidia-shield.ko \
kmod-hid-ortek.ko \
kmod-hid-oxp.ko \
kmod-hid-penmount.ko \
kmod-hid-petalynx.ko \
kmod-hid-picolcd.ko \
kmod-hid-pl.ko \
kmod-hid-plantronics.ko \
kmod-hid-playstation.ko \
kmod-hid-primax.ko \
kmod-hid-prodikeys.ko \
kmod-hid-pxrc.ko \
kmod-hid-rakk.ko \
kmod-hid-rapoo.ko \
kmod-hid-razer.ko \
kmod-hid-redragon.ko \
kmod-hid-retrode.ko \
kmod-hid-rmi.ko \
kmod-hid-roccat-arvo.ko \
kmod-hid-roccat-common.ko \
kmod-hid-roccat-isku.ko \
kmod-hid-roccat-kone.ko \
kmod-hid-roccat-koneplus.ko \
kmod-hid-roccat-konepure.ko \
kmod-hid-roccat-kovaplus.ko \
kmod-hid-roccat-lua.ko \
kmod-hid-roccat-pyra.ko \
kmod-hid-roccat-ryos.ko \
kmod-hid-roccat-savu.ko \
kmod-hid-roccat.ko \
kmod-hid-saitek.ko \
kmod-hid-samsung.ko \
kmod-hid-semitek.ko \
kmod-hid-sensor-accel-3d.ko \
kmod-hid-sensor-als.ko \
kmod-hid-sensor-custom-intel-hinge.ko \
kmod-hid-sensor-custom.ko \
kmod-hid-sensor-gyro-3d.ko \
kmod-hid-sensor-hub.ko \
kmod-hid-sensor-humidity.ko \
kmod-hid-sensor-iio-common.ko \
kmod-hid-sensor-incl-3d.ko \
kmod-hid-sensor-magn-3d.ko \
kmod-hid-sensor-press.ko \
kmod-hid-sensor-prox.ko \
kmod-hid-sensor-rotation.ko \
kmod-hid-sensor-temperature.ko \
kmod-hid-sensor-trigger.ko \
kmod-hid-sigmamicro.ko \
kmod-hid-sjoy.ko \
kmod-hid-sony.ko \
kmod-hid-speedlink.ko \
kmod-hid-steam.ko \
kmod-hid-steelseries.ko \
kmod-hid-sunplus.ko \
kmod-hid-thrustmaster.ko \
kmod-hid-tivo.ko \
kmod-hid-tmff.ko \
kmod-hid-topre.ko \
kmod-hid-topseed.ko \
kmod-hid-twinhan.ko \
kmod-hid-u2fzero.ko \
kmod-hid-uclogic.ko \
kmod-hid-udraw-ps3.ko \
kmod-hid-universal-pidff.ko \
kmod-hid-viewsonic.ko \
kmod-hid-vivaldi-common.ko \
kmod-hid-vivaldi.ko \
kmod-hid-vrc2.ko \
kmod-hid-waltop.ko \
kmod-hid-wiimote.ko \
kmod-hid-winwing.ko \
kmod-hid-xiaomi.ko \
kmod-hid-xinmo.ko \
kmod-hid-zpff.ko \
kmod-hid-zydacron.ko \
kmod-hid.ko \
kmod-hideep.ko \
kmod-hidp.ko \
kmod-hih6130.ko \
kmod-himax-hx83112b.ko \
kmod-himax-hx852x.ko \
kmod-hinic.ko \
kmod-hinic3.ko \
kmod-hip04-eth.ko \
kmod-hisi-acc-vfio-pci.ko \
kmod-hisi-dma.ko \
kmod-hisi-femac.ko \
kmod-hisi-hikey-usb.ko \
kmod-hisi-hpre.ko \
kmod-hisi-pcie-pmu.ko \
kmod-hisi-powerkey.ko \
kmod-hisi-ptt.ko \
kmod-hisi-qm.ko \
kmod-hisi-rng.ko \
kmod-hisi-sas-main.ko \
kmod-hisi-sas-v1-hw.ko \
kmod-hisi-sas-v2-hw.ko \
kmod-hisi-sas-v3-hw.ko \
kmod-hisi-sec.ko \
kmod-hisi-sec2.ko \
kmod-hisi-sfc.ko \
kmod-hisi-soc-hha.ko \
kmod-hisi-thermal.ko \
kmod-hisi-trng-v2.ko \
kmod-hisi-uncore-cpa-pmu.ko \
kmod-hisi-uncore-ddrc-pmu.ko \
kmod-hisi-uncore-freq.ko \
kmod-hisi-uncore-hha-pmu.ko \
kmod-hisi-uncore-l3c-pmu.ko \
kmod-hisi-uncore-mn-pmu.ko \
kmod-hisi-uncore-noc-pmu.ko \
kmod-hisi-uncore-pa-pmu.ko \
kmod-hisi-uncore-pmu.ko \
kmod-hisi-uncore-sllc-pmu.ko \
kmod-hisi-uncore-uc-pmu.ko \
kmod-hisi-zip.ko \
kmod-hisi504-nand.ko \
kmod-histb-rng.ko \
kmod-hix5hd2-gmac.ko \
kmod-hmac.ko \
kmod-hmc425a.ko \
kmod-hmc6352.ko \
kmod-hnae.ko \
kmod-hnae3.ko \
kmod-hns-dsaf.ko \
kmod-hns-enet-drv.ko \
kmod-hns-mdio.ko \
kmod-hns-roce-hw-v2.ko \
kmod-hns3-pmu.ko \
kmod-hns3.ko \
kmod-hopper.ko \
kmod-horus3a.ko \
kmod-host1x.ko \
kmod-hpfs.ko \
kmod-hpilo.ko \
kmod-hpsa.ko \
kmod-hptiop.ko \
kmod-hpwdt.ko \
kmod-hs3001.ko \
kmod-hsi-char.ko \
kmod-hsi.ko \
kmod-hso.ko \
kmod-hsr.ko \
kmod-ht16k33.ko \
kmod-hte-tegra194.ko \
kmod-hts221-i2c.ko \
kmod-hts221-spi.ko \
kmod-hts221.ko \
kmod-htu21.ko \
kmod-htu31.ko \
kmod-huawei-cdc-ncm.ko \
kmod-huawei-gaokun-battery.ko \
kmod-huawei-gaokun-ec.ko \
kmod-hv-balloon.ko \
kmod-hv-netvsc.ko \
kmod-hv-sock.ko \
kmod-hv-storvsc.ko \
kmod-hv-utils.ko \
kmod-hv-vmbus.ko \
kmod-hwmon-vid.ko \
kmod-hwmon.ko \
kmod-hwpoison-inject.ko \
kmod-hws.ko \
kmod-hx711.ko \
kmod-hx8357d.ko \
kmod-hx9023s.ko \
kmod-hycon-hy46xx.ko \
kmod-hynitron-cst816x.ko \
kmod-hynitron-cstxxx.ko \
kmod-hyperbus-core.ko \
kmod-hyperv-drm.ko \
kmod-hyperv-keyboard.ko \
kmod-i2c-algo-bit.ko \
kmod-i2c-algo-pca.ko \
kmod-i2c-ali1535.ko \
kmod-i2c-ali1563.ko \
kmod-i2c-ali15x3.ko \
kmod-i2c-altera.ko \
kmod-i2c-amd756.ko \
kmod-i2c-amd8111.ko \
kmod-i2c-aspeed.ko \
kmod-i2c-at91.ko \
kmod-i2c-atr.ko \
kmod-i2c-bcm-iproc.ko \
kmod-i2c-bcm2835.ko \
kmod-i2c-brcmstb.ko \
kmod-i2c-cadence.ko \
kmod-i2c-cbus-gpio.ko \
kmod-i2c-ccgx-ucsi.ko \
kmod-i2c-core.ko \
kmod-i2c-cp2615.ko \
kmod-i2c-cros-ec-tunnel.ko \
kmod-i2c-demux-pinctrl.ko \
kmod-i2c-designware-amdisp.ko \
kmod-i2c-designware-core.ko \
kmod-i2c-designware-pci.ko \
kmod-i2c-designware-platform.ko \
kmod-i2c-dev.ko \
kmod-i2c-diolan-u2c.ko \
kmod-i2c-dln2.ko \
kmod-i2c-gpio.ko \
kmod-i2c-hid-acpi.ko \
kmod-i2c-hid-of-elan.ko \
kmod-i2c-hid-of-goodix.ko \
kmod-i2c-hid-of.ko \
kmod-i2c-hid.ko \
kmod-i2c-hisi.ko \
kmod-i2c-hix5hd2.ko \
kmod-i2c-i801.ko \
kmod-i2c-imx-lpi2c.ko \
kmod-i2c-imx.ko \
kmod-i2c-isch.ko \
kmod-i2c-keba.ko \
kmod-i2c-kempld.ko \
kmod-i2c-ljca.ko \
kmod-i2c-mchp-pci1xxxx.ko \
kmod-i2c-meson.ko \
kmod-i2c-mlxbf.ko \
kmod-i2c-mlxcpld.ko \
kmod-i2c-mt65xx.ko \
kmod-i2c-mt7621.ko \
kmod-i2c-mux-gpio.ko \
kmod-i2c-mux-gpmux.ko \
kmod-i2c-mux-ltc4306.ko \
kmod-i2c-mux-mlxcpld.ko \
kmod-i2c-mux-mule.ko \
kmod-i2c-mux-pca9541.ko \
kmod-i2c-mux-pca954x.ko \
kmod-i2c-mux-pinctrl.ko \
kmod-i2c-mux-reg.ko \
kmod-i2c-mux.ko \
kmod-i2c-mv64xxx.ko \
kmod-i2c-nct6694.ko \
kmod-i2c-nforce2.ko \
kmod-i2c-npcm7xx.ko \
kmod-i2c-nvidia-gpu.ko \
kmod-i2c-ocores.ko \
kmod-i2c-owl.ko \
kmod-i2c-parport.ko \
kmod-i2c-pasemi-core.ko \
kmod-i2c-pasemi-platform.ko \
kmod-i2c-pca-platform.ko \
kmod-i2c-piix4.ko \
kmod-i2c-pxa.ko \
kmod-i2c-qcom-cci.ko \
kmod-i2c-qcom-geni.ko \
kmod-i2c-qup.ko \
kmod-i2c-rcar.ko \
kmod-i2c-riic.ko \
kmod-i2c-rk3x.ko \
kmod-i2c-robotfuzz-osif.ko \
kmod-i2c-rzv2m.ko \
kmod-i2c-s3c2410.ko \
kmod-i2c-sh-mobile.ko \
kmod-i2c-sis5595.ko \
kmod-i2c-sis630.ko \
kmod-i2c-sis96x.ko \
kmod-i2c-slave-eeprom.ko \
kmod-i2c-smbus.ko \
kmod-i2c-sprd.ko \
kmod-i2c-stm32f4.ko \
kmod-i2c-stm32f7-drv.ko \
kmod-i2c-stub.ko \
kmod-i2c-synquacer.ko \
kmod-i2c-taos-evm.ko \
kmod-i2c-tegra-bpmp.ko \
kmod-i2c-tegra.ko \
kmod-i2c-thunderx.ko \
kmod-i2c-tiny-usb.ko \
kmod-i2c-viai2c-common.ko \
kmod-i2c-viai2c-zhaoxin.ko \
kmod-i2c-viapro.ko \
kmod-i2c-viperboard.ko \
kmod-i2c-virtio.ko \
kmod-i2c-xgene-slimpro.ko \
kmod-i2c-xiic.ko \
kmod-i2c-xlp9xx.ko \
kmod-i3c-master-cdns.ko \
kmod-i3c.ko \
kmod-i40e.ko \
kmod-i5k-amb.ko \
kmod-i6300esb.ko \
kmod-iavf.ko \
kmod-ib-cm.ko \
kmod-ib-core.ko \
kmod-ib-ipoib.ko \
kmod-ib-iser.ko \
kmod-ib-isert.ko \
kmod-ib-mthca.ko \
kmod-ib-srp.ko \
kmod-ib-srpt.ko \
kmod-ib-umad.ko \
kmod-ib-uverbs-support.ko \
kmod-ib-uverbs.ko \
kmod-ibm-panel.ko \
kmod-ibmaem.ko \
kmod-ibmpex.ko \
kmod-icc-bcm-voter.ko \
kmod-icc-bwmon.ko \
kmod-icc-clk.ko \
kmod-icc-emi.ko \
kmod-icc-osm-l3.ko \
kmod-icc-rpmh.ko \
kmod-icc-smd-rpm.ko \
kmod-ice.ko \
kmod-ice40-spi.ko \
kmod-icp10100.ko \
kmod-icplus.ko \
kmod-ics932s401.ko \
kmod-idmouse.ko \
kmod-idpf.ko \
kmod-idt-89hpesx.ko \
kmod-idt-gen2.ko \
kmod-idt-gen3.ko \
kmod-idtcps.ko \
kmod-ieee802154-6lowpan.ko \
kmod-ieee802154-socket.ko \
kmod-ieee802154.ko \
kmod-ifb.ko \
kmod-ifcvf.ko \
kmod-ife.ko \
kmod-ifi-canfd.ko \
kmod-iforce-serio.ko \
kmod-iforce-usb.ko \
kmod-iforce.ko \
kmod-igb.ko \
kmod-igbvf.ko \
kmod-igc.ko \
kmod-igorplugusb.ko \
kmod-iguanair.ko \
kmod-iio-mux.ko \
kmod-iio-rescale.ko \
kmod-iio-trig-hrtimer.ko \
kmod-iio-trig-loop.ko \
kmod-iio-trig-sysfs.ko \
kmod-ila.ko \
kmod-ili210x.ko \
kmod-ilitek-ts-i2c.ko \
kmod-imagis.ko \
kmod-imm.ko \
kmod-imon-raw.ko \
kmod-imon.ko \
kmod-ims-pcu.ko \
kmod-imx-aipstz.ko \
kmod-imx-audio-rpmsg.ko \
kmod-imx-bus.ko \
kmod-imx-common.ko \
kmod-imx-cpufreq-dt.ko \
kmod-imx-dcss.ko \
kmod-imx-dma.ko \
kmod-imx-dsp-rproc.ko \
kmod-imx-dsp.ko \
kmod-imx-earlycon.ko \
kmod-imx-interconnect.ko \
kmod-imx-keypad.ko \
kmod-imx-lcdc.ko \
kmod-imx-lcdif.ko \
kmod-imx-ldb-helper.ko \
kmod-imx-mailbox.ko \
kmod-imx-mipi-csis.ko \
kmod-imx-pcm-dma.ko \
kmod-imx-pcm-rpmsg.ko \
kmod-imx-pxp.ko \
kmod-imx-rproc.ko \
kmod-imx-sc-key.ko \
kmod-imx-sc-thermal.ko \
kmod-imx-sc-wdt.ko \
kmod-imx-scu.ko \
kmod-imx-sdma.ko \
kmod-imx-sm-bbm-key.ko \
kmod-imx-sm-bbm.ko \
kmod-imx-sm-cpu.ko \
kmod-imx-sm-lmm.ko \
kmod-imx-sm-misc.ko \
kmod-imx-thermal.ko \
kmod-imx-weim.ko \
kmod-imx.ko \
kmod-imx111.ko \
kmod-imx2-wdt.ko \
kmod-imx208.ko \
kmod-imx214.ko \
kmod-imx219.ko \
kmod-imx258.ko \
kmod-imx274.ko \
kmod-imx283.ko \
kmod-imx290.ko \
kmod-imx296.ko \
kmod-imx319.ko \
kmod-imx334.ko \
kmod-imx335.ko \
kmod-imx355.ko \
kmod-imx412.ko \
kmod-imx415.ko \
kmod-imx7-media-csi.ko \
kmod-imx7ulp-wdt.ko \
kmod-imx8-dc-drm.ko \
kmod-imx8-isi.ko \
kmod-imx8m-blk-ctrl.ko \
kmod-imx8m-ddrc.ko \
kmod-imx8mm-interconnect.ko \
kmod-imx8mm-thermal.ko \
kmod-imx8mn-interconnect.ko \
kmod-imx8mp-blk-ctrl.ko \
kmod-imx8mp-hdmi-pai.ko \
kmod-imx8mp-hdmi-pvi.ko \
kmod-imx8mp-hdmi-tx.ko \
kmod-imx8mp-interconnect.ko \
kmod-imx8mq-interconnect.ko \
kmod-imx8qm-ldb.ko \
kmod-imx8qxp-adc.ko \
kmod-imx8qxp-ldb.ko \
kmod-imx8qxp-pixel-combiner.ko \
kmod-imx8qxp-pixel-link.ko \
kmod-imx8qxp-pxl2dpi.ko \
kmod-imx91-thermal.ko \
kmod-imx93-adc.ko \
kmod-imx93-blk-ctrl.ko \
kmod-imx93-mipi-dsi.ko \
kmod-imx93-pd.ko \
kmod-imx93-src.ko \
kmod-imxfb.ko \
kmod-ina209.ko \
kmod-ina233.ko \
kmod-ina238.ko \
kmod-ina2xx-adc.ko \
kmod-ina2xx.ko \
kmod-ina3221.ko \
kmod-industrialio-adc.ko \
kmod-industrialio-backend.ko \
kmod-industrialio-buffer-cb.ko \
kmod-industrialio-buffer-dma.ko \
kmod-industrialio-buffer-dmaengine.ko \
kmod-industrialio-configfs.ko \
kmod-industrialio-gts-helper.ko \
kmod-industrialio-hw-consumer.ko \
kmod-industrialio-sw-device.ko \
kmod-industrialio-sw-trigger.ko \
kmod-industrialio-triggered-buffer.ko \
kmod-industrialio-triggered-event.ko \
kmod-industrialio.ko \
kmod-inet-diag.ko \
kmod-inexio.ko \
kmod-inftl.ko \
kmod-initio.ko \
kmod-inno-hdmi.ko \
kmod-input-core.ko \
kmod-input-leds.ko \
kmod-inspur-ipsps.ko \
kmod-int51x1.ko \
kmod-intel-cvs.ko \
kmod-intel-qat.ko \
kmod-intel-xway.ko \
kmod-interconnect-qcom.ko \
kmod-interrupt-cnt.ko \
kmod-interval-tree-test.ko \
kmod-inv-icm42600-i2c.ko \
kmod-inv-icm42600-spi.ko \
kmod-inv-icm42600.ko \
kmod-inv-mpu6050-i2c.ko \
kmod-inv-mpu6050-spi.ko \
kmod-inv-mpu6050.ko \
kmod-inv-sensors-timestamp.ko \
kmod-io-domain.ko \
kmod-io-edgeport.ko \
kmod-io-ti.ko \
kmod-ionic-rdma.ko \
kmod-ionic.ko \
kmod-iova.ko \
kmod-iowarrior.ko \
kmod-ip-gre.ko \
kmod-ip-set-bitmap-ip.ko \
kmod-ip-set-bitmap-ipmac.ko \
kmod-ip-set-bitmap-port.ko \
kmod-ip-set-hash-ip.ko \
kmod-ip-set-hash-ipmac.ko \
kmod-ip-set-hash-ipmark.ko \
kmod-ip-set-hash-ipport.ko \
kmod-ip-set-hash-ipportip.ko \
kmod-ip-set-hash-ipportnet.ko \
kmod-ip-set-hash-mac.ko \
kmod-ip-set-hash-net.ko \
kmod-ip-set-hash-netiface.ko \
kmod-ip-set-hash-netnet.ko \
kmod-ip-set-hash-netport.ko \
kmod-ip-set-hash-netportnet.ko \
kmod-ip-set-list-set.ko \
kmod-ip-set.ko \
kmod-ip-tables.ko \
kmod-ip-tunnel.ko \
kmod-ip-vs-dh.ko \
kmod-ip-vs-fo.ko \
kmod-ip-vs-ftp.ko \
kmod-ip-vs-lblc.ko \
kmod-ip-vs-lblcr.ko \
kmod-ip-vs-lc.ko \
kmod-ip-vs-mh.ko \
kmod-ip-vs-nq.ko \
kmod-ip-vs-ovf.ko \
kmod-ip-vs-pe-sip.ko \
kmod-ip-vs-rr.ko \
kmod-ip-vs-sed.ko \
kmod-ip-vs-sh.ko \
kmod-ip-vs-twos.ko \
kmod-ip-vs-wlc.ko \
kmod-ip-vs-wrr.ko \
kmod-ip-vs.ko \
kmod-ip-vti.ko \
kmod-ip5xxx-power.ko \
kmod-ip6-gre.ko \
kmod-ip6-tables.ko \
kmod-ip6-tunnel.ko \
kmod-ip6-udp-tunnel.ko \
kmod-ip6-vti.ko \
kmod-ip6t-NPT.ko \
kmod-ip6t-REJECT.ko \
kmod-ip6t-SYNPROXY.ko \
kmod-ip6t-ah.ko \
kmod-ip6t-eui64.ko \
kmod-ip6t-frag.ko \
kmod-ip6t-hbh.ko \
kmod-ip6t-ipv6header.ko \
kmod-ip6t-mh.ko \
kmod-ip6t-rpfilter.ko \
kmod-ip6t-rt.ko \
kmod-ip6t-srh.ko \
kmod-ip6table-filter.ko \
kmod-ip6table-mangle.ko \
kmod-ip6table-nat.ko \
kmod-ip6table-raw.ko \
kmod-ip6table-security.ko \
kmod-ipa.ko \
kmod-ipack.ko \
kmod-ipaq.ko \
kmod-ipcomp.ko \
kmod-ipcomp6.ko \
kmod-ipheth.ko \
kmod-ipip.ko \
kmod-ipmb-dev-int.ko \
kmod-ipmi-devintf.ko \
kmod-ipmi-ipmb.ko \
kmod-ipmi-msghandler.ko \
kmod-ipmi-poweroff.ko \
kmod-ipmi-si.ko \
kmod-ipmi-ssif.ko \
kmod-ipmi-watchdog.ko \
kmod-ipoctal.ko \
kmod-ipq-cmn-pll.ko \
kmod-iproc-rng200.ko \
kmod-ips.ko \
kmod-ipt-ECN.ko \
kmod-ipt-REJECT.ko \
kmod-ipt-SYNPROXY.ko \
kmod-ipt-ah.ko \
kmod-ipt-rpfilter.ko \
kmod-iptable-filter.ko \
kmod-iptable-mangle.ko \
kmod-iptable-nat.ko \
kmod-iptable-raw.ko \
kmod-iptable-security.ko \
kmod-ipu-bridge.ko \
kmod-ipvlan.ko \
kmod-ipvtap.ko \
kmod-ipw.ko \
kmod-ipw2100.ko \
kmod-ipw2200.ko \
kmod-iqs269a.ko \
kmod-iqs5xx.ko \
kmod-iqs620at-temp.ko \
kmod-iqs621-als.ko \
kmod-iqs624-pos.ko \
kmod-iqs626a.ko \
kmod-iqs62x-keys.ko \
kmod-iqs62x.ko \
kmod-iqs7211.ko \
kmod-iqs7222.ko \
kmod-ir-hix5hd2.ko \
kmod-ir-imon-decoder.ko \
kmod-ir-jvc-decoder.ko \
kmod-ir-kbd-i2c.ko \
kmod-ir-mce-kbd-decoder.ko \
kmod-ir-nec-decoder.ko \
kmod-ir-rc5-decoder.ko \
kmod-ir-rc6-decoder.ko \
kmod-ir-rcmm-decoder.ko \
kmod-ir-sanyo-decoder.ko \
kmod-ir-sharp-decoder.ko \
kmod-ir-sony-decoder.ko \
kmod-ir-spi.ko \
kmod-ir-toy.ko \
kmod-ir-usb.ko \
kmod-ir-xmp-decoder.ko \
kmod-ir35221.ko \
kmod-ir36021.ko \
kmod-ir38064.ko \
kmod-irdma.ko \
kmod-irps5401.ko \
kmod-irq-bcm2712-mip.ko \
kmod-irq-bcm7038-l1.ko \
kmod-irq-bcm7120-l2.ko \
kmod-irq-brcmstb-l2.ko \
kmod-irq-imx-mu-msi.ko \
kmod-irq-madera.ko \
kmod-irq-meson-gpio.ko \
kmod-irq-mvebu-pic.ko \
kmod-irq-qcom-mpm.ko \
kmod-irq-renesas-rzt2h.ko \
kmod-irq-stm32mp-exti.ko \
kmod-irqbypass.ko \
kmod-irsd200.ko \
kmod-iscsi-boot-sysfs.ko \
kmod-iscsi-ibft.ko \
kmod-iscsi-target-mod.ko \
kmod-iscsi-tcp.ko \
kmod-isight-firmware.ko \
kmod-isl28022.ko \
kmod-isl29020.ko \
kmod-isl29501.ko \
kmod-isl6405.ko \
kmod-isl6421.ko \
kmod-isl6423.ko \
kmod-isl68137.ko \
kmod-isl7998x.ko \
kmod-isl9305.ko \
kmod-isofs.ko \
kmod-isp116x-hcd.ko \
kmod-isp1704-charger.ko \
kmod-isp1760.ko \
kmod-it5205.ko \
kmod-it87.ko \
kmod-it913x.ko \
kmod-itd1000.ko \
kmod-ite-it6505.ko \
kmod-ite-it66121.ko \
kmod-iuu-phoenix.ko \
kmod-ivtv-alsa.ko \
kmod-ivtv.ko \
kmod-ivtvfb.ko \
kmod-iw-cm.ko \
kmod-iw-cxgb4.ko \
kmod-iwl3945.ko \
kmod-iwl4965.ko \
kmod-iwldvm.ko \
kmod-iwlegacy.ko \
kmod-iwlmld.ko \
kmod-iwlmvm.ko \
kmod-iwlwifi.ko \
kmod-ix2505v.ko \
kmod-ixgbe.ko \
kmod-ixgbevf.ko \
kmod-jbd2.ko \
kmod-jc42.ko \
kmod-jedec-probe.ko \
kmod-jffs2.ko \
kmod-jfs.ko \
kmod-jitterentropy-rng.ko \
kmod-jmb38x-ms.ko \
kmod-jme.ko \
kmod-joydev.ko \
kmod-jsa1212.ko \
kmod-jsm.ko \
kmod-k3dma.ko \
kmod-kafs.ko \
kmod-kalmia.ko \
kmod-kaweth.ko \
kmod-kbatt.ko \
kmod-kbic.ko \
kmod-kbtab.ko \
kmod-kcm.ko \
kmod-kcomedilib.ko \
kmod-kcs-bmc-aspeed.ko \
kmod-kcs-bmc-cdev-ipmi.ko \
kmod-kcs-bmc-npcm7xx.ko \
kmod-kcs-bmc-serio.ko \
kmod-kcs-bmc.ko \
kmod-kdf-sp800108.ko \
kmod-keembay-ocs-aes.ko \
kmod-keembay-ocs-ecc.ko \
kmod-keembay-ocs-hcu.ko \
kmod-keembay-wdt.ko \
kmod-kempld-core.ko \
kmod-kempld-wdt.ko \
kmod-keyspan-pda.ko \
kmod-keyspan-remote.ko \
kmod-keyspan.ko \
kmod-kfan.ko \
kmod-kfifo-buf.ko \
kmod-kgdboc.ko \
kmod-khadas-mcu-fan.ko \
kmod-khadas-mcu.ko \
kmod-kirin-drm.ko \
kmod-kl5kusb105.ko \
kmod-kmem.ko \
kmod-kmx61.ko \
kmod-kobil-sct.ko \
kmod-komeda.ko \
kmod-kpp.ko \
kmod-krb5.ko \
kmod-krb5enc.ko \
kmod-ks0108.ko \
kmod-ks0127.ko \
kmod-ks8842.ko \
kmod-ks8851-common.ko \
kmod-ks8851-par.ko \
kmod-ks8851-spi.ko \
kmod-ks8995.ko \
kmod-ksmbd.ko \
kmod-ksz-spi.ko \
kmod-ksz-switch.ko \
kmod-ksz884x.ko \
kmod-ksz8863-smi.ko \
kmod-ksz9477-i2c.ko \
kmod-ktd253-backlight.ko \
kmod-ktd2801-backlight.ko \
kmod-ktti.ko \
kmod-ktz8866.ko \
kmod-kunpeng-hccs.ko \
kmod-kvaser-pci.ko \
kmod-kvaser-pciefd.ko \
kmod-kvaser-usb.ko \
kmod-kvm.ko \
kmod-kxtj9.ko \
kmod-kyber-iosched.ko \
kmod-l2tp-core.ko \
kmod-l2tp-eth.ko \
kmod-l2tp-ip.ko \
kmod-l2tp-ip6.ko \
kmod-l2tp-netlink.ko \
kmod-l2tp-ppp.ko \
kmod-l64781.ko \
kmod-lan743x.ko \
kmod-lan78xx.ko \
kmod-lan865x.ko \
kmod-lan9252.ko \
kmod-lan9303-core.ko \
kmod-lan9303-i2c.ko \
kmod-lan9303-mdio.ko \
kmod-lan966x-switch.ko \
kmod-lantiq-gswip-common.ko \
kmod-lantiq-gswip.ko \
kmod-lapb.ko \
kmod-lapbether.ko \
kmod-lattice-sysconfig-spi.ko \
kmod-lattice-sysconfig.ko \
kmod-layerscape-edac-mod.ko \
kmod-lcd.ko \
kmod-ldusb.ko \
kmod-led-bl.ko \
kmod-led-class-flash.ko \
kmod-led-class-multicolor.ko \
kmod-led-class.ko \
kmod-leds-an30259a.ko \
kmod-leds-as3645a.ko \
kmod-leds-as3668.ko \
kmod-leds-aw200xx.ko \
kmod-leds-aw2013.ko \
kmod-leds-bcm63138.ko \
kmod-leds-bd2606mvv.ko \
kmod-leds-bd2802.ko \
kmod-leds-blinkm.ko \
kmod-leds-cpcap.ko \
kmod-leds-cr0014114.ko \
kmod-leds-cros-ec.ko \
kmod-leds-el15203000.ko \
kmod-leds-gpio.ko \
kmod-leds-group-multicolor.ko \
kmod-leds-is31fl319x.ko \
kmod-leds-is31fl32xx.ko \
kmod-leds-ktd202x.ko \
kmod-leds-lm3530.ko \
kmod-leds-lm3532.ko \
kmod-leds-lm3533.ko \
kmod-leds-lm355x.ko \
kmod-leds-lm3601x.ko \
kmod-leds-lm36274.ko \
kmod-leds-lm3642.ko \
kmod-leds-lm3692x.ko \
kmod-leds-lm3697.ko \
kmod-leds-lp3944.ko \
kmod-leds-lp3952.ko \
kmod-leds-lp50xx.ko \
kmod-leds-lp5521.ko \
kmod-leds-lp5523.ko \
kmod-leds-lp5562.ko \
kmod-leds-lp5569.ko \
kmod-leds-lp55xx-common.ko \
kmod-leds-lp5812.ko \
kmod-leds-lp5860-core.ko \
kmod-leds-lp5860-spi.ko \
kmod-leds-lp8501.ko \
kmod-leds-lp8860.ko \
kmod-leds-lp8864.ko \
kmod-leds-lt3593.ko \
kmod-leds-max5970.ko \
kmod-leds-max77650.ko \
kmod-leds-menf21bmc.ko \
kmod-leds-mlxreg.ko \
kmod-leds-mt6360.ko \
kmod-leds-ncp5623.ko \
kmod-leds-pca9532.ko \
kmod-leds-pca955x.ko \
kmod-leds-pca963x.ko \
kmod-leds-pca995x.ko \
kmod-leds-pwm-multicolor.ko \
kmod-leds-pwm.ko \
kmod-leds-qcom-flash.ko \
kmod-leds-qcom-lpg.ko \
kmod-leds-qnap-mcu.ko \
kmod-leds-rt4505.ko \
kmod-leds-rt8515.ko \
kmod-leds-s2m-flash.ko \
kmod-leds-s2m-rgb.ko \
kmod-leds-sc27xx-bltc.ko \
kmod-leds-sgm3140.ko \
kmod-leds-spi-byte.ko \
kmod-leds-st1202.ko \
kmod-leds-sun50i-a100.ko \
kmod-leds-sy7802.ko \
kmod-leds-tca6507.ko \
kmod-leds-ti-lmu-common.ko \
kmod-leds-tps6131x.ko \
kmod-ledtrig-activity.ko \
kmod-ledtrig-backlight.ko \
kmod-ledtrig-camera.ko \
kmod-ledtrig-default-on.ko \
kmod-ledtrig-gpio.ko \
kmod-ledtrig-heartbeat.ko \
kmod-ledtrig-input-events.ko \
kmod-ledtrig-netdev.ko \
kmod-ledtrig-oneshot.ko \
kmod-ledtrig-pattern.ko \
kmod-ledtrig-timer.ko \
kmod-ledtrig-transient.ko \
kmod-ledtrig-tty.ko \
kmod-ledtrig-usbport.ko \
kmod-legousbtower.ko \
kmod-lenovo-thinkpad-t14s.ko \
kmod-lenovo-yoga-c630-battery.ko \
kmod-lenovo-yoga-c630.ko \
kmod-lg-vl600.ko \
kmod-lg2160.ko \
kmod-lgdt3305.ko \
kmod-lgdt3306a.ko \
kmod-lgdt330x.ko \
kmod-lgs8gl5.ko \
kmod-lgs8gxx.ko \
kmod-libaes.ko \
kmod-libahci-platform.ko \
kmod-libahci.ko \
kmod-libarc4.ko \
kmod-libata.ko \
kmod-libblake2b.ko \
kmod-libceph.ko \
kmod-libchacha.ko \
kmod-libchacha20poly1305.ko \
kmod-libcomposite.ko \
kmod-libcryptoutils.ko \
kmod-libcurve25519.ko \
kmod-libcxgb.ko \
kmod-libcxgbi.ko \
kmod-libdes.ko \
kmod-libertas-sdio.ko \
kmod-libertas-tf-usb.ko \
kmod-libertas-tf.ko \
kmod-libertas.ko \
kmod-libeth-xdp.ko \
kmod-libeth.ko \
kmod-libfc.ko \
kmod-libfcoe.ko \
kmod-libgf128hash.ko \
kmod-libie-adminq.ko \
kmod-libie-fwlog.ko \
kmod-libie.ko \
kmod-libipw.ko \
kmod-libiscsi-tcp.ko \
kmod-libiscsi.ko \
kmod-libmd5.ko \
kmod-libmldsa.ko \
kmod-libnh.ko \
kmod-libnvdimm.ko \
kmod-libphy.ko \
kmod-libpoly1305.ko \
kmod-libps2.ko \
kmod-libsas.ko \
kmod-libsha1.ko \
kmod-libsha256.ko \
kmod-libsha3.ko \
kmod-libsha512.ko \
kmod-libsm3.ko \
kmod-libwx.ko \
kmod-lima.ko \
kmod-line-display.ko \
kmod-lineage-pem.ko \
kmod-linear-ranges.ko \
kmod-linear.ko \
kmod-linkstation-poweroff.ko \
kmod-liquidio-core.ko \
kmod-liquidio-vf.ko \
kmod-liquidio.ko \
kmod-lis3lv02d-i2c.ko \
kmod-lis3lv02d.ko \
kmod-litex-liteeth.ko \
kmod-lkdtm.ko \
kmod-ll-temac.ko \
kmod-llc.ko \
kmod-llc2.ko \
kmod-llcc-qcom.ko \
kmod-lm25066.ko \
kmod-lm3509-bl.ko \
kmod-lm3533-bl.ko \
kmod-lm3533-core.ko \
kmod-lm3533-ctrlbank.ko \
kmod-lm3560.ko \
kmod-lm3630a-bl.ko \
kmod-lm3639-bl.ko \
kmod-lm363x-regulator.ko \
kmod-lm3646.ko \
kmod-lm63.ko \
kmod-lm73.ko \
kmod-lm75.ko \
kmod-lm77.ko \
kmod-lm78.ko \
kmod-lm80.ko \
kmod-lm83.ko \
kmod-lm8323.ko \
kmod-lm8333.ko \
kmod-lm85.ko \
kmod-lm87.ko \
kmod-lm90.ko \
kmod-lm92.ko \
kmod-lm93.ko \
kmod-lm95234.ko \
kmod-lm95241.ko \
kmod-lm95245.ko \
kmod-lmh.ko \
kmod-lmp91000.ko \
kmod-lnbh25.ko \
kmod-lnbh29.ko \
kmod-lnbp21.ko \
kmod-lnbp22.ko \
kmod-lochnagar-hwmon.ko \
kmod-lochnagar-regulator.ko \
kmod-lockd.ko \
kmod-logicvc-drm.ko \
kmod-lontium-lt8912b.ko \
kmod-lontium-lt9211.ko \
kmod-lontium-lt9611.ko \
kmod-lontium-lt9611uxc.ko \
kmod-loop.ko \
kmod-lp.ko \
kmod-lp3943.ko \
kmod-lp855x-bl.ko \
kmod-lp8727-charger.ko \
kmod-lp873x-regulator.ko \
kmod-lp873x.ko \
kmod-lp87565-regulator.ko \
kmod-lp87565.ko \
kmod-lpass-gfm-sm8250.ko \
kmod-lpassaudiocc-sc7280.ko \
kmod-lpasscc-sc7280.ko \
kmod-lpasscc-sc8280xp.ko \
kmod-lpasscc-sdm845.ko \
kmod-lpasscc-sm6115.ko \
kmod-lpasscorecc-sc7180.ko \
kmod-lpasscorecc-sc7280.ko \
kmod-lpc-ich.ko \
kmod-lpc-sch.ko \
kmod-lpddr-cmds.ko \
kmod-lpfc.ko \
kmod-lru-cache.ko \
kmod-lrw.ko \
kmod-lt3074.ko \
kmod-lt3651-charger.ko \
kmod-lt6911uxe.ko \
kmod-lt7182s.ko \
kmod-ltc1660.ko \
kmod-ltc2309.ko \
kmod-ltc2471.ko \
kmod-ltc2485.ko \
kmod-ltc2496.ko \
kmod-ltc2497-core.ko \
kmod-ltc2497.ko \
kmod-ltc2632.ko \
kmod-ltc2664.ko \
kmod-ltc2688.ko \
kmod-ltc2945.ko \
kmod-ltc2947-core.ko \
kmod-ltc2947-i2c.ko \
kmod-ltc2947-spi.ko \
kmod-ltc2978.ko \
kmod-ltc2983.ko \
kmod-ltc2990.ko \
kmod-ltc2991.ko \
kmod-ltc2992.ko \
kmod-ltc3589.ko \
kmod-ltc3676.ko \
kmod-ltc3815.ko \
kmod-ltc4151.ko \
kmod-ltc4162-l-charger.ko \
kmod-ltc4215.ko \
kmod-ltc4222.ko \
kmod-ltc4245.ko \
kmod-ltc4260.ko \
kmod-ltc4261.ko \
kmod-ltc4282.ko \
kmod-ltc4283.ko \
kmod-lv0104cs.ko \
kmod-lv5207lp.ko \
kmod-lvds-codec.ko \
kmod-lvds.ko \
kmod-lvstest.ko \
kmod-lvts-thermal.ko \
kmod-lx1308.ko \
kmod-lxt.ko \
kmod-lz4-compress.ko \
kmod-lz4-decompress.ko \
kmod-lz4.ko \
kmod-lz4hc-compress.ko \
kmod-lz4hc.ko \
kmod-lzo-compress.ko \
kmod-lzo-decompress.ko \
kmod-lzo-rle.ko \
kmod-lzo.ko \
kmod-m-can-pci.ko \
kmod-m-can-platform.ko \
kmod-m-can.ko \
kmod-m24lr.ko \
kmod-m2m-deinterlace.ko \
kmod-m52790.ko \
kmod-m62332.ko \
kmod-m88ds3103.ko \
kmod-m88rs2000.ko \
kmod-m88rs6000t.ko \
kmod-ma35d1-serial.ko \
kmod-mac-celtic.ko \
kmod-mac-centeuro.ko \
kmod-mac-croatian.ko \
kmod-mac-cyrillic.ko \
kmod-mac-gaelic.ko \
kmod-mac-greek.ko \
kmod-mac-iceland.ko \
kmod-mac-inuit.ko \
kmod-mac-roman.ko \
kmod-mac-romanian.ko \
kmod-mac-turkish.ko \
kmod-mac80211-hwsim.ko \
kmod-mac80211.ko \
kmod-mac802154-hwsim.ko \
kmod-mac802154.ko \
kmod-macb-pci.ko \
kmod-macb.ko \
kmod-machxo2-spi.ko \
kmod-macsec.ko \
kmod-macsmc-hwmon.ko \
kmod-macsmc-power.ko \
kmod-macsmc-reboot.ko \
kmod-macsmc.ko \
kmod-macvlan.ko \
kmod-macvtap.ko \
kmod-madera-i2c.ko \
kmod-madera-spi.ko \
kmod-madera.ko \
kmod-magellan.ko \
kmod-mailbox-mpfs.ko \
kmod-mailbox-xgene-slimpro.ko \
kmod-mali-c55.ko \
kmod-mali-dp.ko \
kmod-mana-ib.ko \
kmod-mana.ko \
kmod-mantis-core.ko \
kmod-mantis.ko \
kmod-map-absent.ko \
kmod-map-funcs.ko \
kmod-map-ram.ko \
kmod-map-rom.ko \
kmod-marvell-88q2xxx.ko \
kmod-marvell-88x2222.ko \
kmod-marvell-cesa.ko \
kmod-marvell-cn10k-ddr-pmu.ko \
kmod-marvell-cn10k-tad-pmu.ko \
kmod-marvell-gti-wdt.ko \
kmod-marvell-nand.ko \
kmod-marvell-pem-pmu.ko \
kmod-marvell.ko \
kmod-marvell10g.ko \
kmod-matrix-keymap.ko \
kmod-matrix-keypad.ko \
kmod-matrox-w1.ko \
kmod-max11100.ko \
kmod-max1118.ko \
kmod-max11801-ts.ko \
kmod-max1241.ko \
kmod-max127.ko \
kmod-max14001.ko \
kmod-max14656-charger-detector.ko \
kmod-max15301.ko \
kmod-max16064.ko \
kmod-max16065.ko \
kmod-max1619.ko \
kmod-max16601.ko \
kmod-max1668.ko \
kmod-max17040-battery.ko \
kmod-max17042-battery.ko \
kmod-max1720x-battery.ko \
kmod-max1721x-battery.ko \
kmod-max17616.ko \
kmod-max20086-regulator.ko \
kmod-max20411-regulator.ko \
kmod-max20730.ko \
kmod-max20751.ko \
kmod-max20830.ko \
kmod-max20860a.ko \
kmod-max2165.ko \
kmod-max2175.ko \
kmod-max22007.ko \
kmod-max25014.ko \
kmod-max30100.ko \
kmod-max30102.ko \
kmod-max30208.ko \
kmod-max31722.ko \
kmod-max31730.ko \
kmod-max31760.ko \
kmod-max31785.ko \
kmod-max31790.ko \
kmod-max31827.ko \
kmod-max31856.ko \
kmod-max31865.ko \
kmod-max3420-udc.ko \
kmod-max3421-hcd.ko \
kmod-max34440.ko \
kmod-max44009.ko \
kmod-max5432.ko \
kmod-max5481.ko \
kmod-max5487.ko \
kmod-max5970-regulator.ko \
kmod-max6620.ko \
kmod-max6621.ko \
kmod-max6639.ko \
kmod-max6650.ko \
kmod-max6697.ko \
kmod-max6875.ko \
kmod-max6959.ko \
kmod-max7359-keypad.ko \
kmod-max7360-keypad.ko \
kmod-max7360-rotary.ko \
kmod-max7360.ko \
kmod-max77503-regulator.ko \
kmod-max77620-regulator.ko \
kmod-max77620-thermal.ko \
kmod-max77620-wdt.ko \
kmod-max77620.ko \
kmod-max77650-charger.ko \
kmod-max77650-onkey.ko \
kmod-max77650-regulator.ko \
kmod-max77650.ko \
kmod-max77675-regulator.ko \
kmod-max77714.ko \
kmod-max77759-charger.ko \
kmod-max77759.ko \
kmod-max77826-regulator.ko \
kmod-max77838-regulator.ko \
kmod-max77857-regulator.ko \
kmod-max77976-charger.ko \
kmod-max8688.ko \
kmod-max8893.ko \
kmod-max8903-charger.ko \
kmod-max8971-charger.ko \
kmod-max9271.ko \
kmod-max9286.ko \
kmod-max9611.ko \
kmod-max96712.ko \
kmod-max96714.ko \
kmod-max96717.ko \
kmod-maxim-thermocouple.ko \
kmod-mb1232.ko \
kmod-mb86a16.ko \
kmod-mb86a20s.ko \
kmod-mbcache.ko \
kmod-mc.ko \
kmod-mc3230.ko \
kmod-mc33xs2410-hwmon.ko \
kmod-mc34vr500.ko \
kmod-mc44s803.ko \
kmod-mcam-core.ko \
kmod-mcba-usb.ko \
kmod-mceusb.ko \
kmod-mchp-pci1xxxx-gp.ko \
kmod-mchp-pci1xxxx-gpio.ko \
kmod-mchp-pci1xxxx-otpe2p.ko \
kmod-mchp23k256.ko \
kmod-mchp48l640.ko \
kmod-mcp16502.ko \
kmod-mcp251xfd.ko \
kmod-mcp3021.ko \
kmod-mcp3564.ko \
kmod-mcp3911.ko \
kmod-mcp4018.ko \
kmod-mcp41010.ko \
kmod-mcp4531.ko \
kmod-mcp4728.ko \
kmod-mcp47feb02.ko \
kmod-mcp9600.ko \
kmod-mcp9982.ko \
kmod-mcr20a.ko \
kmod-mcs7830.ko \
kmod-mct-u232.ko \
kmod-mctp-i2c.ko \
kmod-mctp-i3c.ko \
kmod-mctp-serial.ko \
kmod-mctp-usb.ko \
kmod-md-cluster.ko \
kmod-md-mod.ko \
kmod-md4.ko \
kmod-md5.ko \
kmod-mdc800.ko \
kmod-mdio-airoha.ko \
kmod-mdio-aspeed.ko \
kmod-mdio-bcm-unimac.ko \
kmod-mdio-bitbang.ko \
kmod-mdio-bus.ko \
kmod-mdio-cavium.ko \
kmod-mdio-devres.ko \
kmod-mdio-gpio.ko \
kmod-mdio-hisi-femac.ko \
kmod-mdio-i2c.ko \
kmod-mdio-ipq4019.ko \
kmod-mdio-ipq8064.ko \
kmod-mdio-mscc-miim.ko \
kmod-mdio-mux-bcm-iproc.ko \
kmod-mdio-mux-gpio.ko \
kmod-mdio-mux-meson-g12a.ko \
kmod-mdio-mux-meson-gxl.ko \
kmod-mdio-mux-mmioreg.ko \
kmod-mdio-mux-multiplexer.ko \
kmod-mdio-mux.ko \
kmod-mdio-mvusb.ko \
kmod-mdio-octeon.ko \
kmod-mdio-pic64hpsc.ko \
kmod-mdio-regmap.ko \
kmod-mdio-sun4i.ko \
kmod-mdio-thunder.ko \
kmod-mdio-xgene.ko \
kmod-mdio.ko \
kmod-mdt-loader.ko \
kmod-mediatek-cpufreq-hw.ko \
kmod-mediatek-cpufreq.ko \
kmod-mediatek-drm.ko \
kmod-mediatek.ko \
kmod-megachips-stdpxxxx-ge-b850v3-fw.ko \
kmod-megaraid-mbox.ko \
kmod-megaraid-mm.ko \
kmod-megaraid-sas.ko \
kmod-megaraid.ko \
kmod-melfas-mip4.ko \
kmod-memconsole-coreboot.ko \
kmod-memconsole.ko \
kmod-memory-notifier-error-inject.ko \
kmod-memstick.ko \
kmod-mena21-wdt.ko \
kmod-menf21bmc.ko \
kmod-meson-aoclk.ko \
kmod-meson-canvas.ko \
kmod-meson-clk-measure.ko \
kmod-meson-clkc-utils.ko \
kmod-meson-drm.ko \
kmod-meson-dw-hdmi.ko \
kmod-meson-dw-mipi-dsi.ko \
kmod-meson-ee-pwrc.ko \
kmod-meson-gx-mmc.ko \
kmod-meson-gxbb-wdt.ko \
kmod-meson-gxl.ko \
kmod-meson-ir-tx.ko \
kmod-meson-ir.ko \
kmod-meson-nand.ko \
kmod-meson-rng.ko \
kmod-meson-saradc.ko \
kmod-meson-secure-pwrc.ko \
kmod-meson-sm.ko \
kmod-meson-uart.ko \
kmod-meson-vdec.ko \
kmod-meson-wdt.ko \
kmod-metro-usb.ko \
kmod-mfd-core.ko \
kmod-mgag200.ko \
kmod-mgb4.ko \
kmod-mhi-ep.ko \
kmod-mhi-net.ko \
kmod-mhi-pci-generic.ko \
kmod-mhi-wwan-ctrl.ko \
kmod-mhi-wwan-mbim.ko \
kmod-mhi.ko \
kmod-mhz19b.ko \
kmod-mi0283qt.ko \
kmod-micrel.ko \
kmod-microchip-spi.ko \
kmod-microchip-t1.ko \
kmod-microchip-t1s.ko \
kmod-microchip.ko \
kmod-microread-i2c.ko \
kmod-microread.ko \
kmod-microtek.ko \
kmod-mii.ko \
kmod-minix.ko \
kmod-mip6.ko \
kmod-mipi-i3c-hci-pci.ko \
kmod-mipi-i3c-hci.ko \
kmod-ml86v7667.ko \
kmod-mldsa.ko \
kmod-mlx-platform.ko \
kmod-mlx-wdt.ko \
kmod-mlx4-core.ko \
kmod-mlx4-en.ko \
kmod-mlx4-ib.ko \
kmod-mlx5-core.ko \
kmod-mlx5-dpll.ko \
kmod-mlx5-fwctl.ko \
kmod-mlx5-ib.ko \
kmod-mlx5-vdpa.ko \
kmod-mlx5-vfio-pci.ko \
kmod-mlx90614.ko \
kmod-mlx90632.ko \
kmod-mlx90635.ko \
kmod-mlxbf-bootctl.ko \
kmod-mlxbf-gige.ko \
kmod-mlxbf-pmc.ko \
kmod-mlxbf-tmfifo.ko \
kmod-mlxfw.ko \
kmod-mlxreg-dpu.ko \
kmod-mlxreg-fan.ko \
kmod-mlxreg-hotplug.ko \
kmod-mlxreg-io.ko \
kmod-mlxreg-lc.ko \
kmod-mlxsw-core.ko \
kmod-mlxsw-i2c.ko \
kmod-mlxsw-minimal.ko \
kmod-mlxsw-pci.ko \
kmod-mlxsw-spectrum.ko \
kmod-mm8013.ko \
kmod-mma7455-core.ko \
kmod-mma7455-i2c.ko \
kmod-mma7455-spi.ko \
kmod-mma7660.ko \
kmod-mma8450.ko \
kmod-mma9551-core.ko \
kmod-mma9551.ko \
kmod-mma9553.ko \
kmod-mmc-block.ko \
kmod-mmc-core.ko \
kmod-mmc-hsq.ko \
kmod-mmc5633.ko \
kmod-mmc5983.ko \
kmod-mmcc-msm8994.ko \
kmod-mmcc-msm8998.ko \
kmod-mmcc-sdm660.ko \
kmod-mmp-camera.ko \
kmod-mmp-pdma.ko \
kmod-mmp-tdma.ko \
kmod-mms114.ko \
kmod-mn88443x.ko \
kmod-mn88472.ko \
kmod-mn88473.ko \
kmod-mos7720.ko \
kmod-mos7840.ko \
kmod-motorcomm.ko \
kmod-motorola-cpcap.ko \
kmod-mousedev.ko \
kmod-moxtet.ko \
kmod-mp2629-adc.ko \
kmod-mp2629-charger.ko \
kmod-mp2629.ko \
kmod-mp2856.ko \
kmod-mp2869.ko \
kmod-mp2888.ko \
kmod-mp2891.ko \
kmod-mp2925.ko \
kmod-mp29502.ko \
kmod-mp2975.ko \
kmod-mp2985.ko \
kmod-mp2993.ko \
kmod-mp3309c.ko \
kmod-mp5023.ko \
kmod-mp5416.ko \
kmod-mp5920.ko \
kmod-mp5926.ko \
kmod-mp5990.ko \
kmod-mp8859.ko \
kmod-mp886x.ko \
kmod-mp9941.ko \
kmod-mp9945.ko \
kmod-mpfs-auto-update.ko \
kmod-mpfs-control-scb.ko \
kmod-mpfs-irqmux.ko \
kmod-mpfs-mss-top-sysreg.ko \
kmod-mpfs-rng.ko \
kmod-mpfs-sys-controller.ko \
kmod-mpi.ko \
kmod-mpi3mr.ko \
kmod-mpl115-i2c.ko \
kmod-mpl115-spi.ko \
kmod-mpl115.ko \
kmod-mpls-gso.ko \
kmod-mpls-iptunnel.ko \
kmod-mpls-router.ko \
kmod-mpq7920.ko \
kmod-mpq7932.ko \
kmod-mpq8785.ko \
kmod-mpr121-touchkey.ko \
kmod-mprls0025pa-i2c.ko \
kmod-mprls0025pa-spi.ko \
kmod-mprls0025pa.ko \
kmod-mpt3sas.ko \
kmod-mptbase.ko \
kmod-mptcp-diag.ko \
kmod-mptctl.ko \
kmod-mptfc.ko \
kmod-mptlan.ko \
kmod-mptsas.ko \
kmod-mptscsih.ko \
kmod-mptspi.ko \
kmod-mpu3050.ko \
kmod-mq-deadline.ko \
kmod-mr75203.ko \
kmod-mrp.ko \
kmod-mrvl-cn10k-dpi.ko \
kmod-ms-block.ko \
kmod-ms-sensors-i2c.ko \
kmod-ms5637.ko \
kmod-mscc-felix-dsa-lib.ko \
kmod-mscc-felix.ko \
kmod-mscc-ocelot-ext.ko \
kmod-mscc-ocelot-switch-lib.ko \
kmod-mscc-ocelot.ko \
kmod-mscc-seville.ko \
kmod-mscc.ko \
kmod-msdos.ko \
kmod-mse102x.ko \
kmod-msg2638.ko \
kmod-mshv-root.ko \
kmod-msi001.ko \
kmod-msi2500.ko \
kmod-msm-serial.ko \
kmod-msm.ko \
kmod-msp3400.ko \
kmod-mspro-block.ko \
kmod-mt2060.ko \
kmod-mt2063.ko \
kmod-mt20xx.ko \
kmod-mt2131.ko \
kmod-mt2266.ko \
kmod-mt312.ko \
kmod-mt352.ko \
kmod-mt6315-regulator.ko \
kmod-mt6316-regulator.ko \
kmod-mt6357-regulator.ko \
kmod-mt6358-regulator.ko \
kmod-mt6359-accdet.ko \
kmod-mt6359-auxadc.ko \
kmod-mt6359-regulator.ko \
kmod-mt6360-adc.ko \
kmod-mt6360-charger.ko \
kmod-mt6360-core.ko \
kmod-mt6360-regulator.ko \
kmod-mt6363-regulator.ko \
kmod-mt6380-regulator.ko \
kmod-mt6397-regulator.ko \
kmod-mt6397.ko \
kmod-mt6577-auxadc.ko \
kmod-mt6779-keypad.ko \
kmod-mt6797-mt6351.ko \
kmod-mt7530-mdio.ko \
kmod-mt7530-mmio.ko \
kmod-mt7530.ko \
kmod-mt76-connac-lib.ko \
kmod-mt76-sdio.ko \
kmod-mt76-usb.ko \
kmod-mt76.ko \
kmod-mt7601u.ko \
kmod-mt7603e.ko \
kmod-mt7615-common.ko \
kmod-mt7615e.ko \
kmod-mt7663-usb-sdio-common.ko \
kmod-mt7663s.ko \
kmod-mt7663u.ko \
kmod-mt76x0-common.ko \
kmod-mt76x02-lib.ko \
kmod-mt76x02-usb.ko \
kmod-mt76x0e.ko \
kmod-mt76x0u.ko \
kmod-mt76x2-common.ko \
kmod-mt76x2e.ko \
kmod-mt76x2u.ko \
kmod-mt7915e.ko \
kmod-mt7921-common.ko \
kmod-mt7921e.ko \
kmod-mt7921s.ko \
kmod-mt7921u.ko \
kmod-mt7925-common.ko \
kmod-mt7925e.ko \
kmod-mt7925u.ko \
kmod-mt792x-lib.ko \
kmod-mt792x-usb.ko \
kmod-mt7996e.ko \
kmod-mt8183-da7219-max98357.ko \
kmod-mt8183-mt6358-ts3a227-max98357.ko \
kmod-mt8183.ko \
kmod-mt8186-mt6366.ko \
kmod-mt8188-mt6359.ko \
kmod-mt8189-nau8825.ko \
kmod-mt8192-mt6359-rt1015-rt5682.ko \
kmod-mt8195-mt6359.ko \
kmod-mt8195.ko \
kmod-mt8196-nau8825.ko \
kmod-mt8196.ko \
kmod-mt8365-mt6357.ko \
kmod-mt9m001.ko \
kmod-mt9m111.ko \
kmod-mt9m114.ko \
kmod-mt9p031.ko \
kmod-mt9t112.ko \
kmod-mt9v011.ko \
kmod-mt9v032.ko \
kmod-mt9v111.ko \
kmod-mtd-blkdevs.ko \
kmod-mtd-intel-dg.ko \
kmod-mtd-nandbiterrs.ko \
kmod-mtd-nandecctest.ko \
kmod-mtd-oobtest.ko \
kmod-mtd-pagetest.ko \
kmod-mtd-readtest.ko \
kmod-mtd-speedtest.ko \
kmod-mtd-stresstest.ko \
kmod-mtd-subpagetest.ko \
kmod-mtd-test.ko \
kmod-mtd-torturetest.ko \
kmod-mtd.ko \
kmod-mtdblock-ro.ko \
kmod-mtdblock.ko \
kmod-mtdoops.ko \
kmod-mtdpstore.ko \
kmod-mtdram.ko \
kmod-mtdswap.ko \
kmod-mtip32xx.ko \
kmod-mtk-2p5ge.ko \
kmod-mtk-adsp-common.ko \
kmod-mtk-adsp-ipc.ko \
kmod-mtk-adsp-mailbox.ko \
kmod-mtk-btcvsd.ko \
kmod-mtk-cci-devfreq.ko \
kmod-mtk-cec.ko \
kmod-mtk-cir.ko \
kmod-mtk-cmdq-helper.ko \
kmod-mtk-cmdq-mailbox.ko \
kmod-mtk-cqdma.ko \
kmod-mtk-devapc.ko \
kmod-mtk-dp.ko \
kmod-mtk-dvfsrc-regulator.ko \
kmod-mtk-dvfsrc.ko \
kmod-mtk-eint.ko \
kmod-mtk-eth.ko \
kmod-mtk-ge-soc.ko \
kmod-mtk-ge.ko \
kmod-mtk-gpueb-mailbox.ko \
kmod-mtk-hdmi-common.ko \
kmod-mtk-hdmi-ddc-v2.ko \
kmod-mtk-hdmi-ddc.ko \
kmod-mtk-hdmi-v2.ko \
kmod-mtk-hdmi.ko \
kmod-mtk-hsdma.ko \
kmod-mtk-iommu.ko \
kmod-mtk-jpeg-dec-hw.ko \
kmod-mtk-jpeg-enc-hw.ko \
kmod-mtk-jpeg.ko \
kmod-mtk-mdp.ko \
kmod-mtk-mdp3.ko \
kmod-mtk-mfg-pmdomain.ko \
kmod-mtk-mmsys.ko \
kmod-mtk-mutex.ko \
kmod-mtk-nand.ko \
kmod-mtk-phy-lib.ko \
kmod-mtk-pmic-keys.ko \
kmod-mtk-pmic-wrap.ko \
kmod-mtk-regulator-coupler.ko \
kmod-mtk-rng.ko \
kmod-mtk-rpmsg.ko \
kmod-mtk-scp-ipi.ko \
kmod-mtk-scp.ko \
kmod-mtk-sd.ko \
kmod-mtk-smi.ko \
kmod-mtk-socinfo.ko \
kmod-mtk-star-emac.ko \
kmod-mtk-svs.ko \
kmod-mtk-t7xx.ko \
kmod-mtk-uart-apdma.ko \
kmod-mtk-vcodec-common.ko \
kmod-mtk-vcodec-dbgfs.ko \
kmod-mtk-vcodec-dec-hw.ko \
kmod-mtk-vcodec-dec.ko \
kmod-mtk-vcodec-enc.ko \
kmod-mtk-vcp-mailbox.ko \
kmod-mtk-vpu.ko \
kmod-mtk-wdt.ko \
kmod-mtouch.ko \
kmod-mtu3.ko \
kmod-musb-hdrc.ko \
kmod-mux-adg792a.ko \
kmod-mux-adgs1408.ko \
kmod-mux-core.ko \
kmod-mux-gpio.ko \
kmod-mux-mmio.ko \
kmod-mv88e6060.ko \
kmod-mv88e6xxx.ko \
kmod-mvmdio.ko \
kmod-mvneta.ko \
kmod-mvpp2.ko \
kmod-mvsas.ko \
kmod-mvumi.ko \
kmod-mwifiex-pcie.ko \
kmod-mwifiex-sdio.ko \
kmod-mwifiex-usb.ko \
kmod-mwifiex.ko \
kmod-mwl8k.ko \
kmod-mxc-clk.ko \
kmod-mxc-jpeg-encdec.ko \
kmod-mxc-nand.ko \
kmod-mxc-w1.ko \
kmod-mxc4005.ko \
kmod-mxc6255.ko \
kmod-mxic-nand.ko \
kmod-mxl-86110.ko \
kmod-mxl-gpy.ko \
kmod-mxl-gsw1xx.ko \
kmod-mxl111sf-demod.ko \
kmod-mxl111sf-tuner.ko \
kmod-mxl301rf.ko \
kmod-mxl5005s.ko \
kmod-mxl5007t.ko \
kmod-mxl5xx.ko \
kmod-mxl692.ko \
kmod-mxl862xx-dsa.ko \
kmod-mxs-dcp.ko \
kmod-mxs-dma.ko \
kmod-mxser.ko \
kmod-mxuport.ko \
kmod-myrb.ko \
kmod-myri10ge.ko \
kmod-myrs.ko \
kmod-n-hdlc.ko \
kmod-n-null.ko \
kmod-n5pf.ko \
kmod-nand.ko \
kmod-nandcore.ko \
kmod-nandsim.ko \
kmod-national.ko \
kmod-natsemi.ko \
kmod-navman.ko \
kmod-nb7vpq904m.ko \
kmod-nbd.ko \
kmod-nci-uart.ko \
kmod-nci.ko \
kmod-ncn26000.ko \
kmod-nct6683.ko \
kmod-nct6694-canfd.ko \
kmod-nct6694-hwmon.ko \
kmod-nct6694-wdt.ko \
kmod-nct6694.ko \
kmod-nct6775-core.ko \
kmod-nct6775-i2c.ko \
kmod-nct6775.ko \
kmod-nct7363.ko \
kmod-nct7802.ko \
kmod-nct7904.ko \
kmod-nd-btt.ko \
kmod-nd-pmem.ko \
kmod-nd-virtio.ko \
kmod-ne2k-pci.ko \
kmod-negcc-nord.ko \
kmod-net-failover.ko \
kmod-net1080.ko \
kmod-netconsole.ko \
kmod-netdev-notifier-error-inject.ko \
kmod-netdevsim.ko \
kmod-netfilter.ko \
kmod-netfs.ko \
kmod-netkit.ko \
kmod-netlink-diag.ko \
kmod-netsec.ko \
kmod-netup-unidvb.ko \
kmod-netxen-nic.ko \
kmod-newtonkbd.ko \
kmod-nf-conncount.ko \
kmod-nf-conntrack-amanda.ko \
kmod-nf-conntrack-bridge.ko \
kmod-nf-conntrack-broadcast.ko \
kmod-nf-conntrack-ftp.ko \
kmod-nf-conntrack-h323.ko \
kmod-nf-conntrack-irc.ko \
kmod-nf-conntrack-netbios-ns.ko \
kmod-nf-conntrack-netlink.ko \
kmod-nf-conntrack-pptp.ko \
kmod-nf-conntrack-sane.ko \
kmod-nf-conntrack-sip.ko \
kmod-nf-conntrack-snmp.ko \
kmod-nf-conntrack-tftp.ko \
kmod-nf-conntrack.ko \
kmod-nf-defrag-ipv4.ko \
kmod-nf-defrag-ipv6.ko \
kmod-nf-dup-ipv4.ko \
kmod-nf-dup-ipv6.ko \
kmod-nf-dup-netdev.ko \
kmod-nf-flow-table-inet.ko \
kmod-nf-flow-table.ko \
kmod-nf-log-syslog.ko \
kmod-nf-nat-amanda.ko \
kmod-nf-nat-ftp.ko \
kmod-nf-nat-h323.ko \
kmod-nf-nat-irc.ko \
kmod-nf-nat-pptp.ko \
kmod-nf-nat-sip.ko \
kmod-nf-nat-snmp-basic.ko \
kmod-nf-nat-tftp.ko \
kmod-nf-nat.ko \
kmod-nf-reject-ipv4.ko \
kmod-nf-reject-ipv6.ko \
kmod-nf-socket-ipv4.ko \
kmod-nf-socket-ipv6.ko \
kmod-nf-synproxy-core.ko \
kmod-nf-tables.ko \
kmod-nf-tproxy-ipv4.ko \
kmod-nf-tproxy-ipv6.ko \
kmod-nfc-digital.ko \
kmod-nfc.ko \
kmod-nfcmrvl-i2c.ko \
kmod-nfcmrvl-uart.ko \
kmod-nfcmrvl-usb.ko \
kmod-nfcmrvl.ko \
kmod-nfcsim.ko \
kmod-nfit.ko \
kmod-nfnetlink-acct.ko \
kmod-nfnetlink-cthelper.ko \
kmod-nfnetlink-cttimeout.ko \
kmod-nfnetlink-hook.ko \
kmod-nfnetlink-log.ko \
kmod-nfnetlink-osf.ko \
kmod-nfnetlink-queue.ko \
kmod-nfp.ko \
kmod-nfs-acl.ko \
kmod-nfs-layout-flexfiles.ko \
kmod-nfs-layout-nfsv41-files.ko \
kmod-nfs.ko \
kmod-nfsd.ko \
kmod-nfsv2.ko \
kmod-nfsv3.ko \
kmod-nfsv4.ko \
kmod-nft-chain-nat.ko \
kmod-nft-compat.ko \
kmod-nft-connlimit.ko \
kmod-nft-ct.ko \
kmod-nft-dup-ipv4.ko \
kmod-nft-dup-ipv6.ko \
kmod-nft-dup-netdev.ko \
kmod-nft-fib-inet.ko \
kmod-nft-fib-ipv4.ko \
kmod-nft-fib-ipv6.ko \
kmod-nft-fib-netdev.ko \
kmod-nft-fib.ko \
kmod-nft-flow-offload.ko \
kmod-nft-fwd-netdev.ko \
kmod-nft-hash.ko \
kmod-nft-limit.ko \
kmod-nft-log.ko \
kmod-nft-masq.ko \
kmod-nft-meta-bridge.ko \
kmod-nft-nat.ko \
kmod-nft-numgen.ko \
kmod-nft-osf.ko \
kmod-nft-queue.ko \
kmod-nft-quota.ko \
kmod-nft-redir.ko \
kmod-nft-reject-bridge.ko \
kmod-nft-reject-inet.ko \
kmod-nft-reject-ipv4.ko \
kmod-nft-reject-ipv6.ko \
kmod-nft-reject-netdev.ko \
kmod-nft-reject.ko \
kmod-nft-socket.ko \
kmod-nft-synproxy.ko \
kmod-nft-tproxy.ko \
kmod-nft-tunnel.ko \
kmod-nft-xfrm.ko \
kmod-nftl.ko \
kmod-ngbe.ko \
kmod-ngbevf.ko \
kmod-ngene.ko \
kmod-nhc-dest.ko \
kmod-nhc-fragment.ko \
kmod-nhc-ghc-ext-dest.ko \
kmod-nhc-ghc-ext-frag.ko \
kmod-nhc-ghc-ext-hop.ko \
kmod-nhc-ghc-ext-route.ko \
kmod-nhc-ghc-icmpv6.ko \
kmod-nhc-ghc-udp.ko \
kmod-nhc-hop.ko \
kmod-nhc-ipv6.ko \
kmod-nhc-mobility.ko \
kmod-nhc-routing.ko \
kmod-nhc-udp.ko \
kmod-ni-usb6501.ko \
kmod-nic7018-wdt.ko \
kmod-nicpf.ko \
kmod-nicvf.ko \
kmod-nilfs2.ko \
kmod-nitro-enclaves.ko \
kmod-niu.ko \
kmod-nixge.ko \
kmod-nlmon.ko \
kmod-nls-ascii.ko \
kmod-nls-base.ko \
kmod-nls-cp1250.ko \
kmod-nls-cp1251.ko \
kmod-nls-cp1255.ko \
kmod-nls-cp437.ko \
kmod-nls-cp737.ko \
kmod-nls-cp775.ko \
kmod-nls-cp850.ko \
kmod-nls-cp852.ko \
kmod-nls-cp855.ko \
kmod-nls-cp857.ko \
kmod-nls-cp860.ko \
kmod-nls-cp861.ko \
kmod-nls-cp862.ko \
kmod-nls-cp863.ko \
kmod-nls-cp864.ko \
kmod-nls-cp865.ko \
kmod-nls-cp866.ko \
kmod-nls-cp869.ko \
kmod-nls-cp874.ko \
kmod-nls-cp932.ko \
kmod-nls-cp936.ko \
kmod-nls-cp949.ko \
kmod-nls-cp950.ko \
kmod-nls-euc-jp.ko \
kmod-nls-iso8859-1.ko \
kmod-nls-iso8859-13.ko \
kmod-nls-iso8859-14.ko \
kmod-nls-iso8859-15.ko \
kmod-nls-iso8859-2.ko \
kmod-nls-iso8859-3.ko \
kmod-nls-iso8859-4.ko \
kmod-nls-iso8859-5.ko \
kmod-nls-iso8859-6.ko \
kmod-nls-iso8859-7.ko \
kmod-nls-iso8859-9.ko \
kmod-nls-koi8-r.ko \
kmod-nls-koi8-ru.ko \
kmod-nls-koi8-u.ko \
kmod-nls-ucs2-utils.ko \
kmod-nls-utf8.ko \
kmod-noa1305.ko \
kmod-nosy.ko \
kmod-notifier-error-inject.ko \
kmod-nouveau.ko \
kmod-novatek-nvt-ts.ko \
kmod-nozomi.ko \
kmod-npcm-adc.ko \
kmod-npcm-edac.ko \
kmod-npcm-rng.ko \
kmod-npcm-video.ko \
kmod-npcm-wdt.ko \
kmod-npcm750-pwm-fan.ko \
kmod-nps-enet.ko \
kmod-ns-thermal.ko \
kmod-ns83820.ko \
kmod-nsh.ko \
kmod-nsm.ko \
kmod-nsscc-ipq5424.ko \
kmod-nsscc-qca8k.ko \
kmod-ntb-hw-epf.ko \
kmod-ntb-hw-idt.ko \
kmod-ntb-hw-switchtec.ko \
kmod-ntb-netdev.ko \
kmod-ntb-perf.ko \
kmod-ntb-transport.ko \
kmod-ntb.ko \
kmod-ntfs.ko \
kmod-ntfs3.ko \
kmod-ntsync.ko \
kmod-null-blk.ko \
kmod-nuvoton-ma35d1-nand-controller.ko \
kmod-nvec-kbd.ko \
kmod-nvec-paz00.ko \
kmod-nvec-power.ko \
kmod-nvec-ps2.ko \
kmod-nvec.ko \
kmod-nvgrace-gpu-vfio-pci.ko \
kmod-nvidia-t410-c2c-pmu.ko \
kmod-nvidia-t410-cmem-latency-pmu.ko \
kmod-nvme-apple.ko \
kmod-nvme-auth.ko \
kmod-nvme-core.ko \
kmod-nvme-fabrics.ko \
kmod-nvme-fc.ko \
kmod-nvme-fcloop.ko \
kmod-nvme-keyring.ko \
kmod-nvme-loop.ko \
kmod-nvme-rdma.ko \
kmod-nvme-tcp.ko \
kmod-nvme.ko \
kmod-nvmem-apple-efuses.ko \
kmod-nvmem-bcm-ocotp.ko \
kmod-nvmem-imx-iim.ko \
kmod-nvmem-imx-ocotp-ele.ko \
kmod-nvmem-imx-ocotp-scu.ko \
kmod-nvmem-imx-ocotp.ko \
kmod-nvmem-layerscape-sfp.ko \
kmod-nvmem-max77759.ko \
kmod-nvmem-meson-efuse.ko \
kmod-nvmem-meson-mx-efuse.ko \
kmod-nvmem-mtk-efuse.ko \
kmod-nvmem-qcom-spmi-sdam.ko \
kmod-nvmem-qfprom.ko \
kmod-nvmem-qnap-mcu-eeprom.ko \
kmod-nvmem-rcar-efuse.ko \
kmod-nvmem-reboot-mode.ko \
kmod-nvmem-rmem.ko \
kmod-nvmem-rockchip-efuse.ko \
kmod-nvmem-rockchip-otp.ko \
kmod-nvmem-s32g-ocotp-nvmem.ko \
kmod-nvmem-sc27xx-efuse.ko \
kmod-nvmem-snvs-lpgpr.ko \
kmod-nvmem-sprd-efuse.ko \
kmod-nvmem-stm32-romem.ko \
kmod-nvmem-sunxi-sid.ko \
kmod-nvmem-u-boot-env.ko \
kmod-nvmem-zynqmp-nvmem.ko \
kmod-nvmet-fc.ko \
kmod-nvmet-pci-epf.ko \
kmod-nvmet-rdma.ko \
kmod-nvmet-tcp.ko \
kmod-nvmet.ko \
kmod-nvsw-sn2201.ko \
kmod-nwgcc-nord.ko \
kmod-nwl-dsi.ko \
kmod-nxp-bbnsm-pwrkey.ko \
kmod-nxp-c45-tja.ko \
kmod-nxp-cbtx.ko \
kmod-nxp-enetc-pf-common.ko \
kmod-nxp-enetc4.ko \
kmod-nxp-nci-i2c.ko \
kmod-nxp-nci.ko \
kmod-nxp-netc-blk-ctrl.ko \
kmod-nxp-netc-lib.ko \
kmod-nxp-netc-switch.ko \
kmod-nxp-ptn3460.ko \
kmod-nxp-sar-adc.ko \
kmod-nxp-tja11xx.ko \
kmod-nxt200x.ko \
kmod-nxt6000.ko \
kmod-nzxt-kraken2.ko \
kmod-nzxt-smart2.ko \
kmod-oa-tc6.ko \
kmod-objagg.ko \
kmod-ocelot-soc.ko \
kmod-ocfs2-dlm.ko \
kmod-ocfs2-dlmfs.ko \
kmod-ocfs2-nodemanager.ko \
kmod-ocfs2-stack-o2cb.ko \
kmod-ocfs2-stack-user.ko \
kmod-ocfs2-stackglue.ko \
kmod-ocfs2.ko \
kmod-ocmem.ko \
kmod-ocrdma.ko \
kmod-octeon-ep-vf.ko \
kmod-octeon-ep.ko \
kmod-octeontx-cpt.ko \
kmod-octeontx-cptvf.ko \
kmod-octep-hp.ko \
kmod-octep-vdpa.ko \
kmod-odroid-go-ultra-poweroff.ko \
kmod-of-fpga-region.ko \
kmod-of-mdio.ko \
kmod-of-pmem.ko \
kmod-of-reconfig-notifier-error-inject.ko \
kmod-of-xilinx-wdt.ko \
kmod-ofpart.ko \
kmod-og01a1b.ko \
kmod-og0ve1b.ko \
kmod-ohci-exynos.ko \
kmod-ohci-hcd.ko \
kmod-ohci-pci.ko \
kmod-ohci-platform.ko \
kmod-oid-registry.ko \
kmod-olpc-apsp.ko \
kmod-olpc-battery.ko \
kmod-olpc-xo175-ec.ko \
kmod-omap-rng.ko \
kmod-omfs.ko \
kmod-omninet.ko \
kmod-on20.ko \
kmod-on26.ko \
kmod-onboard-usb-dev.ko \
kmod-onenand.ko \
kmod-onie-tlv.ko \
kmod-open-dice.ko \
kmod-opencores-kbd.ko \
kmod-openvswitch.ko \
kmod-opt3001.ko \
kmod-opt4060.ko \
kmod-optee-rng.ko \
kmod-optee.ko \
kmod-opticon.ko \
kmod-option.ko \
kmod-or51132.ko \
kmod-or51211.ko \
kmod-orangefs.ko \
kmod-os05b10.ko \
kmod-oti6858.ko \
kmod-otm3225a.ko \
kmod-otx2-ptp.ko \
kmod-ov01a10.ko \
kmod-ov02a10.ko \
kmod-ov02c10.ko \
kmod-ov02e10.ko \
kmod-ov08d10.ko \
kmod-ov08x40.ko \
kmod-ov13858.ko \
kmod-ov13b10.ko \
kmod-ov2640.ko \
kmod-ov2659.ko \
kmod-ov2680.ko \
kmod-ov2685.ko \
kmod-ov2732.ko \
kmod-ov2735.ko \
kmod-ov2740.ko \
kmod-ov4689.ko \
kmod-ov5640.ko \
kmod-ov5645.ko \
kmod-ov5647.ko \
kmod-ov5648.ko \
kmod-ov5670.ko \
kmod-ov5675.ko \
kmod-ov5693.ko \
kmod-ov5695.ko \
kmod-ov6211.ko \
kmod-ov64a40.ko \
kmod-ov7251.ko \
kmod-ov7640.ko \
kmod-ov7670.ko \
kmod-ov772x.ko \
kmod-ov7740.ko \
kmod-ov8856.ko \
kmod-ov8858.ko \
kmod-ov8865.ko \
kmod-ov9282.ko \
kmod-ov9640.ko \
kmod-ov9650.ko \
kmod-ov9734.ko \
kmod-overlay.ko \
kmod-ovpn.ko \
kmod-owl-dma.ko \
kmod-owl-emac.ko \
kmod-owl-mmc.ko \
kmod-owl-uart.ko \
kmod-oxu210hp-hcd.ko \
kmod-p54common.ko \
kmod-p54pci.ko \
kmod-p54usb.ko \
kmod-pa12203001.ko \
kmod-pac1921.ko \
kmod-pac1934.ko \
kmod-panel-abt-y030xx067a.ko \
kmod-panel-arm-versatile.ko \
kmod-panel-asus-z00t-tm5p5-n35596.ko \
kmod-panel-auo-a030jtn01.ko \
kmod-panel-boe-bf060y8m-aj0.ko \
kmod-panel-boe-himax8279d.ko \
kmod-panel-boe-td4320.ko \
kmod-panel-boe-th101mb31ig002-28a.ko \
kmod-panel-boe-tv101wum-ll2.ko \
kmod-panel-boe-tv101wum-nl6.ko \
kmod-panel-chipwealth-ch13726a.ko \
kmod-panel-dsi-cm.ko \
kmod-panel-ebbg-ft8719.ko \
kmod-panel-edp.ko \
kmod-panel-elida-kd35t133.ko \
kmod-panel-feixin-k101-im2ba02.ko \
kmod-panel-feiyang-fy07024di26a30d.ko \
kmod-panel-focaltech-ota7290b.ko \
kmod-panel-himax-hx8279.ko \
kmod-panel-himax-hx83112a.ko \
kmod-panel-himax-hx83112b.ko \
kmod-panel-hydis-hv101hd1.ko \
kmod-panel-ilitek-ili9322.ko \
kmod-panel-ilitek-ili9881c.ko \
kmod-panel-ilitek-ili9882t.ko \
kmod-panel-innolux-p079zca.ko \
kmod-panel-jdi-fhd-r63452.ko \
kmod-panel-jdi-lpm102a188a.ko \
kmod-panel-jdi-lt070me05000.ko \
kmod-panel-khadas-ts050.ko \
kmod-panel-kingdisplay-kd097d04.ko \
kmod-panel-leadtek-ltk050h3146w.ko \
kmod-panel-leadtek-ltk500hd1829.ko \
kmod-panel-lg-lb035q02.ko \
kmod-panel-lg-lg4573.ko \
kmod-panel-lg-sw43408.ko \
kmod-panel-lvds.ko \
kmod-panel-magnachip-d53e6ea8966.ko \
kmod-panel-mantix-mlaf057we51.ko \
kmod-panel-mipi-dbi.ko \
kmod-panel-nec-nl8048hl11.ko \
kmod-panel-newvision-nv3052c.ko \
kmod-panel-novatek-nt35510.ko \
kmod-panel-novatek-nt35532.ko \
kmod-panel-novatek-nt35560.ko \
kmod-panel-novatek-nt35950.ko \
kmod-panel-novatek-nt36523.ko \
kmod-panel-novatek-nt36672a.ko \
kmod-panel-novatek-nt36672e.ko \
kmod-panel-novatek-nt37801.ko \
kmod-panel-novatek-nt39016.ko \
kmod-panel-olimex-lcd-olinuxino.ko \
kmod-panel-orisetech-otm8009a.ko \
kmod-panel-osd-osd101t2587-53ts.ko \
kmod-panel-panasonic-vvx10f034n00.ko \
kmod-panel-raspberrypi-touchscreen.ko \
kmod-panel-raydium-rm67191.ko \
kmod-panel-raydium-rm68200.ko \
kmod-panel-raydium-rm692e5.ko \
kmod-panel-raydium-rm69380.ko \
kmod-panel-renesas-r61307.ko \
kmod-panel-renesas-r69328.ko \
kmod-panel-ronbo-rb070d30.ko \
kmod-panel-samsung-ld9040.ko \
kmod-panel-samsung-ltl106hl02.ko \
kmod-panel-samsung-s6d16d0.ko \
kmod-panel-samsung-s6d27a1.ko \
kmod-panel-samsung-s6e3fa7.ko \
kmod-panel-samsung-s6e3ha2.ko \
kmod-panel-samsung-s6e63j0x03.ko \
kmod-panel-samsung-s6e63m0-spi.ko \
kmod-panel-samsung-s6e63m0.ko \
kmod-panel-samsung-s6e88a0-ams452ef01.ko \
kmod-panel-samsung-s6e8aa0.ko \
kmod-panel-samsung-s6e8aa5x01-ams561ra01.ko \
kmod-panel-samsung-sofef00.ko \
kmod-panel-seiko-43wvf1g.ko \
kmod-panel-sharp-lq101r1sx01.ko \
kmod-panel-sharp-ls037v7dw01.ko \
kmod-panel-sharp-ls043t1le01.ko \
kmod-panel-sharp-ls060t1sx01.ko \
kmod-panel-simple.ko \
kmod-panel-sitronix-st7701.ko \
kmod-panel-sitronix-st7703.ko \
kmod-panel-sitronix-st7789v.ko \
kmod-panel-sony-acx565akm.ko \
kmod-panel-sony-td4353-jdi.ko \
kmod-panel-sony-tulip-truly-nt35521.ko \
kmod-panel-startek-kd070fhfid015.ko \
kmod-panel-tdo-tl070wsh30.ko \
kmod-panel-tpo-td028ttec1.ko \
kmod-panel-tpo-td043mtea1.ko \
kmod-panel-tpo-tpg110.ko \
kmod-panel-truly-nt35597.ko \
kmod-panel-visionox-g2647fb105.ko \
kmod-panel-visionox-r66451.ko \
kmod-panel-visionox-rm69299.ko \
kmod-panel-xinpeng-xpp055c272.ko \
kmod-panel.ko \
kmod-panfrost.ko \
kmod-panthor.ko \
kmod-parade-ps8622.ko \
kmod-parade-ps8640.ko \
kmod-parkbd.ko \
kmod-parman.ko \
kmod-parport-pc.ko \
kmod-parport-serial.ko \
kmod-parport.ko \
kmod-parser-trx.ko \
kmod-pata-ali.ko \
kmod-pata-amd.ko \
kmod-pata-artop.ko \
kmod-pata-atiixp.ko \
kmod-pata-atp867x.ko \
kmod-pata-cmd640.ko \
kmod-pata-cmd64x.ko \
kmod-pata-cypress.ko \
kmod-pata-efar.ko \
kmod-pata-hpt366.ko \
kmod-pata-hpt37x.ko \
kmod-pata-hpt3x2n.ko \
kmod-pata-hpt3x3.ko \
kmod-pata-imx.ko \
kmod-pata-it8213.ko \
kmod-pata-it821x.ko \
kmod-pata-jmicron.ko \
kmod-pata-marvell.ko \
kmod-pata-mpiix.ko \
kmod-pata-netcell.ko \
kmod-pata-ninja32.ko \
kmod-pata-ns87410.ko \
kmod-pata-ns87415.ko \
kmod-pata-oldpiix.ko \
kmod-pata-opti.ko \
kmod-pata-optidma.ko \
kmod-pata-parport.ko \
kmod-pata-pdc2027x.ko \
kmod-pata-pdc202xx-old.ko \
kmod-pata-piccolo.ko \
kmod-pata-radisys.ko \
kmod-pata-rdc.ko \
kmod-pata-rz1000.ko \
kmod-pata-sch.ko \
kmod-pata-serverworks.ko \
kmod-pata-sil680.ko \
kmod-pata-sis.ko \
kmod-pata-sl82c105.ko \
kmod-pata-triflex.ko \
kmod-pata-via.ko \
kmod-pc300too.ko \
kmod-pc87360.ko \
kmod-pc87427.ko \
kmod-pca9450-regulator.ko \
kmod-pcf8574-keypad.ko \
kmod-pcf8591.ko \
kmod-pci-aardvark.ko \
kmod-pci-endpoint-test.ko \
kmod-pci-epf-mhi.ko \
kmod-pci-epf-ntb.ko \
kmod-pci-epf-test.ko \
kmod-pci-epf-vntb.ko \
kmod-pci-exynos.ko \
kmod-pci-host-common.ko \
kmod-pci-host-generic.ko \
kmod-pci-hyperv-intf.ko \
kmod-pci-hyperv.ko \
kmod-pci-layerscape.ko \
kmod-pci-meson.ko \
kmod-pci-pf-stub.ko \
kmod-pci-pwrctrl-core.ko \
kmod-pci-pwrctrl-generic.ko \
kmod-pci-pwrctrl-pwrseq.ko \
kmod-pci-pwrctrl-tc9563.ko \
kmod-pci-sky1.ko \
kmod-pci-stub.ko \
kmod-pci-tegra.ko \
kmod-pci.ko \
kmod-pci200syn.ko \
kmod-pcie-altera-msi.ko \
kmod-pcie-altera.ko \
kmod-pcie-apple.ko \
kmod-pcie-aspeed.ko \
kmod-pcie-brcmstb.ko \
kmod-pcie-cadence-ep-mod.ko \
kmod-pcie-cadence-host-mod.ko \
kmod-pcie-cadence-mod.ko \
kmod-pcie-cadence-plat.ko \
kmod-pcie-iproc-platform.ko \
kmod-pcie-iproc.ko \
kmod-pcie-kirin.ko \
kmod-pcie-mediatek-gen3.ko \
kmod-pcie-mediatek.ko \
kmod-pcie-microchip-host.ko \
kmod-pcie-nxp-s32g.ko \
kmod-pcie-qcom-ep.ko \
kmod-pcie-rcar-gen4.ko \
kmod-pcie-rockchip-host.ko \
kmod-pcie-sg2042.ko \
kmod-pcie-stm32-ep.ko \
kmod-pcie-stm32.ko \
kmod-pcie-tegra194.ko \
kmod-pcips2.ko \
kmod-pcnet32.ko \
kmod-pcrypt.ko \
kmod-pcs-lynx.ko \
kmod-pcs-mtk-lynxi.ko \
kmod-pcs-rzn1-miic.ko \
kmod-pcs-xpcs.ko \
kmod-pcwd-pci.ko \
kmod-pcwd-usb.ko \
kmod-pd692x0.ko \
kmod-pdc-adma.ko \
kmod-pdr-interface.ko \
kmod-pds-core.ko \
kmod-pds-fwctl.ko \
kmod-pds-vdpa.ko \
kmod-pds-vfio-pci.ko \
kmod-peak-pci.ko \
kmod-peak-pciefd.ko \
kmod-peak-usb.ko \
kmod-pegasus-notetaker.ko \
kmod-pegasus.ko \
kmod-penmount.ko \
kmod-pf0900-regulator.ko \
kmod-pf530x-regulator.ko \
kmod-pf8x00-regulator.ko \
kmod-pf9453-regulator.ko \
kmod-pfcp.ko \
kmod-pfr-telemetry.ko \
kmod-pfr-update.ko \
kmod-pfuze100-regulator.ko \
kmod-phantom.ko \
kmod-phonet.ko \
kmod-phram.ko \
kmod-phy-airoha-pcie.ko \
kmod-phy-apple-atc.ko \
kmod-phy-armada38x-comphy.ko \
kmod-phy-axiado-emmc.ko \
kmod-phy-bcm-kona-usb2.ko \
kmod-phy-bcm-ns-usb2.ko \
kmod-phy-bcm-ns-usb3.ko \
kmod-phy-bcm-ns2-pcie.ko \
kmod-phy-bcm-ns2-usbdrd.ko \
kmod-phy-bcm-sr-pcie.ko \
kmod-phy-bcm-sr-usb.ko \
kmod-phy-berlin-sata.ko \
kmod-phy-berlin-usb.ko \
kmod-phy-brcm-sata.ko \
kmod-phy-brcm-usb-dvr.ko \
kmod-phy-cadence-salvo.ko \
kmod-phy-cadence-sierra.ko \
kmod-phy-cadence-torrent.ko \
kmod-phy-can-transceiver.ko \
kmod-phy-cpcap-usb.ko \
kmod-phy-cv1800-usb2.ko \
kmod-phy-ds125df111.ko \
kmod-phy-exynos-dp-video.ko \
kmod-phy-exynos-mipi-video.ko \
kmod-phy-exynos-ufs.ko \
kmod-phy-fsl-imx8-mipi-dphy.ko \
kmod-phy-fsl-imx8m-pcie.ko \
kmod-phy-fsl-imx8mq-usb.ko \
kmod-phy-fsl-imx8qm-hsio.ko \
kmod-phy-fsl-imx8qm-lvds-phy.ko \
kmod-phy-fsl-lynx-10g.ko \
kmod-phy-fsl-lynx-28g.ko \
kmod-phy-fsl-lynx-core.ko \
kmod-phy-fsl-samsung-hdmi.ko \
kmod-phy-generic.ko \
kmod-phy-google-usb.ko \
kmod-phy-hi3660-usb3.ko \
kmod-phy-hi3670-pcie.ko \
kmod-phy-hi3670-usb3.ko \
kmod-phy-hi6220-usb.ko \
kmod-phy-hisi-inno-usb2.ko \
kmod-phy-histb-combphy.ko \
kmod-phy-intel-keembay-emmc.ko \
kmod-phy-intel-keembay-usb.ko \
kmod-phy-isp1301.ko \
kmod-phy-ma35d1-usb2.ko \
kmod-phy-mapphone-mdm6600.ko \
kmod-phy-meson-axg-mipi-dphy.ko \
kmod-phy-meson-axg-mipi-pcie-analog.ko \
kmod-phy-meson-axg-pcie.ko \
kmod-phy-meson-g12a-mipi-dphy-analog.ko \
kmod-phy-meson-g12a-usb2.ko \
kmod-phy-meson-g12a-usb3-pcie.ko \
kmod-phy-meson-gxl-usb2.ko \
kmod-phy-meson8b-usb2.ko \
kmod-phy-mtk-dp.ko \
kmod-phy-mtk-hdmi-drv.ko \
kmod-phy-mtk-mipi-csi-0-5.ko \
kmod-phy-mtk-mipi-dsi-drv.ko \
kmod-phy-mtk-pcie.ko \
kmod-phy-mtk-tphy.ko \
kmod-phy-mtk-ufs.ko \
kmod-phy-mtk-xsphy.ko \
kmod-phy-mvebu-a3700-comphy.ko \
kmod-phy-mvebu-a3700-utmi.ko \
kmod-phy-mvebu-cp110-comphy.ko \
kmod-phy-mvebu-cp110-utmi.ko \
kmod-phy-mxs-usb.ko \
kmod-phy-nxp-ptn3222.ko \
kmod-phy-nxp-tja1145.ko \
kmod-phy-ocelot-serdes.ko \
kmod-phy-package.ko \
kmod-phy-pxa-28nm-hsic.ko \
kmod-phy-pxa-28nm-usb2.ko \
kmod-phy-pxa-usb.ko \
kmod-phy-qcom-apq8064-sata.ko \
kmod-phy-qcom-edp.ko \
kmod-phy-qcom-eusb2-repeater.ko \
kmod-phy-qcom-ipq806x-sata.ko \
kmod-phy-qcom-ipq806x-usb.ko \
kmod-phy-qcom-m31-eusb2.ko \
kmod-phy-qcom-m31.ko \
kmod-phy-qcom-pcie2.ko \
kmod-phy-qcom-qmp-combo.ko \
kmod-phy-qcom-qmp-pcie-msm8996.ko \
kmod-phy-qcom-qmp-pcie.ko \
kmod-phy-qcom-qmp-ufs.ko \
kmod-phy-qcom-qmp-usb.ko \
kmod-phy-qcom-qmp-usbc.ko \
kmod-phy-qcom-qusb2.ko \
kmod-phy-qcom-sgmii-eth.ko \
kmod-phy-qcom-snps-femto-v2.ko \
kmod-phy-qcom-uniphy-pcie-28lp.ko \
kmod-phy-qcom-usb-hs-28nm.ko \
kmod-phy-qcom-usb-hs.ko \
kmod-phy-qcom-usb-hsic.ko \
kmod-phy-qcom-usb-ss.ko \
kmod-phy-rcar-gen2.ko \
kmod-phy-rcar-gen3-pcie.ko \
kmod-phy-rcar-gen3-usb2.ko \
kmod-phy-rcar-gen3-usb3.ko \
kmod-phy-rockchip-dp.ko \
kmod-phy-rockchip-dphy-rx0.ko \
kmod-phy-rockchip-emmc.ko \
kmod-phy-rockchip-inno-csidphy.ko \
kmod-phy-rockchip-inno-dsidphy.ko \
kmod-phy-rockchip-inno-hdmi.ko \
kmod-phy-rockchip-inno-usb2.ko \
kmod-phy-rockchip-naneng-combphy.ko \
kmod-phy-rockchip-pcie.ko \
kmod-phy-rockchip-samsung-dcphy.ko \
kmod-phy-rockchip-samsung-hdptx.ko \
kmod-phy-rockchip-snps-pcie3.ko \
kmod-phy-rockchip-typec.ko \
kmod-phy-rockchip-usb.ko \
kmod-phy-rockchip-usbdp.ko \
kmod-phy-rtk-usb2.ko \
kmod-phy-rtk-usb3.ko \
kmod-phy-rzg3e-usb3.ko \
kmod-phy-snps-eusb2.ko \
kmod-phy-stm32-combophy.ko \
kmod-phy-stm32-usbphyc.ko \
kmod-phy-sun4i-usb.ko \
kmod-phy-sun50i-usb3.ko \
kmod-phy-sun6i-mipi-dphy.ko \
kmod-phy-sun9i-usb.ko \
kmod-phy-tegra-usb.ko \
kmod-phy-tegra-xusb.ko \
kmod-phy-tegra194-p2u.ko \
kmod-phy-xgene.ko \
kmod-phy-zynqmp.ko \
kmod-phylink.ko \
kmod-physmap.ko \
kmod-pi3usb30532.ko \
kmod-pim4328.ko \
kmod-pinctrl-airoha.ko \
kmod-pinctrl-amdisp.ko \
kmod-pinctrl-amlogic-a4.ko \
kmod-pinctrl-amlogic-c3.ko \
kmod-pinctrl-amlogic-t7.ko \
kmod-pinctrl-apple-gpio.ko \
kmod-pinctrl-aw9523.ko \
kmod-pinctrl-axp209.ko \
kmod-pinctrl-bcm2835.ko \
kmod-pinctrl-bcm4908.ko \
kmod-pinctrl-brcmstb-bcm2712.ko \
kmod-pinctrl-brcmstb.ko \
kmod-pinctrl-cs42l43.ko \
kmod-pinctrl-cv1800b.ko \
kmod-pinctrl-cv1812h.ko \
kmod-pinctrl-cy8c95x0.ko \
kmod-pinctrl-eliza.ko \
kmod-pinctrl-generic-mux.ko \
kmod-pinctrl-glymur.ko \
kmod-pinctrl-hawi.ko \
kmod-pinctrl-imx-scmi.ko \
kmod-pinctrl-imx.ko \
kmod-pinctrl-imx8dxl.ko \
kmod-pinctrl-imx8mm.ko \
kmod-pinctrl-imx8mn.ko \
kmod-pinctrl-imx8mp.ko \
kmod-pinctrl-imx8mq.ko \
kmod-pinctrl-imx8qm.ko \
kmod-pinctrl-imx8qxp.ko \
kmod-pinctrl-imx8ulp.ko \
kmod-pinctrl-imx91.ko \
kmod-pinctrl-imx93.ko \
kmod-pinctrl-ipq5018.ko \
kmod-pinctrl-ipq5210.ko \
kmod-pinctrl-ipq5332.ko \
kmod-pinctrl-ipq5424.ko \
kmod-pinctrl-ipq6018.ko \
kmod-pinctrl-ipq9574.ko \
kmod-pinctrl-ipq9650.ko \
kmod-pinctrl-kaanapali.ko \
kmod-pinctrl-keembay.ko \
kmod-pinctrl-lochnagar.ko \
kmod-pinctrl-lpass-lpi.ko \
kmod-pinctrl-madera.ko \
kmod-pinctrl-max7360.ko \
kmod-pinctrl-max77620.ko \
kmod-pinctrl-mcp23s08-i2c.ko \
kmod-pinctrl-mcp23s08-spi.ko \
kmod-pinctrl-mcp23s08.ko \
kmod-pinctrl-meson-a1.ko \
kmod-pinctrl-meson-axg-pmx.ko \
kmod-pinctrl-meson-axg.ko \
kmod-pinctrl-meson-g12a.ko \
kmod-pinctrl-meson-gxbb.ko \
kmod-pinctrl-meson-gxl.ko \
kmod-pinctrl-meson-s4.ko \
kmod-pinctrl-meson.ko \
kmod-pinctrl-meson8-pmx.ko \
kmod-pinctrl-milos-lpass-lpi.ko \
kmod-pinctrl-milos.ko \
kmod-pinctrl-mlxbf3.ko \
kmod-pinctrl-msm.ko \
kmod-pinctrl-msm8916.ko \
kmod-pinctrl-msm8917.ko \
kmod-pinctrl-msm8953.ko \
kmod-pinctrl-msm8976.ko \
kmod-pinctrl-msm8998.ko \
kmod-pinctrl-mt6765.ko \
kmod-pinctrl-mt6779.ko \
kmod-pinctrl-mtk-common-v2.ko \
kmod-pinctrl-nord.ko \
kmod-pinctrl-paris.ko \
kmod-pinctrl-qcm2290.ko \
kmod-pinctrl-qcs615.ko \
kmod-pinctrl-qcs8300.ko \
kmod-pinctrl-qdf2xxx.ko \
kmod-pinctrl-qdu1000.ko \
kmod-pinctrl-rk805.ko \
kmod-pinctrl-rockchip.ko \
kmod-pinctrl-rp1.ko \
kmod-pinctrl-rtd.ko \
kmod-pinctrl-rtd1315e.ko \
kmod-pinctrl-rtd1319d.ko \
kmod-pinctrl-rtd1619b.ko \
kmod-pinctrl-rtd1625.ko \
kmod-pinctrl-rzt2h.ko \
kmod-pinctrl-s32g2.ko \
kmod-pinctrl-sa8775p.ko \
kmod-pinctrl-sar2130p.ko \
kmod-pinctrl-sc7180.ko \
kmod-pinctrl-sc7280-lpass-lpi.ko \
kmod-pinctrl-sc7280.ko \
kmod-pinctrl-sc8180x.ko \
kmod-pinctrl-sc8280xp-lpass-lpi.ko \
kmod-pinctrl-sc8280xp.ko \
kmod-pinctrl-scmi.ko \
kmod-pinctrl-scu.ko \
kmod-pinctrl-sdm660-lpass-lpi.ko \
kmod-pinctrl-sdm670-lpass-lpi.ko \
kmod-pinctrl-sdm845.ko \
kmod-pinctrl-sdx75.ko \
kmod-pinctrl-sg2000.ko \
kmod-pinctrl-sg2002.ko \
kmod-pinctrl-sg2042.ko \
kmod-pinctrl-sg2044.ko \
kmod-pinctrl-shikra.ko \
kmod-pinctrl-single.ko \
kmod-pinctrl-sky1-base.ko \
kmod-pinctrl-sky1.ko \
kmod-pinctrl-sm4250-lpass-lpi.ko \
kmod-pinctrl-sm4450.ko \
kmod-pinctrl-sm6115-lpass-lpi.ko \
kmod-pinctrl-sm6115.ko \
kmod-pinctrl-sm6125.ko \
kmod-pinctrl-sm6350-lpass-lpi.ko \
kmod-pinctrl-sm6350.ko \
kmod-pinctrl-sm7150.ko \
kmod-pinctrl-sm8150.ko \
kmod-pinctrl-sm8250-lpass-lpi.ko \
kmod-pinctrl-sm8250.ko \
kmod-pinctrl-sm8350.ko \
kmod-pinctrl-sm8450-lpass-lpi.ko \
kmod-pinctrl-sm8450.ko \
kmod-pinctrl-sm8550-lpass-lpi.ko \
kmod-pinctrl-sm8550.ko \
kmod-pinctrl-sm8650-lpass-lpi.ko \
kmod-pinctrl-sm8650.ko \
kmod-pinctrl-sm8750.ko \
kmod-pinctrl-sophgo.ko \
kmod-pinctrl-spmi-gpio.ko \
kmod-pinctrl-spmi-mpp.ko \
kmod-pinctrl-sprd-sc9860.ko \
kmod-pinctrl-sprd.ko \
kmod-pinctrl-ssbi-gpio.ko \
kmod-pinctrl-ssbi-mpp.ko \
kmod-pinctrl-stm32-hdp.ko \
kmod-pinctrl-stm32.ko \
kmod-pinctrl-stm32mp257.ko \
kmod-pinctrl-stmfx.ko \
kmod-pinctrl-sx150x.ko \
kmod-pinctrl-tegra238.ko \
kmod-pinctrl-tegra264.ko \
kmod-pinctrl-x1e80100.ko \
kmod-pinctrl-zynqmp.ko \
kmod-pinephone-keyboard.ko \
kmod-ping.ko \
kmod-pisp-be.ko \
kmod-pixcir-i2c-ts.ko \
kmod-pixpaper.ko \
kmod-pkcs7-message.ko \
kmod-pkcs8-key-parser.ko \
kmod-pktgen.ko \
kmod-pl111-drm.ko \
kmod-pl172.ko \
kmod-pl2303.ko \
kmod-pl330.ko \
kmod-plat-nand.ko \
kmod-plat-ram.ko \
kmod-platform-lcd.ko \
kmod-platform-mhu.ko \
kmod-platform-profile.ko \
kmod-plfxlc.ko \
kmod-pli1209bc.ko \
kmod-plip.ko \
kmod-plusb.ko \
kmod-pluto2.ko \
kmod-plx-dma.ko \
kmod-plx-pci.ko \
kmod-pm-notifier-error-inject.ko \
kmod-pm6764tr.ko \
kmod-pm80xx.ko \
kmod-pm8916-bms-vm.ko \
kmod-pm8916-lbc.ko \
kmod-pm8916-wdt.ko \
kmod-pm8941-pwrkey.ko \
kmod-pm8xxx-vibrator.ko \
kmod-pmbus-core.ko \
kmod-pmbus.ko \
kmod-pmc551.ko \
kmod-pmcraid.ko \
kmod-pmic-glink-altmode.ko \
kmod-pmic-glink.ko \
kmod-pmic-pdcharger-ulog.ko \
kmod-pms7003.ko \
kmod-pn-pep.ko \
kmod-pn532-uart.ko \
kmod-pn533-i2c.ko \
kmod-pn533-usb.ko \
kmod-pn533.ko \
kmod-pn544-i2c.ko \
kmod-pn544.ko \
kmod-polynomial.ko \
kmod-port100.ko \
kmod-powermate.ko \
kmod-powervr.ko \
kmod-powerz.ko \
kmod-powr1220.ko \
kmod-ppa.ko \
kmod-ppdev.ko \
kmod-ppp-async.ko \
kmod-ppp-deflate.ko \
kmod-ppp-generic.ko \
kmod-ppp-mppe.ko \
kmod-ppp-synctty.ko \
kmod-pppoatm.ko \
kmod-pppoe.ko \
kmod-pppox.ko \
kmod-pps-core.ko \
kmod-pps-gpio.ko \
kmod-pps-ldisc.ko \
kmod-pps-parport.ko \
kmod-pptp.ko \
kmod-prestera-pci.ko \
kmod-prestera.ko \
kmod-pretimeout-noop.ko \
kmod-pretimeout-panic.ko \
kmod-processor.ko \
kmod-ps2-gpio.ko \
kmod-ps2mult.ko \
kmod-ps883x.ko \
kmod-psample.ko \
kmod-pse-regulator.ko \
kmod-psmouse.ko \
kmod-psnap.ko \
kmod-pstore-blk.ko \
kmod-pstore-zone.ko \
kmod-pstore.ko \
kmod-psxpad-spi.ko \
kmod-pt5161l.ko \
kmod-ptn36502.ko \
kmod-ptp-clockmatrix.ko \
kmod-ptp-dfl-tod.ko \
kmod-ptp-dte.ko \
kmod-ptp-fc3.ko \
kmod-ptp-idt82p33.ko \
kmod-ptp-kvm.ko \
kmod-ptp-mock.ko \
kmod-ptp-netc.ko \
kmod-ptp-ocp.ko \
kmod-ptp-qoriq.ko \
kmod-ptp-vmclock.ko \
kmod-ptp.ko \
kmod-public-key.ko \
kmod-pulse8-cec.ko \
kmod-pulsedlight-lidar-lite-v2.ko \
kmod-pvpanic-mmio.ko \
kmod-pvpanic-pci.ko \
kmod-pvpanic.ko \
kmod-pvrusb2.ko \
kmod-pwc-rzv2m.ko \
kmod-pwc.ko \
kmod-pwm-adp5585.ko \
kmod-pwm-airoha.ko \
kmod-pwm-apple.ko \
kmod-pwm-argon-fan-hat.ko \
kmod-pwm-atmel-hlcdc.ko \
kmod-pwm-atmel-tcb.ko \
kmod-pwm-axi-pwmgen.ko \
kmod-pwm-bcm-iproc.ko \
kmod-pwm-bcm2835.ko \
kmod-pwm-beeper.ko \
kmod-pwm-berlin.ko \
kmod-pwm-bl.ko \
kmod-pwm-brcmstb.ko \
kmod-pwm-clk.ko \
kmod-pwm-cros-ec.ko \
kmod-pwm-dwc-core.ko \
kmod-pwm-dwc.ko \
kmod-pwm-fan.ko \
kmod-pwm-gpio.ko \
kmod-pwm-hibvt.ko \
kmod-pwm-imx-tpm.ko \
kmod-pwm-ipq.ko \
kmod-pwm-iqs620a.ko \
kmod-pwm-ir-tx.ko \
kmod-pwm-keembay.ko \
kmod-pwm-lp3943.ko \
kmod-pwm-max7360.ko \
kmod-pwm-mc33xs2410.ko \
kmod-pwm-mediatek.ko \
kmod-pwm-meson.ko \
kmod-pwm-mtk-disp.ko \
kmod-pwm-pxa.ko \
kmod-pwm-raspberrypi-poe.ko \
kmod-pwm-rcar.ko \
kmod-pwm-regulator.ko \
kmod-pwm-renesas-tpu.ko \
kmod-pwm-rockchip.ko \
kmod-pwm-rzg2l-gpt.ko \
kmod-pwm-samsung.ko \
kmod-pwm-sophgo-sg2042.ko \
kmod-pwm-sprd.ko \
kmod-pwm-stm32-lp.ko \
kmod-pwm-stm32.ko \
kmod-pwm-sun4i.ko \
kmod-pwm-tegra.ko \
kmod-pwm-vibra.ko \
kmod-pwm-visconti.ko \
kmod-pwm-xilinx.ko \
kmod-pwr-mlxbf.ko \
kmod-pwrseq-core.ko \
kmod-pwrseq-emmc.ko \
kmod-pwrseq-pcie-m2.ko \
kmod-pwrseq-qcom-wcn.ko \
kmod-pwrseq-sd8787.ko \
kmod-pwrseq-simple.ko \
kmod-pxa-dma.ko \
kmod-pxa1908-power-controller.ko \
kmod-pxa27x-keypad.ko \
kmod-pxe1610.ko \
kmod-pxrc.ko \
kmod-q54sj108a2.ko \
kmod-q6adm.ko \
kmod-q6afe-clocks.ko \
kmod-q6afe-dai.ko \
kmod-q6afe.ko \
kmod-q6apm-dai.ko \
kmod-q6apm-lpass-dais.ko \
kmod-q6asm-dai.ko \
kmod-q6asm.ko \
kmod-q6core.ko \
kmod-q6prm-clocks.ko \
kmod-q6prm.ko \
kmod-q6routing.ko \
kmod-q6sstop-qcs404.ko \
kmod-q6usb.ko \
kmod-qaic.ko \
kmod-qat-420xx.ko \
kmod-qat-4xxx.ko \
kmod-qat-c3xxx.ko \
kmod-qat-c3xxxvf.ko \
kmod-qat-c62x.ko \
kmod-qat-c62xvf.ko \
kmod-qat-dh895xcc.ko \
kmod-qat-dh895xccvf.ko \
kmod-qat-vfio-pci.ko \
kmod-qca-7k-common.ko \
kmod-qca807x.ko \
kmod-qca808x.ko \
kmod-qca83xx.ko \
kmod-qca8k.ko \
kmod-qcaspi.ko \
kmod-qcauart.ko \
kmod-qcaux.ko \
kmod-qcom-aoss.ko \
kmod-qcom-apcs-ipc-mailbox.ko \
kmod-qcom-bam-dmux.ko \
kmod-qcom-battmgr.ko \
kmod-qcom-camss.ko \
kmod-qcom-common.ko \
kmod-qcom-cpucp-mbox.ko \
kmod-qcom-cpufreq-hw.ko \
kmod-qcom-cpufreq-nvmem.ko \
kmod-qcom-edac.ko \
kmod-qcom-emac.ko \
kmod-qcom-eud.ko \
kmod-qcom-geni-se.ko \
kmod-qcom-geni-serial.ko \
kmod-qcom-glink-rpm.ko \
kmod-qcom-glink-smem.ko \
kmod-qcom-glink.ko \
kmod-qcom-gsbi.ko \
kmod-qcom-hamoa-ec.ko \
kmod-qcom-hwspinlock.ko \
kmod-qcom-ice.ko \
kmod-qcom-ipcc.ko \
kmod-qcom-iris.ko \
kmod-qcom-labibb-regulator.ko \
kmod-qcom-nandc.ko \
kmod-qcom-pbs.ko \
kmod-qcom-pd-mapper.ko \
kmod-qcom-pdc.ko \
kmod-qcom-pdr-msg.ko \
kmod-qcom-phy-lib.ko \
kmod-qcom-pil-info.ko \
kmod-qcom-pm8008-regulator.ko \
kmod-qcom-pm8008.ko \
kmod-qcom-pmic-tcpm.ko \
kmod-qcom-pon.ko \
kmod-qcom-ppe.ko \
kmod-qcom-q6v5-adsp.ko \
kmod-qcom-q6v5-mss.ko \
kmod-qcom-q6v5-pas.ko \
kmod-qcom-q6v5-wcss.ko \
kmod-qcom-q6v5.ko \
kmod-qcom-qseecom-uefisecapp.ko \
kmod-qcom-qseecom.ko \
kmod-qcom-refgen-regulator.ko \
kmod-qcom-rng.ko \
kmod-qcom-rpm-regulator.ko \
kmod-qcom-rpm.ko \
kmod-qcom-rpmh-regulator.ko \
kmod-qcom-rpmh.ko \
kmod-qcom-scm.ko \
kmod-qcom-smbb.ko \
kmod-qcom-smbx.ko \
kmod-qcom-smd-regulator.ko \
kmod-qcom-smd.ko \
kmod-qcom-spmi-adc-tm5.ko \
kmod-qcom-spmi-adc5.ko \
kmod-qcom-spmi-pmic.ko \
kmod-qcom-spmi-regulator.ko \
kmod-qcom-spmi-rradc.ko \
kmod-qcom-stats.ko \
kmod-qcom-sysmon.ko \
kmod-qcom-tsens.ko \
kmod-qcom-tzmem.ko \
kmod-qcom-usb-vbus-regulator.ko \
kmod-qcom-vadc-common.ko \
kmod-qcom-wled.ko \
kmod-qcomsmempart.ko \
kmod-qcomtee.ko \
kmod-qcrypto.ko \
kmod-qcserial.ko \
kmod-qed.ko \
kmod-qede.ko \
kmod-qedf.ko \
kmod-qedi.ko \
kmod-qedr.ko \
kmod-qemu-fw-cfg.ko \
kmod-qemu-virt-ctrl.ko \
kmod-qinfo-probe.ko \
kmod-qla1280.ko \
kmod-qla2xxx.ko \
kmod-qla3xxx.ko \
kmod-qla4xxx.ko \
kmod-qlcnic.ko \
kmod-qm1d1b0004.ko \
kmod-qm1d1c0042.ko \
kmod-qmi-helpers.ko \
kmod-qmi-wwan.ko \
kmod-qnap-mcu-hwmon.ko \
kmod-qnap-mcu-input.ko \
kmod-qnap-mcu.ko \
kmod-qnoc-eliza.ko \
kmod-qnoc-glymur.ko \
kmod-qnoc-hawi.ko \
kmod-qnoc-kaanapali.ko \
kmod-qnoc-milos.ko \
kmod-qnoc-msm8916.ko \
kmod-qnoc-msm8937.ko \
kmod-qnoc-msm8939.ko \
kmod-qnoc-msm8953.ko \
kmod-qnoc-msm8976.ko \
kmod-qnoc-msm8996.ko \
kmod-qnoc-nord.ko \
kmod-qnoc-qcm2290.ko \
kmod-qnoc-qcs404.ko \
kmod-qnoc-qcs615.ko \
kmod-qnoc-qcs8300.ko \
kmod-qnoc-qdu1000.ko \
kmod-qnoc-sa8775p.ko \
kmod-qnoc-sar2130p.ko \
kmod-qnoc-sc7180.ko \
kmod-qnoc-sc7280.ko \
kmod-qnoc-sc8180x.ko \
kmod-qnoc-sc8280xp.ko \
kmod-qnoc-sdm660.ko \
kmod-qnoc-sdm670.ko \
kmod-qnoc-sdm845.ko \
kmod-qnoc-sdx75.ko \
kmod-qnoc-shikra.ko \
kmod-qnoc-sm6115.ko \
kmod-qnoc-sm6350.ko \
kmod-qnoc-sm7150.ko \
kmod-qnoc-sm8150.ko \
kmod-qnoc-sm8250.ko \
kmod-qnoc-sm8350.ko \
kmod-qnoc-sm8450.ko \
kmod-qnoc-sm8550.ko \
kmod-qnoc-sm8650.ko \
kmod-qnoc-sm8750.ko \
kmod-qnoc-x1e80100.ko \
kmod-qnx4.ko \
kmod-qnx6.ko \
kmod-qoriq-cpufreq.ko \
kmod-qoriq-thermal.ko \
kmod-qpic-common.ko \
kmod-qrtr-mhi.ko \
kmod-qrtr-smd.ko \
kmod-qrtr-tun.ko \
kmod-qrtr.ko \
kmod-qsemi.ko \
kmod-qt1010.ko \
kmod-qt1050.ko \
kmod-qt1070.ko \
kmod-qt2160.ko \
kmod-qtnfmac-pcie.ko \
kmod-qtnfmac.ko \
kmod-quatech2.ko \
kmod-quota-tree.ko \
kmod-quota-v1.ko \
kmod-quota-v2.ko \
kmod-qwiic-joystick.ko \
kmod-qxl.ko \
kmod-r592.ko \
kmod-r6040.ko \
kmod-r8152.ko \
kmod-r8153-ecm.ko \
kmod-r8169.ko \
kmod-r820t.ko \
kmod-r852.ko \
kmod-r8723bs.ko \
kmod-r8a66597-hcd.ko \
kmod-r8a779f0-ether-serdes.ko \
kmod-raa215300.ko \
kmod-radeon.ko \
kmod-radio-keene.ko \
kmod-radio-ma901.ko \
kmod-radio-maxiradio.ko \
kmod-radio-mr800.ko \
kmod-radio-platform-si4713.ko \
kmod-radio-raremono.ko \
kmod-radio-shark.ko \
kmod-radio-si470x-common.ko \
kmod-radio-si470x-usb.ko \
kmod-radio-tea5764.ko \
kmod-radio-usb-si4713.ko \
kmod-raid-class.ko \
kmod-raid0.ko \
kmod-raid1.ko \
kmod-raid10.ko \
kmod-raid456.ko \
kmod-raid6-pq.ko \
kmod-raid6test.ko \
kmod-rainshadow-cec.ko \
kmod-ramdax.ko \
kmod-ramoops.ko \
kmod-ramp-controller.ko \
kmod-rapidio.ko \
kmod-raspberrypi-cpufreq.ko \
kmod-raspberrypi-hwmon.ko \
kmod-raspberrypi-ts.ko \
kmod-raspberrypi.ko \
kmod-rational.ko \
kmod-ravb.ko \
kmod-raw-diag.ko \
kmod-raw-gadget.ko \
kmod-raydium-i2c-ts.ko \
kmod-rbd.ko \
kmod-rbtree-test.ko \
kmod-rc-adstech-dvb-t-pci.ko \
kmod-rc-alink-dtu-m.ko \
kmod-rc-anysee.ko \
kmod-rc-apac-viewcomp.ko \
kmod-rc-astrometa-t2hybrid.ko \
kmod-rc-asus-pc39.ko \
kmod-rc-asus-ps3-100.ko \
kmod-rc-ati-tv-wonder-hd-600.ko \
kmod-rc-ati-x10.ko \
kmod-rc-avermedia-a16d.ko \
kmod-rc-avermedia-cardbus.ko \
kmod-rc-avermedia-dvbt.ko \
kmod-rc-avermedia-m135a.ko \
kmod-rc-avermedia-m733a-rm-k6.ko \
kmod-rc-avermedia-rm-ks.ko \
kmod-rc-avermedia.ko \
kmod-rc-avertv-303.ko \
kmod-rc-azurewave-ad-tu700.ko \
kmod-rc-beelink-gs1.ko \
kmod-rc-beelink-mxiii.ko \
kmod-rc-behold-columbus.ko \
kmod-rc-behold.ko \
kmod-rc-budget-ci-old.ko \
kmod-rc-cinergy-1400.ko \
kmod-rc-cinergy.ko \
kmod-rc-core.ko \
kmod-rc-ct-90405.ko \
kmod-rc-d680-dmb.ko \
kmod-rc-delock-61959.ko \
kmod-rc-dib0700-nec.ko \
kmod-rc-dib0700-rc5.ko \
kmod-rc-digitalnow-tinytwin.ko \
kmod-rc-digittrade.ko \
kmod-rc-dm1105-nec.ko \
kmod-rc-dntv-live-dvb-t.ko \
kmod-rc-dntv-live-dvbt-pro.ko \
kmod-rc-dreambox.ko \
kmod-rc-dtt200u.ko \
kmod-rc-dvbsky.ko \
kmod-rc-dvico-mce.ko \
kmod-rc-dvico-portable.ko \
kmod-rc-em-terratec.ko \
kmod-rc-encore-enltv-fm53.ko \
kmod-rc-encore-enltv.ko \
kmod-rc-encore-enltv2.ko \
kmod-rc-evga-indtube.ko \
kmod-rc-eztv.ko \
kmod-rc-flydvb.ko \
kmod-rc-flyvideo.ko \
kmod-rc-fusionhdtv-mce.ko \
kmod-rc-gadmei-rm008z.ko \
kmod-rc-geekbox.ko \
kmod-rc-genius-tvgo-a11mce.ko \
kmod-rc-gotview7135.ko \
kmod-rc-hauppauge.ko \
kmod-rc-hisi-poplar.ko \
kmod-rc-hisi-tv-demo.ko \
kmod-rc-imon-mce.ko \
kmod-rc-imon-pad.ko \
kmod-rc-imon-rsc.ko \
kmod-rc-iodata-bctv7e.ko \
kmod-rc-it913x-v1.ko \
kmod-rc-it913x-v2.ko \
kmod-rc-kaiomy.ko \
kmod-rc-khadas.ko \
kmod-rc-khamsin.ko \
kmod-rc-kworld-315u.ko \
kmod-rc-kworld-pc150u.ko \
kmod-rc-kworld-plus-tv-analog.ko \
kmod-rc-leadtek-y04g0051.ko \
kmod-rc-lme2510.ko \
kmod-rc-loopback.ko \
kmod-rc-manli.ko \
kmod-rc-mecool-kii-pro.ko \
kmod-rc-mecool-kiii-pro.ko \
kmod-rc-medion-x10-digitainer.ko \
kmod-rc-medion-x10-or2x.ko \
kmod-rc-medion-x10.ko \
kmod-rc-minix-neo.ko \
kmod-rc-msi-digivox-ii.ko \
kmod-rc-msi-digivox-iii.ko \
kmod-rc-msi-tvanywhere-plus.ko \
kmod-rc-msi-tvanywhere.ko \
kmod-rc-mygica-utv3.ko \
kmod-rc-nebula.ko \
kmod-rc-nec-terratec-cinergy-xs.ko \
kmod-rc-norwood.ko \
kmod-rc-npgtech.ko \
kmod-rc-odroid.ko \
kmod-rc-pctv-sedna.ko \
kmod-rc-pine64.ko \
kmod-rc-pinnacle-color.ko \
kmod-rc-pinnacle-grey.ko \
kmod-rc-pinnacle-pctv-hd.ko \
kmod-rc-pixelview-002t.ko \
kmod-rc-pixelview-mk12.ko \
kmod-rc-pixelview-new.ko \
kmod-rc-pixelview.ko \
kmod-rc-powercolor-real-angel.ko \
kmod-rc-proteus-2309.ko \
kmod-rc-purpletv.ko \
kmod-rc-pv951.ko \
kmod-rc-rc6-mce.ko \
kmod-rc-real-audio-220-32-keys.ko \
kmod-rc-reddo.ko \
kmod-rc-siemens-gigaset-rc20.ko \
kmod-rc-snapstream-firefly.ko \
kmod-rc-streamzap.ko \
kmod-rc-su3000.ko \
kmod-rc-tanix-tx3mini.ko \
kmod-rc-tanix-tx5max.ko \
kmod-rc-tbs-nec.ko \
kmod-rc-technisat-ts35.ko \
kmod-rc-technisat-usb2.ko \
kmod-rc-terratec-cinergy-c-pci.ko \
kmod-rc-terratec-cinergy-s2-hd.ko \
kmod-rc-terratec-cinergy-xs.ko \
kmod-rc-terratec-slim-2.ko \
kmod-rc-terratec-slim.ko \
kmod-rc-tevii-nec.ko \
kmod-rc-tivo.ko \
kmod-rc-total-media-in-hand-02.ko \
kmod-rc-total-media-in-hand.ko \
kmod-rc-trekstor.ko \
kmod-rc-tt-1500.ko \
kmod-rc-twinhan-dtv-cab-ci.ko \
kmod-rc-twinhan1027.ko \
kmod-rc-vega-s9x.ko \
kmod-rc-videomate-m1f.ko \
kmod-rc-videomate-s350.ko \
kmod-rc-videomate-tv-pvr.ko \
kmod-rc-videostrong-kii-pro.ko \
kmod-rc-wetek-hub.ko \
kmod-rc-wetek-play2.ko \
kmod-rc-winfast-usbii-deluxe.ko \
kmod-rc-winfast.ko \
kmod-rc-x96max.ko \
kmod-rc-xbox-360.ko \
kmod-rc-xbox-dvd.ko \
kmod-rc-zx-irdec.ko \
kmod-rcar-can.ko \
kmod-rcar-canfd.ko \
kmod-rcar-cmm.ko \
kmod-rcar-csi2.ko \
kmod-rcar-dmac.ko \
kmod-rcar-drif.ko \
kmod-rcar-du-drm.ko \
kmod-rcar-dw-hdmi.ko \
kmod-rcar-fcp.ko \
kmod-rcar-fdp1.ko \
kmod-rcar-gen3-thermal.ko \
kmod-rcar-gen4-ptp.ko \
kmod-rcar-isp.ko \
kmod-rcar-jpu.ko \
kmod-rcar-lvds.ko \
kmod-rcar-mfis.ko \
kmod-rcar-mipi-dsi.ko \
kmod-rcar-rproc.ko \
kmod-rcar-thermal.ko \
kmod-rcar-vin.ko \
kmod-rcuscale.ko \
kmod-rcutorture.ko \
kmod-rdacm20.ko \
kmod-rdacm21.ko \
kmod-rdma-cm.ko \
kmod-rdma-rxe.ko \
kmod-rdma-ucm.ko \
kmod-rds-rdma.ko \
kmod-rds-tcp.ko \
kmod-rds.ko \
kmod-realtek-dsa.ko \
kmod-realtek.ko \
kmod-reboot-mode.ko \
kmod-redboot.ko \
kmod-redrat3.ko \
kmod-reed-solomon.ko \
kmod-regmap-i2c.ko \
kmod-regmap-i3c.ko \
kmod-regmap-mmio.ko \
kmod-regmap-sccb.ko \
kmod-regmap-sdw-mbq.ko \
kmod-regmap-sdw.ko \
kmod-regmap-slimbus.ko \
kmod-regmap-spi.ko \
kmod-regmap-spmi.ko \
kmod-regmap-w1.ko \
kmod-regulator-haptic.ko \
kmod-renesas-i3c.ko \
kmod-renesas-nand-controller.ko \
kmod-renesas-rpc-if.ko \
kmod-renesas-sdhi-core.ko \
kmod-renesas-sdhi-internal-dmac.ko \
kmod-renesas-usb-vbus-regulator.ko \
kmod-renesas-usb3.ko \
kmod-renesas-usbf.ko \
kmod-renesas-usbhs.ko \
kmod-renesas-wdt.ko \
kmod-renesas-wwdt.ko \
kmod-repaper.ko \
kmod-reset-a10sr.ko \
kmod-reset-aspeed.ko \
kmod-reset-berlin.ko \
kmod-reset-brcmstb-rescal.ko \
kmod-reset-brcmstb.ko \
kmod-reset-gpio.ko \
kmod-reset-hi3660.ko \
kmod-reset-imx-scu.ko \
kmod-reset-imx7.ko \
kmod-reset-imx8mp-audiomix.ko \
kmod-reset-meson-audio-arb.ko \
kmod-reset-meson-aux.ko \
kmod-reset-meson-common.ko \
kmod-reset-meson.ko \
kmod-reset-microchip-sparx5.ko \
kmod-reset-qcom-aoss.ko \
kmod-reset-qcom-pdc.ko \
kmod-reset-raspberrypi.ko \
kmod-reset-rzg2l-usbphy-ctrl.ko \
kmod-reset-rzv2h-usb2phy.ko \
kmod-reset-scmi.ko \
kmod-reset-sky1.ko \
kmod-reset-ti-syscon.ko \
kmod-reset-tn48m.ko \
kmod-reset.ko \
kmod-resistive-adc-touch.ko \
kmod-rfcomm.ko \
kmod-rfd-ftl.ko \
kmod-rfd77402.ko \
kmod-rfkill-gpio.ko \
kmod-rfkill.ko \
kmod-ring-buffer-benchmark.ko \
kmod-rio-cm.ko \
kmod-rio-mport-cdev.ko \
kmod-rio-scan.ko \
kmod-rionet.ko \
kmod-rj54n1cb0c.ko \
kmod-rk-crypto.ko \
kmod-rk3399-dmc.ko \
kmod-rk805-pwrkey.ko \
kmod-rk808-regulator.ko \
kmod-rk817-charger.ko \
kmod-rk8xx-core.ko \
kmod-rk8xx-i2c.ko \
kmod-rk8xx-spi.ko \
kmod-rm3100-core.ko \
kmod-rm3100-i2c.ko \
kmod-rm3100-spi.ko \
kmod-rmd160.ko \
kmod-rmi-core.ko \
kmod-rmi-i2c.ko \
kmod-rmi-smbus.ko \
kmod-rmi-spi.ko \
kmod-rmnet.ko \
kmod-rmtfs-mem.ko \
kmod-rnbd-client.ko \
kmod-rnbd-server.ko \
kmod-rndis-host.ko \
kmod-rng-core.ko \
kmod-rng.ko \
kmod-rnpgbe.ko \
kmod-rockchip-canfd.ko \
kmod-rockchip-cif.ko \
kmod-rockchip-dfi.ko \
kmod-rockchip-isp1.ko \
kmod-rockchip-nand-controller.ko \
kmod-rockchip-rga.ko \
kmod-rockchip-rng.ko \
kmod-rockchip-thermal.ko \
kmod-rockchip-vdec.ko \
kmod-rockchip.ko \
kmod-rockchipdrm.ko \
kmod-rocker.ko \
kmod-rocket.ko \
kmod-rohm-bd71828.ko \
kmod-rohm-bd718x7.ko \
kmod-rohm-bd79112.ko \
kmod-rohm-bd79124.ko \
kmod-rohm-bd79703.ko \
kmod-rohm-bd9576.ko \
kmod-rohm-bm1390.ko \
kmod-rohm-bu21023.ko \
kmod-rohm-regulator.ko \
kmod-roles.ko \
kmod-romfs.ko \
kmod-rotary-encoder.ko \
kmod-rp1-cfe.ko \
kmod-rp1-pci.ko \
kmod-rp2.ko \
kmod-rpcrdma.ko \
kmod-rpcsec-gss-krb5.ko \
kmod-rpi-panel-attiny-regulator.ko \
kmod-rpi-panel-v2-regulator.ko \
kmod-rpm-master-stats.ko \
kmod-rpm-proc.ko \
kmod-rpmb-core.ko \
kmod-rpmhpd.ko \
kmod-rpmpd.ko \
kmod-rpmsg-char.ko \
kmod-rpmsg-core.ko \
kmod-rpmsg-ctrl.ko \
kmod-rpmsg-ns.ko \
kmod-rpmsg-tty.ko \
kmod-rpmsg-wwan-ctrl.ko \
kmod-rpr0521.ko \
kmod-rsa-generic.ko \
kmod-rsci.ko \
kmod-rsi-91x.ko \
kmod-rsi-sdio.ko \
kmod-rsi-usb.ko \
kmod-rswitch.ko \
kmod-rt1719.ko \
kmod-rt2400pci.ko \
kmod-rt2500pci.ko \
kmod-rt2500usb.ko \
kmod-rt2800lib.ko \
kmod-rt2800mmio.ko \
kmod-rt2800pci.ko \
kmod-rt2800usb.ko \
kmod-rt2x00lib.ko \
kmod-rt2x00mmio.ko \
kmod-rt2x00pci.ko \
kmod-rt2x00usb.ko \
kmod-rt4801-regulator.ko \
kmod-rt4803.ko \
kmod-rt4831-backlight.ko \
kmod-rt4831-regulator.ko \
kmod-rt4831.ko \
kmod-rt5033-battery.ko \
kmod-rt5133-regulator.ko \
kmod-rt5190a-regulator.ko \
kmod-rt5739.ko \
kmod-rt5759-regulator.ko \
kmod-rt6160-regulator.ko \
kmod-rt6190-regulator.ko \
kmod-rt61pci.ko \
kmod-rt6245-regulator.ko \
kmod-rt73usb.ko \
kmod-rt8092.ko \
kmod-rt9455-charger.ko \
kmod-rt9467-charger.ko \
kmod-rt9471.ko \
kmod-rt9756.ko \
kmod-rtase.ko \
kmod-rtc-ab-b5ze-s3.ko \
kmod-rtc-ab-eoz9.ko \
kmod-rtc-abx80x.ko \
kmod-rtc-ac100.ko \
kmod-rtc-amlogic-a4.ko \
kmod-rtc-armada38x.ko \
kmod-rtc-aspeed.ko \
kmod-rtc-bd70528.ko \
kmod-rtc-brcmstb-waketimer.ko \
kmod-rtc-cadence.ko \
kmod-rtc-cpcap.ko \
kmod-rtc-cros-ec.ko \
kmod-rtc-cv1800.ko \
kmod-rtc-ds1307.ko \
kmod-rtc-ds1374.ko \
kmod-rtc-ds1672.ko \
kmod-rtc-ds1685.ko \
kmod-rtc-ds3232.ko \
kmod-rtc-efi.ko \
kmod-rtc-fm3130.ko \
kmod-rtc-fsl-ftm-alarm.ko \
kmod-rtc-ftrtc010.ko \
kmod-rtc-goldfish.ko \
kmod-rtc-hid-sensor-time.ko \
kmod-rtc-hym8563.ko \
kmod-rtc-imx-sc.ko \
kmod-rtc-imx-sm-bbm.ko \
kmod-rtc-imxdi.ko \
kmod-rtc-isl12026.ko \
kmod-rtc-isl1208.ko \
kmod-rtc-m41t80.ko \
kmod-rtc-ma35d1.ko \
kmod-rtc-macsmc.ko \
kmod-rtc-max31335.ko \
kmod-rtc-max6900.ko \
kmod-rtc-max6916.ko \
kmod-rtc-max77686.ko \
kmod-rtc-meson-vrtc.ko \
kmod-rtc-mt2712.ko \
kmod-rtc-mt6397.ko \
kmod-rtc-mt7622.ko \
kmod-rtc-mv.ko \
kmod-rtc-mxc-v2.ko \
kmod-rtc-mxc.ko \
kmod-rtc-nct3018y.ko \
kmod-rtc-nct6694.ko \
kmod-rtc-nvidia-vrs10.ko \
kmod-rtc-nxp-bbnsm.ko \
kmod-rtc-optee.ko \
kmod-rtc-pcf2127.ko \
kmod-rtc-pcf85063.ko \
kmod-rtc-pcf8523.ko \
kmod-rtc-pcf85363.ko \
kmod-rtc-pcf8563.ko \
kmod-rtc-pcf8583.ko \
kmod-rtc-pl030.ko \
kmod-rtc-pl031.ko \
kmod-rtc-pm8xxx.ko \
kmod-rtc-r7301.ko \
kmod-rtc-renesas-rtca3.ko \
kmod-rtc-rk808.ko \
kmod-rtc-rs5c372.ko \
kmod-rtc-rv3028.ko \
kmod-rtc-rv3032.ko \
kmod-rtc-rv8803.ko \
kmod-rtc-rx8010.ko \
kmod-rtc-rx8025.ko \
kmod-rtc-rx8111.ko \
kmod-rtc-s32g.ko \
kmod-rtc-s35390a.ko \
kmod-rtc-s3c.ko \
kmod-rtc-s5m.ko \
kmod-rtc-sa1100.ko \
kmod-rtc-sc27xx.ko \
kmod-rtc-sd2405al.ko \
kmod-rtc-sd3078.ko \
kmod-rtc-sh.ko \
kmod-rtc-stm32.ko \
kmod-rtc-tegra.ko \
kmod-rtc-tps6594.ko \
kmod-rtc-x1205.ko \
kmod-rtc-xgene.ko \
kmod-rtc-zynqmp.ko \
kmod-rtl-pci.ko \
kmod-rtl-usb.ko \
kmod-rtl2830.ko \
kmod-rtl2832-sdr.ko \
kmod-rtl2832.ko \
kmod-rtl8150.ko \
kmod-rtl8187.ko \
kmod-rtl8188ee.ko \
kmod-rtl818x-pci.ko \
kmod-rtl8192c-common.ko \
kmod-rtl8192ce.ko \
kmod-rtl8192cu.ko \
kmod-rtl8192d-common.ko \
kmod-rtl8192de.ko \
kmod-rtl8192du.ko \
kmod-rtl8192ee.ko \
kmod-rtl8192se.ko \
kmod-rtl8365mb.ko \
kmod-rtl8366.ko \
kmod-rtl8723-common.ko \
kmod-rtl8723ae.ko \
kmod-rtl8723be.ko \
kmod-rtl8821ae.ko \
kmod-rtl8xxxu.ko \
kmod-rtlwifi.ko \
kmod-rtmv20-regulator.ko \
kmod-rtq2134-regulator.ko \
kmod-rtq2208-regulator.ko \
kmod-rtq6752-regulator.ko \
kmod-rtrs-client.ko \
kmod-rtrs-core.ko \
kmod-rtrs-server.ko \
kmod-rtsn.ko \
kmod-rtsx-pci-sdmmc.ko \
kmod-rtsx-pci.ko \
kmod-rtsx-usb-ms.ko \
kmod-rtsx-usb-sdmmc.ko \
kmod-rtsx-usb.ko \
kmod-rtw88-8703b.ko \
kmod-rtw88-8723cs.ko \
kmod-rtw88-8723d.ko \
kmod-rtw88-8723de.ko \
kmod-rtw88-8723ds.ko \
kmod-rtw88-8723du.ko \
kmod-rtw88-8723x.ko \
kmod-rtw88-8812a.ko \
kmod-rtw88-8812au.ko \
kmod-rtw88-8814a.ko \
kmod-rtw88-8814ae.ko \
kmod-rtw88-8814au.ko \
kmod-rtw88-8821a.ko \
kmod-rtw88-8821au.ko \
kmod-rtw88-8821c.ko \
kmod-rtw88-8821ce.ko \
kmod-rtw88-8821cs.ko \
kmod-rtw88-8821cu.ko \
kmod-rtw88-8822b.ko \
kmod-rtw88-8822be.ko \
kmod-rtw88-8822bs.ko \
kmod-rtw88-8822bu.ko \
kmod-rtw88-8822c.ko \
kmod-rtw88-8822ce.ko \
kmod-rtw88-8822cs.ko \
kmod-rtw88-8822cu.ko \
kmod-rtw88-88xxa.ko \
kmod-rtw88-core.ko \
kmod-rtw88-pci.ko \
kmod-rtw88-sdio.ko \
kmod-rtw88-usb.ko \
kmod-rtw89-8851b.ko \
kmod-rtw89-8851be.ko \
kmod-rtw89-8851bu.ko \
kmod-rtw89-8852a.ko \
kmod-rtw89-8852ae.ko \
kmod-rtw89-8852au.ko \
kmod-rtw89-8852b-common.ko \
kmod-rtw89-8852b.ko \
kmod-rtw89-8852be.ko \
kmod-rtw89-8852bt.ko \
kmod-rtw89-8852bte.ko \
kmod-rtw89-8852bu.ko \
kmod-rtw89-8852c.ko \
kmod-rtw89-8852ce.ko \
kmod-rtw89-8852cu.ko \
kmod-rtw89-8922a.ko \
kmod-rtw89-8922ae.ko \
kmod-rtw89-8922au.ko \
kmod-rtw89-core.ko \
kmod-rtw89-pci.ko \
kmod-rtw89-usb.ko \
kmod-rvu-af.ko \
kmod-rvu-cptcommon.ko \
kmod-rvu-cptpf.ko \
kmod-rvu-cptvf.ko \
kmod-rvu-mbox.ko \
kmod-rvu-nicpf.ko \
kmod-rvu-nicvf.ko \
kmod-rvu-rep.ko \
kmod-rxperf.ko \
kmod-rxrpc.ko \
kmod-rz-dmac.ko \
kmod-rz-sysc.ko \
kmod-rza-wdt.ko \
kmod-rzg2l-adc.ko \
kmod-rzg2l-du-drm.ko \
kmod-rzg2l-mipi-dsi.ko \
kmod-rzg2l-thermal.ko \
kmod-rzg2l-wdt.ko \
kmod-rzg3e-thermal.ko \
kmod-rzg3s-thermal.ko \
kmod-rzn1-wdt.ko \
kmod-rzv2h-ivc.ko \
kmod-rzv2h-wdt.ko \
kmod-rzv2m-usb3drd.ko \
kmod-s2250.ko \
kmod-s2255drv.ko \
kmod-s2dos05-regulator.ko \
kmod-s2mpa01.ko \
kmod-s2mps11.ko \
kmod-s2mu005-battery.ko \
kmod-s32g-wdt.ko \
kmod-s3c2410-wdt.ko \
kmod-s3fwrn5-i2c.ko \
kmod-s3fwrn5.ko \
kmod-s3fwrn82-uart.ko \
kmod-s4-peripherals.ko \
kmod-s4-pll.ko \
kmod-s5c73m3.ko \
kmod-s5h1409.ko \
kmod-s5h1411.ko \
kmod-s5h1420.ko \
kmod-s5h1432.ko \
kmod-s5k3m5.ko \
kmod-s5k5baf.ko \
kmod-s5k6a3.ko \
kmod-s5kjn1.ko \
kmod-s5m8767.ko \
kmod-s5p-cec.ko \
kmod-s5p-g2d.ko \
kmod-s5p-jpeg.ko \
kmod-s5p-mfc.ko \
kmod-s5p-sss.ko \
kmod-s6sy761.ko \
kmod-s921.ko \
kmod-saa6588.ko \
kmod-saa6752hs.ko \
kmod-saa7110.ko \
kmod-saa7115.ko \
kmod-saa7127.ko \
kmod-saa7134-alsa.ko \
kmod-saa7134-dvb.ko \
kmod-saa7134-empress.ko \
kmod-saa7134-go7007.ko \
kmod-saa7134.ko \
kmod-saa7146-vv.ko \
kmod-saa7146.ko \
kmod-saa7164.ko \
kmod-saa717x.ko \
kmod-saa7185.ko \
kmod-saa7706h.ko \
kmod-safe-serial.ko \
kmod-sahara.ko \
kmod-samsung-sxgbe.ko \
kmod-samsung-tty.ko \
kmod-sata-dwc-460ex.ko \
kmod-sata-inic162x.ko \
kmod-sata-mv.ko \
kmod-sata-nv.ko \
kmod-sata-promise.ko \
kmod-sata-qstor.ko \
kmod-sata-rcar.ko \
kmod-sata-sil.ko \
kmod-sata-sil24.ko \
kmod-sata-sis.ko \
kmod-sata-svw.ko \
kmod-sata-sx4.ko \
kmod-sata-uli.ko \
kmod-sata-via.ko \
kmod-sata-vsc.ko \
kmod-sbp-target.ko \
kmod-sbs-battery.ko \
kmod-sbs-charger.ko \
kmod-sbs-manager.ko \
kmod-sbsa-gwdt.ko \
kmod-sbtsi-temp.ko \
kmod-sc16is7xx-i2c.ko \
kmod-sc16is7xx-spi.ko \
kmod-sc16is7xx.ko \
kmod-sc2731-charger.ko \
kmod-sc2731-regulator.ko \
kmod-sc27xx-adc.ko \
kmod-sc27xx-fuel-gauge.ko \
kmod-sc27xx-poweroff.ko \
kmod-sc27xx-vibra.ko \
kmod-sc92031.ko \
kmod-sc9860-clk.ko \
kmod-sc9863a-clk.ko \
kmod-sca3300.ko \
kmod-scd30-core.ko \
kmod-scd30-i2c.ko \
kmod-scd30-serial.ko \
kmod-scd4x.ko \
kmod-sch-cake.ko \
kmod-sch-cbs.ko \
kmod-sch-choke.ko \
kmod-sch-codel.ko \
kmod-sch-drr.ko \
kmod-sch-dualpi2.ko \
kmod-sch-etf.ko \
kmod-sch-ets.ko \
kmod-sch-fq-codel.ko \
kmod-sch-fq-pie.ko \
kmod-sch-fq.ko \
kmod-sch-gred.ko \
kmod-sch-hfsc.ko \
kmod-sch-hhf.ko \
kmod-sch-htb.ko \
kmod-sch-ingress.ko \
kmod-sch-mqprio-lib.ko \
kmod-sch-mqprio.ko \
kmod-sch-multiq.ko \
kmod-sch-netem.ko \
kmod-sch-pie.ko \
kmod-sch-plug.ko \
kmod-sch-prio.ko \
kmod-sch-qfq.ko \
kmod-sch-red.ko \
kmod-sch-sfb.ko \
kmod-sch-sfq.ko \
kmod-sch-skbprio.ko \
kmod-sch-taprio.ko \
kmod-sch-tbf.ko \
kmod-sch-teql.ko \
kmod-sch5627.ko \
kmod-sch5636.ko \
kmod-sch56xx-common.ko \
kmod-sclk-div.ko \
kmod-scmi-core.ko \
kmod-scmi-cpufreq.ko \
kmod-scmi-hwmon.ko \
kmod-scmi-iio.ko \
kmod-scmi-module.ko \
kmod-scmi-perf-domain.ko \
kmod-scmi-pm-domain.ko \
kmod-scmi-power-control.ko \
kmod-scmi-regulator.ko \
kmod-scmi-transport-mailbox.ko \
kmod-scmi-transport-optee.ko \
kmod-scmi-transport-smc.ko \
kmod-scmi-transport-virtio.ko \
kmod-scpi-cpufreq.ko \
kmod-scpi-hwmon.ko \
kmod-scpi-pm-domain.ko \
kmod-scsi-common.ko \
kmod-scsi-debug.ko \
kmod-scsi-dh-alua.ko \
kmod-scsi-dh-emc.ko \
kmod-scsi-dh-hp-sw.ko \
kmod-scsi-dh-rdac.ko \
kmod-scsi-mod.ko \
kmod-scsi-transport-fc.ko \
kmod-scsi-transport-iscsi.ko \
kmod-scsi-transport-sas.ko \
kmod-scsi-transport-spi.ko \
kmod-scsi-transport-srp.ko \
kmod-sctp-diag.ko \
kmod-sctp.ko \
kmod-scu-pd.ko \
kmod-sd-mod.ko \
kmod-sdhci-acpi.ko \
kmod-sdhci-brcmstb.ko \
kmod-sdhci-cadence.ko \
kmod-sdhci-esdhc-imx.ko \
kmod-sdhci-f-sdh30.ko \
kmod-sdhci-iproc.ko \
kmod-sdhci-msm.ko \
kmod-sdhci-npcm.ko \
kmod-sdhci-of-arasan.ko \
kmod-sdhci-of-aspeed.ko \
kmod-sdhci-of-bst.ko \
kmod-sdhci-of-dwcmshc.ko \
kmod-sdhci-of-esdhc.ko \
kmod-sdhci-of-ma35d1.ko \
kmod-sdhci-of-sparx5.ko \
kmod-sdhci-pci.ko \
kmod-sdhci-pltfm.ko \
kmod-sdhci-pxav2.ko \
kmod-sdhci-pxav3.ko \
kmod-sdhci-s3c.ko \
kmod-sdhci-sprd.ko \
kmod-sdhci-tegra.ko \
kmod-sdhci-uhs2.ko \
kmod-sdhci-xenon-driver.ko \
kmod-sdhci.ko \
kmod-sdio-uart.ko \
kmod-sdp500.ko \
kmod-sec-core.ko \
kmod-sec-i2c.ko \
kmod-seg-led-gpio.ko \
kmod-segcc-nord.ko \
kmod-selftests.ko \
kmod-sen0322.ko \
kmod-sensehat-joystick.ko \
kmod-seqiv.ko \
kmod-serdev.ko \
kmod-serial-base.ko \
kmod-serial-ir.ko \
kmod-serial-mctrl-gpio.ko \
kmod-serial-tegra.ko \
kmod-serio-raw.ko \
kmod-serio.ko \
kmod-sermouse.ko \
kmod-serpent-generic.ko \
kmod-serport.ko \
kmod-ses.ko \
kmod-sfc-falcon.ko \
kmod-sfc-siena.ko \
kmod-sfc.ko \
kmod-sfp.ko \
kmod-sg.ko \
kmod-sg2042-mcu.ko \
kmod-sg2044-topsys.ko \
kmod-sgm3804-regulator.ko \
kmod-sh-eth.ko \
kmod-sh-mmcif.ko \
kmod-sh-sci.ko \
kmod-sha1.ko \
kmod-sha256.ko \
kmod-sha3.ko \
kmod-sha512.ko \
kmod-shark2.ko \
kmod-sht15.ko \
kmod-sht21.ko \
kmod-sht3x.ko \
kmod-sht4x.ko \
kmod-shtc1.ko \
kmod-si1133.ko \
kmod-si1145.ko \
kmod-si2157.ko \
kmod-si2165.ko \
kmod-si2168.ko \
kmod-si21xx.ko \
kmod-si3474.ko \
kmod-si4713.ko \
kmod-si7210.ko \
kmod-sierra-net.ko \
kmod-sierra.ko \
kmod-sig.ko \
kmod-sii902x.ko \
kmod-sii9234.ko \
kmod-sil-sii8620.ko \
kmod-sil164.ko \
kmod-silead.ko \
kmod-simple-bridge.ko \
kmod-simple-mfd-i2c.ko \
kmod-simpledrm.ko \
kmod-sis-i2c.ko \
kmod-sis190.ko \
kmod-sis5595.ko \
kmod-sis900.ko \
kmod-sisusbvga.ko \
kmod-sit.ko \
kmod-siw.ko \
kmod-sja1000.ko \
kmod-sja1105.ko \
kmod-skfp.ko \
kmod-skge.ko \
kmod-sky2.ko \
kmod-sky81452-backlight.ko \
kmod-sky81452-regulator.ko \
kmod-sky81452.ko \
kmod-sl28vpd.ko \
kmod-sl811-hcd.ko \
kmod-slcan.ko \
kmod-slg51000-regulator.ko \
kmod-slhc.ko \
kmod-slic-ds26522.ko \
kmod-slicoss.ko \
kmod-slim-qcom-ngd-ctrl.ko \
kmod-slimbus.ko \
kmod-slip.ko \
kmod-slram.ko \
kmod-sm-common.ko \
kmod-sm-cpu.ko \
kmod-sm-lmm.ko \
kmod-sm-misc.ko \
kmod-sm3.ko \
kmod-sm4-ce-ccm.ko \
kmod-sm4-ce-cipher.ko \
kmod-sm4-ce-gcm.ko \
kmod-sm4-ce.ko \
kmod-sm4-generic.ko \
kmod-sm4-neon.ko \
kmod-sm4.ko \
kmod-sm750fb.ko \
kmod-smartpqi.ko \
kmod-smb-compress.ko \
kmod-smb347-charger.ko \
kmod-smc-diag.ko \
kmod-smc.ko \
kmod-smc91x.ko \
kmod-smd-rpm.ko \
kmod-smem.ko \
kmod-smi240.ko \
kmod-smipcie.ko \
kmod-smp2p.ko \
kmod-smpro-core.ko \
kmod-smpro-errmon.ko \
kmod-smpro-hwmon.ko \
kmod-smpro-misc.ko \
kmod-smsc.ko \
kmod-smsc47b397.ko \
kmod-smsc47m1.ko \
kmod-smsc47m192.ko \
kmod-smsc75xx.ko \
kmod-smsc911x.ko \
kmod-smsc9420.ko \
kmod-smsc95xx.ko \
kmod-smsdvb.ko \
kmod-smsm.ko \
kmod-smsmdtv.ko \
kmod-smssdio.ko \
kmod-smsusb.ko \
kmod-snd-ac97-codec.ko \
kmod-snd-acp-config.ko \
kmod-snd-ad1889.ko \
kmod-snd-ak4113.ko \
kmod-snd-ak4114.ko \
kmod-snd-ak4xxx-adda.ko \
kmod-snd-aloop.ko \
kmod-snd-atiixp-modem.ko \
kmod-snd-atiixp.ko \
kmod-snd-au8810.ko \
kmod-snd-au8820.ko \
kmod-snd-au8830.ko \
kmod-snd-aw2.ko \
kmod-snd-bcd2000.ko \
kmod-snd-bcm2835.ko \
kmod-snd-bebob.ko \
kmod-snd-bt87x.ko \
kmod-snd-ca0106.ko \
kmod-snd-cmipci.ko \
kmod-snd-compress.ko \
kmod-snd-cs4281.ko \
kmod-snd-cs46xx.ko \
kmod-snd-ctl-led.ko \
kmod-snd-ctxfi.ko \
kmod-snd-darla20.ko \
kmod-snd-darla24.ko \
kmod-snd-dice.ko \
kmod-snd-dummy.ko \
kmod-snd-echo3g.ko \
kmod-snd-ens1370.ko \
kmod-snd-ens1371.ko \
kmod-snd-fireface.ko \
kmod-snd-firewire-digi00x.ko \
kmod-snd-firewire-lib.ko \
kmod-snd-firewire-motu.ko \
kmod-snd-firewire-tascam.ko \
kmod-snd-fireworks.ko \
kmod-snd-fm801.ko \
kmod-snd-gina20.ko \
kmod-snd-gina24.ko \
kmod-snd-hda-acpi.ko \
kmod-snd-hda-cirrus-scodec.ko \
kmod-snd-hda-cix-ipbloq.ko \
kmod-snd-hda-codec-alc260.ko \
kmod-snd-hda-codec-alc262.ko \
kmod-snd-hda-codec-alc268.ko \
kmod-snd-hda-codec-alc269.ko \
kmod-snd-hda-codec-alc662.ko \
kmod-snd-hda-codec-alc680.ko \
kmod-snd-hda-codec-alc861.ko \
kmod-snd-hda-codec-alc861vd.ko \
kmod-snd-hda-codec-alc880.ko \
kmod-snd-hda-codec-alc882.ko \
kmod-snd-hda-codec-analog.ko \
kmod-snd-hda-codec-atihdmi.ko \
kmod-snd-hda-codec-ca0110.ko \
kmod-snd-hda-codec-ca0132.ko \
kmod-snd-hda-codec-cm9825.ko \
kmod-snd-hda-codec-cmedia.ko \
kmod-snd-hda-codec-conexant.ko \
kmod-snd-hda-codec-cs420x.ko \
kmod-snd-hda-codec-cs421x.ko \
kmod-snd-hda-codec-cs8409.ko \
kmod-snd-hda-codec-generic.ko \
kmod-snd-hda-codec-hdmi.ko \
kmod-snd-hda-codec-idt.ko \
kmod-snd-hda-codec-intelhdmi.ko \
kmod-snd-hda-codec-nvhdmi-mcp.ko \
kmod-snd-hda-codec-nvhdmi.ko \
kmod-snd-hda-codec-realtek-lib.ko \
kmod-snd-hda-codec-senarytech.ko \
kmod-snd-hda-codec-si3054.ko \
kmod-snd-hda-codec-simplehdmi.ko \
kmod-snd-hda-codec-tegrahdmi.ko \
kmod-snd-hda-codec-via.ko \
kmod-snd-hda-codec.ko \
kmod-snd-hda-core.ko \
kmod-snd-hda-ext-core.ko \
kmod-snd-hda-intel.ko \
kmod-snd-hda-scodec-component.ko \
kmod-snd-hda-scodec-cs35l41-i2c.ko \
kmod-snd-hda-scodec-cs35l41-spi.ko \
kmod-snd-hda-scodec-cs35l41.ko \
kmod-snd-hda-scodec-cs35l56-i2c.ko \
kmod-snd-hda-scodec-cs35l56-spi.ko \
kmod-snd-hda-scodec-cs35l56.ko \
kmod-snd-hda-scodec-tas2781-i2c.ko \
kmod-snd-hda-scodec-tas2781-spi.ko \
kmod-snd-hda-scodec-tas2781.ko \
kmod-snd-hda-tegra.ko \
kmod-snd-hdsp.ko \
kmod-snd-hdspm.ko \
kmod-snd-hrtimer.ko \
kmod-snd-hwdep.ko \
kmod-snd-i2c.ko \
kmod-snd-ice1724.ko \
kmod-snd-ice17xx-ak4xxx.ko \
kmod-snd-indigo.ko \
kmod-snd-indigodj.ko \
kmod-snd-indigodjx.ko \
kmod-snd-indigoio.ko \
kmod-snd-indigoiox.ko \
kmod-snd-intel-dspcfg.ko \
kmod-snd-intel-sdw-acpi.ko \
kmod-snd-intel8x0.ko \
kmod-snd-intel8x0m.ko \
kmod-snd-isight.ko \
kmod-snd-korg1212.ko \
kmod-snd-layla20.ko \
kmod-snd-layla24.ko \
kmod-snd-lola.ko \
kmod-snd-lx6464es.ko \
kmod-snd-mia.ko \
kmod-snd-mixart.ko \
kmod-snd-mixer-oss.ko \
kmod-snd-mona.ko \
kmod-snd-mpu401-uart.ko \
kmod-snd-mpu401.ko \
kmod-snd-mtpav.ko \
kmod-snd-mts64.ko \
kmod-snd-nm256.ko \
kmod-snd-opl3-lib.ko \
kmod-snd-opl3-synth.ko \
kmod-snd-oxfw.ko \
kmod-snd-oxygen-lib.ko \
kmod-snd-oxygen.ko \
kmod-snd-pcm-dmaengine.ko \
kmod-snd-pcm-oss.ko \
kmod-snd-pcm.ko \
kmod-snd-pcmtest.ko \
kmod-snd-pcxhr.ko \
kmod-snd-portman2x4.ko \
kmod-snd-pt2258.ko \
kmod-snd-q6apm.ko \
kmod-snd-q6dsp-common.ko \
kmod-snd-rawmidi.ko \
kmod-snd-riptide.ko \
kmod-snd-rme32.ko \
kmod-snd-rme96.ko \
kmod-snd-rme9652.ko \
kmod-snd-seq-device.ko \
kmod-snd-seq-dummy.ko \
kmod-snd-seq-midi-emul.ko \
kmod-snd-seq-midi-event.ko \
kmod-snd-seq-midi.ko \
kmod-snd-seq-oss.ko \
kmod-snd-seq-ump-client.ko \
kmod-snd-seq-virmidi.ko \
kmod-snd-seq.ko \
kmod-snd-serial-generic.ko \
kmod-snd-serial-u16550.ko \
kmod-snd-soc-63xx.ko \
kmod-snd-soc-ac97.ko \
kmod-snd-soc-acp-da7219mx98357-mach.ko \
kmod-snd-soc-acp-es8336-mach.ko \
kmod-snd-soc-acp-rt5645-mach.ko \
kmod-snd-soc-acpi.ko \
kmod-snd-soc-adau-utils.ko \
kmod-snd-soc-adau1701.ko \
kmod-snd-soc-adau1761-i2c.ko \
kmod-snd-soc-adau1761-spi.ko \
kmod-snd-soc-adau1761.ko \
kmod-snd-soc-adau17x1.ko \
kmod-snd-soc-adau7002.ko \
kmod-snd-soc-adau7118-hw.ko \
kmod-snd-soc-adau7118-i2c.ko \
kmod-snd-soc-adau7118.ko \
kmod-snd-soc-adi-axi-i2s.ko \
kmod-snd-soc-adi-axi-spdif.ko \
kmod-snd-soc-ak4104.ko \
kmod-snd-soc-ak4118.ko \
kmod-snd-soc-ak4375.ko \
kmod-snd-soc-ak4458.ko \
kmod-snd-soc-ak4554.ko \
kmod-snd-soc-ak4613.ko \
kmod-snd-soc-ak4642.ko \
kmod-snd-soc-ak5386.ko \
kmod-snd-soc-ak5558.ko \
kmod-snd-soc-alc5623.ko \
kmod-snd-soc-apple-mca.ko \
kmod-snd-soc-apq8016-sbc.ko \
kmod-snd-soc-apq8096.ko \
kmod-snd-soc-aries-wm8994.ko \
kmod-snd-soc-armada-370-db.ko \
kmod-snd-soc-audio-graph-card.ko \
kmod-snd-soc-audio-graph-card2-custom-sample.ko \
kmod-snd-soc-audio-graph-card2.ko \
kmod-snd-soc-aw8738.ko \
kmod-snd-soc-aw88081.ko \
kmod-snd-soc-aw88261.ko \
kmod-snd-soc-aw88395-lib.ko \
kmod-snd-soc-bcm2835-i2s.ko \
kmod-snd-soc-bd28623.ko \
kmod-snd-soc-bt-sco.ko \
kmod-snd-soc-chv3-codec.ko \
kmod-snd-soc-core.ko \
kmod-snd-soc-cpcap.ko \
kmod-snd-soc-cros-ec-codec.ko \
kmod-snd-soc-cs-amp-lib.ko \
kmod-snd-soc-cs35l32.ko \
kmod-snd-soc-cs35l33.ko \
kmod-snd-soc-cs35l34.ko \
kmod-snd-soc-cs35l35.ko \
kmod-snd-soc-cs35l36.ko \
kmod-snd-soc-cs35l41-i2c.ko \
kmod-snd-soc-cs35l41-lib.ko \
kmod-snd-soc-cs35l41-spi.ko \
kmod-snd-soc-cs35l41.ko \
kmod-snd-soc-cs35l45-i2c.ko \
kmod-snd-soc-cs35l45-spi.ko \
kmod-snd-soc-cs35l45.ko \
kmod-snd-soc-cs35l56-i2c.ko \
kmod-snd-soc-cs35l56-sdw.ko \
kmod-snd-soc-cs35l56-shared.ko \
kmod-snd-soc-cs35l56-spi.ko \
kmod-snd-soc-cs35l56.ko \
kmod-snd-soc-cs4265.ko \
kmod-snd-soc-cs4270.ko \
kmod-snd-soc-cs4271-i2c.ko \
kmod-snd-soc-cs4271-spi.ko \
kmod-snd-soc-cs4271.ko \
kmod-snd-soc-cs42l42-i2c.ko \
kmod-snd-soc-cs42l42-sdw.ko \
kmod-snd-soc-cs42l42.ko \
kmod-snd-soc-cs42l43-sdw.ko \
kmod-snd-soc-cs42l43.ko \
kmod-snd-soc-cs42l51-i2c.ko \
kmod-snd-soc-cs42l51.ko \
kmod-snd-soc-cs42l52.ko \
kmod-snd-soc-cs42l56.ko \
kmod-snd-soc-cs42l73.ko \
kmod-snd-soc-cs42xx8-i2c.ko \
kmod-snd-soc-cs42xx8-spi.ko \
kmod-snd-soc-cs42xx8.ko \
kmod-snd-soc-cs43130.ko \
kmod-snd-soc-cs4341.ko \
kmod-snd-soc-cs4349.ko \
kmod-snd-soc-cs48l32.ko \
kmod-snd-soc-cs53l30.ko \
kmod-snd-soc-cx2072x.ko \
kmod-snd-soc-da7213.ko \
kmod-snd-soc-da7219.ko \
kmod-snd-soc-dmic.ko \
kmod-snd-soc-es7134.ko \
kmod-snd-soc-es7241.ko \
kmod-snd-soc-es8316.ko \
kmod-snd-soc-es8326.ko \
kmod-snd-soc-es8328-i2c.ko \
kmod-snd-soc-es8328-spi.ko \
kmod-snd-soc-es8328.ko \
kmod-snd-soc-es8375.ko \
kmod-snd-soc-es8389.ko \
kmod-snd-soc-es9356.ko \
kmod-snd-soc-framer.ko \
kmod-snd-soc-fs-amp-lib.ko \
kmod-snd-soc-fs210x.ko \
kmod-snd-soc-fsi.ko \
kmod-snd-soc-fsl-asoc-card.ko \
kmod-snd-soc-fsl-asrc.ko \
kmod-snd-soc-fsl-aud2htx.ko \
kmod-snd-soc-fsl-audmix.ko \
kmod-snd-soc-fsl-easrc.ko \
kmod-snd-soc-fsl-esai.ko \
kmod-snd-soc-fsl-micfil.ko \
kmod-snd-soc-fsl-mqs.ko \
kmod-snd-soc-fsl-rpmsg.ko \
kmod-snd-soc-fsl-sai.ko \
kmod-snd-soc-fsl-spdif.ko \
kmod-snd-soc-fsl-ssi.ko \
kmod-snd-soc-fsl-utils.ko \
kmod-snd-soc-gtm601.ko \
kmod-snd-soc-hda-codec.ko \
kmod-snd-soc-hdmi-codec.ko \
kmod-snd-soc-i2s.ko \
kmod-snd-soc-idma.ko \
kmod-snd-soc-imx-audmix.ko \
kmod-snd-soc-imx-audmux.ko \
kmod-snd-soc-imx-card.ko \
kmod-snd-soc-imx-es8328.ko \
kmod-snd-soc-imx-hdmi.ko \
kmod-snd-soc-imx-rpmsg.ko \
kmod-snd-soc-imx-sgtl5000.ko \
kmod-snd-soc-kirkwood.ko \
kmod-snd-soc-kmb-platform.ko \
kmod-snd-soc-lochnagar-sc.ko \
kmod-snd-soc-lpass-apq8016.ko \
kmod-snd-soc-lpass-cdc-dma.ko \
kmod-snd-soc-lpass-cpu.ko \
kmod-snd-soc-lpass-hdmi.ko \
kmod-snd-soc-lpass-ipq806x.ko \
kmod-snd-soc-lpass-macro-common.ko \
kmod-snd-soc-lpass-platform.ko \
kmod-snd-soc-lpass-rx-macro.ko \
kmod-snd-soc-lpass-sc7180.ko \
kmod-snd-soc-lpass-sc7280.ko \
kmod-snd-soc-lpass-tx-macro.ko \
kmod-snd-soc-lpass-va-macro.ko \
kmod-snd-soc-lpass-wsa-macro.ko \
kmod-snd-soc-max9759.ko \
kmod-snd-soc-max98088.ko \
kmod-snd-soc-max98090.ko \
kmod-snd-soc-max98095.ko \
kmod-snd-soc-max98357a.ko \
kmod-snd-soc-max98363.ko \
kmod-snd-soc-max98373-i2c.ko \
kmod-snd-soc-max98373-sdw.ko \
kmod-snd-soc-max98373.ko \
kmod-snd-soc-max98388.ko \
kmod-snd-soc-max98390.ko \
kmod-snd-soc-max98396.ko \
kmod-snd-soc-max98504.ko \
kmod-snd-soc-max98520.ko \
kmod-snd-soc-max9860.ko \
kmod-snd-soc-max9867.ko \
kmod-snd-soc-max98927.ko \
kmod-snd-soc-meson-aiu.ko \
kmod-snd-soc-meson-axg-fifo.ko \
kmod-snd-soc-meson-axg-frddr.ko \
kmod-snd-soc-meson-axg-pdm.ko \
kmod-snd-soc-meson-axg-sound-card.ko \
kmod-snd-soc-meson-axg-spdifin.ko \
kmod-snd-soc-meson-axg-spdifout.ko \
kmod-snd-soc-meson-axg-tdm-formatter.ko \
kmod-snd-soc-meson-axg-tdm-interface.ko \
kmod-snd-soc-meson-axg-tdmin.ko \
kmod-snd-soc-meson-axg-tdmout.ko \
kmod-snd-soc-meson-axg-toddr.ko \
kmod-snd-soc-meson-card-utils.ko \
kmod-snd-soc-meson-codec-glue.ko \
kmod-snd-soc-meson-g12a-toacodec.ko \
kmod-snd-soc-meson-g12a-tohdmitx.ko \
kmod-snd-soc-meson-gx-sound-card.ko \
kmod-snd-soc-meson-t9015.ko \
kmod-snd-soc-midas-wm1811.ko \
kmod-snd-soc-mmp-sspa.ko \
kmod-snd-soc-msiof.ko \
kmod-snd-soc-mt6351.ko \
kmod-snd-soc-mt6357.ko \
kmod-snd-soc-mt6358.ko \
kmod-snd-soc-mt6359.ko \
kmod-snd-soc-mt6660.ko \
kmod-snd-soc-mt6797-afe.ko \
kmod-snd-soc-mt7986-afe.ko \
kmod-snd-soc-mt8183-afe.ko \
kmod-snd-soc-mt8186-afe.ko \
kmod-snd-soc-mt8188-afe.ko \
kmod-snd-soc-mt8189-afe.ko \
kmod-snd-soc-mt8192-afe.ko \
kmod-snd-soc-mt8195-afe.ko \
kmod-snd-soc-mt8196-afe.ko \
kmod-snd-soc-mt8365-pcm.ko \
kmod-snd-soc-mtk-common.ko \
kmod-snd-soc-nau8315.ko \
kmod-snd-soc-nau8325.ko \
kmod-snd-soc-nau8540.ko \
kmod-snd-soc-nau8810.ko \
kmod-snd-soc-nau8821.ko \
kmod-snd-soc-nau8822.ko \
kmod-snd-soc-nau8824.ko \
kmod-snd-soc-nau8825.ko \
kmod-snd-soc-pcm.ko \
kmod-snd-soc-pcm1681.ko \
kmod-snd-soc-pcm1754.ko \
kmod-snd-soc-pcm1789-codec.ko \
kmod-snd-soc-pcm1789-i2c.ko \
kmod-snd-soc-pcm179x-codec.ko \
kmod-snd-soc-pcm179x-i2c.ko \
kmod-snd-soc-pcm179x-spi.ko \
kmod-snd-soc-pcm186x-i2c.ko \
kmod-snd-soc-pcm186x-spi.ko \
kmod-snd-soc-pcm186x.ko \
kmod-snd-soc-pcm3060-i2c.ko \
kmod-snd-soc-pcm3060-spi.ko \
kmod-snd-soc-pcm3060.ko \
kmod-snd-soc-pcm512x-i2c.ko \
kmod-snd-soc-pcm512x-spi.ko \
kmod-snd-soc-pcm512x.ko \
kmod-snd-soc-pm4125-sdw.ko \
kmod-snd-soc-pm4125.ko \
kmod-snd-soc-qcom-common.ko \
kmod-snd-soc-qcom-offload-utils.ko \
kmod-snd-soc-qcom-sdw.ko \
kmod-snd-soc-rcar.ko \
kmod-snd-soc-rk3288-hdmi-analog.ko \
kmod-snd-soc-rk3308.ko \
kmod-snd-soc-rk3328.ko \
kmod-snd-soc-rk3399-gru-sound.ko \
kmod-snd-soc-rk817.ko \
kmod-snd-soc-rl6231.ko \
kmod-snd-soc-rockchip-i2s-tdm.ko \
kmod-snd-soc-rockchip-i2s.ko \
kmod-snd-soc-rockchip-max98090.ko \
kmod-snd-soc-rockchip-pdm.ko \
kmod-snd-soc-rockchip-rt5645.ko \
kmod-snd-soc-rockchip-sai.ko \
kmod-snd-soc-rockchip-spdif.ko \
kmod-snd-soc-rt1011.ko \
kmod-snd-soc-rt1015.ko \
kmod-snd-soc-rt1015p.ko \
kmod-snd-soc-rt1017-sdca.ko \
kmod-snd-soc-rt1308-sdw.ko \
kmod-snd-soc-rt1316-sdw.ko \
kmod-snd-soc-rt1320-sdw.ko \
kmod-snd-soc-rt5514-spi.ko \
kmod-snd-soc-rt5514.ko \
kmod-snd-soc-rt5575.ko \
kmod-snd-soc-rt5616.ko \
kmod-snd-soc-rt5631.ko \
kmod-snd-soc-rt5640.ko \
kmod-snd-soc-rt5645.ko \
kmod-snd-soc-rt5659.ko \
kmod-snd-soc-rt5663.ko \
kmod-snd-soc-rt5682-i2c.ko \
kmod-snd-soc-rt5682-sdw.ko \
kmod-snd-soc-rt5682.ko \
kmod-snd-soc-rt5682s.ko \
kmod-snd-soc-rt700.ko \
kmod-snd-soc-rt711-sdca.ko \
kmod-snd-soc-rt711.ko \
kmod-snd-soc-rt712-sdca-dmic.ko \
kmod-snd-soc-rt712-sdca.ko \
kmod-snd-soc-rt715-sdca.ko \
kmod-snd-soc-rt715.ko \
kmod-snd-soc-rt722-sdca.ko \
kmod-snd-soc-rt9120.ko \
kmod-snd-soc-rt9123.ko \
kmod-snd-soc-rt9123p.ko \
kmod-snd-soc-rtq9124.ko \
kmod-snd-soc-rtq9128.ko \
kmod-snd-soc-rz-ssi.ko \
kmod-snd-soc-s3c-dma.ko \
kmod-snd-soc-samsung-spdif.ko \
kmod-snd-soc-sc7180.ko \
kmod-snd-soc-sc7280.ko \
kmod-snd-soc-sc8280xp.ko \
kmod-snd-soc-sdca.ko \
kmod-snd-soc-sdm845.ko \
kmod-snd-soc-sdw-mockup.ko \
kmod-snd-soc-sgtl5000.ko \
kmod-snd-soc-sigmadsp-i2c.ko \
kmod-snd-soc-sigmadsp-regmap.ko \
kmod-snd-soc-sigmadsp.ko \
kmod-snd-soc-simple-amplifier.ko \
kmod-snd-soc-simple-card-utils.ko \
kmod-snd-soc-simple-card.ko \
kmod-snd-soc-sm8250.ko \
kmod-snd-soc-smdk-spdif.ko \
kmod-snd-soc-smdk-wm8994.ko \
kmod-snd-soc-smdk-wm8994pcm.ko \
kmod-snd-soc-snow.ko \
kmod-snd-soc-spdif-rx.ko \
kmod-snd-soc-spdif-tx.ko \
kmod-snd-soc-sprd-platform.ko \
kmod-snd-soc-ssm2305.ko \
kmod-snd-soc-ssm2518.ko \
kmod-snd-soc-ssm2602-i2c.ko \
kmod-snd-soc-ssm2602-spi.ko \
kmod-snd-soc-ssm2602.ko \
kmod-snd-soc-ssm4567.ko \
kmod-snd-soc-sta32x.ko \
kmod-snd-soc-sta350.ko \
kmod-snd-soc-sti-sas.ko \
kmod-snd-soc-stm32-i2s.ko \
kmod-snd-soc-stm32-sai-sub.ko \
kmod-snd-soc-stm32-sai.ko \
kmod-snd-soc-stm32-spdifrx.ko \
kmod-snd-soc-storm.ko \
kmod-snd-soc-tac5xx2-sdw.ko \
kmod-snd-soc-tas2552.ko \
kmod-snd-soc-tas2562.ko \
kmod-snd-soc-tas2770.ko \
kmod-snd-soc-tas2781-comlib-i2c.ko \
kmod-snd-soc-tas2781-comlib.ko \
kmod-snd-soc-tas2781-fmwlib.ko \
kmod-snd-soc-tas2781-i2c.ko \
kmod-snd-soc-tas2783-sdw.ko \
kmod-snd-soc-tas5086.ko \
kmod-snd-soc-tas571x.ko \
kmod-snd-soc-tas5720.ko \
kmod-snd-soc-tas5805m.ko \
kmod-snd-soc-tas6424.ko \
kmod-snd-soc-tas675x.ko \
kmod-snd-soc-tda7419.ko \
kmod-snd-soc-tegra-audio-graph-card.ko \
kmod-snd-soc-tegra-machine.ko \
kmod-snd-soc-tegra-pcm.ko \
kmod-snd-soc-tegra186-asrc.ko \
kmod-snd-soc-tegra186-dspk.ko \
kmod-snd-soc-tegra210-admaif.ko \
kmod-snd-soc-tegra210-adx.ko \
kmod-snd-soc-tegra210-ahub.ko \
kmod-snd-soc-tegra210-amx.ko \
kmod-snd-soc-tegra210-dmic.ko \
kmod-snd-soc-tegra210-i2s.ko \
kmod-snd-soc-tegra210-mixer.ko \
kmod-snd-soc-tegra210-mvc.ko \
kmod-snd-soc-tegra210-ope.ko \
kmod-snd-soc-tegra210-sfc.ko \
kmod-snd-soc-test-component.ko \
kmod-snd-soc-tfa9879.ko \
kmod-snd-soc-tfa989x.ko \
kmod-snd-soc-tlv320adcx140.ko \
kmod-snd-soc-tlv320aic23-i2c.ko \
kmod-snd-soc-tlv320aic23-spi.ko \
kmod-snd-soc-tlv320aic23.ko \
kmod-snd-soc-tlv320aic31xx.ko \
kmod-snd-soc-tlv320aic32x4-i2c.ko \
kmod-snd-soc-tlv320aic32x4-spi.ko \
kmod-snd-soc-tlv320aic32x4.ko \
kmod-snd-soc-tlv320aic3x-i2c.ko \
kmod-snd-soc-tlv320aic3x-spi.ko \
kmod-snd-soc-tlv320aic3x.ko \
kmod-snd-soc-tpa6130a2.ko \
kmod-snd-soc-ts3a227e.ko \
kmod-snd-soc-tscs42xx.ko \
kmod-snd-soc-tscs454.ko \
kmod-snd-soc-uda1334.ko \
kmod-snd-soc-uda1380.ko \
kmod-snd-soc-wcd-classh.ko \
kmod-snd-soc-wcd-common.ko \
kmod-snd-soc-wcd-mbhc.ko \
kmod-snd-soc-wcd9335.ko \
kmod-snd-soc-wcd934x.ko \
kmod-snd-soc-wcd938x-sdw.ko \
kmod-snd-soc-wcd938x.ko \
kmod-snd-soc-wcd939x-sdw.ko \
kmod-snd-soc-wcd939x.ko \
kmod-snd-soc-wm-adsp.ko \
kmod-snd-soc-wm-hubs.ko \
kmod-snd-soc-wm8510.ko \
kmod-snd-soc-wm8523.ko \
kmod-snd-soc-wm8524.ko \
kmod-snd-soc-wm8580.ko \
kmod-snd-soc-wm8711.ko \
kmod-snd-soc-wm8728.ko \
kmod-snd-soc-wm8737.ko \
kmod-snd-soc-wm8741.ko \
kmod-snd-soc-wm8750.ko \
kmod-snd-soc-wm8753.ko \
kmod-snd-soc-wm8770.ko \
kmod-snd-soc-wm8776.ko \
kmod-snd-soc-wm8782.ko \
kmod-snd-soc-wm8804-i2c.ko \
kmod-snd-soc-wm8804-spi.ko \
kmod-snd-soc-wm8804.ko \
kmod-snd-soc-wm8903.ko \
kmod-snd-soc-wm8904.ko \
kmod-snd-soc-wm8960.ko \
kmod-snd-soc-wm8962.ko \
kmod-snd-soc-wm8974.ko \
kmod-snd-soc-wm8978.ko \
kmod-snd-soc-wm8985.ko \
kmod-snd-soc-wm8994.ko \
kmod-snd-soc-wsa881x.ko \
kmod-snd-soc-wsa883x.ko \
kmod-snd-soc-x1e80100.ko \
kmod-snd-soc-xlnx-formatter-pcm.ko \
kmod-snd-soc-xlnx-i2s.ko \
kmod-snd-soc-xlnx-spdif.ko \
kmod-snd-soc-xtfpga-i2s.ko \
kmod-snd-soc-zl38060.ko \
kmod-snd-sof-imx8.ko \
kmod-snd-sof-imx9.ko \
kmod-snd-sof-mt8186.ko \
kmod-snd-sof-mt8195.ko \
kmod-snd-sof-of.ko \
kmod-snd-sof-utils.ko \
kmod-snd-sof-xtensa-dsp.ko \
kmod-snd-sof.ko \
kmod-snd-timer.ko \
kmod-snd-ua101.ko \
kmod-snd-ump.ko \
kmod-snd-usb-6fire.ko \
kmod-snd-usb-audio-qmi.ko \
kmod-snd-usb-audio.ko \
kmod-snd-usb-caiaq.ko \
kmod-snd-usb-hiface.ko \
kmod-snd-usb-line6.ko \
kmod-snd-usb-pod.ko \
kmod-snd-usb-podhd.ko \
kmod-snd-usb-toneport.ko \
kmod-snd-usb-variax.ko \
kmod-snd-usbmidi-lib.ko \
kmod-snd-via82xx-modem.ko \
kmod-snd-via82xx.ko \
kmod-snd-virmidi.ko \
kmod-snd-virtuoso.ko \
kmod-snd-vx-lib.ko \
kmod-snd-vx222.ko \
kmod-snd-ymfpci.ko \
kmod-snd.ko \
kmod-snet-vdpa.ko \
kmod-snic.ko \
kmod-snps-udc-core.ko \
kmod-snps-udc-plat.ko \
kmod-snvs-pwrkey.ko \
kmod-soc-button-array.ko \
kmod-soc-imx8m.ko \
kmod-soc-imx9.ko \
kmod-soc-usb.ko \
kmod-socfpga-a10.ko \
kmod-socfpga.ko \
kmod-socinfo.ko \
kmod-softdog.ko \
kmod-softing.ko \
kmod-solo6x10.ko \
kmod-solos-pci.ko \
kmod-sony-btf-mpx.ko \
kmod-sophgo-cv1800b-adc.ko \
kmod-soundcore.ko \
kmod-soundwire-amd.ko \
kmod-soundwire-bus.ko \
kmod-soundwire-generic-allocation.ko \
kmod-soundwire-qcom.ko \
kmod-sp2.ko \
kmod-sp805-wdt.ko \
kmod-sp8870.ko \
kmod-sp887x.ko \
kmod-spaceball.ko \
kmod-spaceorb.ko \
kmod-sparse-keymap.ko \
kmod-sparx5-serdes.ko \
kmod-sparx5-switch.ko \
kmod-sparx5-temp.ko \
kmod-spcp8x5.ko \
kmod-spd5118.ko \
kmod-speedtch.ko \
kmod-spi-airoha-snfi.ko \
kmod-spi-altera-core.ko \
kmod-spi-altera-dfl.ko \
kmod-spi-amd-pci.ko \
kmod-spi-amd.ko \
kmod-spi-amlogic-spifc-a1.ko \
kmod-spi-amlogic-spifc-a4.ko \
kmod-spi-amlogic-spisg.ko \
kmod-spi-apple.ko \
kmod-spi-armada-3700.ko \
kmod-spi-aspeed-smc.ko \
kmod-spi-atmel.ko \
kmod-spi-axiado.ko \
kmod-spi-bcm-qspi.ko \
kmod-spi-bcm2835.ko \
kmod-spi-bcm2835aux.ko \
kmod-spi-bcm63xx-hsspi.ko \
kmod-spi-bcmbca-hsspi.ko \
kmod-spi-bitbang.ko \
kmod-spi-brcmstb-qspi.ko \
kmod-spi-cadence-quadspi.ko \
kmod-spi-cadence-xspi.ko \
kmod-spi-cadence.ko \
kmod-spi-cs42l43.ko \
kmod-spi-dln2.ko \
kmod-spi-dw-mmio.ko \
kmod-spi-dw-pci.ko \
kmod-spi-dw.ko \
kmod-spi-fsl-dspi.ko \
kmod-spi-fsl-lib.ko \
kmod-spi-fsl-lpspi.ko \
kmod-spi-fsl-qspi.ko \
kmod-spi-fsl-spi.ko \
kmod-spi-geni-qcom.ko \
kmod-spi-gpio.ko \
kmod-spi-hisi-kunpeng.ko \
kmod-spi-hisi-sfc-v3xx.ko \
kmod-spi-imx.ko \
kmod-spi-iproc-qspi.ko \
kmod-spi-kspi2.ko \
kmod-spi-ljca.ko \
kmod-spi-loopback-test.ko \
kmod-spi-meson-spicc.ko \
kmod-spi-microchip-core-qspi.ko \
kmod-spi-microchip-core-spi.ko \
kmod-spi-mpfs.ko \
kmod-spi-mt65xx.ko \
kmod-spi-mtk-nor.ko \
kmod-spi-mtk-snfi.ko \
kmod-spi-mux.ko \
kmod-spi-mxic.ko \
kmod-spi-nor.ko \
kmod-spi-npcm-fiu.ko \
kmod-spi-npcm-pspi.ko \
kmod-spi-nxp-fspi.ko \
kmod-spi-nxp-xspi.ko \
kmod-spi-oc-tiny.ko \
kmod-spi-offload-trigger-adi-util-sigma-delta.ko \
kmod-spi-offload-trigger-pwm.ko \
kmod-spi-orion.ko \
kmod-spi-pl022.ko \
kmod-spi-pxa2xx-core.ko \
kmod-spi-pxa2xx-pci.ko \
kmod-spi-pxa2xx-platform.ko \
kmod-spi-qcom-qspi.ko \
kmod-spi-qpic-snand.ko \
kmod-spi-qup.ko \
kmod-spi-rockchip-sfc.ko \
kmod-spi-rockchip.ko \
kmod-spi-rpc-if.ko \
kmod-spi-rspi.ko \
kmod-spi-rzv2h-rspi.ko \
kmod-spi-rzv2m-csi.ko \
kmod-spi-s3c64xx.ko \
kmod-spi-sc18is602.ko \
kmod-spi-sg2044-nor.ko \
kmod-spi-sh-hspi.ko \
kmod-spi-sh-msiof.ko \
kmod-spi-sifive.ko \
kmod-spi-slave-mt27xx.ko \
kmod-spi-slave-system-control.ko \
kmod-spi-slave-time.ko \
kmod-spi-sprd-adi.ko \
kmod-spi-sprd.ko \
kmod-spi-stm32-ospi.ko \
kmod-spi-stm32-qspi.ko \
kmod-spi-stm32.ko \
kmod-spi-sun4i.ko \
kmod-spi-sun6i.ko \
kmod-spi-synquacer.ko \
kmod-spi-tegra114.ko \
kmod-spi-tegra20-sflash.ko \
kmod-spi-tegra20-slink.ko \
kmod-spi-tegra210-quad.ko \
kmod-spi-thunderx.ko \
kmod-spi-virtio.ko \
kmod-spi-wpcm-fiu.ko \
kmod-spi-xcomm.ko \
kmod-spi-xilinx.ko \
kmod-spi-xlp.ko \
kmod-spi-zynqmp-gqspi.ko \
kmod-spidev.ko \
kmod-spinand.ko \
kmod-spm.ko \
kmod-spmi-apple-controller.ko \
kmod-spmi-devres.ko \
kmod-spmi-mtk-pmif.ko \
kmod-spmi-pmic-arb.ko \
kmod-spmi.ko \
kmod-sprd-dma.ko \
kmod-sprd-drm.ko \
kmod-sprd-hwspinlock.ko \
kmod-sprd-iommu.ko \
kmod-sprd-mailbox.ko \
kmod-sprd-mcdt.ko \
kmod-sprd-sc27xx-spi.ko \
kmod-sprd-serial.ko \
kmod-sprd-thermal.ko \
kmod-sprd-wdt.ko \
kmod-sps30-i2c.ko \
kmod-sps30-serial.ko \
kmod-sps30.ko \
kmod-squashfs.ko \
kmod-sr-mod.ko \
kmod-sr-thermal.ko \
kmod-sr9700.ko \
kmod-sr9800.ko \
kmod-srf04.ko \
kmod-srf08.ko \
kmod-ssb-hcd.ko \
kmod-ssb.ko \
kmod-ssd130x-i2c.ko \
kmod-ssd130x-spi.ko \
kmod-ssd130x.ko \
kmod-ssd2825.ko \
kmod-ssfdc.ko \
kmod-ssif-bmc.ko \
kmod-ssp.ko \
kmod-ssu100.ko \
kmod-st-accel-i2c.ko \
kmod-st-accel-spi.ko \
kmod-st-accel.ko \
kmod-st-lsm6dsx-i2c.ko \
kmod-st-lsm6dsx-i3c.ko \
kmod-st-lsm6dsx-spi.ko \
kmod-st-lsm6dsx.ko \
kmod-st-lsm9ds0-i2c.ko \
kmod-st-lsm9ds0-spi.ko \
kmod-st-lsm9ds0.ko \
kmod-st-magn-i2c.ko \
kmod-st-magn-spi.ko \
kmod-st-magn.ko \
kmod-st-nci-i2c.ko \
kmod-st-nci-spi.ko \
kmod-st-nci.ko \
kmod-st-pressure-i2c.ko \
kmod-st-pressure-spi.ko \
kmod-st-pressure.ko \
kmod-st-sensors-i2c.ko \
kmod-st-sensors-spi.ko \
kmod-st-sensors.ko \
kmod-st-thermal-memmap.ko \
kmod-st-thermal.ko \
kmod-st-uvis25-core.ko \
kmod-st-uvis25-i2c.ko \
kmod-st-uvis25-spi.ko \
kmod-st.ko \
kmod-st1232.ko \
kmod-st21nfca-hci.ko \
kmod-st21nfca-i2c.ko \
kmod-st7571-i2c.ko \
kmod-st7571-spi.ko \
kmod-st7571.ko \
kmod-st7586.ko \
kmod-st7735r.ko \
kmod-st7920.ko \
kmod-st95hf.ko \
kmod-starfire.ko \
kmod-stb0899.ko \
kmod-stb6000.ko \
kmod-stb6100.ko \
kmod-stc3117-fuel-gauge.ko \
kmod-ste10Xp.ko \
kmod-stef48h28.ko \
kmod-stex.ko \
kmod-stinger.ko \
kmod-stk1160.ko \
kmod-stk8312.ko \
kmod-stk8ba50.ko \
kmod-stm-console.ko \
kmod-stm-core.ko \
kmod-stm-drm.ko \
kmod-stm-ftrace.ko \
kmod-stm-p-basic.ko \
kmod-stm-p-sys-t.ko \
kmod-stm32-adc-core.ko \
kmod-stm32-adc.ko \
kmod-stm32-adfsdm.ko \
kmod-stm32-booster.ko \
kmod-stm32-cec.ko \
kmod-stm32-cryp.ko \
kmod-stm32-csi.ko \
kmod-stm32-dac-core.ko \
kmod-stm32-dac.ko \
kmod-stm32-dcmi.ko \
kmod-stm32-dcmipp.ko \
kmod-stm32-dfsdm-adc.ko \
kmod-stm32-dfsdm-core.ko \
kmod-stm32-dma2d.ko \
kmod-stm32-dma3.ko \
kmod-stm32-etzpc.ko \
kmod-stm32-fmc2-ebi.ko \
kmod-stm32-fmc2-nand.ko \
kmod-stm32-hash.ko \
kmod-stm32-iwdg.ko \
kmod-stm32-lptimer-cnt.ko \
kmod-stm32-lptimer-trigger.ko \
kmod-stm32-lptimer.ko \
kmod-stm32-omm.ko \
kmod-stm32-rifsc.ko \
kmod-stm32-rng.ko \
kmod-stm32-rproc.ko \
kmod-stm32-timer-cnt.ko \
kmod-stm32-timer-trigger.ko \
kmod-stm32-timers.ko \
kmod-stm32-usart.ko \
kmod-stm32-vrefbuf.ko \
kmod-stmfts.ko \
kmod-stmfx.ko \
kmod-stmmac-libpci.ko \
kmod-stmmac-pci.ko \
kmod-stmmac-platform.ko \
kmod-stmmac.ko \
kmod-stp.ko \
kmod-stpddc60.ko \
kmod-stpmic1-onkey.ko \
kmod-stpmic1-regulator.ko \
kmod-stpmic1-wdt.ko \
kmod-stpmic1.ko \
kmod-stratix10-rsu.ko \
kmod-stratix10-soc.ko \
kmod-stratix10-svc.ko \
kmod-streamzap.ko \
kmod-streebog-generic.ko \
kmod-stts751.ko \
kmod-stusb160x.ko \
kmod-stv0288.ko \
kmod-stv0297.ko \
kmod-stv0299.ko \
kmod-stv0367.ko \
kmod-stv0900.ko \
kmod-stv090x.ko \
kmod-stv0910.ko \
kmod-stv6110.ko \
kmod-stv6110x.ko \
kmod-stv6111.ko \
kmod-sun20i-gpadc-iio.ko \
kmod-sun20i-regulator.ko \
kmod-sun4i-codec.ko \
kmod-sun4i-csi.ko \
kmod-sun4i-drm.ko \
kmod-sun4i-gpadc-iio.ko \
kmod-sun4i-gpadc.ko \
kmod-sun4i-i2s.ko \
kmod-sun4i-lradc-keys.ko \
kmod-sun4i-spdif.ko \
kmod-sun4i-ss.ko \
kmod-sun4i-tcon.ko \
kmod-sun4i-ts.ko \
kmod-sun4i-tv.ko \
kmod-sun50i-a100-ccu.ko \
kmod-sun50i-a100-r-ccu.ko \
kmod-sun50i-a64-ccu.ko \
kmod-sun50i-codec-analog.ko \
kmod-sun50i-cpufreq-nvmem.ko \
kmod-sun50i-dmic.ko \
kmod-sun50i-h6-ccu.ko \
kmod-sun50i-h6-prcm-ppu.ko \
kmod-sun50i-h6-r-ccu.ko \
kmod-sun50i-h616-ccu.ko \
kmod-sun55i-a523-ccu.ko \
kmod-sun55i-a523-mcu-ccu.ko \
kmod-sun55i-a523-r-ccu.ko \
kmod-sun55i-pck600.ko \
kmod-sun6i-dma.ko \
kmod-sun6i-drc.ko \
kmod-sun6i-hwspinlock.ko \
kmod-sun6i-mipi-csi2.ko \
kmod-sun6i-mipi-dsi.ko \
kmod-sun6i-msgbox.ko \
kmod-sun6i-rtc-ccu.ko \
kmod-sun8i-a33-mbus.ko \
kmod-sun8i-a83t-mipi-csi2.ko \
kmod-sun8i-adda-pr-regmap.ko \
kmod-sun8i-ce.ko \
kmod-sun8i-codec-analog.ko \
kmod-sun8i-codec.ko \
kmod-sun8i-de2-ccu.ko \
kmod-sun8i-di.ko \
kmod-sun8i-drm-hdmi.ko \
kmod-sun8i-h3-ccu.ko \
kmod-sun8i-mixer.ko \
kmod-sun8i-r-ccu.ko \
kmod-sun8i-rotate.ko \
kmod-sun8i-ss.ko \
kmod-sun8i-tcon-top.ko \
kmod-sun8i-thermal.ko \
kmod-sundance.ko \
kmod-sungem-phy.ko \
kmod-sungem.ko \
kmod-sunhme.ko \
kmod-sunkbd.ko \
kmod-sunrise-co2.ko \
kmod-sunrpc.ko \
kmod-sunxi-ccu.ko \
kmod-sunxi-cedrus.ko \
kmod-sunxi-cir.ko \
kmod-sunxi-mmc.ko \
kmod-sunxi-nand.ko \
kmod-sunxi-rsb.ko \
kmod-sunxi-wdt.ko \
kmod-sunxi.ko \
kmod-sur40.ko \
kmod-surface-acpi-notify.ko \
kmod-surface-aggregator-cdev.ko \
kmod-surface-aggregator-hub.ko \
kmod-surface-aggregator-registry.ko \
kmod-surface-aggregator-tabletsw.ko \
kmod-surface-aggregator.ko \
kmod-surface-battery.ko \
kmod-surface-charger.ko \
kmod-surface-dtx.ko \
kmod-surface-fan.ko \
kmod-surface-gpe.ko \
kmod-surface-hid-core.ko \
kmod-surface-hid.ko \
kmod-surface-hotplug.ko \
kmod-surface-kbd.ko \
kmod-surface-platform-profile.ko \
kmod-surface-temp.ko \
kmod-surface3-power.ko \
kmod-surfacepro3-button.ko \
kmod-svc-i3c-master.ko \
kmod-switchtec-dma.ko \
kmod-switchtec.ko \
kmod-sx-common.ko \
kmod-sx8654.ko \
kmod-sx9310.ko \
kmod-sx9324.ko \
kmod-sx9360.ko \
kmod-sx9500.ko \
kmod-sy8106a-regulator.ko \
kmod-sy8824x.ko \
kmod-sy8827n.ko \
kmod-sym53c8xx.ko \
kmod-symbolserial.ko \
kmod-synaptics-i2c.ko \
kmod-synaptics-usb.ko \
kmod-synopsys-edac.ko \
kmod-synopsys-hdmirx.ko \
kmod-syscon-reboot-mode.ko \
kmod-syscopyarea.ko \
kmod-sysfillrect.ko \
kmod-sysimgblt.ko \
kmod-system-heap.ko \
kmod-t4ka3.ko \
kmod-t7-peripherals.ko \
kmod-t7-pll.ko \
kmod-tag-brcm.ko \
kmod-tag-dsa.ko \
kmod-tag-gswip.ko \
kmod-tag-hellcreek.ko \
kmod-tag-ksz.ko \
kmod-tag-lan9303.ko \
kmod-tag-mtk.ko \
kmod-tag-mxl-gsw1xx.ko \
kmod-tag-mxl862xx.ko \
kmod-tag-netc.ko \
kmod-tag-none.ko \
kmod-tag-ocelot-8021q.ko \
kmod-tag-ocelot.ko \
kmod-tag-qca.ko \
kmod-tag-rtl4-a.ko \
kmod-tag-rtl8-4.ko \
kmod-tag-rzn1-a5psw.ko \
kmod-tag-sja1105.ko \
kmod-tag-trailer.ko \
kmod-tag-vsc73xx-8021q.ko \
kmod-tag-xrs700x.ko \
kmod-tag-yt921x.ko \
kmod-tap.ko \
kmod-target-core-file.ko \
kmod-target-core-iblock.ko \
kmod-target-core-mod.ko \
kmod-target-core-pscsi.ko \
kmod-target-core-user.ko \
kmod-tc358743.ko \
kmod-tc358746.ko \
kmod-tc358762.ko \
kmod-tc358764.ko \
kmod-tc358767.ko \
kmod-tc358768.ko \
kmod-tc358775.ko \
kmod-tc654.ko \
kmod-tc74.ko \
kmod-tc90522.ko \
kmod-tca8418-keypad.ko \
kmod-tcan4x5x.ko \
kmod-tcm-fc.ko \
kmod-tcm-loop.ko \
kmod-tcm-qla2xxx.ko \
kmod-tcm-remote.ko \
kmod-tcm-usb-gadget.ko \
kmod-tcp-bbr.ko \
kmod-tcp-bic.ko \
kmod-tcp-cdg.ko \
kmod-tcp-cubic.ko \
kmod-tcp-dctcp.ko \
kmod-tcp-diag.ko \
kmod-tcp-highspeed.ko \
kmod-tcp-htcp.ko \
kmod-tcp-hybla.ko \
kmod-tcp-illinois.ko \
kmod-tcp-lp.ko \
kmod-tcp-nv.ko \
kmod-tcp-scalable.ko \
kmod-tcp-vegas.ko \
kmod-tcp-veno.ko \
kmod-tcp-westwood.ko \
kmod-tcp-yeah.ko \
kmod-tcpci-maxim.ko \
kmod-tcpci-mt6360.ko \
kmod-tcpci-rt1711h.ko \
kmod-tcpci.ko \
kmod-tcpm.ko \
kmod-tcrypt.ko \
kmod-tcsrcc-eliza.ko \
kmod-tcsrcc-glymur.ko \
kmod-tcsrcc-hawi.ko \
kmod-tcsrcc-kaanapali.ko \
kmod-tcsrcc-nord.ko \
kmod-tcsrcc-sm8550.ko \
kmod-tcsrcc-sm8650.ko \
kmod-tcsrcc-sm8750.ko \
kmod-tcsrcc-x1e80100.ko \
kmod-tda10021.ko \
kmod-tda10023.ko \
kmod-tda10048.ko \
kmod-tda1004x.ko \
kmod-tda10071.ko \
kmod-tda10086.ko \
kmod-tda18212.ko \
kmod-tda18218.ko \
kmod-tda18250.ko \
kmod-tda18271.ko \
kmod-tda18271c2dd.ko \
kmod-tda1997x.ko \
kmod-tda38640.ko \
kmod-tda665x.ko \
kmod-tda7432.ko \
kmod-tda8083.ko \
kmod-tda8261.ko \
kmod-tda826x.ko \
kmod-tda827x.ko \
kmod-tda8290.ko \
kmod-tda9840.ko \
kmod-tda9887.ko \
kmod-tda9950.ko \
kmod-tda998x.ko \
kmod-tdx-ec-poweroff.ko \
kmod-tea575x.ko \
kmod-tea5761.ko \
kmod-tea5767.ko \
kmod-tea6415c.ko \
kmod-tea6420.ko \
kmod-team-mode-activebackup.ko \
kmod-team-mode-broadcast.ko \
kmod-team-mode-loadbalance.ko \
kmod-team-mode-random.ko \
kmod-team-mode-roundrobin.ko \
kmod-team.ko \
kmod-tee-bnxt-fw.ko \
kmod-tee-stmm-efi.ko \
kmod-tee.ko \
kmod-tef6862.ko \
kmod-tegra-aconnect.ko \
kmod-tegra-bpmp-thermal.ko \
kmod-tegra-cec.ko \
kmod-tegra-drm.ko \
kmod-tegra-gmi.ko \
kmod-tegra-kbc.ko \
kmod-tegra-nand.ko \
kmod-tegra-se.ko \
kmod-tegra-soctherm.ko \
kmod-tegra-tcu.ko \
kmod-tegra-utc.ko \
kmod-tegra-vde.ko \
kmod-tegra-video.ko \
kmod-tegra-wdt.ko \
kmod-tegra-xudc.ko \
kmod-tegra124-cpufreq.ko \
kmod-tegra186-cpufreq.ko \
kmod-tegra186-gpc-dma.ko \
kmod-tegra194-cpufreq.ko \
kmod-tegra20-apb-dma.ko \
kmod-tegra210-adma.ko \
kmod-tegra210-emc.ko \
kmod-tegra30-devfreq.ko \
kmod-tehuti.ko \
kmod-teranetics.ko \
kmod-test-firmware.ko \
kmod-test-module.ko \
kmod-test-sysctl.ko \
kmod-tg3.ko \
kmod-thc63lvd1024.ko \
kmod-thermal-generic-adc.ko \
kmod-thermal-mmio.ko \
kmod-thermal.ko \
kmod-thmc50.ko \
kmod-thp7312.ko \
kmod-ths7303.ko \
kmod-ths8200.ko \
kmod-thunder-bgx.ko \
kmod-thunder-xcv.ko \
kmod-thunderbolt-net.ko \
kmod-thunderbolt-stream.ko \
kmod-thunderbolt.ko \
kmod-thunderx-edac.ko \
kmod-thunderx-mmc.ko \
kmod-thunderx2-pmu.ko \
kmod-ti-adc0832.ko \
kmod-ti-adc084s021.ko \
kmod-ti-adc108s102.ko \
kmod-ti-adc12138.ko \
kmod-ti-adc161s626.ko \
kmod-ti-ads1015.ko \
kmod-ti-ads1018.ko \
kmod-ti-ads124s08.ko \
kmod-ti-ads1298.ko \
kmod-ti-ads131e08.ko \
kmod-ti-ads131m02.ko \
kmod-ti-ads7138.ko \
kmod-ti-ads7950.ko \
kmod-ti-ads8344.ko \
kmod-ti-dac082s085.ko \
kmod-ti-dac5571.ko \
kmod-ti-dac7311.ko \
kmod-ti-dac7612.ko \
kmod-ti-dlpc3433.ko \
kmod-ti-fpc202.ko \
kmod-ti-lmu.ko \
kmod-ti-sn65dsi83.ko \
kmod-ti-sn65dsi86.ko \
kmod-ti-tfp410.ko \
kmod-ti-tlc4541.ko \
kmod-ti-tpd12s015.ko \
kmod-ti-tsc2046.ko \
kmod-ti-usb-3410-5052.ko \
kmod-tidss.ko \
kmod-tifm-7xx1.ko \
kmod-tifm-core.ko \
kmod-tifm-ms.ko \
kmod-tifm-sd.ko \
kmod-timer-nxp-stm.ko \
kmod-timeriomem-rng.ko \
kmod-tiny-power-button.ko \
kmod-tipc-diag.ko \
kmod-tipc.ko \
kmod-tlan.ko \
kmod-tls.ko \
kmod-tlv320aic23b.ko \
kmod-tlv493d.ko \
kmod-tm2-touchkey.ko \
kmod-tmio-mmc-core.ko \
kmod-tmp007.ko \
kmod-tmp102.ko \
kmod-tmp103.ko \
kmod-tmp108.ko \
kmod-tmp117.ko \
kmod-tmp401.ko \
kmod-tmp421.ko \
kmod-tmp464.ko \
kmod-tmp513.ko \
kmod-tn40xx.ko \
kmod-torture.ko \
kmod-toshsd.ko \
kmod-touchit213.ko \
kmod-touchright.ko \
kmod-touchwin.ko \
kmod-tpci200.ko \
kmod-tpl0102.ko \
kmod-tpm-atmel.ko \
kmod-tpm-crb-ffa.ko \
kmod-tpm-crb.ko \
kmod-tpm-ftpm-tee.ko \
kmod-tpm-i2c-atmel.ko \
kmod-tpm-i2c-infineon.ko \
kmod-tpm-i2c-nuvoton.ko \
kmod-tpm-infineon.ko \
kmod-tpm-st33zp24-i2c.ko \
kmod-tpm-st33zp24-spi.ko \
kmod-tpm-st33zp24.ko \
kmod-tpm-tis-core.ko \
kmod-tpm-tis-i2c-cr50.ko \
kmod-tpm-tis-i2c.ko \
kmod-tpm-tis-spi.ko \
kmod-tpm-tis-synquacer.ko \
kmod-tpm-tis.ko \
kmod-tpm-vtpm-proxy.ko \
kmod-tpm.ko \
kmod-tps23861.ko \
kmod-tps23881.ko \
kmod-tps25990.ko \
kmod-tps40422.ko \
kmod-tps53679.ko \
kmod-tps546d24.ko \
kmod-tps6286x-regulator.ko \
kmod-tps6287x-regulator.ko \
kmod-tps65010.ko \
kmod-tps6507x-ts.ko \
kmod-tps6507x.ko \
kmod-tps65132-regulator.ko \
kmod-tps65185.ko \
kmod-tps6594-core.ko \
kmod-tps6594-esm.ko \
kmod-tps6594-i2c.ko \
kmod-tps6594-pfsm.ko \
kmod-tps6594-pwrbutton.ko \
kmod-tps6594-regulator.ko \
kmod-tps6594-spi.ko \
kmod-tps6598x.ko \
kmod-tqmx86.ko \
kmod-trancevibrator.ko \
kmod-trusted.ko \
kmod-ts-bm.ko \
kmod-ts-fsm.ko \
kmod-ts-kmp.ko \
kmod-ts2020.ko \
kmod-tsa.ko \
kmod-tsc1641.ko \
kmod-tsc2004.ko \
kmod-tsc2007.ko \
kmod-tsc200x-core.ko \
kmod-tsc40.ko \
kmod-tsi721-mport.ko \
kmod-tsl2550.ko \
kmod-tsl2591.ko \
kmod-tsl2772.ko \
kmod-tsm-core.ko \
kmod-tsm-report.ko \
kmod-tsnep.ko \
kmod-tsys01.ko \
kmod-tsys02d.ko \
kmod-ttm.ko \
kmod-ttpci-eeprom.ko \
kmod-ttusb-dec.ko \
kmod-ttusbdecfe.ko \
kmod-ttusbir.ko \
kmod-ttynull.ko \
kmod-tua6100.ko \
kmod-tua9001.ko \
kmod-tulip.ko \
kmod-tun.ko \
kmod-tuner-simple.ko \
kmod-tuner-types.ko \
kmod-tuner.ko \
kmod-tunnel4.ko \
kmod-tunnel6.ko \
kmod-turbografx.ko \
kmod-turingcc-qcs404.ko \
kmod-turris-mox-rwtm.ko \
kmod-turris-signing-key.ko \
kmod-tusb1046.ko \
kmod-tvaudio.ko \
kmod-tveeprom.ko \
kmod-tvp514x.ko \
kmod-tvp5150.ko \
kmod-tvp7002.ko \
kmod-tw2804.ko \
kmod-tw5864.ko \
kmod-tw68.ko \
kmod-tw686x.ko \
kmod-tw9900.ko \
kmod-tw9903.ko \
kmod-tw9906.ko \
kmod-tw9910.ko \
kmod-twidjoy.ko \
kmod-twofish-common.ko \
kmod-twofish-generic.ko \
kmod-txgbe.ko \
kmod-txgbevf.ko \
kmod-typec-displayport.ko \
kmod-typec-nvidia.ko \
kmod-typec-thunderbolt.ko \
kmod-typec-ucsi.ko \
kmod-typec.ko \
kmod-typhoon.ko \
kmod-u-audio.ko \
kmod-u-boot-env.ko \
kmod-u-ether.ko \
kmod-u-serial.ko \
kmod-uPD60620.ko \
kmod-uacce.ko \
kmod-uas.ko \
kmod-ubi.ko \
kmod-ubifs.ko \
kmod-ublk-drv.ko \
kmod-ubwc-config.ko \
kmod-ucan.ko \
kmod-ucd9000.ko \
kmod-ucd9200.ko \
kmod-ucs1002-power.ko \
kmod-ucs2-string.ko \
kmod-ucsi-acpi.ko \
kmod-ucsi-ccg.ko \
kmod-ucsi-glink.ko \
kmod-ucsi-huawei-gaokun.ko \
kmod-ucsi-stm32g0.ko \
kmod-ucsi-yoga-c630.ko \
kmod-uda1342.ko \
kmod-udc-core.ko \
kmod-udc-xilinx.ko \
kmod-udf.ko \
kmod-udl.ko \
kmod-udp-diag.ko \
kmod-udp-tunnel.ko \
kmod-ueagle-atm.ko \
kmod-ufs-amd-versal2.ko \
kmod-ufs-exynos.ko \
kmod-ufs-hisi.ko \
kmod-ufs-mediatek.ko \
kmod-ufs-qcom.ko \
kmod-ufs-renesas.ko \
kmod-ufs-rockchip.ko \
kmod-ufs-sprd.ko \
kmod-ufs.ko \
kmod-ufshcd-core.ko \
kmod-ufshcd-dwc.ko \
kmod-ufshcd-pci.ko \
kmod-ufshcd-pltfrm.ko \
kmod-ug3105-battery.ko \
kmod-uhci-hcd.ko \
kmod-uhid.ko \
kmod-uinput.ko \
kmod-uio-aec.ko \
kmod-uio-cif.ko \
kmod-uio-dfl.ko \
kmod-uio-dmem-genirq.ko \
kmod-uio-hv-generic.ko \
kmod-uio-mf624.ko \
kmod-uio-netx.ko \
kmod-uio-pci-generic-sva.ko \
kmod-uio-pci-generic.ko \
kmod-uio-pdrv-genirq.ko \
kmod-uio-sercos3.ko \
kmod-uio.ko \
kmod-uleds.ko \
kmod-uli526x.ko \
kmod-ulpi.ko \
kmod-ultrasoc-smb.ko \
kmod-ums-alauda.ko \
kmod-ums-cypress.ko \
kmod-ums-datafab.ko \
kmod-ums-eneub6250.ko \
kmod-ums-freecom.ko \
kmod-ums-isd200.ko \
kmod-ums-jumpshot.ko \
kmod-ums-karma.ko \
kmod-ums-onetouch.ko \
kmod-ums-realtek.ko \
kmod-ums-sddr09.ko \
kmod-ums-sddr55.ko \
kmod-ums-usbat.ko \
kmod-ums512-clk.ko \
kmod-unix-diag.ko \
kmod-upd64031a.ko \
kmod-upd64083.ko \
kmod-upd78f0730.ko \
kmod-us5182d.ko \
kmod-usb-8dev.ko \
kmod-usb-common.ko \
kmod-usb-conn-gpio.ko \
kmod-usb-debug.ko \
kmod-usb-dmac.ko \
kmod-usb-f-acm.ko \
kmod-usb-f-ecm-subset.ko \
kmod-usb-f-ecm.ko \
kmod-usb-f-eem.ko \
kmod-usb-f-fs.ko \
kmod-usb-f-hid.ko \
kmod-usb-f-mass-storage.ko \
kmod-usb-f-midi.ko \
kmod-usb-f-midi2.ko \
kmod-usb-f-ncm.ko \
kmod-usb-f-obex.ko \
kmod-usb-f-phonet.ko \
kmod-usb-f-printer.ko \
kmod-usb-f-rndis.ko \
kmod-usb-f-serial.ko \
kmod-usb-f-ss-lb.ko \
kmod-usb-f-tcm.ko \
kmod-usb-f-uac1.ko \
kmod-usb-f-uac2.ko \
kmod-usb-f-uvc.ko \
kmod-usb-ljca.ko \
kmod-usb-otg-fsm.ko \
kmod-usb-serial-simple.ko \
kmod-usb-storage.ko \
kmod-usb-wwan.ko \
kmod-usb251xb.ko \
kmod-usb3503.ko \
kmod-usb4604.ko \
kmod-usb8xxx.ko \
kmod-usbatm.ko \
kmod-usbcore.ko \
kmod-usbdux.ko \
kmod-usbduxfast.ko \
kmod-usbduxsigma.ko \
kmod-usbhid.ko \
kmod-usbip-core.ko \
kmod-usbip-host.ko \
kmod-usbip-vudc.ko \
kmod-usblcd.ko \
kmod-usblp.ko \
kmod-usbmisc-imx.ko \
kmod-usbmon.ko \
kmod-usbnet.ko \
kmod-usbserial.ko \
kmod-usbsevseg.ko \
kmod-usbtmc.ko \
kmod-usbtouchscreen.ko \
kmod-usbtv.ko \
kmod-usdhi6rol0.ko \
kmod-userio.ko \
kmod-ushc.ko \
kmod-uss720.ko \
kmod-utf8data.ko \
kmod-uvc.ko \
kmod-uvcvideo.ko \
kmod-v3d.ko \
kmod-v4l2-async.ko \
kmod-v4l2-cci.ko \
kmod-v4l2-dv-timings.ko \
kmod-v4l2-fwnode.ko \
kmod-v4l2-h264.ko \
kmod-v4l2-isp.ko \
kmod-v4l2-jpeg.ko \
kmod-v4l2-mem2mem.ko \
kmod-v4l2-vp9.ko \
kmod-vboxguest.ko \
kmod-vboxsf.ko \
kmod-vc4.ko \
kmod-vcan.ko \
kmod-vchiq.ko \
kmod-vclk.ko \
kmod-vcnl3020.ko \
kmod-vcnl4035.ko \
kmod-vcpu-stall-detector.ko \
kmod-vctrl-regulator.ko \
kmod-vd55g1.ko \
kmod-vd56g3.ko \
kmod-vdpa-sim-blk.ko \
kmod-vdpa-sim-net.ko \
kmod-vdpa-sim.ko \
kmod-vdpa.ko \
kmod-vduse.ko \
kmod-veml3235.ko \
kmod-veml3328.ko \
kmod-veml6030.ko \
kmod-veml6046x00.ko \
kmod-venus-core.ko \
kmod-venus-dec.ko \
kmod-venus-enc.ko \
kmod-versal-edac.ko \
kmod-versal-fpga.ko \
kmod-versalnet-edac.ko \
kmod-ves1820.ko \
kmod-ves1x93.ko \
kmod-veth.ko \
kmod-vexpress-config.ko \
kmod-vexpress-hwmon.ko \
kmod-vexpress-regulator.ko \
kmod-vexpress-sysreg.ko \
kmod-vfat.ko \
kmod-vfio-amba.ko \
kmod-vfio-cdx.ko \
kmod-vfio-fsl-mc.ko \
kmod-vfio-iommu-type1.ko \
kmod-vfio-pci-core.ko \
kmod-vfio-pci.ko \
kmod-vfio-platform-base.ko \
kmod-vfio.ko \
kmod-vgxy61.ko \
kmod-vhci-hcd.ko \
kmod-vhost-iotlb.ko \
kmod-vhost-net.ko \
kmod-vhost-scsi.ko \
kmod-vhost-vdpa.ko \
kmod-vhost-vsock.ko \
kmod-vhost.ko \
kmod-via-rhine.ko \
kmod-via-sdmmc.ko \
kmod-via-velocity.ko \
kmod-via686a.ko \
kmod-vid-pll-div.ko \
kmod-video-i2c.ko \
kmod-video-mux.ko \
kmod-video.ko \
kmod-videobuf2-common.ko \
kmod-videobuf2-dma-contig.ko \
kmod-videobuf2-dma-sg.ko \
kmod-videobuf2-dvb.ko \
kmod-videobuf2-memops.ko \
kmod-videobuf2-v4l2.ko \
kmod-videobuf2-vmalloc.ko \
kmod-videocc-glymur.ko \
kmod-videocc-kaanapali.ko \
kmod-videocc-milos.ko \
kmod-videocc-qcs615.ko \
kmod-videocc-sa8775p.ko \
kmod-videocc-sc7180.ko \
kmod-videocc-sc7280.ko \
kmod-videocc-sdm845.ko \
kmod-videocc-sm6350.ko \
kmod-videocc-sm7150.ko \
kmod-videocc-sm8150.ko \
kmod-videocc-sm8250.ko \
kmod-videocc-sm8350.ko \
kmod-videocc-sm8450.ko \
kmod-videocc-sm8550.ko \
kmod-videocc-sm8750.ko \
kmod-videocc-x1p42100.ko \
kmod-videodev.ko \
kmod-viperboard.ko \
kmod-virt-dma.ko \
kmod-virt-wifi.ko \
kmod-virtio-balloon.ko \
kmod-virtio-blk.ko \
kmod-virtio-bt.ko \
kmod-virtio-can.ko \
kmod-virtio-console.ko \
kmod-virtio-crypto.ko \
kmod-virtio-dma-buf.ko \
kmod-virtio-gpu.ko \
kmod-virtio-input.ko \
kmod-virtio-iommu.ko \
kmod-virtio-mem.ko \
kmod-virtio-mmio.ko \
kmod-virtio-net.ko \
kmod-virtio-pci-legacy-dev.ko \
kmod-virtio-pci-modern-dev.ko \
kmod-virtio-pci.ko \
kmod-virtio-pmem.ko \
kmod-virtio-ring.ko \
kmod-virtio-rng.ko \
kmod-virtio-rpmsg-bus.ko \
kmod-virtio-rtc.ko \
kmod-virtio-scsi.ko \
kmod-virtio-snd.ko \
kmod-virtio-vdpa.ko \
kmod-virtio-vfio-pci.ko \
kmod-virtio.ko \
kmod-virtiofs.ko \
kmod-virtual-cpufreq.ko \
kmod-virtual-ncidev.ko \
kmod-visconti-wdt.ko \
kmod-visor.ko \
kmod-vitesse-vsc73xx-core.ko \
kmod-vitesse-vsc73xx-platform.ko \
kmod-vitesse-vsc73xx-spi.ko \
kmod-vitesse.ko \
kmod-vivaldi-fmap.ko \
kmod-vkms.ko \
kmod-vl53l0x-i2c.ko \
kmod-vl53l1x-i2c.ko \
kmod-vl6180.ko \
kmod-vmgenid.ko \
kmod-vmk80xx.ko \
kmod-vmw-vmci.ko \
kmod-vmw-vsock-virtio-transport-common.ko \
kmod-vmw-vsock-virtio-transport.ko \
kmod-vmw-vsock-vmci-transport.ko \
kmod-vmwgfx.ko \
kmod-vmxnet3.ko \
kmod-vp-vdpa.ko \
kmod-vp27smpx.ko \
kmod-vpd-sysfs.ko \
kmod-vport-geneve.ko \
kmod-vport-gre.ko \
kmod-vport-vxlan.ko \
kmod-vpx3220.ko \
kmod-vqmmc-ipq4019-regulator.ko \
kmod-vrf.ko \
kmod-vringh.ko \
kmod-vsi-iommu.ko \
kmod-vsock-diag.ko \
kmod-vsock-loopback.ko \
kmod-vsock.ko \
kmod-vsockmon.ko \
kmod-vsp1.ko \
kmod-vsxxxaa.ko \
kmod-vt1211.ko \
kmod-vt8231.ko \
kmod-vub300.ko \
kmod-vx855.ko \
kmod-vxcan.ko \
kmod-vxlan.ko \
kmod-vz89x.ko \
kmod-w1-ds2405.ko \
kmod-w1-ds2406.ko \
kmod-w1-ds2408.ko \
kmod-w1-ds2413.ko \
kmod-w1-ds2423.ko \
kmod-w1-ds2430.ko \
kmod-w1-ds2431.ko \
kmod-w1-ds2433.ko \
kmod-w1-ds2438.ko \
kmod-w1-ds250x.ko \
kmod-w1-ds2780.ko \
kmod-w1-ds2781.ko \
kmod-w1-ds2805.ko \
kmod-w1-ds28e04.ko \
kmod-w1-ds28e17.ko \
kmod-w1-gpio.ko \
kmod-w1-smem.ko \
kmod-w1-therm.ko \
kmod-w1-uart.ko \
kmod-w5100-spi.ko \
kmod-w5100.ko \
kmod-w83627ehf.ko \
kmod-w83627hf.ko \
kmod-w83773g.ko \
kmod-w83781d.ko \
kmod-w83791d.ko \
kmod-w83792d.ko \
kmod-w83793.ko \
kmod-w83795.ko \
kmod-w83l785ts.ko \
kmod-w83l786ng.ko \
kmod-wacom-i2c.ko \
kmod-wacom-serial4.ko \
kmod-wacom-w8001.ko \
kmod-wacom-w9000.ko \
kmod-wacom.ko \
kmod-walkera0701.ko \
kmod-wanxl.ko \
kmod-warrior.ko \
kmod-watchdog.ko \
kmod-waveshare-dsi.ko \
kmod-wcd934x.ko \
kmod-wcd939x-usbss.ko \
kmod-wcn36xx.ko \
kmod-wcnss-ctrl.ko \
kmod-wd719x.ko \
kmod-wdat-wdt.ko \
kmod-wdt-pci.ko \
kmod-wdt87xx-i2c.ko \
kmod-wfx.ko \
kmod-whiteheat.ko \
kmod-wil6210.ko \
kmod-winbond-840.ko \
kmod-wire.ko \
kmod-wireguard.ko \
kmod-wishbone-serial.ko \
kmod-wl1251-sdio.ko \
kmod-wl1251.ko \
kmod-wl12xx.ko \
kmod-wl18xx.ko \
kmod-wlcore-sdio.ko \
kmod-wlcore.ko \
kmod-wm8739.ko \
kmod-wm8775.ko \
kmod-wm8994-regulator.ko \
kmod-wm8994.ko \
kmod-wm97xx-ts.ko \
kmod-wp512.ko \
kmod-wpcm450-soc.ko \
kmod-wusb3801.ko \
kmod-wwan-hwsim.ko \
kmod-wwan.ko \
kmod-x-tables.ko \
kmod-x25.ko \
kmod-x509-key-parser.ko \
kmod-x9250.ko \
kmod-xbox-remote.ko \
kmod-xc2028.ko \
kmod-xc4000.ko \
kmod-xc5000.ko \
kmod-xcbc.ko \
kmod-xctr.ko \
kmod-xdma.ko \
kmod-xdp710.ko \
kmod-xdp720.ko \
kmod-xdpe12284.ko \
kmod-xdpe152c4.ko \
kmod-xdpe1a2g7b.ko \
kmod-xe-vfio-pci.ko \
kmod-xe.ko \
kmod-xfrm-algo.ko \
kmod-xfrm-interface.ko \
kmod-xfrm-ipcomp.ko \
kmod-xfrm-iptfs.ko \
kmod-xfrm-user.ko \
kmod-xfrm4-tunnel.ko \
kmod-xfrm6-tunnel.ko \
kmod-xfs.ko \
kmod-xgene-dma.ko \
kmod-xgene-edac.ko \
kmod-xgene-enet-v2.ko \
kmod-xgene-enet.ko \
kmod-xgene-hwmon.ko \
kmod-xgene-rng.ko \
kmod-xgmac-mdio.ko \
kmod-xhci-hcd.ko \
kmod-xhci-histb.ko \
kmod-xhci-mtk-hcd.ko \
kmod-xhci-pci-renesas.ko \
kmod-xhci-pci.ko \
kmod-xhci-plat-hcd.ko \
kmod-xhci-rcar-hcd.ko \
kmod-xhci-tegra.ko \
kmod-xilinx-ams.ko \
kmod-xilinx-can.ko \
kmod-xilinx-core.ko \
kmod-xilinx-csi2rxss.ko \
kmod-xilinx-dma.ko \
kmod-xilinx-dpdma.ko \
kmod-xilinx-emac.ko \
kmod-xilinx-emaclite.ko \
kmod-xilinx-gmii2rgmii.ko \
kmod-xilinx-pr-decoupler.ko \
kmod-xilinx-sdfec.ko \
kmod-xilinx-selectmap.ko \
kmod-xilinx-spi.ko \
kmod-xilinx-trng.ko \
kmod-xilinx-uartps.ko \
kmod-xilinx-video.ko \
kmod-xilinx-vtc.ko \
kmod-xilinx-wwdt.ko \
kmod-xilinx-xadc.ko \
kmod-xilinxfb.ko \
kmod-xillybus-class.ko \
kmod-xillybus-core.ko \
kmod-xillybus-of.ko \
kmod-xillybus-pcie.ko \
kmod-xillyusb.ko \
kmod-xiphera-trng.ko \
kmod-xlnx-vcu.ko \
kmod-xor.ko \
kmod-xpad.ko \
kmod-xr-serial.ko \
kmod-xrs700x-i2c.ko \
kmod-xrs700x-mdio.ko \
kmod-xrs700x.ko \
kmod-xsens-mt.ko \
kmod-xsk-diag.ko \
kmod-xt-AUDIT.ko \
kmod-xt-CHECKSUM.ko \
kmod-xt-CLASSIFY.ko \
kmod-xt-CONNSECMARK.ko \
kmod-xt-CT.ko \
kmod-xt-DSCP.ko \
kmod-xt-HL.ko \
kmod-xt-HMARK.ko \
kmod-xt-IDLETIMER.ko \
kmod-xt-LED.ko \
kmod-xt-LOG.ko \
kmod-xt-MASQUERADE.ko \
kmod-xt-NETMAP.ko \
kmod-xt-NFLOG.ko \
kmod-xt-NFQUEUE.ko \
kmod-xt-RATEEST.ko \
kmod-xt-REDIRECT.ko \
kmod-xt-SECMARK.ko \
kmod-xt-TCPMSS.ko \
kmod-xt-TCPOPTSTRIP.ko \
kmod-xt-TEE.ko \
kmod-xt-TPROXY.ko \
kmod-xt-TRACE.ko \
kmod-xt-addrtype.ko \
kmod-xt-bpf.ko \
kmod-xt-cgroup.ko \
kmod-xt-cluster.ko \
kmod-xt-comment.ko \
kmod-xt-connbytes.ko \
kmod-xt-connlabel.ko \
kmod-xt-connlimit.ko \
kmod-xt-connmark.ko \
kmod-xt-conntrack.ko \
kmod-xt-cpu.ko \
kmod-xt-dccp.ko \
kmod-xt-devgroup.ko \
kmod-xt-dscp.ko \
kmod-xt-ecn.ko \
kmod-xt-esp.ko \
kmod-xt-hashlimit.ko \
kmod-xt-helper.ko \
kmod-xt-hl.ko \
kmod-xt-ipcomp.ko \
kmod-xt-iprange.ko \
kmod-xt-ipvs.ko \
kmod-xt-l2tp.ko \
kmod-xt-length.ko \
kmod-xt-limit.ko \
kmod-xt-mac.ko \
kmod-xt-mark.ko \
kmod-xt-multiport.ko \
kmod-xt-nat.ko \
kmod-xt-nfacct.ko \
kmod-xt-osf.ko \
kmod-xt-owner.ko \
kmod-xt-physdev.ko \
kmod-xt-pkttype.ko \
kmod-xt-policy.ko \
kmod-xt-quota.ko \
kmod-xt-rateest.ko \
kmod-xt-realm.ko \
kmod-xt-recent.ko \
kmod-xt-sctp.ko \
kmod-xt-set.ko \
kmod-xt-socket.ko \
kmod-xt-state.ko \
kmod-xt-statistic.ko \
kmod-xt-string.ko \
kmod-xt-tcpmss.ko \
kmod-xt-tcpudp.ko \
kmod-xt-time.ko \
kmod-xt-u32.ko \
kmod-xtkbd.ko \
kmod-xts.ko \
kmod-xusbatm.ko \
kmod-xxhash-generic.ko \
kmod-xxhash.ko \
kmod-xz-dec.ko \
kmod-yamaha-yas530.ko \
kmod-yealink.ko \
kmod-yogafan.ko \
kmod-yt921x.ko \
kmod-yurex.ko \
kmod-zaurus.ko \
kmod-zd1211rw.ko \
kmod-zd1301-demod.ko \
kmod-zd1301.ko \
kmod-zet6223.ko \
kmod-zforce-ts.ko \
kmod-zhenhua.ko \
kmod-ziirave-wdt.ko \
kmod-zinitix.ko \
kmod-zl10036.ko \
kmod-zl10039.ko \
kmod-zl10353.ko \
kmod-zl3073x-i2c.ko \
kmod-zl3073x-spi.ko \
kmod-zl3073x.ko \
kmod-zl6100.ko \
kmod-zlib-deflate.ko \
kmod-zlib-inflate.ko \
kmod-zloop.ko \
kmod-zonefs.ko \
kmod-zopt2201.ko \
kmod-zpa2326-i2c.ko \
kmod-zpa2326-spi.ko \
kmod-zpa2326.ko \
kmod-zr36067.ko \
kmod-zram.ko \
kmod-zsmalloc.ko \
kmod-zstd-common.ko \
kmod-zstd-compress.ko \
kmod-zstd-decompress.ko \
kmod-zstd.ko \
kmod-zynqmp-aes-gcm.ko \
kmod-zynqmp-dma.ko \
kmod-zynqmp-dpsub.ko \
kmod-zynqmp-edac.ko \
kmod-zynqmp-fpga.ko \
kmod-zynqmp-ipi-mailbox.ko \
kmod-zynqmp-sha.ko \
ksym-vanilla-----mt76-poll-msec \
ksym-vanilla----migrate-enable \
ksym-vanilla----mt76u-rr \
ksym-vanilla----mt76u-wr \
ksym-vanilla----pskb-trim \
ksym-vanilla----ratelimit \
ksym-vanilla---SCK--tp-func-9p-fid-ref \
ksym-vanilla---SCK--tp-func-add-device-to-group \
ksym-vanilla---SCK--tp-func-arm-event \
ksym-vanilla---SCK--tp-func-ata-bmdma-setup \
ksym-vanilla---SCK--tp-func-ata-bmdma-start \
ksym-vanilla---SCK--tp-func-ata-bmdma-status \
ksym-vanilla---SCK--tp-func-ata-exec-command \
ksym-vanilla---SCK--tp-func-ata-tf-load \
ksym-vanilla---SCK--tp-func-attach-device-to-domain \
ksym-vanilla---SCK--tp-func-bcache-alloc-fail \
ksym-vanilla---SCK--tp-func-bcache-btree-cache-cannibalize \
ksym-vanilla---SCK--tp-func-bcache-btree-gc-coalesce \
ksym-vanilla---SCK--tp-func-bcache-btree-insert-key \
ksym-vanilla---SCK--tp-func-bcache-btree-node-alloc \
ksym-vanilla---SCK--tp-func-bcache-btree-node-alloc-fail \
ksym-vanilla---SCK--tp-func-bcache-btree-node-compact \
ksym-vanilla---SCK--tp-func-bcache-btree-node-free \
ksym-vanilla---SCK--tp-func-bcache-btree-node-split \
ksym-vanilla---SCK--tp-func-bcache-btree-read \
ksym-vanilla---SCK--tp-func-bcache-btree-set-root \
ksym-vanilla---SCK--tp-func-bcache-btree-write \
ksym-vanilla---SCK--tp-func-bcache-bypass-congested \
ksym-vanilla---SCK--tp-func-bcache-bypass-sequential \
ksym-vanilla---SCK--tp-func-bcache-cache-insert \
ksym-vanilla---SCK--tp-func-bcache-gc-copy \
ksym-vanilla---SCK--tp-func-bcache-gc-copy-collision \
ksym-vanilla---SCK--tp-func-bcache-gc-end \
ksym-vanilla---SCK--tp-func-bcache-gc-start \
ksym-vanilla---SCK--tp-func-bcache-invalidate \
ksym-vanilla---SCK--tp-func-bcache-journal-entry-full \
ksym-vanilla---SCK--tp-func-bcache-journal-full \
ksym-vanilla---SCK--tp-func-bcache-journal-replay-key \
ksym-vanilla---SCK--tp-func-bcache-journal-write \
ksym-vanilla---SCK--tp-func-bcache-read \
ksym-vanilla---SCK--tp-func-bcache-read-retry \
ksym-vanilla---SCK--tp-func-bcache-request-end \
ksym-vanilla---SCK--tp-func-bcache-request-start \
ksym-vanilla---SCK--tp-func-bcache-write \
ksym-vanilla---SCK--tp-func-bcache-writeback \
ksym-vanilla---SCK--tp-func-bcache-writeback-collision \
ksym-vanilla---SCK--tp-func-bl-ext-tree-prepare-commit \
ksym-vanilla---SCK--tp-func-bl-pr-key-reg \
ksym-vanilla---SCK--tp-func-bl-pr-key-reg-err \
ksym-vanilla---SCK--tp-func-bl-pr-key-unreg \
ksym-vanilla---SCK--tp-func-bl-pr-key-unreg-err \
ksym-vanilla---SCK--tp-func-block-bio-complete \
ksym-vanilla---SCK--tp-func-block-bio-remap \
ksym-vanilla---SCK--tp-func-block-rq-insert \
ksym-vanilla---SCK--tp-func-block-rq-remap \
ksym-vanilla---SCK--tp-func-block-split \
ksym-vanilla---SCK--tp-func-block-unplug \
ksym-vanilla---SCK--tp-func-br-fdb-add \
ksym-vanilla---SCK--tp-func-br-fdb-external-learn-add \
ksym-vanilla---SCK--tp-func-br-fdb-update \
ksym-vanilla---SCK--tp-func-br-mdb-full \
ksym-vanilla---SCK--tp-func-console \
ksym-vanilla---SCK--tp-func-contended-release \
ksym-vanilla---SCK--tp-func-contention-begin \
ksym-vanilla---SCK--tp-func-contention-end \
ksym-vanilla---SCK--tp-func-cpu-frequency \
ksym-vanilla---SCK--tp-func-cpu-idle \
ksym-vanilla---SCK--tp-func-dev-irq \
ksym-vanilla---SCK--tp-func-devlink-hwerr \
ksym-vanilla---SCK--tp-func-devlink-hwmsg \
ksym-vanilla---SCK--tp-func-devlink-trap-report \
ksym-vanilla---SCK--tp-func-dma-fence-emit \
ksym-vanilla---SCK--tp-func-dma-fence-enable-signal \
ksym-vanilla---SCK--tp-func-dma-fence-signaled \
ksym-vanilla---SCK--tp-func-error-report-end \
ksym-vanilla---SCK--tp-func-fdb-delete \
ksym-vanilla---SCK--tp-func-ff-layout-commit-error \
ksym-vanilla---SCK--tp-func-ff-layout-read-error \
ksym-vanilla---SCK--tp-func-ff-layout-write-error \
ksym-vanilla---SCK--tp-func-fib6-table-lookup \
ksym-vanilla---SCK--tp-func-fl-getdevinfo \
ksym-vanilla---SCK--tp-func-fscache-access \
ksym-vanilla---SCK--tp-func-fscache-access-cache \
ksym-vanilla---SCK--tp-func-fscache-access-volume \
ksym-vanilla---SCK--tp-func-gpu-mem-total \
ksym-vanilla---SCK--tp-func-io-page-fault \
ksym-vanilla---SCK--tp-func-ipi-send-cpu \
ksym-vanilla---SCK--tp-func-ipi-send-cpumask \
ksym-vanilla---SCK--tp-func-iscsi-dbg-conn \
ksym-vanilla---SCK--tp-func-iscsi-dbg-eh \
ksym-vanilla---SCK--tp-func-iscsi-dbg-session \
ksym-vanilla---SCK--tp-func-iscsi-dbg-sw-tcp \
ksym-vanilla---SCK--tp-func-iscsi-dbg-tcp \
ksym-vanilla---SCK--tp-func-isoc-inbound-multiple-completions \
ksym-vanilla---SCK--tp-func-isoc-inbound-single-completions \
ksym-vanilla---SCK--tp-func-isoc-outbound-completions \
ksym-vanilla---SCK--tp-func-kfree \
ksym-vanilla---SCK--tp-func-kfree-skb \
ksym-vanilla---SCK--tp-func-kmalloc \
ksym-vanilla---SCK--tp-func-kmem-cache-alloc \
ksym-vanilla---SCK--tp-func-kmem-cache-free \
ksym-vanilla---SCK--tp-func-lp-event \
ksym-vanilla---SCK--tp-func-mac-txdone \
ksym-vanilla---SCK--tp-func-map \
ksym-vanilla---SCK--tp-func-mc-event \
ksym-vanilla---SCK--tp-func-mlx5-fs-add-fg \
ksym-vanilla---SCK--tp-func-mlx5-fs-add-ft \
ksym-vanilla---SCK--tp-func-mlx5-fs-add-rule \
ksym-vanilla---SCK--tp-func-mlx5-fs-del-fg \
ksym-vanilla---SCK--tp-func-mlx5-fs-del-ft \
ksym-vanilla---SCK--tp-func-mlx5-fs-del-fte \
ksym-vanilla---SCK--tp-func-mlx5-fs-del-rule \
ksym-vanilla---SCK--tp-func-mlx5-fs-set-fte \
ksym-vanilla---SCK--tp-func-mlx5-fw \
ksym-vanilla---SCK--tp-func-mmap-lock-acquire-returned \
ksym-vanilla---SCK--tp-func-mmap-lock-released \
ksym-vanilla---SCK--tp-func-mmap-lock-start-locking \
ksym-vanilla---SCK--tp-func-module-get \
ksym-vanilla---SCK--tp-func-napi-poll \
ksym-vanilla---SCK--tp-func-neigh-cleanup-and-release \
ksym-vanilla---SCK--tp-func-neigh-event-send-dead \
ksym-vanilla---SCK--tp-func-neigh-event-send-done \
ksym-vanilla---SCK--tp-func-neigh-timer-handler \
ksym-vanilla---SCK--tp-func-neigh-update \
ksym-vanilla---SCK--tp-func-neigh-update-done \
ksym-vanilla---SCK--tp-func-netfs-sreq \
ksym-vanilla---SCK--tp-func-nfs-fsync-enter \
ksym-vanilla---SCK--tp-func-nfs-fsync-exit \
ksym-vanilla---SCK--tp-func-nfs-xdr-bad-filehandle \
ksym-vanilla---SCK--tp-func-nfs-xdr-status \
ksym-vanilla---SCK--tp-func-nfs4-pnfs-commit-ds \
ksym-vanilla---SCK--tp-func-nfs4-pnfs-read \
ksym-vanilla---SCK--tp-func-nfs4-pnfs-write \
ksym-vanilla---SCK--tp-func-non-standard-event \
ksym-vanilla---SCK--tp-func-nvme-sq \
ksym-vanilla---SCK--tp-func-otx2-msg-alloc \
ksym-vanilla---SCK--tp-func-otx2-msg-interrupt \
ksym-vanilla---SCK--tp-func-otx2-msg-process \
ksym-vanilla---SCK--tp-func-otx2-msg-status \
ksym-vanilla---SCK--tp-func-otx2-parse-dump \
ksym-vanilla---SCK--tp-func-pelt-cfs-tp \
ksym-vanilla---SCK--tp-func-pelt-dl-tp \
ksym-vanilla---SCK--tp-func-pelt-hw-tp \
ksym-vanilla---SCK--tp-func-pelt-irq-tp \
ksym-vanilla---SCK--tp-func-pelt-rt-tp \
ksym-vanilla---SCK--tp-func-pelt-se-tp \
ksym-vanilla---SCK--tp-func-pnfs-ds-connect \
ksym-vanilla---SCK--tp-func-pnfs-mds-fallback-pg-get-mirror-count \
ksym-vanilla---SCK--tp-func-pnfs-mds-fallback-pg-init-read \
ksym-vanilla---SCK--tp-func-pnfs-mds-fallback-pg-init-write \
ksym-vanilla---SCK--tp-func-pnfs-mds-fallback-read-done \
ksym-vanilla---SCK--tp-func-pnfs-mds-fallback-read-pagelist \
ksym-vanilla---SCK--tp-func-pnfs-mds-fallback-write-done \
ksym-vanilla---SCK--tp-func-pnfs-mds-fallback-write-pagelist \
ksym-vanilla---SCK--tp-func-remove-device-from-group \
ksym-vanilla---SCK--tp-func-rpm-idle \
ksym-vanilla---SCK--tp-func-rpm-resume \
ksym-vanilla---SCK--tp-func-rpm-return-int \
ksym-vanilla---SCK--tp-func-rpm-suspend \
ksym-vanilla---SCK--tp-func-sched-compute-energy-tp \
ksym-vanilla---SCK--tp-func-sched-cpu-capacity-tp \
ksym-vanilla---SCK--tp-func-sched-dl-replenish-tp \
ksym-vanilla---SCK--tp-func-sched-dl-server-start-tp \
ksym-vanilla---SCK--tp-func-sched-dl-server-stop-tp \
ksym-vanilla---SCK--tp-func-sched-dl-throttle-tp \
ksym-vanilla---SCK--tp-func-sched-dl-update-tp \
ksym-vanilla---SCK--tp-func-sched-entry-tp \
ksym-vanilla---SCK--tp-func-sched-exit-tp \
ksym-vanilla---SCK--tp-func-sched-overutilized-tp \
ksym-vanilla---SCK--tp-func-sched-set-need-resched-tp \
ksym-vanilla---SCK--tp-func-sched-set-state-tp \
ksym-vanilla---SCK--tp-func-sched-update-nr-running-tp \
ksym-vanilla---SCK--tp-func-sched-util-est-cfs-tp \
ksym-vanilla---SCK--tp-func-sched-util-est-se-tp \
ksym-vanilla---SCK--tp-func-sk-data-ready \
ksym-vanilla---SCK--tp-func-smc-rx-recvmsg \
ksym-vanilla---SCK--tp-func-smc-switch-to-fallback \
ksym-vanilla---SCK--tp-func-smc-tx-sendmsg \
ksym-vanilla---SCK--tp-func-smcr-link-down \
ksym-vanilla---SCK--tp-func-spi-transfer-start \
ksym-vanilla---SCK--tp-func-spi-transfer-stop \
ksym-vanilla---SCK--tp-func-suspend-resume \
ksym-vanilla---SCK--tp-func-tcp-bad-csum \
ksym-vanilla---SCK--tp-func-tcp-send-reset \
ksym-vanilla---SCK--tp-func-udp-fail-queue-rcv-skb \
ksym-vanilla---SCK--tp-func-unmap \
ksym-vanilla---SCK--tp-func-vb2-buf-done \
ksym-vanilla---SCK--tp-func-vb2-buf-queue \
ksym-vanilla---SCK--tp-func-vb2-dqbuf \
ksym-vanilla---SCK--tp-func-vb2-qbuf \
ksym-vanilla---SCK--tp-func-vb2-v4l2-buf-done \
ksym-vanilla---SCK--tp-func-vb2-v4l2-buf-queue \
ksym-vanilla---SCK--tp-func-vb2-v4l2-dqbuf \
ksym-vanilla---SCK--tp-func-vb2-v4l2-qbuf \
ksym-vanilla---SCK--tp-func-wbc-writepage \
ksym-vanilla---SCK--tp-func-xdp-bulk-tx \
ksym-vanilla---SCK--tp-func-xdp-exception \
ksym-vanilla---SCK--tp-func-xhci-dbg-init \
ksym-vanilla---SCK--tp-func-xhci-dbg-quirks \
ksym-vanilla---account-locked-vm \
ksym-vanilla---acpi-bus-register-driver \
ksym-vanilla---acpi-handle-debug \
ksym-vanilla---acpi-mdiobus-register \
ksym-vanilla---acpi-nfit-notify \
ksym-vanilla---acpi-node-get-property-reference \
ksym-vanilla---acpi-nvdimm-notify \
ksym-vanilla---acpi-video-get-backlight-type \
ksym-vanilla---adis-check-status \
ksym-vanilla---adis-enable-irq \
ksym-vanilla---adis-initial-startup \
ksym-vanilla---adis-read-reg \
ksym-vanilla---adis-reset \
ksym-vanilla---adis-update-bits-base \
ksym-vanilla---adis-write-reg \
ksym-vanilla---alloc-bucket-spinlocks \
ksym-vanilla---alloc-ei-netdev \
ksym-vanilla---alloc-frozen-pages-noprof \
ksym-vanilla---alloc-pages-noprof \
ksym-vanilla---alloc-skb \
ksym-vanilla---amba-driver-register \
ksym-vanilla---apei-exec-run \
ksym-vanilla---aperture-remove-legacy-vga-devices \
ksym-vanilla---apr-driver-register \
ksym-vanilla---arch-clear-user \
ksym-vanilla---arch-copy-from-user \
ksym-vanilla---arch-copy-to-user \
ksym-vanilla---arm-smccc-hvc \
ksym-vanilla---arm-smccc-smc \
ksym-vanilla---ashlti3 \
ksym-vanilla---ashrti3 \
ksym-vanilla---async-tx-find-channel \
ksym-vanilla---ata-ehi-push-desc \
ksym-vanilla---ath10k-ce-rx-num-free-bufs \
ksym-vanilla---ath10k-ce-send-revert \
ksym-vanilla---ath12k-warn \
ksym-vanilla---audit-inode-child \
ksym-vanilla---audit-log-nfcfg \
ksym-vanilla---auxiliary-device-add \
ksym-vanilla---auxiliary-driver-register \
ksym-vanilla---bcm-phy-modify-exp \
ksym-vanilla---bcm-phy-modify-rdb \
ksym-vanilla---bcm-phy-read-exp \
ksym-vanilla---bcm-phy-read-rdb \
ksym-vanilla---bcm-phy-write-exp \
ksym-vanilla---bcm-phy-write-rdb \
ksym-vanilla---bcma-driver-register \
ksym-vanilla---bforget \
ksym-vanilla---bh-read \
ksym-vanilla---bh-read-batch \
ksym-vanilla---bio-add-page \
ksym-vanilla---bio-advance \
ksym-vanilla---bio-integrity-action \
ksym-vanilla---bio-release-pages \
ksym-vanilla---bitmap-and \
ksym-vanilla---bitmap-andnot \
ksym-vanilla---bitmap-clear \
ksym-vanilla---bitmap-complement \
ksym-vanilla---bitmap-equal \
ksym-vanilla---bitmap-intersects \
ksym-vanilla---bitmap-or \
ksym-vanilla---bitmap-or-equal \
ksym-vanilla---bitmap-replace \
ksym-vanilla---bitmap-set \
ksym-vanilla---bitmap-shift-left \
ksym-vanilla---bitmap-shift-right \
ksym-vanilla---bitmap-subset \
ksym-vanilla---bitmap-weight \
ksym-vanilla---bitmap-weight-and \
ksym-vanilla---bitmap-weight-andnot \
ksym-vanilla---bitmap-weighted-or \
ksym-vanilla---bitmap-weighted-xor \
ksym-vanilla---bitmap-xor \
ksym-vanilla---blk-alloc-disk \
ksym-vanilla---blk-crypto-submit-bio \
ksym-vanilla---blk-mq-alloc-disk \
ksym-vanilla---blk-mq-debugfs-rq-show \
ksym-vanilla---blk-mq-end-request \
ksym-vanilla---blk-rq-map-sg \
ksym-vanilla---blk-trace-note-message \
ksym-vanilla---blkdev-issue-discard \
ksym-vanilla---blkdev-issue-zeroout \
ksym-vanilla---blkg-prfill-rwstat \
ksym-vanilla---blkg-prfill-u64 \
ksym-vanilla---block-write-begin \
ksym-vanilla---block-write-full-folio \
ksym-vanilla---blockdev-direct-IO \
ksym-vanilla---bpf-call-base \
ksym-vanilla---bread-gfp \
ksym-vanilla---breadahead \
ksym-vanilla---break-lease \
ksym-vanilla---brelse \
ksym-vanilla---cast5-decrypt \
ksym-vanilla---cast5-encrypt \
ksym-vanilla---cast6-decrypt \
ksym-vanilla---cast6-encrypt \
ksym-vanilla---cast6-setkey \
ksym-vanilla---cdx-driver-register \
ksym-vanilla---ceph-alloc-sparse-ext-map \
ksym-vanilla---ceph-auth-get-authorizer \
ksym-vanilla---ceph-open-session \
ksym-vanilla---cfg80211-alloc-event-skb \
ksym-vanilla---cfg80211-alloc-reply-skb \
ksym-vanilla---cfg80211-get-bss \
ksym-vanilla---cfg80211-radar-event \
ksym-vanilla---cfg80211-send-event-skb \
ksym-vanilla---cgroup-bpf-run-filter-sk \
ksym-vanilla---cgroup-bpf-run-filter-skb \
ksym-vanilla---cgroup-bpf-run-filter-sock-addr \
ksym-vanilla---cgroup-bpf-run-filter-sock-ops \
ksym-vanilla---check-object-size \
ksym-vanilla---check-sticky \
ksym-vanilla---clk-determine-rate \
ksym-vanilla---clk-get-hw \
ksym-vanilla---clk-get-name \
ksym-vanilla---clk-hw-register-divider \
ksym-vanilla---clk-hw-register-fixed-rate \
ksym-vanilla---clk-hw-register-gate \
ksym-vanilla---clk-hw-register-mux \
ksym-vanilla---clk-is-enabled \
ksym-vanilla---clk-mux-determine-rate \
ksym-vanilla---clk-mux-determine-rate-closest \
ksym-vanilla---clocksource-register-scale \
ksym-vanilla---closure-sync \
ksym-vanilla---closure-sync-timeout \
ksym-vanilla---closure-wake-up \
ksym-vanilla---clzdi2 \
ksym-vanilla---clzsi2 \
ksym-vanilla---comedi-check-request-region \
ksym-vanilla---compat-vma-mmap \
ksym-vanilla---cond-resched \
ksym-vanilla---cond-resched-lock \
ksym-vanilla---cond-resched-rwlock-read \
ksym-vanilla---cond-resched-rwlock-write \
ksym-vanilla---const-udelay \
ksym-vanilla---contpte-try-fold \
ksym-vanilla---contpte-try-unfold \
ksym-vanilla---cookie-v4-check \
ksym-vanilla---cookie-v4-init-sequence \
ksym-vanilla---cookie-v6-check \
ksym-vanilla---cookie-v6-init-sequence \
ksym-vanilla---copy-overflow \
ksym-vanilla---coreboot-driver-register \
ksym-vanilla---cpu-active-mask \
ksym-vanilla---cpu-dying-mask \
ksym-vanilla---cpu-enabled-mask \
ksym-vanilla---cpu-online-mask \
ksym-vanilla---cpu-possible-mask \
ksym-vanilla---cpu-present-mask \
ksym-vanilla---cpufreq-driver-target \
ksym-vanilla---cpuhp-remove-state \
ksym-vanilla---cpuhp-remove-state-cpuslocked \
ksym-vanilla---cpuhp-setup-state \
ksym-vanilla---cpuhp-setup-state-cpuslocked \
ksym-vanilla---cpuhp-state-add-instance \
ksym-vanilla---cpuhp-state-remove-instance \
ksym-vanilla---crypto-alloc-tfm \
ksym-vanilla---crypto-inst-setname \
ksym-vanilla---crypto-memneq \
ksym-vanilla---crypto-stdrng-get-bytes \
ksym-vanilla---crypto-xor \
ksym-vanilla---ct-user-enter \
ksym-vanilla---ct-user-exit \
ksym-vanilla---ctzdi2 \
ksym-vanilla---ctzsi2 \
ksym-vanilla---cxl-driver-register \
ksym-vanilla---d-drop \
ksym-vanilla---d-lookup-unhash-wake \
ksym-vanilla---dax-driver-register \
ksym-vanilla---dec-node-page-state \
ksym-vanilla---dec-zone-page-state \
ksym-vanilla---delay \
ksym-vanilla---destroy-inode \
ksym-vanilla---dev-direct-xmit \
ksym-vanilla---dev-forward-skb \
ksym-vanilla---dev-fwnode \
ksym-vanilla---dev-fwnode-const \
ksym-vanilla---dev-get-by-index \
ksym-vanilla---dev-get-by-name \
ksym-vanilla---dev-queue-xmit \
ksym-vanilla---dev-remove-pack \
ksym-vanilla---device-reset \
ksym-vanilla---device-set-driver-override \
ksym-vanilla---devm-add-action \
ksym-vanilla---devm-alloc-percpu \
ksym-vanilla---devm-auxiliary-device-create \
ksym-vanilla---devm-clk-hw-register-divider \
ksym-vanilla---devm-clk-hw-register-gate \
ksym-vanilla---devm-clk-hw-register-mux \
ksym-vanilla---devm-clocksource-register-scale \
ksym-vanilla---devm-cxl-add-memdev \
ksym-vanilla---devm-cxl-add-nvdimm-bridge \
ksym-vanilla---devm-drm-bridge-alloc \
ksym-vanilla---devm-drm-dev-alloc \
ksym-vanilla---devm-drm-panel-alloc \
ksym-vanilla---devm-fpga-mgr-register \
ksym-vanilla---devm-fpga-mgr-register-full \
ksym-vanilla---devm-framer-provider-of-register \
ksym-vanilla---devm-iio-backend-get-from-fwnode-lookup \
ksym-vanilla---devm-iio-device-register \
ksym-vanilla---devm-iio-trigger-alloc \
ksym-vanilla---devm-irq-alloc-descs \
ksym-vanilla---devm-mdiobus-register \
ksym-vanilla---devm-of-mdiobus-register \
ksym-vanilla---devm-of-phy-provider-register \
ksym-vanilla---devm-pci-epc-create \
ksym-vanilla---devm-pwmchip-add \
ksym-vanilla---devm-regmap-init \
ksym-vanilla---devm-regmap-init-i2c \
ksym-vanilla---devm-regmap-init-i3c \
ksym-vanilla---devm-regmap-init-mmio-clk \
ksym-vanilla---devm-regmap-init-sccb \
ksym-vanilla---devm-regmap-init-sdw \
ksym-vanilla---devm-regmap-init-sdw-mbq \
ksym-vanilla---devm-regmap-init-slimbus \
ksym-vanilla---devm-regmap-init-spi \
ksym-vanilla---devm-regmap-init-spmi-base \
ksym-vanilla---devm-regmap-init-spmi-ext \
ksym-vanilla---devm-regmap-init-sunxi-rsb \
ksym-vanilla---devm-regmap-init-w1 \
ksym-vanilla---devm-release-region \
ksym-vanilla---devm-request-region \
ksym-vanilla---devm-reset-control-bulk-get \
ksym-vanilla---devm-reset-control-get \
ksym-vanilla---devm-rtc-register-device \
ksym-vanilla---devm-spi-alloc-controller \
ksym-vanilla---devm-uio-register-device \
ksym-vanilla---devm-v4l2-sensor-clk-get \
ksym-vanilla---devres-alloc-node \
ksym-vanilla---dfl-driver-register \
ksym-vanilla---dfl-fpga-cdev-find-port-data \
ksym-vanilla---dma-fence-unwrap-merge \
ksym-vanilla---dma-need-sync \
ksym-vanilla---dma-request-channel \
ksym-vanilla---dma-sync-sg-for-cpu \
ksym-vanilla---dma-sync-sg-for-device \
ksym-vanilla---dma-sync-single-for-cpu \
ksym-vanilla---dma-sync-single-for-device \
ksym-vanilla---do-once-done \
ksym-vanilla---do-once-sleepable-done \
ksym-vanilla---do-once-sleepable-start \
ksym-vanilla---do-once-start \
ksym-vanilla---dp-aux-dp-driver-register \
ksym-vanilla---dpll-device-change-ntf \
ksym-vanilla---dpll-pin-change-ntf \
ksym-vanilla---dquot-alloc-space \
ksym-vanilla---dquot-free-space \
ksym-vanilla---dquot-transfer \
ksym-vanilla---drm-atomic-commit-free \
ksym-vanilla---drm-atomic-helper-bridge-duplicate-state \
ksym-vanilla---drm-atomic-helper-bridge-reset \
ksym-vanilla---drm-atomic-helper-connector-destroy-state \
ksym-vanilla---drm-atomic-helper-connector-duplicate-state \
ksym-vanilla---drm-atomic-helper-connector-hdmi-reset \
ksym-vanilla---drm-atomic-helper-connector-reset \
ksym-vanilla---drm-atomic-helper-connector-state-reset \
ksym-vanilla---drm-atomic-helper-crtc-destroy-state \
ksym-vanilla---drm-atomic-helper-crtc-duplicate-state \
ksym-vanilla---drm-atomic-helper-crtc-reset \
ksym-vanilla---drm-atomic-helper-crtc-state-reset \
ksym-vanilla---drm-atomic-helper-disable-plane \
ksym-vanilla---drm-atomic-helper-plane-destroy-state \
ksym-vanilla---drm-atomic-helper-plane-duplicate-state \
ksym-vanilla---drm-atomic-helper-plane-reset \
ksym-vanilla---drm-atomic-helper-plane-state-reset \
ksym-vanilla---drm-atomic-helper-private-obj-create-state \
ksym-vanilla---drm-atomic-helper-private-obj-duplicate-state \
ksym-vanilla---drm-atomic-helper-set-config \
ksym-vanilla---drm-crtc-commit-free \
ksym-vanilla---drm-debug \
ksym-vanilla---drm-dev-alloc \
ksym-vanilla---drm-dev-dbg \
ksym-vanilla---drm-err \
ksym-vanilla---drm-gem-destroy-shadow-plane-state \
ksym-vanilla---drm-gem-duplicate-shadow-plane-state \
ksym-vanilla---drm-gem-reset-shadow-plane \
ksym-vanilla---drm-gem-shmem-free-sgt-locked \
ksym-vanilla---drm-mm-interval-first \
ksym-vanilla---drm-printfn-coredump \
ksym-vanilla---drm-printfn-dbg \
ksym-vanilla---drm-printfn-err \
ksym-vanilla---drm-printfn-info \
ksym-vanilla---drm-printfn-line \
ksym-vanilla---drm-printfn-seq-file \
ksym-vanilla---drm-puts-coredump \
ksym-vanilla---drm-puts-seq-file \
ksym-vanilla---drm-universal-plane-alloc \
ksym-vanilla---drmm-add-action \
ksym-vanilla---drmm-add-action-or-reset \
ksym-vanilla---drmm-crtc-alloc-with-planes \
ksym-vanilla---drmm-encoder-alloc \
ksym-vanilla---drmm-mutex-release \
ksym-vanilla---drmm-simple-encoder-alloc \
ksym-vanilla---drmm-universal-plane-alloc \
ksym-vanilla---drmm-workqueue-release \
ksym-vanilla---dst-destroy-metrics-generic \
ksym-vanilla---dynamic-dev-dbg \
ksym-vanilla---dynamic-ibdev-dbg \
ksym-vanilla---dynamic-netdev-dbg \
ksym-vanilla---dynamic-pr-debug \
ksym-vanilla---ethtool-get-link-ksettings \
ksym-vanilla---f-setown \
ksym-vanilla---fat-fs-error \
ksym-vanilla---fcoe-get-lesb \
ksym-vanilla---fdma-dcb-add \
ksym-vanilla---fib-lookup \
ksym-vanilla---fib6-flush-trees \
ksym-vanilla---file-ref-put \
ksym-vanilla---filemap-get-folio-mpol \
ksym-vanilla---filemap-set-wb-err \
ksym-vanilla---find-get-block \
ksym-vanilla---find-get-block-nonatomic \
ksym-vanilla---find-nth-and-andnot-bit \
ksym-vanilla---find-nth-and-bit \
ksym-vanilla---find-nth-bit \
ksym-vanilla---fl6-sock-lookup \
ksym-vanilla---fl6-update-dst \
ksym-vanilla---flush-workqueue \
ksym-vanilla---folio-alloc-noprof \
ksym-vanilla---folio-batch-release \
ksym-vanilla---folio-cancel-dirty \
ksym-vanilla---folio-lock \
ksym-vanilla---folio-lock-killable \
ksym-vanilla---folio-put \
ksym-vanilla---folio-start-writeback \
ksym-vanilla---fortify-panic \
ksym-vanilla---fortify-report \
ksym-vanilla---fou-build-header \
ksym-vanilla---fpga-bridge-register \
ksym-vanilla---fpga-mgr-register \
ksym-vanilla---fpga-mgr-register-full \
ksym-vanilla---fpga-region-register \
ksym-vanilla---fpga-region-register-full \
ksym-vanilla---fput-sync \
ksym-vanilla---framer-provider-of-register \
ksym-vanilla---free-iova \
ksym-vanilla---free-pages \
ksym-vanilla---fs-parse \
ksym-vanilla---fscache-acquire-cookie \
ksym-vanilla---fscache-acquire-volume \
ksym-vanilla---fscache-begin-read-operation \
ksym-vanilla---fscache-begin-write-operation \
ksym-vanilla---fscache-clear-page-bits \
ksym-vanilla---fscache-invalidate \
ksym-vanilla---fscache-relinquish-cookie \
ksym-vanilla---fscache-relinquish-volume \
ksym-vanilla---fscache-resize-cookie \
ksym-vanilla---fscache-unuse-cookie \
ksym-vanilla---fscache-use-cookie \
ksym-vanilla---fscache-write-to-cache \
ksym-vanilla---fscrypt-encrypt-symlink \
ksym-vanilla---fscrypt-inode-uses-inline-crypto \
ksym-vanilla---fscrypt-prepare-link \
ksym-vanilla---fscrypt-prepare-lookup \
ksym-vanilla---fscrypt-prepare-readdir \
ksym-vanilla---fscrypt-prepare-rename \
ksym-vanilla---fscrypt-prepare-setattr \
ksym-vanilla---fsl-mc-driver-register \
ksym-vanilla---fsnotify-inode-delete \
ksym-vanilla---fsnotify-parent \
ksym-vanilla---fsverity-file-open \
ksym-vanilla---fsverity-get-info \
ksym-vanilla---ftrace-vbprintk \
ksym-vanilla---ftrace-vprintk \
ksym-vanilla---fw-iso-context-create \
ksym-vanilla---fw-send-request \
ksym-vanilla---fwnode-reset-control-get \
ksym-vanilla---generic-file-write-iter \
ksym-vanilla---genphy-config-aneg \
ksym-vanilla---genradix-free \
ksym-vanilla---genradix-iter-peek \
ksym-vanilla---genradix-iter-peek-prev \
ksym-vanilla---genradix-prealloc \
ksym-vanilla---genradix-ptr \
ksym-vanilla---genradix-ptr-alloc \
ksym-vanilla---get-hash-from-flowi6 \
ksym-vanilla---get-mtd-device \
ksym-vanilla---get-netmem \
ksym-vanilla---get-random-u32-below \
ksym-vanilla---gro-flush \
ksym-vanilla---gue-build-header \
ksym-vanilla---hci-cmd-send \
ksym-vanilla---hci-cmd-sync \
ksym-vanilla---hci-cmd-sync-ev \
ksym-vanilla---hci-cmd-sync-sk \
ksym-vanilla---hci-cmd-sync-status \
ksym-vanilla---hci-cmd-sync-status-sk \
ksym-vanilla---hda-codec-driver-register \
ksym-vanilla---hid-register-driver \
ksym-vanilla---hid-request \
ksym-vanilla---hmac-sha256-init \
ksym-vanilla---hmac-sha512-init \
ksym-vanilla---host1x-client-init \
ksym-vanilla---host1x-client-register \
ksym-vanilla---hrtimer-get-remaining \
ksym-vanilla---hsiphash-unaligned \
ksym-vanilla---hv-pkt-iter-next \
ksym-vanilla---hvc-resize \
ksym-vanilla---hw-addr-init \
ksym-vanilla---hw-addr-ref-sync-dev \
ksym-vanilla---hw-addr-ref-unsync-dev \
ksym-vanilla---hw-addr-sync \
ksym-vanilla---hw-addr-sync-dev \
ksym-vanilla---hw-addr-sync-multiple \
ksym-vanilla---hw-addr-unsync \
ksym-vanilla---hw-addr-unsync-dev \
ksym-vanilla---hw-protection-trigger \
ksym-vanilla---hwspin-lock-timeout \
ksym-vanilla---hwspin-trylock \
ksym-vanilla---hwspin-unlock \
ksym-vanilla---i2c-board-list \
ksym-vanilla---i2c-board-lock \
ksym-vanilla---i2c-first-dynamic-bus-num \
ksym-vanilla---i2c-smbus-xfer \
ksym-vanilla---i2c-transfer \
ksym-vanilla---ib-alloc-cq \
ksym-vanilla---ib-alloc-cq-any \
ksym-vanilla---ib-alloc-pd \
ksym-vanilla---ib-create-cq \
ksym-vanilla---icmp-send \
ksym-vanilla---ieee80211-create-tpt-led-trigger \
ksym-vanilla---ieee80211-get-assoc-led-name \
ksym-vanilla---ieee80211-get-radio-led-name \
ksym-vanilla---ieee80211-get-rx-led-name \
ksym-vanilla---ieee80211-get-tx-led-name \
ksym-vanilla---ieee80211-iterate-interfaces \
ksym-vanilla---ieee80211-iterate-stations \
ksym-vanilla---ieee80211-schedule-txq \
ksym-vanilla---iio-dev-mode-lock \
ksym-vanilla---iio-dev-mode-unlock \
ksym-vanilla---iio-device-register \
ksym-vanilla---iio-trigger-alloc \
ksym-vanilla---imx8m-clk-hw-composite \
ksym-vanilla---inc-node-page-state \
ksym-vanilla---inc-zone-page-state \
ksym-vanilla---inet-accept \
ksym-vanilla---inet-lookup-established \
ksym-vanilla---inet-lookup-listener \
ksym-vanilla---inet-stream-connect \
ksym-vanilla---inet6-lookup-established \
ksym-vanilla---init-rwsem \
ksym-vanilla---init-swait-queue-head \
ksym-vanilla---init-waitqueue-head \
ksym-vanilla---inode-add-bytes \
ksym-vanilla---inode-sub-bytes \
ksym-vanilla---insert-inode-hash \
ksym-vanilla---io-uring-cmd-do-in-task \
ksym-vanilla---io-uring-cmd-done \
ksym-vanilla---iomap-dio-rw \
ksym-vanilla---ioread32-copy \
ksym-vanilla---ioremap-prot \
ksym-vanilla---iowrite32-copy-full \
ksym-vanilla---iowrite64-copy-full \
ksym-vanilla---ip-dev-find \
ksym-vanilla---ip-mc-dec-group \
ksym-vanilla---ip-mc-inc-group \
ksym-vanilla---ip-options-compile \
ksym-vanilla---ip-queue-xmit \
ksym-vanilla---ip-select-ident \
ksym-vanilla---ip-tunnel-change-mtu \
ksym-vanilla---ip-tunnel-init \
ksym-vanilla---ip4-datagram-connect \
ksym-vanilla---ip6-datagram-connect \
ksym-vanilla---ip6-local-out \
ksym-vanilla---iptunnel-pull-header \
ksym-vanilla---ipv6-addr-type \
ksym-vanilla---ipv6-fixup-options \
ksym-vanilla---irq-alloc-descs \
ksym-vanilla---irq-alloc-domain-generic-chips \
ksym-vanilla---irq-apply-affinity-hint \
ksym-vanilla---irq-domain-alloc-fwnode \
ksym-vanilla---irq-domain-alloc-irqs \
ksym-vanilla---irq-regs \
ksym-vanilla---irq-resolve-mapping \
ksym-vanilla---irq-set-handler \
ksym-vanilla---iscsi-complete-pdu \
ksym-vanilla---iscsi-put-task \
ksym-vanilla---iscsit-check-dataout-hdr \
ksym-vanilla---iwl-crit \
ksym-vanilla---iwl-dbg \
ksym-vanilla---iwl-err \
ksym-vanilla---iwl-info \
ksym-vanilla---iwl-warn \
ksym-vanilla---kernel-write \
ksym-vanilla---kfence-pool \
ksym-vanilla---kfifo-alloc-node \
ksym-vanilla---kfifo-dma-in-finish-r \
ksym-vanilla---kfifo-dma-in-prepare \
ksym-vanilla---kfifo-dma-in-prepare-r \
ksym-vanilla---kfifo-dma-out-prepare \
ksym-vanilla---kfifo-dma-out-prepare-r \
ksym-vanilla---kfifo-free \
ksym-vanilla---kfifo-from-user \
ksym-vanilla---kfifo-from-user-r \
ksym-vanilla---kfifo-in \
ksym-vanilla---kfifo-in-r \
ksym-vanilla---kfifo-init \
ksym-vanilla---kfifo-len-r \
ksym-vanilla---kfifo-max-r \
ksym-vanilla---kfifo-out \
ksym-vanilla---kfifo-out-linear \
ksym-vanilla---kfifo-out-linear-r \
ksym-vanilla---kfifo-out-peek \
ksym-vanilla---kfifo-out-peek-r \
ksym-vanilla---kfifo-out-r \
ksym-vanilla---kfifo-skip-r \
ksym-vanilla---kfifo-to-user \
ksym-vanilla---kfifo-to-user-r \
ksym-vanilla---kfree-skb \
ksym-vanilla---kmalloc-cache-node-noprof \
ksym-vanilla---kmalloc-cache-noprof \
ksym-vanilla---kmalloc-large-node-noprof \
ksym-vanilla---kmalloc-large-noprof \
ksym-vanilla---kmalloc-node-noprof \
ksym-vanilla---kmalloc-node-track-caller-noprof \
ksym-vanilla---kmalloc-noprof \
ksym-vanilla---kmem-cache-create-args \
ksym-vanilla---kprobe-event-add-fields \
ksym-vanilla---kprobe-event-gen-cmd-start \
ksym-vanilla---kthread-init-worker \
ksym-vanilla---kvmalloc-node-noprof \
ksym-vanilla---lbs-cmd \
ksym-vanilla---lbtf-cmd \
ksym-vanilla---libeth-xdp-return-stash \
ksym-vanilla---libeth-xdp-set-features \
ksym-vanilla---libeth-xdpsq-get \
ksym-vanilla---libeth-xdpsq-lock \
ksym-vanilla---libeth-xdpsq-put \
ksym-vanilla---libeth-xdpsq-unlock \
ksym-vanilla---libeth-xsk-run-prog-slow \
ksym-vanilla---list-add-valid-or-report \
ksym-vanilla---list-del-entry-valid-or-report \
ksym-vanilla---list-lru-init \
ksym-vanilla---local-bh-enable-ip \
ksym-vanilla---lock-buffer \
ksym-vanilla---lock-sock-fast \
ksym-vanilla---lshrti3 \
ksym-vanilla---lwq-dequeue \
ksym-vanilla---mark-inode-dirty \
ksym-vanilla---max730x-probe \
ksym-vanilla---max730x-remove \
ksym-vanilla---mb-cache-entry-free \
ksym-vanilla---md-wakeup-thread \
ksym-vanilla---mdiobus-c45-read \
ksym-vanilla---mdiobus-c45-write \
ksym-vanilla---mdiobus-modify \
ksym-vanilla---mdiobus-modify-changed \
ksym-vanilla---mdiobus-read \
ksym-vanilla---mdiobus-register \
ksym-vanilla---mdiobus-write \
ksym-vanilla---media-device-register \
ksym-vanilla---media-device-usb-init \
ksym-vanilla---media-entity-next-link \
ksym-vanilla---media-entity-remove-links \
ksym-vanilla---media-entity-setup-link \
ksym-vanilla---media-pipeline-entity-iter-next \
ksym-vanilla---media-pipeline-pad-iter-next \
ksym-vanilla---media-pipeline-start \
ksym-vanilla---media-pipeline-stop \
ksym-vanilla---media-remove-intf-link \
ksym-vanilla---media-remove-intf-links \
ksym-vanilla---memcat-p \
ksym-vanilla---memcg-memory-event \
ksym-vanilla---memcpy \
ksym-vanilla---memmove \
ksym-vanilla---memset \
ksym-vanilla---mhi-driver-register \
ksym-vanilla---mhi-ep-driver-register \
ksym-vanilla---min-heap-del \
ksym-vanilla---min-heap-full \
ksym-vanilla---min-heap-init \
ksym-vanilla---min-heap-peek \
ksym-vanilla---min-heap-pop \
ksym-vanilla---min-heap-pop-push \
ksym-vanilla---min-heap-push \
ksym-vanilla---min-heap-sift-down \
ksym-vanilla---min-heap-sift-up \
ksym-vanilla---min-heapify-all \
ksym-vanilla---mlog-printk \
ksym-vanilla---mlx4-cmd \
ksym-vanilla---mlx4-register-mac \
ksym-vanilla---mlx4-replace-mac \
ksym-vanilla---mlx4-unregister-mac \
ksym-vanilla---mmap-lock-do-trace-acquire-returned \
ksym-vanilla---mmap-lock-do-trace-released \
ksym-vanilla---mmap-lock-do-trace-start-locking \
ksym-vanilla---mmc-claim-host \
ksym-vanilla---mmc-poll-for-busy \
ksym-vanilla---mmc-send-status \
ksym-vanilla---mmdrop \
ksym-vanilla---mmu-notifier-register \
ksym-vanilla---mnt-is-readonly \
ksym-vanilla---mod-node-page-state \
ksym-vanilla---mod-zone-page-state \
ksym-vanilla---module-get \
ksym-vanilla---module-put-and-kthread-exit \
ksym-vanilla---move-to-shrink-list \
ksym-vanilla---moxtet-register-driver \
ksym-vanilla---mpage-writepages \
ksym-vanilla---mpol-put \
ksym-vanilla---msecs-to-jiffies \
ksym-vanilla---msi-lock-descs \
ksym-vanilla---msi-unlock-descs \
ksym-vanilla---mt-destroy \
ksym-vanilla---mt-dup \
ksym-vanilla---mt76-connac-mcu-alloc-sta-req \
ksym-vanilla---mt76-mcu-msg-alloc \
ksym-vanilla---mt76-mcu-send-firmware \
ksym-vanilla---mt76-poll \
ksym-vanilla---mt76-set-tx-blocked \
ksym-vanilla---mt76-sta-remove \
ksym-vanilla---mt76-tx-complete-skb \
ksym-vanilla---mt76-worker-fn \
ksym-vanilla---mt7663-load-firmware \
ksym-vanilla---mt76u-init \
ksym-vanilla---mt76u-vendor-request \
ksym-vanilla---mt7921-start \
ksym-vanilla---mt7925-start \
ksym-vanilla---mt792xe-mcu-drv-pmctrl \
ksym-vanilla---mtd-next-device \
ksym-vanilla---mtk-tr-clr-bits \
ksym-vanilla---mtk-tr-modify \
ksym-vanilla---mtk-tr-set-bits \
ksym-vanilla---napi-alloc-frag-align \
ksym-vanilla---napi-schedule \
ksym-vanilla---napi-schedule-irqoff \
ksym-vanilla---nd-driver-register \
ksym-vanilla---ndelay \
ksym-vanilla---ndisc-fill-addr-option \
ksym-vanilla---neigh-create \
ksym-vanilla---neigh-event-send \
ksym-vanilla---neigh-for-each-release \
ksym-vanilla---neigh-set-probe-once \
ksym-vanilla---netdev-alloc-frag-align \
ksym-vanilla---netdev-alloc-skb \
ksym-vanilla---netdev-notify-peers \
ksym-vanilla---netif-napi-del-locked \
ksym-vanilla---netif-rx \
ksym-vanilla---netif-schedule \
ksym-vanilla---netif-set-mtu \
ksym-vanilla---netif-set-xps-queue \
ksym-vanilla---netlink-dump-start \
ksym-vanilla---netlink-kernel-create \
ksym-vanilla---netlink-ns-capable \
ksym-vanilla---netpoll-free \
ksym-vanilla---netpoll-setup \
ksym-vanilla---nf-conntrack-confirm \
ksym-vanilla---nf-conntrack-helper-find \
ksym-vanilla---nf-conntrack-helper-register \
ksym-vanilla---nf-ct-change-status \
ksym-vanilla---nf-ct-change-timeout \
ksym-vanilla---nf-ct-expect-find \
ksym-vanilla---nf-ct-refresh-acct \
ksym-vanilla---nf-ct-try-assign-helper \
ksym-vanilla---nf-ip6-route \
ksym-vanilla---nf-nat-mangle-tcp-packet \
ksym-vanilla---nfc-alloc-vendor-cmd-reply-skb \
ksym-vanilla---nla-parse \
ksym-vanilla---nla-put \
ksym-vanilla---nla-put-64bit \
ksym-vanilla---nla-put-nohdr \
ksym-vanilla---nla-reserve \
ksym-vanilla---nla-reserve-64bit \
ksym-vanilla---nla-reserve-nohdr \
ksym-vanilla---nla-validate \
ksym-vanilla---nlmsg-put \
ksym-vanilla---node-distance \
ksym-vanilla---ns-tree-remove \
ksym-vanilla---ntb-register-client \
ksym-vanilla---num-online-cpus \
ksym-vanilla---num-possible-cpus \
ksym-vanilla---nvdimm-create \
ksym-vanilla---nvme-check-ready \
ksym-vanilla---nvme-submit-sync-cmd \
ksym-vanilla---nvmem-layout-driver-register \
ksym-vanilla---ocelot-bulk-read-ix \
ksym-vanilla---ocelot-read-ix \
ksym-vanilla---ocelot-rmw-ix \
ksym-vanilla---ocelot-write-ix \
ksym-vanilla---of-get-address \
ksym-vanilla---of-mdiobus-register \
ksym-vanilla---of-parse-phandle-with-args \
ksym-vanilla---of-phy-provider-register \
ksym-vanilla---otx2-mbox-reset \
ksym-vanilla---ovs-vport-ops-register \
ksym-vanilla---page-frag-alloc-align \
ksym-vanilla---page-frag-cache-drain \
ksym-vanilla---page-table-check-pmd-clear \
ksym-vanilla---page-table-check-pmds-set \
ksym-vanilla---page-table-check-pte-clear \
ksym-vanilla---page-table-check-ptes-set \
ksym-vanilla---page-table-check-pud-clear \
ksym-vanilla---page-table-check-puds-set \
ksym-vanilla---par-io-config-pin \
ksym-vanilla---parport-register-driver \
ksym-vanilla---pci-epc-create \
ksym-vanilla---pci-epf-register-driver \
ksym-vanilla---pci-hp-initialize \
ksym-vanilla---pci-hp-register \
ksym-vanilla---pci-register-driver \
ksym-vanilla---pci-reset-function-locked \
ksym-vanilla---per-cpu-offset \
ksym-vanilla---percpu-counter-compare \
ksym-vanilla---percpu-counter-init-many \
ksym-vanilla---percpu-counter-sum \
ksym-vanilla---percpu-down-read \
ksym-vanilla---percpu-init-rwsem \
ksym-vanilla---percpu-up-read \
ksym-vanilla---phy-modify \
ksym-vanilla---phy-modify-mmd \
ksym-vanilla---phy-modify-mmd-changed \
ksym-vanilla---phy-package-read \
ksym-vanilla---phy-package-read-mmd \
ksym-vanilla---phy-package-write \
ksym-vanilla---phy-package-write-mmd \
ksym-vanilla---phy-read-mmd \
ksym-vanilla---phy-resume \
ksym-vanilla---phy-write-mmd \
ksym-vanilla---platform-create-bundle \
ksym-vanilla---platform-driver-probe \
ksym-vanilla---platform-driver-register \
ksym-vanilla---platform-register-drivers \
ksym-vanilla---pm-relax \
ksym-vanilla---pm-runtime-disable \
ksym-vanilla---pm-runtime-idle \
ksym-vanilla---pm-runtime-resume \
ksym-vanilla---pm-runtime-set-status \
ksym-vanilla---pm-runtime-suspend \
ksym-vanilla---pm-runtime-use-autosuspend \
ksym-vanilla---pm-stay-awake \
ksym-vanilla---posix-acl-chmod \
ksym-vanilla---posix-acl-create \
ksym-vanilla---post-watch-notification \
ksym-vanilla---printk-cpu-sync-put \
ksym-vanilla---printk-cpu-sync-try-get \
ksym-vanilla---printk-cpu-sync-wait \
ksym-vanilla---printk-ratelimit \
ksym-vanilla---ps2-command \
ksym-vanilla---pskb-copy-fclone \
ksym-vanilla---pskb-pull-tail \
ksym-vanilla---put-cred \
ksym-vanilla---put-mtd-device \
ksym-vanilla---put-net \
ksym-vanilla---put-netmem \
ksym-vanilla---put-task-struct \
ksym-vanilla---put-task-struct-rcu-cb \
ksym-vanilla---put-user-ns \
ksym-vanilla---pwmchip-add \
ksym-vanilla---quota-error \
ksym-vanilla---rb-erase-color \
ksym-vanilla---rb-insert-augmented \
ksym-vanilla---rcu-read-lock \
ksym-vanilla---rcu-read-unlock \
ksym-vanilla---rdma-block-iter-next \
ksym-vanilla---rdma-block-iter-start \
ksym-vanilla---rdma-create-kernel-id \
ksym-vanilla---read-overflow2-field \
ksym-vanilla---refrigerator \
ksym-vanilla---register-binfmt \
ksym-vanilla---register-blkdev \
ksym-vanilla---register-bpf-struct-ops \
ksym-vanilla---register-chrdev \
ksym-vanilla---register-mtd-parser \
ksym-vanilla---register-nls \
ksym-vanilla---register-rpmsg-driver \
ksym-vanilla---register-virtio-driver \
ksym-vanilla---regmap-init \
ksym-vanilla---regmap-init-i2c \
ksym-vanilla---regmap-init-i3c \
ksym-vanilla---regmap-init-mmio-clk \
ksym-vanilla---regmap-init-sccb \
ksym-vanilla---regmap-init-sdw \
ksym-vanilla---regmap-init-sdw-mbq \
ksym-vanilla---regmap-init-slimbus \
ksym-vanilla---regmap-init-spi \
ksym-vanilla---regmap-init-spmi-base \
ksym-vanilla---regmap-init-spmi-ext \
ksym-vanilla---regmap-init-w1 \
ksym-vanilla---release-region \
ksym-vanilla---remove-inode-hash \
ksym-vanilla---request-module \
ksym-vanilla---request-region \
ksym-vanilla---reset-control-bulk-get \
ksym-vanilla---reset-control-get \
ksym-vanilla---rhashtable-init-noprof \
ksym-vanilla---rhltable-init-noprof \
ksym-vanilla---rht-bucket-nested \
ksym-vanilla---ring-buffer-alloc \
ksym-vanilla---rio-local-read-config-16 \
ksym-vanilla---rio-local-read-config-32 \
ksym-vanilla---rio-local-read-config-8 \
ksym-vanilla---rio-local-write-config-16 \
ksym-vanilla---rio-local-write-config-32 \
ksym-vanilla---rio-local-write-config-8 \
ksym-vanilla---rmi-register-function-handler \
ksym-vanilla---root-device-register \
ksym-vanilla---round-jiffies-relative \
ksym-vanilla---round-jiffies-up-relative \
ksym-vanilla---rt-mutex-init \
ksym-vanilla---rtnl-register-many \
ksym-vanilla---rtnl-unregister-many \
ksym-vanilla---sbitmap-queue-get \
ksym-vanilla---scm-destroy \
ksym-vanilla---scm-send \
ksym-vanilla---screen-info-lfb-bits-per-pixel \
ksym-vanilla---scsi-add-device \
ksym-vanilla---scsi-device-lookup \
ksym-vanilla---scsi-device-lookup-by-target \
ksym-vanilla---scsi-format-command \
ksym-vanilla---scsi-iterate-devices \
ksym-vanilla---scsi-print-sense \
ksym-vanilla---scsi-register-driver \
ksym-vanilla---sdhci-add-host \
ksym-vanilla---sdhci-execute-tuning \
ksym-vanilla---sdhci-finish-data-common \
ksym-vanilla---sdhci-finish-mrq \
ksym-vanilla---sdhci-read-caps \
ksym-vanilla---sdhci-set-timeout \
ksym-vanilla---sdio-register-driver \
ksym-vanilla---sdw-register-driver \
ksym-vanilla---seq-open-private \
ksym-vanilla---seq-puts \
ksym-vanilla---serdev-device-driver-register \
ksym-vanilla---serio-register-driver \
ksym-vanilla---serio-register-port \
ksym-vanilla---serpent-decrypt \
ksym-vanilla---serpent-encrypt \
ksym-vanilla---serpent-setkey \
ksym-vanilla---sg-alloc-table \
ksym-vanilla---sg-free-table \
ksym-vanilla---sg-page-iter-dma-next \
ksym-vanilla---sg-page-iter-next \
ksym-vanilla---sg-page-iter-start \
ksym-vanilla---sha256-update \
ksym-vanilla---sha3-update \
ksym-vanilla---sha512-update \
ksym-vanilla---simple-rmdir \
ksym-vanilla---simple-unlink \
ksym-vanilla---siphash-unaligned \
ksym-vanilla---sk-backlog-rcv \
ksym-vanilla---sk-dst-check \
ksym-vanilla---sk-flush-backlog \
ksym-vanilla---sk-mem-reclaim \
ksym-vanilla---sk-mem-schedule \
ksym-vanilla---sk-queue-drop-skb \
ksym-vanilla---sk-receive-skb \
ksym-vanilla---skb-checksum-complete \
ksym-vanilla---skb-checksum-complete-head \
ksym-vanilla---skb-ext-del \
ksym-vanilla---skb-ext-put \
ksym-vanilla---skb-ext-set \
ksym-vanilla---skb-flow-dissect \
ksym-vanilla---skb-get-hash-net \
ksym-vanilla---skb-get-hash-symmetric-net \
ksym-vanilla---skb-gro-checksum-complete \
ksym-vanilla---skb-gso-segment \
ksym-vanilla---skb-pad \
ksym-vanilla---skb-recv-datagram \
ksym-vanilla---skb-recv-udp \
ksym-vanilla---skb-try-recv-datagram \
ksym-vanilla---skb-tstamp-tx \
ksym-vanilla---skb-vlan-pop \
ksym-vanilla---skb-wait-for-more-packets \
ksym-vanilla---skb-warn-lro-forwarding \
ksym-vanilla---skb-zcopy-downgrade-managed \
ksym-vanilla---slim-driver-register \
ksym-vanilla---snd-hda-add-vmaster \
ksym-vanilla---snd-hda-apply-fixup \
ksym-vanilla---snd-hda-codec-cleanup-stream \
ksym-vanilla---snd-pcm-lib-xfer \
ksym-vanilla---snd-seq-driver-register \
ksym-vanilla---snd-usbmidi-create \
ksym-vanilla---sock-cmsg-send \
ksym-vanilla---sock-create \
ksym-vanilla---sock-queue-rcv-skb \
ksym-vanilla---sock-recv-cmsgs \
ksym-vanilla---sock-recv-timestamp \
ksym-vanilla---sock-recv-wifi-status \
ksym-vanilla---sock-tx-timestamp \
ksym-vanilla---sock-wfree \
ksym-vanilla---spi-alloc-controller \
ksym-vanilla---spi-register-driver \
ksym-vanilla---splice-from-pipe \
ksym-vanilla---spmi-driver-register \
ksym-vanilla---srcu-check-read-flavor \
ksym-vanilla---srcu-read-lock \
ksym-vanilla---srcu-read-unlock \
ksym-vanilla---ssam-device-driver-register \
ksym-vanilla---ssam-notifier-unregister \
ksym-vanilla---ssam-register-clients \
ksym-vanilla---ssb-driver-register \
ksym-vanilla---stack-chk-fail \
ksym-vanilla---starget-for-each-device \
ksym-vanilla---static-key-deferred-flush \
ksym-vanilla---static-key-slow-dec-deferred \
ksym-vanilla---suspend-report-result \
ksym-vanilla---sw-hweight16 \
ksym-vanilla---sw-hweight32 \
ksym-vanilla---sw-hweight64 \
ksym-vanilla---sw-hweight8 \
ksym-vanilla---symbol-get \
ksym-vanilla---symbol-put \
ksym-vanilla---sync-dirty-buffer \
ksym-vanilla---sync-icache-dcache \
ksym-vanilla---synth-event-gen-cmd-start \
ksym-vanilla---sysfs-match-string \
ksym-vanilla---target-init-cmd \
ksym-vanilla---task-pid-nr-ns \
ksym-vanilla---tasklet-hi-schedule \
ksym-vanilla---tasklet-schedule \
ksym-vanilla---tb-ring-enqueue \
ksym-vanilla---tcf-em-tree-match \
ksym-vanilla---tcf-kfree-skb-list \
ksym-vanilla---tcp-send-ack \
ksym-vanilla---tee-client-driver-register \
ksym-vanilla---trace-array-puts \
ksym-vanilla---trace-bprintk \
ksym-vanilla---trace-bputs \
ksym-vanilla---trace-printk \
ksym-vanilla---trace-puts \
ksym-vanilla---trace-set-current-state \
ksym-vanilla---trace-set-need-resched \
ksym-vanilla---trace-trigger-soft-disabled \
ksym-vanilla---traceiter-9p-fid-ref \
ksym-vanilla---traceiter-add-device-to-group \
ksym-vanilla---traceiter-arm-event \
ksym-vanilla---traceiter-ata-bmdma-setup \
ksym-vanilla---traceiter-ata-bmdma-start \
ksym-vanilla---traceiter-ata-bmdma-status \
ksym-vanilla---traceiter-ata-exec-command \
ksym-vanilla---traceiter-ata-tf-load \
ksym-vanilla---traceiter-attach-device-to-domain \
ksym-vanilla---traceiter-bcache-alloc-fail \
ksym-vanilla---traceiter-bcache-btree-cache-cannibalize \
ksym-vanilla---traceiter-bcache-btree-gc-coalesce \
ksym-vanilla---traceiter-bcache-btree-insert-key \
ksym-vanilla---traceiter-bcache-btree-node-alloc \
ksym-vanilla---traceiter-bcache-btree-node-alloc-fail \
ksym-vanilla---traceiter-bcache-btree-node-compact \
ksym-vanilla---traceiter-bcache-btree-node-free \
ksym-vanilla---traceiter-bcache-btree-node-split \
ksym-vanilla---traceiter-bcache-btree-read \
ksym-vanilla---traceiter-bcache-btree-set-root \
ksym-vanilla---traceiter-bcache-btree-write \
ksym-vanilla---traceiter-bcache-bypass-congested \
ksym-vanilla---traceiter-bcache-bypass-sequential \
ksym-vanilla---traceiter-bcache-cache-insert \
ksym-vanilla---traceiter-bcache-gc-copy \
ksym-vanilla---traceiter-bcache-gc-copy-collision \
ksym-vanilla---traceiter-bcache-gc-end \
ksym-vanilla---traceiter-bcache-gc-start \
ksym-vanilla---traceiter-bcache-invalidate \
ksym-vanilla---traceiter-bcache-journal-entry-full \
ksym-vanilla---traceiter-bcache-journal-full \
ksym-vanilla---traceiter-bcache-journal-replay-key \
ksym-vanilla---traceiter-bcache-journal-write \
ksym-vanilla---traceiter-bcache-read \
ksym-vanilla---traceiter-bcache-read-retry \
ksym-vanilla---traceiter-bcache-request-end \
ksym-vanilla---traceiter-bcache-request-start \
ksym-vanilla---traceiter-bcache-write \
ksym-vanilla---traceiter-bcache-writeback \
ksym-vanilla---traceiter-bcache-writeback-collision \
ksym-vanilla---traceiter-bl-ext-tree-prepare-commit \
ksym-vanilla---traceiter-bl-pr-key-reg \
ksym-vanilla---traceiter-bl-pr-key-reg-err \
ksym-vanilla---traceiter-bl-pr-key-unreg \
ksym-vanilla---traceiter-bl-pr-key-unreg-err \
ksym-vanilla---traceiter-block-bio-complete \
ksym-vanilla---traceiter-block-bio-remap \
ksym-vanilla---traceiter-block-rq-insert \
ksym-vanilla---traceiter-block-rq-remap \
ksym-vanilla---traceiter-block-split \
ksym-vanilla---traceiter-block-unplug \
ksym-vanilla---traceiter-br-fdb-add \
ksym-vanilla---traceiter-br-fdb-external-learn-add \
ksym-vanilla---traceiter-br-fdb-update \
ksym-vanilla---traceiter-br-mdb-full \
ksym-vanilla---traceiter-console \
ksym-vanilla---traceiter-contended-release \
ksym-vanilla---traceiter-contention-begin \
ksym-vanilla---traceiter-contention-end \
ksym-vanilla---traceiter-cpu-frequency \
ksym-vanilla---traceiter-cpu-idle \
ksym-vanilla---traceiter-dev-irq \
ksym-vanilla---traceiter-devlink-hwerr \
ksym-vanilla---traceiter-devlink-hwmsg \
ksym-vanilla---traceiter-devlink-trap-report \
ksym-vanilla---traceiter-dma-fence-emit \
ksym-vanilla---traceiter-dma-fence-enable-signal \
ksym-vanilla---traceiter-dma-fence-signaled \
ksym-vanilla---traceiter-error-report-end \
ksym-vanilla---traceiter-fdb-delete \
ksym-vanilla---traceiter-ff-layout-commit-error \
ksym-vanilla---traceiter-ff-layout-read-error \
ksym-vanilla---traceiter-ff-layout-write-error \
ksym-vanilla---traceiter-fib6-table-lookup \
ksym-vanilla---traceiter-fl-getdevinfo \
ksym-vanilla---traceiter-fscache-access \
ksym-vanilla---traceiter-fscache-access-cache \
ksym-vanilla---traceiter-fscache-access-volume \
ksym-vanilla---traceiter-gpu-mem-total \
ksym-vanilla---traceiter-io-page-fault \
ksym-vanilla---traceiter-ipi-send-cpu \
ksym-vanilla---traceiter-ipi-send-cpumask \
ksym-vanilla---traceiter-iscsi-dbg-conn \
ksym-vanilla---traceiter-iscsi-dbg-eh \
ksym-vanilla---traceiter-iscsi-dbg-session \
ksym-vanilla---traceiter-iscsi-dbg-sw-tcp \
ksym-vanilla---traceiter-iscsi-dbg-tcp \
ksym-vanilla---traceiter-isoc-inbound-multiple-completions \
ksym-vanilla---traceiter-isoc-inbound-single-completions \
ksym-vanilla---traceiter-isoc-outbound-completions \
ksym-vanilla---traceiter-kfree \
ksym-vanilla---traceiter-kfree-skb \
ksym-vanilla---traceiter-kmalloc \
ksym-vanilla---traceiter-kmem-cache-alloc \
ksym-vanilla---traceiter-kmem-cache-free \
ksym-vanilla---traceiter-lp-event \
ksym-vanilla---traceiter-mac-txdone \
ksym-vanilla---traceiter-map \
ksym-vanilla---traceiter-mc-event \
ksym-vanilla---traceiter-mlx5-fs-add-fg \
ksym-vanilla---traceiter-mlx5-fs-add-ft \
ksym-vanilla---traceiter-mlx5-fs-add-rule \
ksym-vanilla---traceiter-mlx5-fs-del-fg \
ksym-vanilla---traceiter-mlx5-fs-del-ft \
ksym-vanilla---traceiter-mlx5-fs-del-fte \
ksym-vanilla---traceiter-mlx5-fs-del-rule \
ksym-vanilla---traceiter-mlx5-fs-set-fte \
ksym-vanilla---traceiter-mlx5-fw \
ksym-vanilla---traceiter-mmap-lock-acquire-returned \
ksym-vanilla---traceiter-mmap-lock-released \
ksym-vanilla---traceiter-mmap-lock-start-locking \
ksym-vanilla---traceiter-module-get \
ksym-vanilla---traceiter-napi-poll \
ksym-vanilla---traceiter-neigh-cleanup-and-release \
ksym-vanilla---traceiter-neigh-event-send-dead \
ksym-vanilla---traceiter-neigh-event-send-done \
ksym-vanilla---traceiter-neigh-timer-handler \
ksym-vanilla---traceiter-neigh-update \
ksym-vanilla---traceiter-neigh-update-done \
ksym-vanilla---traceiter-netfs-sreq \
ksym-vanilla---traceiter-nfs-fsync-enter \
ksym-vanilla---traceiter-nfs-fsync-exit \
ksym-vanilla---traceiter-nfs-xdr-bad-filehandle \
ksym-vanilla---traceiter-nfs-xdr-status \
ksym-vanilla---traceiter-nfs4-pnfs-commit-ds \
ksym-vanilla---traceiter-nfs4-pnfs-read \
ksym-vanilla---traceiter-nfs4-pnfs-write \
ksym-vanilla---traceiter-non-standard-event \
ksym-vanilla---traceiter-nvme-sq \
ksym-vanilla---traceiter-otx2-msg-alloc \
ksym-vanilla---traceiter-otx2-msg-interrupt \
ksym-vanilla---traceiter-otx2-msg-process \
ksym-vanilla---traceiter-otx2-msg-status \
ksym-vanilla---traceiter-otx2-parse-dump \
ksym-vanilla---traceiter-pelt-cfs-tp \
ksym-vanilla---traceiter-pelt-dl-tp \
ksym-vanilla---traceiter-pelt-hw-tp \
ksym-vanilla---traceiter-pelt-irq-tp \
ksym-vanilla---traceiter-pelt-rt-tp \
ksym-vanilla---traceiter-pelt-se-tp \
ksym-vanilla---traceiter-pnfs-ds-connect \
ksym-vanilla---traceiter-pnfs-mds-fallback-pg-get-mirror-count \
ksym-vanilla---traceiter-pnfs-mds-fallback-pg-init-read \
ksym-vanilla---traceiter-pnfs-mds-fallback-pg-init-write \
ksym-vanilla---traceiter-pnfs-mds-fallback-read-done \
ksym-vanilla---traceiter-pnfs-mds-fallback-read-pagelist \
ksym-vanilla---traceiter-pnfs-mds-fallback-write-done \
ksym-vanilla---traceiter-pnfs-mds-fallback-write-pagelist \
ksym-vanilla---traceiter-remove-device-from-group \
ksym-vanilla---traceiter-rpm-idle \
ksym-vanilla---traceiter-rpm-resume \
ksym-vanilla---traceiter-rpm-return-int \
ksym-vanilla---traceiter-rpm-suspend \
ksym-vanilla---traceiter-sched-compute-energy-tp \
ksym-vanilla---traceiter-sched-cpu-capacity-tp \
ksym-vanilla---traceiter-sched-dl-replenish-tp \
ksym-vanilla---traceiter-sched-dl-server-start-tp \
ksym-vanilla---traceiter-sched-dl-server-stop-tp \
ksym-vanilla---traceiter-sched-dl-throttle-tp \
ksym-vanilla---traceiter-sched-dl-update-tp \
ksym-vanilla---traceiter-sched-entry-tp \
ksym-vanilla---traceiter-sched-exit-tp \
ksym-vanilla---traceiter-sched-overutilized-tp \
ksym-vanilla---traceiter-sched-set-need-resched-tp \
ksym-vanilla---traceiter-sched-set-state-tp \
ksym-vanilla---traceiter-sched-update-nr-running-tp \
ksym-vanilla---traceiter-sched-util-est-cfs-tp \
ksym-vanilla---traceiter-sched-util-est-se-tp \
ksym-vanilla---traceiter-sk-data-ready \
ksym-vanilla---traceiter-smc-rx-recvmsg \
ksym-vanilla---traceiter-smc-switch-to-fallback \
ksym-vanilla---traceiter-smc-tx-sendmsg \
ksym-vanilla---traceiter-smcr-link-down \
ksym-vanilla---traceiter-spi-transfer-start \
ksym-vanilla---traceiter-spi-transfer-stop \
ksym-vanilla---traceiter-suspend-resume \
ksym-vanilla---traceiter-tcp-bad-csum \
ksym-vanilla---traceiter-tcp-send-reset \
ksym-vanilla---traceiter-udp-fail-queue-rcv-skb \
ksym-vanilla---traceiter-unmap \
ksym-vanilla---traceiter-vb2-buf-done \
ksym-vanilla---traceiter-vb2-buf-queue \
ksym-vanilla---traceiter-vb2-dqbuf \
ksym-vanilla---traceiter-vb2-qbuf \
ksym-vanilla---traceiter-vb2-v4l2-buf-done \
ksym-vanilla---traceiter-vb2-v4l2-buf-queue \
ksym-vanilla---traceiter-vb2-v4l2-dqbuf \
ksym-vanilla---traceiter-vb2-v4l2-qbuf \
ksym-vanilla---traceiter-wbc-writepage \
ksym-vanilla---traceiter-xdp-bulk-tx \
ksym-vanilla---traceiter-xdp-exception \
ksym-vanilla---traceiter-xhci-dbg-init \
ksym-vanilla---traceiter-xhci-dbg-quirks \
ksym-vanilla---tracepoint-9p-fid-ref \
ksym-vanilla---tracepoint-add-device-to-group \
ksym-vanilla---tracepoint-arm-event \
ksym-vanilla---tracepoint-ata-bmdma-setup \
ksym-vanilla---tracepoint-ata-bmdma-start \
ksym-vanilla---tracepoint-ata-bmdma-status \
ksym-vanilla---tracepoint-ata-exec-command \
ksym-vanilla---tracepoint-ata-tf-load \
ksym-vanilla---tracepoint-attach-device-to-domain \
ksym-vanilla---tracepoint-bcache-alloc-fail \
ksym-vanilla---tracepoint-bcache-btree-cache-cannibalize \
ksym-vanilla---tracepoint-bcache-btree-gc-coalesce \
ksym-vanilla---tracepoint-bcache-btree-insert-key \
ksym-vanilla---tracepoint-bcache-btree-node-alloc \
ksym-vanilla---tracepoint-bcache-btree-node-alloc-fail \
ksym-vanilla---tracepoint-bcache-btree-node-compact \
ksym-vanilla---tracepoint-bcache-btree-node-free \
ksym-vanilla---tracepoint-bcache-btree-node-split \
ksym-vanilla---tracepoint-bcache-btree-read \
ksym-vanilla---tracepoint-bcache-btree-set-root \
ksym-vanilla---tracepoint-bcache-btree-write \
ksym-vanilla---tracepoint-bcache-bypass-congested \
ksym-vanilla---tracepoint-bcache-bypass-sequential \
ksym-vanilla---tracepoint-bcache-cache-insert \
ksym-vanilla---tracepoint-bcache-gc-copy \
ksym-vanilla---tracepoint-bcache-gc-copy-collision \
ksym-vanilla---tracepoint-bcache-gc-end \
ksym-vanilla---tracepoint-bcache-gc-start \
ksym-vanilla---tracepoint-bcache-invalidate \
ksym-vanilla---tracepoint-bcache-journal-entry-full \
ksym-vanilla---tracepoint-bcache-journal-full \
ksym-vanilla---tracepoint-bcache-journal-replay-key \
ksym-vanilla---tracepoint-bcache-journal-write \
ksym-vanilla---tracepoint-bcache-read \
ksym-vanilla---tracepoint-bcache-read-retry \
ksym-vanilla---tracepoint-bcache-request-end \
ksym-vanilla---tracepoint-bcache-request-start \
ksym-vanilla---tracepoint-bcache-write \
ksym-vanilla---tracepoint-bcache-writeback \
ksym-vanilla---tracepoint-bcache-writeback-collision \
ksym-vanilla---tracepoint-bl-ext-tree-prepare-commit \
ksym-vanilla---tracepoint-bl-pr-key-reg \
ksym-vanilla---tracepoint-bl-pr-key-reg-err \
ksym-vanilla---tracepoint-bl-pr-key-unreg \
ksym-vanilla---tracepoint-bl-pr-key-unreg-err \
ksym-vanilla---tracepoint-block-bio-complete \
ksym-vanilla---tracepoint-block-bio-remap \
ksym-vanilla---tracepoint-block-rq-insert \
ksym-vanilla---tracepoint-block-rq-remap \
ksym-vanilla---tracepoint-block-split \
ksym-vanilla---tracepoint-block-unplug \
ksym-vanilla---tracepoint-br-fdb-add \
ksym-vanilla---tracepoint-br-fdb-external-learn-add \
ksym-vanilla---tracepoint-br-fdb-update \
ksym-vanilla---tracepoint-br-mdb-full \
ksym-vanilla---tracepoint-console \
ksym-vanilla---tracepoint-contended-release \
ksym-vanilla---tracepoint-contention-begin \
ksym-vanilla---tracepoint-contention-end \
ksym-vanilla---tracepoint-cpu-frequency \
ksym-vanilla---tracepoint-cpu-idle \
ksym-vanilla---tracepoint-dev-irq \
ksym-vanilla---tracepoint-devlink-hwerr \
ksym-vanilla---tracepoint-devlink-hwmsg \
ksym-vanilla---tracepoint-devlink-trap-report \
ksym-vanilla---tracepoint-dma-fence-emit \
ksym-vanilla---tracepoint-dma-fence-enable-signal \
ksym-vanilla---tracepoint-dma-fence-signaled \
ksym-vanilla---tracepoint-error-report-end \
ksym-vanilla---tracepoint-fdb-delete \
ksym-vanilla---tracepoint-ff-layout-commit-error \
ksym-vanilla---tracepoint-ff-layout-read-error \
ksym-vanilla---tracepoint-ff-layout-write-error \
ksym-vanilla---tracepoint-fib6-table-lookup \
ksym-vanilla---tracepoint-fl-getdevinfo \
ksym-vanilla---tracepoint-fscache-access \
ksym-vanilla---tracepoint-fscache-access-cache \
ksym-vanilla---tracepoint-fscache-access-volume \
ksym-vanilla---tracepoint-gpu-mem-total \
ksym-vanilla---tracepoint-io-page-fault \
ksym-vanilla---tracepoint-ipi-send-cpu \
ksym-vanilla---tracepoint-ipi-send-cpumask \
ksym-vanilla---tracepoint-iscsi-dbg-conn \
ksym-vanilla---tracepoint-iscsi-dbg-eh \
ksym-vanilla---tracepoint-iscsi-dbg-session \
ksym-vanilla---tracepoint-iscsi-dbg-sw-tcp \
ksym-vanilla---tracepoint-iscsi-dbg-tcp \
ksym-vanilla---tracepoint-isoc-inbound-multiple-completions \
ksym-vanilla---tracepoint-isoc-inbound-single-completions \
ksym-vanilla---tracepoint-isoc-outbound-completions \
ksym-vanilla---tracepoint-kfree \
ksym-vanilla---tracepoint-kfree-skb \
ksym-vanilla---tracepoint-kmalloc \
ksym-vanilla---tracepoint-kmem-cache-alloc \
ksym-vanilla---tracepoint-kmem-cache-free \
ksym-vanilla---tracepoint-lp-event \
ksym-vanilla---tracepoint-mac-txdone \
ksym-vanilla---tracepoint-map \
ksym-vanilla---tracepoint-mc-event \
ksym-vanilla---tracepoint-mlx5-fs-add-fg \
ksym-vanilla---tracepoint-mlx5-fs-add-ft \
ksym-vanilla---tracepoint-mlx5-fs-add-rule \
ksym-vanilla---tracepoint-mlx5-fs-del-fg \
ksym-vanilla---tracepoint-mlx5-fs-del-ft \
ksym-vanilla---tracepoint-mlx5-fs-del-fte \
ksym-vanilla---tracepoint-mlx5-fs-del-rule \
ksym-vanilla---tracepoint-mlx5-fs-set-fte \
ksym-vanilla---tracepoint-mlx5-fw \
ksym-vanilla---tracepoint-mmap-lock-acquire-returned \
ksym-vanilla---tracepoint-mmap-lock-released \
ksym-vanilla---tracepoint-mmap-lock-start-locking \
ksym-vanilla---tracepoint-module-get \
ksym-vanilla---tracepoint-napi-poll \
ksym-vanilla---tracepoint-neigh-cleanup-and-release \
ksym-vanilla---tracepoint-neigh-event-send-dead \
ksym-vanilla---tracepoint-neigh-event-send-done \
ksym-vanilla---tracepoint-neigh-timer-handler \
ksym-vanilla---tracepoint-neigh-update \
ksym-vanilla---tracepoint-neigh-update-done \
ksym-vanilla---tracepoint-netfs-sreq \
ksym-vanilla---tracepoint-nfs-fsync-enter \
ksym-vanilla---tracepoint-nfs-fsync-exit \
ksym-vanilla---tracepoint-nfs-xdr-bad-filehandle \
ksym-vanilla---tracepoint-nfs-xdr-status \
ksym-vanilla---tracepoint-nfs4-pnfs-commit-ds \
ksym-vanilla---tracepoint-nfs4-pnfs-read \
ksym-vanilla---tracepoint-nfs4-pnfs-write \
ksym-vanilla---tracepoint-non-standard-event \
ksym-vanilla---tracepoint-nvme-sq \
ksym-vanilla---tracepoint-otx2-msg-alloc \
ksym-vanilla---tracepoint-otx2-msg-interrupt \
ksym-vanilla---tracepoint-otx2-msg-process \
ksym-vanilla---tracepoint-otx2-msg-status \
ksym-vanilla---tracepoint-otx2-parse-dump \
ksym-vanilla---tracepoint-pelt-cfs-tp \
ksym-vanilla---tracepoint-pelt-dl-tp \
ksym-vanilla---tracepoint-pelt-hw-tp \
ksym-vanilla---tracepoint-pelt-irq-tp \
ksym-vanilla---tracepoint-pelt-rt-tp \
ksym-vanilla---tracepoint-pelt-se-tp \
ksym-vanilla---tracepoint-pnfs-ds-connect \
ksym-vanilla---tracepoint-pnfs-mds-fallback-pg-get-mirror-count \
ksym-vanilla---tracepoint-pnfs-mds-fallback-pg-init-read \
ksym-vanilla---tracepoint-pnfs-mds-fallback-pg-init-write \
ksym-vanilla---tracepoint-pnfs-mds-fallback-read-done \
ksym-vanilla---tracepoint-pnfs-mds-fallback-read-pagelist \
ksym-vanilla---tracepoint-pnfs-mds-fallback-write-done \
ksym-vanilla---tracepoint-pnfs-mds-fallback-write-pagelist \
ksym-vanilla---tracepoint-remove-device-from-group \
ksym-vanilla---tracepoint-rpm-idle \
ksym-vanilla---tracepoint-rpm-resume \
ksym-vanilla---tracepoint-rpm-return-int \
ksym-vanilla---tracepoint-rpm-suspend \
ksym-vanilla---tracepoint-sched-compute-energy-tp \
ksym-vanilla---tracepoint-sched-cpu-capacity-tp \
ksym-vanilla---tracepoint-sched-dl-replenish-tp \
ksym-vanilla---tracepoint-sched-dl-server-start-tp \
ksym-vanilla---tracepoint-sched-dl-server-stop-tp \
ksym-vanilla---tracepoint-sched-dl-throttle-tp \
ksym-vanilla---tracepoint-sched-dl-update-tp \
ksym-vanilla---tracepoint-sched-entry-tp \
ksym-vanilla---tracepoint-sched-exit-tp \
ksym-vanilla---tracepoint-sched-overutilized-tp \
ksym-vanilla---tracepoint-sched-set-need-resched-tp \
ksym-vanilla---tracepoint-sched-set-state-tp \
ksym-vanilla---tracepoint-sched-update-nr-running-tp \
ksym-vanilla---tracepoint-sched-util-est-cfs-tp \
ksym-vanilla---tracepoint-sched-util-est-se-tp \
ksym-vanilla---tracepoint-sk-data-ready \
ksym-vanilla---tracepoint-smc-rx-recvmsg \
ksym-vanilla---tracepoint-smc-switch-to-fallback \
ksym-vanilla---tracepoint-smc-tx-sendmsg \
ksym-vanilla---tracepoint-smcr-link-down \
ksym-vanilla---tracepoint-spi-transfer-start \
ksym-vanilla---tracepoint-spi-transfer-stop \
ksym-vanilla---tracepoint-suspend-resume \
ksym-vanilla---tracepoint-tcp-bad-csum \
ksym-vanilla---tracepoint-tcp-send-reset \
ksym-vanilla---tracepoint-udp-fail-queue-rcv-skb \
ksym-vanilla---tracepoint-unmap \
ksym-vanilla---tracepoint-vb2-buf-done \
ksym-vanilla---tracepoint-vb2-buf-queue \
ksym-vanilla---tracepoint-vb2-dqbuf \
ksym-vanilla---tracepoint-vb2-qbuf \
ksym-vanilla---tracepoint-vb2-v4l2-buf-done \
ksym-vanilla---tracepoint-vb2-v4l2-buf-queue \
ksym-vanilla---tracepoint-vb2-v4l2-dqbuf \
ksym-vanilla---tracepoint-vb2-v4l2-qbuf \
ksym-vanilla---tracepoint-wbc-writepage \
ksym-vanilla---tracepoint-xdp-bulk-tx \
ksym-vanilla---tracepoint-xdp-exception \
ksym-vanilla---tracepoint-xhci-dbg-init \
ksym-vanilla---tracepoint-xhci-dbg-quirks \
ksym-vanilla---transport-register-session \
ksym-vanilla---tty-alloc-driver \
ksym-vanilla---tty-insert-flip-string-flags \
ksym-vanilla---tty-port-tty-hangup \
ksym-vanilla---twofish-setkey \
ksym-vanilla---typec-altmode-register-driver \
ksym-vanilla---udelay \
ksym-vanilla---udp-disconnect \
ksym-vanilla---udp4-lib-lookup \
ksym-vanilla---udp6-lib-lookup \
ksym-vanilla---ufshcd-suspend-prepare \
ksym-vanilla---uio-register-device \
ksym-vanilla---ulpi-register-driver \
ksym-vanilla---unregister-chrdev \
ksym-vanilla---unregister-nexthop-notifier \
ksym-vanilla---uobj-get-destroy \
ksym-vanilla---uobj-perform-destroy \
ksym-vanilla---usb-create-hcd \
ksym-vanilla---usb-get-extra-descriptor \
ksym-vanilla---usb-serial-register-drivers \
ksym-vanilla---usecs-to-jiffies \
ksym-vanilla---uverbs-cleanup-ufile \
ksym-vanilla---v4l2-async-nf-add-fwnode \
ksym-vanilla---v4l2-async-nf-add-fwnode-remote \
ksym-vanilla---v4l2-async-nf-add-i2c \
ksym-vanilla---v4l2-async-register-subdev \
ksym-vanilla---v4l2-async-register-subdev-sensor \
ksym-vanilla---v4l2-ctrl-grab \
ksym-vanilla---v4l2-ctrl-handler-setup \
ksym-vanilla---v4l2-ctrl-modify-dimensions \
ksym-vanilla---v4l2-ctrl-modify-range \
ksym-vanilla---v4l2-ctrl-s-ctrl \
ksym-vanilla---v4l2-ctrl-s-ctrl-compound \
ksym-vanilla---v4l2-ctrl-s-ctrl-int64 \
ksym-vanilla---v4l2-ctrl-s-ctrl-string \
ksym-vanilla---v4l2-device-register-subdev \
ksym-vanilla---v4l2-device-register-subdev-nodes \
ksym-vanilla---v4l2-find-nearest-size-conditional \
ksym-vanilla---v4l2-subdev-get-frame-desc-passthrough \
ksym-vanilla---v4l2-subdev-init-finalize \
ksym-vanilla---v4l2-subdev-next-active-route \
ksym-vanilla---v4l2-subdev-state-alloc \
ksym-vanilla---v4l2-subdev-state-free \
ksym-vanilla---v4l2-subdev-state-get-compose \
ksym-vanilla---v4l2-subdev-state-get-crop \
ksym-vanilla---v4l2-subdev-state-get-format \
ksym-vanilla---v4l2-subdev-state-get-interval \
ksym-vanilla---var-waitqueue \
ksym-vanilla---vc-resize \
ksym-vanilla---vcalloc-noprof \
ksym-vanilla---vdpa-alloc-device \
ksym-vanilla---vdpa-register-driver \
ksym-vanilla---vfio-pci-memory-enabled \
ksym-vanilla---vfio-platform-register-reset \
ksym-vanilla---vfs-getxattr \
ksym-vanilla---vfs-removexattr \
ksym-vanilla---vfs-removexattr-locked \
ksym-vanilla---vfs-setxattr \
ksym-vanilla---vfs-setxattr-locked \
ksym-vanilla---video-device-pipeline-start \
ksym-vanilla---video-device-pipeline-stop \
ksym-vanilla---video-get-options \
ksym-vanilla---video-register-device \
ksym-vanilla---virtio-unbreak-device \
ksym-vanilla---virtqueue-break \
ksym-vanilla---virtqueue-unbreak \
ksym-vanilla---vlan-find-dev-deep-rcu \
ksym-vanilla---vlan-get-protocol-offset \
ksym-vanilla---vma-start-write \
ksym-vanilla---vmalloc-array-noprof \
ksym-vanilla---vmalloc-noprof \
ksym-vanilla---vmbus-driver-register \
ksym-vanilla---vmbus-request-addr-match \
ksym-vanilla---wait-on-bit \
ksym-vanilla---wait-on-bit-lock \
ksym-vanilla---wait-on-buffer \
ksym-vanilla---wait-rcu-gp \
ksym-vanilla---wake-up \
ksym-vanilla---wake-up-bit \
ksym-vanilla---wake-up-locked \
ksym-vanilla---wake-up-locked-key \
ksym-vanilla---wake-up-locked-sync-key \
ksym-vanilla---wake-up-sync \
ksym-vanilla---wake-up-sync-key \
ksym-vanilla---warn-flushing-systemwide-wq \
ksym-vanilla---warn-printk \
ksym-vanilla---write-overflow-field \
ksym-vanilla---xa-alloc \
ksym-vanilla---xa-alloc-cyclic \
ksym-vanilla---xa-clear-mark \
ksym-vanilla---xa-cmpxchg \
ksym-vanilla---xa-erase \
ksym-vanilla---xa-insert \
ksym-vanilla---xa-set-mark \
ksym-vanilla---xa-store \
ksym-vanilla---xas-next \
ksym-vanilla---xas-prev \
ksym-vanilla---xdp-build-skb-from-frame \
ksym-vanilla---xdp-rxq-info-reg \
ksym-vanilla---xdr-commit-encode \
ksym-vanilla---xfrm-decode-session \
ksym-vanilla---xfrm-dst-lookup \
ksym-vanilla---xfrm-init-state \
ksym-vanilla---xfrm-policy-check \
ksym-vanilla---xfrm-route-forward \
ksym-vanilla---xfrm-state-delete \
ksym-vanilla---xfrm-state-destroy \
ksym-vanilla---zero-page \
ksym-vanilla---zerocopy-sg-from-iter \
ksym-vanilla--atomic-dec-and-lock-irqsave \
ksym-vanilla--atomic-dec-and-raw-lock-irqsave \
ksym-vanilla--bcd2bin \
ksym-vanilla--bin2bcd \
ksym-vanilla--cache-coherency-ops-instance-alloc \
ksym-vanilla--copy-from-iter \
ksym-vanilla--copy-from-iter-flushcache \
ksym-vanilla--copy-from-iter-nocache \
ksym-vanilla--copy-from-pages \
ksym-vanilla--copy-to-iter \
ksym-vanilla--crypto-acomp-lock-stream-bh \
ksym-vanilla--ctype \
ksym-vanilla--dev-alert \
ksym-vanilla--dev-crit \
ksym-vanilla--dev-emerg \
ksym-vanilla--dev-err \
ksym-vanilla--dev-info \
ksym-vanilla--dev-notice \
ksym-vanilla--dev-printk \
ksym-vanilla--dev-warn \
ksym-vanilla--devm-cxl-dev-state-create \
ksym-vanilla--fc-frame-alloc \
ksym-vanilla--find-first-and-and-bit \
ksym-vanilla--find-first-and-bit \
ksym-vanilla--find-first-andnot-bit \
ksym-vanilla--find-first-bit \
ksym-vanilla--find-first-zero-bit \
ksym-vanilla--find-last-bit \
ksym-vanilla--find-next-and-bit \
ksym-vanilla--find-next-andnot-bit \
ksym-vanilla--find-next-bit \
ksym-vanilla--find-next-or-bit \
ksym-vanilla--find-next-zero-bit \
ksym-vanilla--fwctl-alloc-device \
ksym-vanilla--ib-alloc-device \
ksym-vanilla--ib-copy-validate-udata-cm-fail \
ksym-vanilla--ib-copy-validate-udata-in \
ksym-vanilla--ib-respond-udata \
ksym-vanilla--il-apm-stop \
ksym-vanilla--il-grab-nic-access \
ksym-vanilla--il-poll-bit \
ksym-vanilla--iwl-dbg-tlv-time-point \
ksym-vanilla--kmalloc-nolock-noprof \
ksym-vanilla--kstrtol \
ksym-vanilla--kstrtoul \
ksym-vanilla--local-bh-enable \
ksym-vanilla--mwifiex-dbg \
ksym-vanilla--nfs-display-fhandle \
ksym-vanilla--nfs-display-fhandle-hash \
ksym-vanilla--page-poisoning-enabled \
ksym-vanilla--page-poisoning-enabled-early \
ksym-vanilla--phy-start-aneg \
ksym-vanilla--printk \
ksym-vanilla--proc-mkdir \
ksym-vanilla--raw-read-lock \
ksym-vanilla--raw-read-lock-bh \
ksym-vanilla--raw-read-lock-irq \
ksym-vanilla--raw-read-lock-irqsave \
ksym-vanilla--raw-read-trylock \
ksym-vanilla--raw-read-unlock \
ksym-vanilla--raw-read-unlock-bh \
ksym-vanilla--raw-read-unlock-irq \
ksym-vanilla--raw-read-unlock-irqrestore \
ksym-vanilla--raw-spin-lock \
ksym-vanilla--raw-spin-lock-bh \
ksym-vanilla--raw-spin-lock-irq \
ksym-vanilla--raw-spin-lock-irqsave \
ksym-vanilla--raw-spin-trylock \
ksym-vanilla--raw-spin-trylock-bh \
ksym-vanilla--raw-spin-unlock \
ksym-vanilla--raw-spin-unlock-bh \
ksym-vanilla--raw-spin-unlock-irq \
ksym-vanilla--raw-spin-unlock-irqrestore \
ksym-vanilla--raw-write-lock \
ksym-vanilla--raw-write-lock-bh \
ksym-vanilla--raw-write-lock-irq \
ksym-vanilla--raw-write-lock-irqsave \
ksym-vanilla--raw-write-lock-nested \
ksym-vanilla--raw-write-trylock \
ksym-vanilla--raw-write-unlock \
ksym-vanilla--raw-write-unlock-bh \
ksym-vanilla--raw-write-unlock-irq \
ksym-vanilla--raw-write-unlock-irqrestore \
ksym-vanilla--rtl-dbg-print \
ksym-vanilla--rtl-dbg-print-data \
ksym-vanilla--rtl92c-phy-bb8192c-config-parafile \
ksym-vanilla--rtl92c-phy-dbm-to-txpwr-idx \
ksym-vanilla--rtl92c-phy-fw-rf-serial-read \
ksym-vanilla--rtl92c-phy-fw-rf-serial-write \
ksym-vanilla--rtl92c-phy-init-bb-rf-register-definition \
ksym-vanilla--rtl92c-phy-rf-serial-read \
ksym-vanilla--rtl92c-phy-rf-serial-write \
ksym-vanilla--rtl92c-phy-set-rf-sleep \
ksym-vanilla--rtl92c-phy-txpwr-idx-to-dbm \
ksym-vanilla--rtl92c-store-pwrindex-diffrate-offset \
ksym-vanilla--snd-ctl-add-follower \
ksym-vanilla--snd-hda-set-pin-ctl \
ksym-vanilla--snd-hdac-read-parm \
ksym-vanilla--snd-pcm-hw-param-setempty \
ksym-vanilla--snd-pcm-hw-params-any \
ksym-vanilla--snd-pcm-stream-lock-irqsave \
ksym-vanilla--snd-pcm-stream-lock-irqsave-nested \
ksym-vanilla--torture-create-kthread \
ksym-vanilla--torture-stop-kthread \
ksym-vanilla--totalram-pages \
ksym-vanilla--uverbs-alloc \
ksym-vanilla--uverbs-get-const-signed \
ksym-vanilla--uverbs-get-const-unsigned \
ksym-vanilla--vb2-fop-release \
ksym-vanilla--vdpa-register-device \
ksym-vanilla--vdpa-unregister-device \
ksym-vanilla--vfio-alloc-device \
ksym-vanilla-FSE-readNCount \
ksym-vanilla-HUF-readStats \
ksym-vanilla-HUF-readStats-wksp \
ksym-vanilla-I-BDEV \
ksym-vanilla-LZ4-compress-HC \
ksym-vanilla-LZ4-compress-HC-continue \
ksym-vanilla-LZ4-compress-default \
ksym-vanilla-LZ4-compress-destSize \
ksym-vanilla-LZ4-compress-fast \
ksym-vanilla-LZ4-compress-fast-continue \
ksym-vanilla-LZ4-decompress-fast \
ksym-vanilla-LZ4-decompress-fast-continue \
ksym-vanilla-LZ4-decompress-fast-usingDict \
ksym-vanilla-LZ4-decompress-safe \
ksym-vanilla-LZ4-decompress-safe-continue \
ksym-vanilla-LZ4-decompress-safe-partial \
ksym-vanilla-LZ4-decompress-safe-usingDict \
ksym-vanilla-LZ4-loadDict \
ksym-vanilla-LZ4-loadDictHC \
ksym-vanilla-LZ4-resetStreamHC \
ksym-vanilla-LZ4-saveDict \
ksym-vanilla-LZ4-saveDictHC \
ksym-vanilla-LZ4-setStreamDecode \
ksym-vanilla-NS8390-init \
ksym-vanilla-NlsUniUpperRange \
ksym-vanilla-NlsUniUpperTable \
ksym-vanilla-ZSTD-getErrorCode \
ksym-vanilla-ZSTD-getErrorName \
ksym-vanilla-ZSTD-isError \
ksym-vanilla-abort \
ksym-vanilla-abort-creds \
ksym-vanilla-abp2-common-probe \
ksym-vanilla-ac97-bus-type \
ksym-vanilla-accel-open \
ksym-vanilla-access-process-vm \
ksym-vanilla-account-locked-vm \
ksym-vanilla-ack-all-badblocks \
ksym-vanilla-acomp-request-clone \
ksym-vanilla-acomp-walk-done-dst \
ksym-vanilla-acomp-walk-done-src \
ksym-vanilla-acomp-walk-next-dst \
ksym-vanilla-acomp-walk-next-src \
ksym-vanilla-acomp-walk-virt \
ksym-vanilla-acp-bt-uart-enable \
ksym-vanilla-acpi-acquire-mutex \
ksym-vanilla-acpi-active-trip-temp \
ksym-vanilla-acpi-arch-thermal-cpufreq-pctg \
ksym-vanilla-acpi-attach-data \
ksym-vanilla-acpi-bind-one \
ksym-vanilla-acpi-bios-error \
ksym-vanilla-acpi-bios-exception \
ksym-vanilla-acpi-bios-warning \
ksym-vanilla-acpi-buffer-to-resource \
ksym-vanilla-acpi-bus-attach-private-data \
ksym-vanilla-acpi-bus-can-wakeup \
ksym-vanilla-acpi-bus-detach-private-data \
ksym-vanilla-acpi-bus-find-device-by-name \
ksym-vanilla-acpi-bus-for-each-dev \
ksym-vanilla-acpi-bus-generate-netlink-event \
ksym-vanilla-acpi-bus-get-ejd \
ksym-vanilla-acpi-bus-get-private-data \
ksym-vanilla-acpi-bus-get-status \
ksym-vanilla-acpi-bus-get-status-handle \
ksym-vanilla-acpi-bus-power-manageable \
ksym-vanilla-acpi-bus-private-data-handler \
ksym-vanilla-acpi-bus-register-early-device \
ksym-vanilla-acpi-bus-scan \
ksym-vanilla-acpi-bus-set-power \
ksym-vanilla-acpi-bus-trim \
ksym-vanilla-acpi-bus-unregister-driver \
ksym-vanilla-acpi-bus-update-power \
ksym-vanilla-acpi-call-prm-handler \
ksym-vanilla-acpi-check-address-range \
ksym-vanilla-acpi-check-dsm \
ksym-vanilla-acpi-check-region \
ksym-vanilla-acpi-check-resource-conflict \
ksym-vanilla-acpi-cpc-valid \
ksym-vanilla-acpi-cppc-processor-exit \
ksym-vanilla-acpi-cppc-processor-probe \
ksym-vanilla-acpi-cpu-get-madt-gicc \
ksym-vanilla-acpi-create-platform-device \
ksym-vanilla-acpi-critical-trip-temp \
ksym-vanilla-acpi-current-gpe-count \
ksym-vanilla-acpi-data-fwnode-ops \
ksym-vanilla-acpi-dbg-layer \
ksym-vanilla-acpi-dbg-level \
ksym-vanilla-acpi-debugfs-dir \
ksym-vanilla-acpi-decode-pld-buffer \
ksym-vanilla-acpi-detach-data \
ksym-vanilla-acpi-dev-add-driver-gpios \
ksym-vanilla-acpi-dev-clear-dependencies \
ksym-vanilla-acpi-dev-filter-resource-type \
ksym-vanilla-acpi-dev-for-each-child \
ksym-vanilla-acpi-dev-found \
ksym-vanilla-acpi-dev-free-resource-list \
ksym-vanilla-acpi-dev-get-dma-resources \
ksym-vanilla-acpi-dev-get-first-match-dev \
ksym-vanilla-acpi-dev-get-irq-type \
ksym-vanilla-acpi-dev-get-memory-resources \
ksym-vanilla-acpi-dev-get-next-consumer-dev \
ksym-vanilla-acpi-dev-get-next-match-dev \
ksym-vanilla-acpi-dev-get-property \
ksym-vanilla-acpi-dev-get-resources \
ksym-vanilla-acpi-dev-gpio-irq-wake-get-by \
ksym-vanilla-acpi-dev-install-notify-handler \
ksym-vanilla-acpi-dev-irq-flags \
ksym-vanilla-acpi-dev-pm-attach \
ksym-vanilla-acpi-dev-present \
ksym-vanilla-acpi-dev-ready-for-enumeration \
ksym-vanilla-acpi-dev-remove-driver-gpios \
ksym-vanilla-acpi-dev-remove-notify-handler \
ksym-vanilla-acpi-dev-resource-address-space \
ksym-vanilla-acpi-dev-resource-ext-address-space \
ksym-vanilla-acpi-dev-resource-interrupt \
ksym-vanilla-acpi-dev-resource-io \
ksym-vanilla-acpi-dev-resource-memory \
ksym-vanilla-acpi-dev-resume \
ksym-vanilla-acpi-dev-state-d0 \
ksym-vanilla-acpi-dev-suspend \
ksym-vanilla-acpi-dev-uid-to-integer \
ksym-vanilla-acpi-device-dep \
ksym-vanilla-acpi-device-fix-up-power \
ksym-vanilla-acpi-device-fix-up-power-children \
ksym-vanilla-acpi-device-fix-up-power-extended \
ksym-vanilla-acpi-device-fwnode-ops \
ksym-vanilla-acpi-device-get-match-data \
ksym-vanilla-acpi-device-hid \
ksym-vanilla-acpi-device-modalias \
ksym-vanilla-acpi-device-set-power \
ksym-vanilla-acpi-device-uevent-modalias \
ksym-vanilla-acpi-device-update-power \
ksym-vanilla-acpi-disabled \
ksym-vanilla-acpi-dma-configure-id \
ksym-vanilla-acpi-dma-controller-free \
ksym-vanilla-acpi-dma-controller-register \
ksym-vanilla-acpi-dma-request-slave-chan-by-index \
ksym-vanilla-acpi-dma-request-slave-chan-by-name \
ksym-vanilla-acpi-dma-simple-xlate \
ksym-vanilla-acpi-driver-match-device \
ksym-vanilla-acpi-ec-add-query-handler \
ksym-vanilla-acpi-ec-mark-gpe-for-wake \
ksym-vanilla-acpi-ec-remove-query-handler \
ksym-vanilla-acpi-enter-sleep-state \
ksym-vanilla-acpi-enter-sleep-state-prep \
ksym-vanilla-acpi-error \
ksym-vanilla-acpi-evaluate-dsm \
ksym-vanilla-acpi-evaluate-integer \
ksym-vanilla-acpi-evaluate-object \
ksym-vanilla-acpi-evaluate-object-typed \
ksym-vanilla-acpi-evaluate-ost \
ksym-vanilla-acpi-evaluate-reference \
ksym-vanilla-acpi-evaluate-reg \
ksym-vanilla-acpi-evaluation-failure-warn \
ksym-vanilla-acpi-exception \
ksym-vanilla-acpi-execute-reg-methods \
ksym-vanilla-acpi-execute-simple-method \
ksym-vanilla-acpi-extract-package \
ksym-vanilla-acpi-fetch-acpi-dev \
ksym-vanilla-acpi-find-child-by-adr \
ksym-vanilla-acpi-find-child-device \
ksym-vanilla-acpi-format-exception \
ksym-vanilla-acpi-gbl-FADT \
ksym-vanilla-acpi-get-acpi-dev \
ksym-vanilla-acpi-get-cpu-uid \
ksym-vanilla-acpi-get-cpuid \
ksym-vanilla-acpi-get-current-resources \
ksym-vanilla-acpi-get-data \
ksym-vanilla-acpi-get-data-full \
ksym-vanilla-acpi-get-devices \
ksym-vanilla-acpi-get-event-resources \
ksym-vanilla-acpi-get-first-physical-node \
ksym-vanilla-acpi-get-genport-coordinates \
ksym-vanilla-acpi-get-gsi-dispatcher \
ksym-vanilla-acpi-get-handle \
ksym-vanilla-acpi-get-hp-hw-control-from-firmware \
ksym-vanilla-acpi-get-irq-routing-table \
ksym-vanilla-acpi-get-local-address \
ksym-vanilla-acpi-get-local-u64-address \
ksym-vanilla-acpi-get-name \
ksym-vanilla-acpi-get-next-object \
ksym-vanilla-acpi-get-node \
ksym-vanilla-acpi-get-object-info \
ksym-vanilla-acpi-get-parent \
ksym-vanilla-acpi-get-pci-dev \
ksym-vanilla-acpi-get-phys-id \
ksym-vanilla-acpi-get-physical-device-location \
ksym-vanilla-acpi-get-possible-resources \
ksym-vanilla-acpi-get-psd-map \
ksym-vanilla-acpi-get-sleep-type-data \
ksym-vanilla-acpi-get-subsystem-id \
ksym-vanilla-acpi-get-table \
ksym-vanilla-acpi-get-table-by-index \
ksym-vanilla-acpi-get-table-header \
ksym-vanilla-acpi-get-type \
ksym-vanilla-acpi-get-vendor-resource \
ksym-vanilla-acpi-gpe-count \
ksym-vanilla-acpi-gpio-get-io-resource \
ksym-vanilla-acpi-gpio-get-irq-resource \
ksym-vanilla-acpi-gpiochip-free-interrupts \
ksym-vanilla-acpi-gpiochip-request-interrupts \
ksym-vanilla-acpi-gsi-to-irq \
ksym-vanilla-acpi-handle-list-equal \
ksym-vanilla-acpi-handle-list-free \
ksym-vanilla-acpi-handle-list-replace \
ksym-vanilla-acpi-handle-printk \
ksym-vanilla-acpi-has-method \
ksym-vanilla-acpi-has-watchdog \
ksym-vanilla-acpi-hot-trip-temp \
ksym-vanilla-acpi-info \
ksym-vanilla-acpi-initialize-hp-context \
ksym-vanilla-acpi-install-address-space-handler \
ksym-vanilla-acpi-install-address-space-handler-no-reg \
ksym-vanilla-acpi-install-interface \
ksym-vanilla-acpi-install-interface-handler \
ksym-vanilla-acpi-install-method \
ksym-vanilla-acpi-install-notify-handler \
ksym-vanilla-acpi-install-table-handler \
ksym-vanilla-acpi-irq-create-hierarchy \
ksym-vanilla-acpi-irq-get \
ksym-vanilla-acpi-is-pnp-device \
ksym-vanilla-acpi-is-root-bridge \
ksym-vanilla-acpi-is-video-device \
ksym-vanilla-acpi-kobj \
ksym-vanilla-acpi-leave-sleep-state \
ksym-vanilla-acpi-leave-sleep-state-prep \
ksym-vanilla-acpi-lid-open \
ksym-vanilla-acpi-load-table \
ksym-vanilla-acpi-lpat-free-conversion-table \
ksym-vanilla-acpi-lpat-get-conversion-table \
ksym-vanilla-acpi-lpat-raw-to-temp \
ksym-vanilla-acpi-lpat-temp-to-raw \
ksym-vanilla-acpi-map-cpu \
ksym-vanilla-acpi-map-pxm-to-node \
ksym-vanilla-acpi-match-acpi-device \
ksym-vanilla-acpi-match-device \
ksym-vanilla-acpi-match-device-ids \
ksym-vanilla-acpi-match-platform-list \
ksym-vanilla-acpi-nfit-ctl \
ksym-vanilla-acpi-nfit-desc-init \
ksym-vanilla-acpi-nfit-init \
ksym-vanilla-acpi-nfit-shutdown \
ksym-vanilla-acpi-nhlt-endpoint-find-fmtcfg \
ksym-vanilla-acpi-nhlt-endpoint-match \
ksym-vanilla-acpi-nhlt-endpoint-mic-count \
ksym-vanilla-acpi-nhlt-find-endpoint \
ksym-vanilla-acpi-nhlt-find-fmtcfg \
ksym-vanilla-acpi-nhlt-get-gbl-table \
ksym-vanilla-acpi-nhlt-put-gbl-table \
ksym-vanilla-acpi-nhlt-tb-find-endpoint \
ksym-vanilla-acpi-nhlt-tb-find-fmtcfg \
ksym-vanilla-acpi-node-backed-by-real-pxm \
ksym-vanilla-acpi-notifier-call-chain \
ksym-vanilla-acpi-os-execute \
ksym-vanilla-acpi-os-get-iomem \
ksym-vanilla-acpi-os-get-line \
ksym-vanilla-acpi-os-map-generic-address \
ksym-vanilla-acpi-os-map-iomem \
ksym-vanilla-acpi-os-map-memory \
ksym-vanilla-acpi-os-printf \
ksym-vanilla-acpi-os-read-port \
ksym-vanilla-acpi-os-unmap-generic-address \
ksym-vanilla-acpi-os-unmap-iomem \
ksym-vanilla-acpi-os-unmap-memory \
ksym-vanilla-acpi-os-wait-events-complete \
ksym-vanilla-acpi-os-write-port \
ksym-vanilla-acpi-osi-is-win8 \
ksym-vanilla-acpi-passive-trip-temp \
ksym-vanilla-acpi-pci-check-ejectable \
ksym-vanilla-acpi-pci-detect-ejectable \
ksym-vanilla-acpi-pci-disabled \
ksym-vanilla-acpi-pci-find-root \
ksym-vanilla-acpi-pm-device-sleep-state \
ksym-vanilla-acpi-pm-set-device-wakeup \
ksym-vanilla-acpi-pm-wakeup-event \
ksym-vanilla-acpi-prm-handler-available \
ksym-vanilla-acpi-processor-get-bios-limit \
ksym-vanilla-acpi-purge-cached-objects \
ksym-vanilla-acpi-put-table \
ksym-vanilla-acpi-read \
ksym-vanilla-acpi-reconfig-notifier-register \
ksym-vanilla-acpi-reconfig-notifier-unregister \
ksym-vanilla-acpi-reduced-hardware \
ksym-vanilla-acpi-register-gsi \
ksym-vanilla-acpi-register-wakeup-handler \
ksym-vanilla-acpi-release-mutex \
ksym-vanilla-acpi-remove-address-space-handler \
ksym-vanilla-acpi-remove-interface \
ksym-vanilla-acpi-remove-notify-handler \
ksym-vanilla-acpi-remove-table-handler \
ksym-vanilla-acpi-reset \
ksym-vanilla-acpi-resource-to-address64 \
ksym-vanilla-acpi-resources-are-enforced \
ksym-vanilla-acpi-root-dir \
ksym-vanilla-acpi-run-osc \
ksym-vanilla-acpi-scan-lock-acquire \
ksym-vanilla-acpi-scan-lock-release \
ksym-vanilla-acpi-set-current-resources \
ksym-vanilla-acpi-set-firmware-waking-vector \
ksym-vanilla-acpi-set-modalias \
ksym-vanilla-acpi-spi-count-resources \
ksym-vanilla-acpi-spi-device-alloc \
ksym-vanilla-acpi-spi-find-controller-by-adev \
ksym-vanilla-acpi-storage-d3 \
ksym-vanilla-acpi-subsys-complete \
ksym-vanilla-acpi-subsys-freeze \
ksym-vanilla-acpi-subsys-poweroff \
ksym-vanilla-acpi-subsys-prepare \
ksym-vanilla-acpi-subsys-restore-early \
ksym-vanilla-acpi-subsys-runtime-resume \
ksym-vanilla-acpi-subsys-runtime-suspend \
ksym-vanilla-acpi-subsys-suspend \
ksym-vanilla-acpi-subsys-suspend-late \
ksym-vanilla-acpi-subsys-suspend-noirq \
ksym-vanilla-acpi-table-parse-cedt \
ksym-vanilla-acpi-tb-install-and-load-table \
ksym-vanilla-acpi-tb-unload-table \
ksym-vanilla-acpi-unbind-one \
ksym-vanilla-acpi-unload-parent-table \
ksym-vanilla-acpi-unload-table \
ksym-vanilla-acpi-unmap-cpu \
ksym-vanilla-acpi-unregister-gsi \
ksym-vanilla-acpi-unregister-wakeup-handler \
ksym-vanilla-acpi-video-backlight-string \
ksym-vanilla-acpi-video-get-edid \
ksym-vanilla-acpi-video-get-levels \
ksym-vanilla-acpi-video-handles-brightness-key-presses \
ksym-vanilla-acpi-video-register \
ksym-vanilla-acpi-video-register-backlight \
ksym-vanilla-acpi-video-unregister \
ksym-vanilla-acpi-wait-for-acpi-ipmi \
ksym-vanilla-acpi-walk-namespace \
ksym-vanilla-acpi-walk-resource-buffer \
ksym-vanilla-acpi-walk-resources \
ksym-vanilla-acpi-warning \
ksym-vanilla-acpi-write \
ksym-vanilla-acpiphp-register-attention \
ksym-vanilla-acpiphp-unregister-attention \
ksym-vanilla-ad-dpot-probe \
ksym-vanilla-ad-dpot-remove \
ksym-vanilla-ad-sd-calibrate \
ksym-vanilla-ad-sd-calibrate-all \
ksym-vanilla-ad-sd-init \
ksym-vanilla-ad-sd-read-reg \
ksym-vanilla-ad-sd-reset \
ksym-vanilla-ad-sd-set-comm \
ksym-vanilla-ad-sd-validate-trigger \
ksym-vanilla-ad-sd-write-reg \
ksym-vanilla-ad-sigma-delta-single-conversion \
ksym-vanilla-ad3541r-model-data \
ksym-vanilla-ad3542r-model-data \
ksym-vanilla-ad3551r-model-data \
ksym-vanilla-ad3552r-calc-custom-gain \
ksym-vanilla-ad3552r-calc-gain-and-offset \
ksym-vanilla-ad3552r-get-custom-gain \
ksym-vanilla-ad3552r-get-drive-strength \
ksym-vanilla-ad3552r-get-output-range \
ksym-vanilla-ad3552r-get-ref-voltage \
ksym-vanilla-ad3552r-model-data \
ksym-vanilla-ad5310r-chip-info \
ksym-vanilla-ad5311r-chip-info \
ksym-vanilla-ad5337r-chip-info \
ksym-vanilla-ad5338r-chip-info \
ksym-vanilla-ad5592r-probe \
ksym-vanilla-ad5592r-remove \
ksym-vanilla-ad5672r-chip-info \
ksym-vanilla-ad5674r-chip-info \
ksym-vanilla-ad5676-chip-info \
ksym-vanilla-ad5676r-chip-info \
ksym-vanilla-ad5679r-chip-info \
ksym-vanilla-ad5681r-chip-info \
ksym-vanilla-ad5682r-chip-info \
ksym-vanilla-ad5683-chip-info \
ksym-vanilla-ad5683r-chip-info \
ksym-vanilla-ad5684-chip-info \
ksym-vanilla-ad5684r-chip-info \
ksym-vanilla-ad5685r-chip-info \
ksym-vanilla-ad5686-chip-info \
ksym-vanilla-ad5686-probe \
ksym-vanilla-ad5686r-chip-info \
ksym-vanilla-ad7091r-events \
ksym-vanilla-ad7091r-probe \
ksym-vanilla-ad7091r-volatile-reg \
ksym-vanilla-ad7091r-writeable-reg \
ksym-vanilla-ad714x-pm \
ksym-vanilla-ad714x-probe \
ksym-vanilla-ad7605-4-info \
ksym-vanilla-ad7606-4-info \
ksym-vanilla-ad7606-6-info \
ksym-vanilla-ad7606-8-info \
ksym-vanilla-ad7606-pm-ops \
ksym-vanilla-ad7606-probe \
ksym-vanilla-ad7606-pwm-set-low \
ksym-vanilla-ad7606-pwm-set-swing \
ksym-vanilla-ad7606-reset \
ksym-vanilla-ad7606b-info \
ksym-vanilla-ad7606c-16-info \
ksym-vanilla-ad7606c-18-info \
ksym-vanilla-ad7607-info \
ksym-vanilla-ad7608-info \
ksym-vanilla-ad7609-info \
ksym-vanilla-ad7616-info \
ksym-vanilla-ad7879-groups \
ksym-vanilla-ad7879-pm-ops \
ksym-vanilla-ad7879-probe \
ksym-vanilla-adau-calc-pll-cfg \
ksym-vanilla-adau1761-probe \
ksym-vanilla-adau1761-regmap-config \
ksym-vanilla-adau17x1-add-routes \
ksym-vanilla-adau17x1-add-widgets \
ksym-vanilla-adau17x1-dai-ops \
ksym-vanilla-adau17x1-precious-register \
ksym-vanilla-adau17x1-probe \
ksym-vanilla-adau17x1-readable-register \
ksym-vanilla-adau17x1-remove \
ksym-vanilla-adau17x1-resume \
ksym-vanilla-adau17x1-set-micbias-voltage \
ksym-vanilla-adau17x1-volatile-register \
ksym-vanilla-adau7118-probe \
ksym-vanilla-adc-battery-helper-external-power-changed \
ksym-vanilla-adc-battery-helper-get-property \
ksym-vanilla-adc-battery-helper-init \
ksym-vanilla-adc-battery-helper-properties \
ksym-vanilla-adc-battery-helper-resume \
ksym-vanilla-adc-battery-helper-suspend \
ksym-vanilla-add-cpu \
ksym-vanilla-add-device-randomness \
ksym-vanilla-add-disk-fwnode \
ksym-vanilla-add-disk-randomness \
ksym-vanilla-add-hwgenerator-randomness \
ksym-vanilla-add-input-randomness \
ksym-vanilla-add-interrupt-randomness \
ksym-vanilla-add-memory \
ksym-vanilla-add-memory-driver-managed \
ksym-vanilla-add-mtd-blktrans-dev \
ksym-vanilla-add-swap-extent \
ksym-vanilla-add-taint \
ksym-vanilla-add-timer \
ksym-vanilla-add-timer-global \
ksym-vanilla-add-timer-local \
ksym-vanilla-add-timer-on \
ksym-vanilla-add-to-page-cache-lru \
ksym-vanilla-add-to-pipe \
ksym-vanilla-add-uevent-var \
ksym-vanilla-add-vmfork-randomness \
ksym-vanilla-add-wait-queue \
ksym-vanilla-add-wait-queue-exclusive \
ksym-vanilla-add-wait-queue-priority \
ksym-vanilla-add-wait-queue-priority-exclusive \
ksym-vanilla-add-watch-to-object \
ksym-vanilla-addrconf-add-linklocal \
ksym-vanilla-addrconf-prefix-rcv-add-addr \
ksym-vanilla-address-space-init-once \
ksym-vanilla-adf-bank-state-restore \
ksym-vanilla-adf-bank-state-save \
ksym-vanilla-adf-cfg-add-key-value-param \
ksym-vanilla-adf-cfg-dev-add \
ksym-vanilla-adf-cfg-dev-remove \
ksym-vanilla-adf-cfg-get-param-value \
ksym-vanilla-adf-cfg-section-add \
ksym-vanilla-adf-clean-vf-map \
ksym-vanilla-adf-cleanup-etr-data \
ksym-vanilla-adf-dbgfs-exit \
ksym-vanilla-adf-dbgfs-init \
ksym-vanilla-adf-dev-down \
ksym-vanilla-adf-dev-get \
ksym-vanilla-adf-dev-in-use \
ksym-vanilla-adf-dev-measure-clock \
ksym-vanilla-adf-dev-put \
ksym-vanilla-adf-dev-restart \
ksym-vanilla-adf-dev-started \
ksym-vanilla-adf-dev-up \
ksym-vanilla-adf-devmgr-add-dev \
ksym-vanilla-adf-devmgr-in-reset \
ksym-vanilla-adf-devmgr-pci-to-accel-dev \
ksym-vanilla-adf-devmgr-rm-dev \
ksym-vanilla-adf-devmgr-update-class-index \
ksym-vanilla-adf-disable-pf2vf-interrupts \
ksym-vanilla-adf-disable-sriov \
ksym-vanilla-adf-enable-pf2vf-comms \
ksym-vanilla-adf-enable-vf2pf-comms \
ksym-vanilla-adf-err-handler \
ksym-vanilla-adf-exit-admin-comms \
ksym-vanilla-adf-exit-arb \
ksym-vanilla-adf-flush-vf-wq \
ksym-vanilla-adf-gen2-cfg-iov-thds \
ksym-vanilla-adf-gen2-dev-config \
ksym-vanilla-adf-gen2-enable-error-correction \
ksym-vanilla-adf-gen2-enable-ints \
ksym-vanilla-adf-gen2-get-accel-cap \
ksym-vanilla-adf-gen2-get-admin-info \
ksym-vanilla-adf-gen2-get-arb-info \
ksym-vanilla-adf-gen2-get-num-accels \
ksym-vanilla-adf-gen2-get-num-aes \
ksym-vanilla-adf-gen2-init-dc-ops \
ksym-vanilla-adf-gen2-init-hw-csr-ops \
ksym-vanilla-adf-gen2-init-pf-pfvf-ops \
ksym-vanilla-adf-gen2-init-vf-pfvf-ops \
ksym-vanilla-adf-gen2-set-ssm-wdtimer \
ksym-vanilla-adf-gen4-bank-quiesce-coal-timer \
ksym-vanilla-adf-gen4-cfg-dev-init \
ksym-vanilla-adf-gen4-dev-config \
ksym-vanilla-adf-gen4-enable-error-correction \
ksym-vanilla-adf-gen4-enable-ints \
ksym-vanilla-adf-gen4-enable-pm \
ksym-vanilla-adf-gen4-get-accel-mask \
ksym-vanilla-adf-gen4-get-admin-info \
ksym-vanilla-adf-gen4-get-arb-info \
ksym-vanilla-adf-gen4-get-etr-bar-id \
ksym-vanilla-adf-gen4-get-heartbeat-clock \
ksym-vanilla-adf-gen4-get-misc-bar-id \
ksym-vanilla-adf-gen4-get-num-accels \
ksym-vanilla-adf-gen4-get-num-aes \
ksym-vanilla-adf-gen4-get-ring-to-svc-map \
ksym-vanilla-adf-gen4-get-sku \
ksym-vanilla-adf-gen4-get-sram-bar-id \
ksym-vanilla-adf-gen4-get-svc-slice-cnt \
ksym-vanilla-adf-gen4-handle-pm-interrupt \
ksym-vanilla-adf-gen4-init-dc-ops \
ksym-vanilla-adf-gen4-init-device \
ksym-vanilla-adf-gen4-init-hw-csr-ops \
ksym-vanilla-adf-gen4-init-num-svc-aes \
ksym-vanilla-adf-gen4-init-pf-pfvf-ops \
ksym-vanilla-adf-gen4-init-ras-ops \
ksym-vanilla-adf-gen4-init-thd2arb-map \
ksym-vanilla-adf-gen4-init-tl-data \
ksym-vanilla-adf-gen4-init-vf-mig-ops \
ksym-vanilla-adf-gen4-ring-pair-reset \
ksym-vanilla-adf-gen4-services-supported \
ksym-vanilla-adf-gen4-set-msix-default-rttable \
ksym-vanilla-adf-gen4-set-ssm-wdtimer \
ksym-vanilla-adf-gen6-comp-dev-config \
ksym-vanilla-adf-gen6-init-dev-pm-data \
ksym-vanilla-adf-gen6-init-hw-csr-ops \
ksym-vanilla-adf-gen6-init-pf-pfvf-ops \
ksym-vanilla-adf-gen6-init-ras-ops \
ksym-vanilla-adf-gen6-init-tl-data \
ksym-vanilla-adf-gen6-init-vf-mig-ops \
ksym-vanilla-adf-gen6-no-dev-config \
ksym-vanilla-adf-get-service-enabled \
ksym-vanilla-adf-get-service-mask \
ksym-vanilla-adf-heartbeat-check-ctrs \
ksym-vanilla-adf-heartbeat-dbgfs-add \
ksym-vanilla-adf-heartbeat-dbgfs-rm \
ksym-vanilla-adf-heartbeat-save-cfg-param \
ksym-vanilla-adf-init-admin-comms \
ksym-vanilla-adf-init-admin-pm \
ksym-vanilla-adf-init-arb \
ksym-vanilla-adf-init-etr-data \
ksym-vanilla-adf-isr-resource-alloc \
ksym-vanilla-adf-isr-resource-free \
ksym-vanilla-adf-pfvf-comms-disabled \
ksym-vanilla-adf-reset-flr \
ksym-vanilla-adf-reset-sbr \
ksym-vanilla-adf-send-admin-init \
ksym-vanilla-adf-sriov-configure \
ksym-vanilla-adf-sysfs-init \
ksym-vanilla-adf-sysfs-init-kpt \
ksym-vanilla-adf-timer-start \
ksym-vanilla-adf-timer-stop \
ksym-vanilla-adf-vf-isr-resource-alloc \
ksym-vanilla-adf-vf-isr-resource-free \
ksym-vanilla-adf-vf2pf-notify-init \
ksym-vanilla-adf-vf2pf-notify-restart-complete \
ksym-vanilla-adf-vf2pf-notify-shutdown \
ksym-vanilla-adis-debugfs-reg-access \
ksym-vanilla-adis-init \
ksym-vanilla-adis-single-conversion \
ksym-vanilla-adis-update-scan-mode \
ksym-vanilla-adjust-managed-page-count \
ksym-vanilla-adjust-resource \
ksym-vanilla-admin-timeout \
ksym-vanilla-adt7x10-dev-pm-ops \
ksym-vanilla-adt7x10-probe \
ksym-vanilla-adxl312-readable-regs-table \
ksym-vanilla-adxl312-writable-regs-table \
ksym-vanilla-adxl313-core-probe \
ksym-vanilla-adxl313-is-volatile-reg \
ksym-vanilla-adxl313-readable-regs-table \
ksym-vanilla-adxl313-writable-regs-table \
ksym-vanilla-adxl314-readable-regs-table \
ksym-vanilla-adxl314-writable-regs-table \
ksym-vanilla-adxl318-chip-info \
ksym-vanilla-adxl319-chip-info \
ksym-vanilla-adxl31x-chip-info \
ksym-vanilla-adxl345-core-probe \
ksym-vanilla-adxl345-is-volatile-reg \
ksym-vanilla-adxl34x-groups \
ksym-vanilla-adxl34x-pm \
ksym-vanilla-adxl34x-probe \
ksym-vanilla-adxl355-core-probe \
ksym-vanilla-adxl355-readable-regs-tbl \
ksym-vanilla-adxl355-writeable-regs-tbl \
ksym-vanilla-adxl35x-chip-info \
ksym-vanilla-adxl367-probe \
ksym-vanilla-adxl371-chip-info \
ksym-vanilla-adxl372-chip-info \
ksym-vanilla-adxl372-probe \
ksym-vanilla-adxl372-readable-noinc-reg \
ksym-vanilla-adxl380-chip-info \
ksym-vanilla-adxl380-probe \
ksym-vanilla-adxl380-readable-noinc-reg \
ksym-vanilla-adxl382-chip-info \
ksym-vanilla-aead-exit-geniv \
ksym-vanilla-aead-geniv-alloc \
ksym-vanilla-aead-init-geniv \
ksym-vanilla-aead-register-instance \
ksym-vanilla-aer-recover-queue \
ksym-vanilla-aes-cbcmac-final \
ksym-vanilla-aes-cbcmac-update \
ksym-vanilla-aes-cmac-final \
ksym-vanilla-aes-cmac-preparekey \
ksym-vanilla-aes-cmac-update \
ksym-vanilla-aes-dec-tab \
ksym-vanilla-aes-decrypt \
ksym-vanilla-aes-enc-tab \
ksym-vanilla-aes-encrypt \
ksym-vanilla-aes-expandkey \
ksym-vanilla-aes-prepareenckey \
ksym-vanilla-aes-preparekey \
ksym-vanilla-aes-xcbcmac-preparekey \
ksym-vanilla-af-alg-accept \
ksym-vanilla-af-alg-alloc-areq \
ksym-vanilla-af-alg-count-tsgl \
ksym-vanilla-af-alg-free-resources \
ksym-vanilla-af-alg-free-sg \
ksym-vanilla-af-alg-get-rsgl \
ksym-vanilla-af-alg-poll \
ksym-vanilla-af-alg-pull-tsgl \
ksym-vanilla-af-alg-register-type \
ksym-vanilla-af-alg-release \
ksym-vanilla-af-alg-release-parent \
ksym-vanilla-af-alg-sendmsg \
ksym-vanilla-af-alg-unregister-type \
ksym-vanilla-af-alg-wait-for-data \
ksym-vanilla-af-alg-wmem-wakeup \
ksym-vanilla-af9005-rc-decode \
ksym-vanilla-afe-port-send-usb-dev-param \
ksym-vanilla-aggre1-branch-clk \
ksym-vanilla-aggre1-clk \
ksym-vanilla-aggre2-branch-clk \
ksym-vanilla-aggre2-clk \
ksym-vanilla-ahash-free-singlespawn-instance \
ksym-vanilla-ahash-register-instance \
ksym-vanilla-ahash-request-free \
ksym-vanilla-ahci-check-ready \
ksym-vanilla-ahci-dev-classify \
ksym-vanilla-ahci-do-hardreset \
ksym-vanilla-ahci-do-softreset \
ksym-vanilla-ahci-error-handler \
ksym-vanilla-ahci-fill-cmd-slot \
ksym-vanilla-ahci-handle-port-intr \
ksym-vanilla-ahci-host-activate \
ksym-vanilla-ahci-ignore-sss \
ksym-vanilla-ahci-init-controller \
ksym-vanilla-ahci-kick-engine \
ksym-vanilla-ahci-ops \
ksym-vanilla-ahci-platform-assert-rsts \
ksym-vanilla-ahci-platform-deassert-rsts \
ksym-vanilla-ahci-platform-disable-clks \
ksym-vanilla-ahci-platform-disable-phys \
ksym-vanilla-ahci-platform-disable-regulators \
ksym-vanilla-ahci-platform-disable-resources \
ksym-vanilla-ahci-platform-enable-clks \
ksym-vanilla-ahci-platform-enable-phys \
ksym-vanilla-ahci-platform-enable-regulators \
ksym-vanilla-ahci-platform-enable-resources \
ksym-vanilla-ahci-platform-find-clk \
ksym-vanilla-ahci-platform-get-resources \
ksym-vanilla-ahci-platform-init-host \
ksym-vanilla-ahci-platform-ops \
ksym-vanilla-ahci-platform-resume \
ksym-vanilla-ahci-platform-resume-host \
ksym-vanilla-ahci-platform-shutdown \
ksym-vanilla-ahci-platform-suspend \
ksym-vanilla-ahci-platform-suspend-host \
ksym-vanilla-ahci-pmp-retry-srst-ops \
ksym-vanilla-ahci-port-resume \
ksym-vanilla-ahci-print-info \
ksym-vanilla-ahci-qc-issue \
ksym-vanilla-ahci-reset-controller \
ksym-vanilla-ahci-reset-em \
ksym-vanilla-ahci-save-initial-config \
ksym-vanilla-ahci-sdev-groups \
ksym-vanilla-ahci-set-em-messages \
ksym-vanilla-ahci-shost-groups \
ksym-vanilla-ahci-start-engine \
ksym-vanilla-ahci-start-fis-rx \
ksym-vanilla-ahci-stop-engine \
ksym-vanilla-aic32x4-probe \
ksym-vanilla-aic32x4-register-clocks \
ksym-vanilla-aic32x4-regmap-config \
ksym-vanilla-aic32x4-remove \
ksym-vanilla-aic3x-probe \
ksym-vanilla-aic3x-regmap \
ksym-vanilla-aic3x-remove \
ksym-vanilla-air-phy-buckpbus-reg-modify \
ksym-vanilla-air-phy-buckpbus-reg-read \
ksym-vanilla-air-phy-buckpbus-reg-write \
ksym-vanilla-air-phy-read-page \
ksym-vanilla-air-phy-write-page \
ksym-vanilla-akcipher-register-instance \
ksym-vanilla-alarm-cancel \
ksym-vanilla-alarm-expires-remaining \
ksym-vanilla-alarm-forward \
ksym-vanilla-alarm-forward-now \
ksym-vanilla-alarm-init \
ksym-vanilla-alarm-start-timer \
ksym-vanilla-alarm-try-to-cancel \
ksym-vanilla-alarmtimer-get-rtcdev \
ksym-vanilla-alc-alloc-spec \
ksym-vanilla-alc-auto-init-amp \
ksym-vanilla-alc-auto-parse-customize-define \
ksym-vanilla-alc-auto-setup-eapd \
ksym-vanilla-alc-build-controls \
ksym-vanilla-alc-eapd-shutup \
ksym-vanilla-alc-fill-eapd-coef \
ksym-vanilla-alc-find-ext-mic-pin \
ksym-vanilla-alc-fix-pll \
ksym-vanilla-alc-fix-pll-init \
ksym-vanilla-alc-fixup-auto-mute-via-amp \
ksym-vanilla-alc-fixup-bass-chmap \
ksym-vanilla-alc-fixup-dell-xps13 \
ksym-vanilla-alc-fixup-disable-aamix \
ksym-vanilla-alc-fixup-dual-codecs \
ksym-vanilla-alc-fixup-gpio \
ksym-vanilla-alc-fixup-gpio1 \
ksym-vanilla-alc-fixup-gpio2 \
ksym-vanilla-alc-fixup-gpio3 \
ksym-vanilla-alc-fixup-gpio4 \
ksym-vanilla-alc-fixup-headset-mic \
ksym-vanilla-alc-fixup-headset-mode \
ksym-vanilla-alc-fixup-headset-mode-no-hp-mic \
ksym-vanilla-alc-fixup-hp-gpio-led \
ksym-vanilla-alc-fixup-inv-dmic \
ksym-vanilla-alc-fixup-micmute-led \
ksym-vanilla-alc-fixup-no-depop-delay \
ksym-vanilla-alc-fixup-no-jack-detect \
ksym-vanilla-alc-fixup-sku-ignore \
ksym-vanilla-alc-get-coef0 \
ksym-vanilla-alc-get-hp-pin \
ksym-vanilla-alc-has-cdefine-beep \
ksym-vanilla-alc-headset-mic-no-shutup \
ksym-vanilla-alc-init \
ksym-vanilla-alc-parse-auto-config \
ksym-vanilla-alc-power-eapd \
ksym-vanilla-alc-process-coef-fw \
ksym-vanilla-alc-read-coefex-idx \
ksym-vanilla-alc-resume \
ksym-vanilla-alc-set-beep-amp \
ksym-vanilla-alc-setup-gpio \
ksym-vanilla-alc-shutup \
ksym-vanilla-alc-shutup-pins \
ksym-vanilla-alc-ssid-check \
ksym-vanilla-alc-subsystem-id \
ksym-vanilla-alc-suspend \
ksym-vanilla-alc-update-coefex-idx \
ksym-vanilla-alc-update-gpio-data \
ksym-vanilla-alc-update-gpio-led \
ksym-vanilla-alc-update-headset-jack-cb \
ksym-vanilla-alc-update-knob-master \
ksym-vanilla-alc-write-coefex-idx \
ksym-vanilla-alc1220-fixup-gb-dual-codecs \
ksym-vanilla-alc233-alc662-fixup-lenovo-dual-codecs \
ksym-vanilla-alcor-read32 \
ksym-vanilla-alcor-read32be \
ksym-vanilla-alcor-read8 \
ksym-vanilla-alcor-write16 \
ksym-vanilla-alcor-write32 \
ksym-vanilla-alcor-write32be \
ksym-vanilla-alcor-write8 \
ksym-vanilla-alg-test \
ksym-vanilla-all-vm-events \
ksym-vanilla-alloc-anon-inode \
ksym-vanilla-alloc-buffer-head \
ksym-vanilla-alloc-c-can-dev \
ksym-vanilla-alloc-can-err-skb \
ksym-vanilla-alloc-can-skb \
ksym-vanilla-alloc-candev-mqs \
ksym-vanilla-alloc-canfd-skb \
ksym-vanilla-alloc-canxl-skb \
ksym-vanilla-alloc-chrdev-region \
ksym-vanilla-alloc-contig-frozen-pages-noprof \
ksym-vanilla-alloc-contig-frozen-range-noprof \
ksym-vanilla-alloc-contig-pages-noprof \
ksym-vanilla-alloc-contig-range-noprof \
ksym-vanilla-alloc-cpu-rmap \
ksym-vanilla-alloc-cpumask-var-node \
ksym-vanilla-alloc-dax \
ksym-vanilla-alloc-dax-region \
ksym-vanilla-alloc-empty-backing-file \
ksym-vanilla-alloc-ep-req \
ksym-vanilla-alloc-etherdev-mqs \
ksym-vanilla-alloc-fcdev \
ksym-vanilla-alloc-fddidev \
ksym-vanilla-alloc-file-pseudo \
ksym-vanilla-alloc-file-pseudo-noaccount \
ksym-vanilla-alloc-free-mem-region \
ksym-vanilla-alloc-hdlcdev \
ksym-vanilla-alloc-io-pgtable-ops \
ksym-vanilla-alloc-iova \
ksym-vanilla-alloc-iova-fast \
ksym-vanilla-alloc-libipw \
ksym-vanilla-alloc-mdio-bitbang \
ksym-vanilla-alloc-memory-type \
ksym-vanilla-alloc-mtk-intr-urb \
ksym-vanilla-alloc-netdev-dummy \
ksym-vanilla-alloc-netdev-mqs \
ksym-vanilla-alloc-nfs-open-context \
ksym-vanilla-alloc-page-buffers \
ksym-vanilla-alloc-pages-bulk-noprof \
ksym-vanilla-alloc-pages-exact-noprof \
ksym-vanilla-alloc-pages-nolock-noprof \
ksym-vanilla-alloc-pages-noprof \
ksym-vanilla-alloc-sja1000dev \
ksym-vanilla-alloc-skb-for-msg \
ksym-vanilla-alloc-skb-with-frags \
ksym-vanilla-alloc-workqueue-noprof \
ksym-vanilla-allocate-resource \
ksym-vanilla-alt-cb-patch-nops \
ksym-vanilla-alt-pr-register \
ksym-vanilla-altera-ci-init \
ksym-vanilla-altera-ci-irq \
ksym-vanilla-altera-ci-release \
ksym-vanilla-altera-ci-tuner-reset \
ksym-vanilla-altera-init \
ksym-vanilla-altera-spi-init-host \
ksym-vanilla-altera-spi-irq \
ksym-vanilla-altr-sysmgr-regmap-lookup-by-phandle \
ksym-vanilla-always-delete-dentry \
ksym-vanilla-amba-bustype \
ksym-vanilla-amba-device-add \
ksym-vanilla-amba-device-alloc \
ksym-vanilla-amba-device-put \
ksym-vanilla-amba-device-register \
ksym-vanilla-amba-device-unregister \
ksym-vanilla-amba-driver-unregister \
ksym-vanilla-amba-release-regions \
ksym-vanilla-amba-request-regions \
ksym-vanilla-amd-spi-probe-common \
ksym-vanilla-amdgpu-xcp-drm-dev-alloc \
ksym-vanilla-amdgpu-xcp-drm-dev-free \
ksym-vanilla-amdgpu-xcp-drv-release \
ksym-vanilla-amdtp-am824-add-pcm-hw-constraints \
ksym-vanilla-amdtp-am824-init \
ksym-vanilla-amdtp-am824-midi-trigger \
ksym-vanilla-amdtp-am824-set-midi-position \
ksym-vanilla-amdtp-am824-set-parameters \
ksym-vanilla-amdtp-am824-set-pcm-position \
ksym-vanilla-amdtp-domain-add-stream \
ksym-vanilla-amdtp-domain-destroy \
ksym-vanilla-amdtp-domain-init \
ksym-vanilla-amdtp-domain-start \
ksym-vanilla-amdtp-domain-stop \
ksym-vanilla-amdtp-domain-stream-pcm-ack \
ksym-vanilla-amdtp-domain-stream-pcm-pointer \
ksym-vanilla-amdtp-rate-table \
ksym-vanilla-amdtp-stream-add-pcm-hw-constraints \
ksym-vanilla-amdtp-stream-destroy \
ksym-vanilla-amdtp-stream-get-max-payload \
ksym-vanilla-amdtp-stream-init \
ksym-vanilla-amdtp-stream-pcm-abort \
ksym-vanilla-amdtp-stream-pcm-prepare \
ksym-vanilla-amdtp-stream-set-parameters \
ksym-vanilla-amdtp-stream-update \
ksym-vanilla-amdtp-syt-intervals \
ksym-vanilla-amvdec-abort \
ksym-vanilla-amvdec-add-ts \
ksym-vanilla-amvdec-am21c-body-size \
ksym-vanilla-amvdec-am21c-head-size \
ksym-vanilla-amvdec-am21c-size \
ksym-vanilla-amvdec-clear-dos-bits \
ksym-vanilla-amvdec-dst-buf-done \
ksym-vanilla-amvdec-dst-buf-done-idx \
ksym-vanilla-amvdec-dst-buf-done-offset \
ksym-vanilla-amvdec-get-output-size \
ksym-vanilla-amvdec-read-dos \
ksym-vanilla-amvdec-read-parser \
ksym-vanilla-amvdec-remove-ts \
ksym-vanilla-amvdec-set-canvases \
ksym-vanilla-amvdec-set-par-from-dar \
ksym-vanilla-amvdec-src-change \
ksym-vanilla-amvdec-write-dos \
ksym-vanilla-amvdec-write-dos-bits \
ksym-vanilla-amvdec-write-parser \
ksym-vanilla-analogix-dp-aux-to-plat-data \
ksym-vanilla-analogix-dp-bind \
ksym-vanilla-analogix-dp-finish-probe \
ksym-vanilla-analogix-dp-get-aux \
ksym-vanilla-analogix-dp-probe \
ksym-vanilla-analogix-dp-resume \
ksym-vanilla-analogix-dp-start-crc \
ksym-vanilla-analogix-dp-stop-crc \
ksym-vanilla-analogix-dp-suspend \
ksym-vanilla-analogix-dp-unbind \
ksym-vanilla-anon-inode-create-getfile \
ksym-vanilla-anon-inode-getfd \
ksym-vanilla-anon-inode-getfile \
ksym-vanilla-anon-inode-getfile-fmode \
ksym-vanilla-anon-inode-make-secure-inode \
ksym-vanilla-anon-transport-class-register \
ksym-vanilla-anon-transport-class-unregister \
ksym-vanilla-anx-dp-aux-transfer \
ksym-vanilla-apei-exec-collect-resources \
ksym-vanilla-apei-exec-ctx-init \
ksym-vanilla-apei-exec-noop \
ksym-vanilla-apei-exec-post-unmap-gars \
ksym-vanilla-apei-exec-pre-map-gars \
ksym-vanilla-apei-exec-read-register \
ksym-vanilla-apei-exec-read-register-value \
ksym-vanilla-apei-exec-write-register \
ksym-vanilla-apei-exec-write-register-value \
ksym-vanilla-apei-get-debugfs-dir \
ksym-vanilla-apei-map-generic-address \
ksym-vanilla-apei-osc-setup \
ksym-vanilla-apei-read \
ksym-vanilla-apei-resources-add \
ksym-vanilla-apei-resources-fini \
ksym-vanilla-apei-resources-release \
ksym-vanilla-apei-resources-request \
ksym-vanilla-apei-resources-sub \
ksym-vanilla-apei-write \
ksym-vanilla-aperture-remove-conflicting-devices \
ksym-vanilla-aperture-remove-conflicting-pci-devices \
ksym-vanilla-apple-mbox-get \
ksym-vanilla-apple-mbox-get-byname \
ksym-vanilla-apple-mbox-poll \
ksym-vanilla-apple-mbox-send \
ksym-vanilla-apple-mbox-start \
ksym-vanilla-apple-mbox-stop \
ksym-vanilla-apple-rtkit-boot \
ksym-vanilla-apple-rtkit-free \
ksym-vanilla-apple-rtkit-idle \
ksym-vanilla-apple-rtkit-init \
ksym-vanilla-apple-rtkit-is-crashed \
ksym-vanilla-apple-rtkit-is-running \
ksym-vanilla-apple-rtkit-poll \
ksym-vanilla-apple-rtkit-poweroff \
ksym-vanilla-apple-rtkit-quiesce \
ksym-vanilla-apple-rtkit-reinit \
ksym-vanilla-apple-rtkit-send-message \
ksym-vanilla-apple-rtkit-shutdown \
ksym-vanilla-apple-rtkit-start-ep \
ksym-vanilla-apple-rtkit-wake \
ksym-vanilla-apple-sart-add-allowed-region \
ksym-vanilla-apple-sart-remove-allowed-region \
ksym-vanilla-apple-smc-enter-atomic \
ksym-vanilla-apple-smc-get-key-by-index \
ksym-vanilla-apple-smc-get-key-info \
ksym-vanilla-apple-smc-read \
ksym-vanilla-apple-smc-rw \
ksym-vanilla-apple-smc-write \
ksym-vanilla-apple-smc-write-atomic \
ksym-vanilla-apple-tunable-apply \
ksym-vanilla-apply-to-page-range \
ksym-vanilla-apr-driver-unregister \
ksym-vanilla-apr-send-pkt \
ksym-vanilla-aprbus \
ksym-vanilla-aptina-pll-calculate \
ksym-vanilla-aq-xdp-locking-key \
ksym-vanilla-ar9003-get-pll-sqsum-dvc \
ksym-vanilla-ar9003-hw-bb-watchdog-check \
ksym-vanilla-ar9003-hw-bb-watchdog-dbg-info \
ksym-vanilla-ar9003-hw-disable-phy-restart \
ksym-vanilla-ar9003-is-paprd-enabled \
ksym-vanilla-ar9003-mci-cleanup \
ksym-vanilla-ar9003-mci-get-interrupt \
ksym-vanilla-ar9003-mci-get-next-gpm-offset \
ksym-vanilla-ar9003-mci-send-message \
ksym-vanilla-ar9003-mci-send-wlan-channels \
ksym-vanilla-ar9003-mci-set-bt-version \
ksym-vanilla-ar9003-mci-setup \
ksym-vanilla-ar9003-mci-state \
ksym-vanilla-ar9003-paprd-create-curve \
ksym-vanilla-ar9003-paprd-enable \
ksym-vanilla-ar9003-paprd-init-table \
ksym-vanilla-ar9003-paprd-is-done \
ksym-vanilla-ar9003-paprd-populate-single-table \
ksym-vanilla-ar9003-paprd-setup-gain-table \
ksym-vanilla-arc4-crypt \
ksym-vanilla-arc4-setkey \
ksym-vanilla-arch-apei-enable-cmcff \
ksym-vanilla-arch-apei-report-mem-error \
ksym-vanilla-arch-freq-scale \
ksym-vanilla-arch-hibernation-header-restore \
ksym-vanilla-arch-hibernation-header-save \
ksym-vanilla-arch-invalidate-pmem \
ksym-vanilla-arch-timer-read-counter \
ksym-vanilla-arch-touch-nmi-watchdog \
ksym-vanilla-arch-wb-cache-pmem \
ksym-vanilla-argv-free \
ksym-vanilla-argv-split \
ksym-vanilla-aria-decrypt \
ksym-vanilla-aria-encrypt \
ksym-vanilla-aria-set-key \
ksym-vanilla-arm-smccc-1-1-get-conduit \
ksym-vanilla-arm-smccc-1-2-hvc \
ksym-vanilla-arm-smccc-1-2-smc \
ksym-vanilla-arm-smccc-get-soc-id-revision \
ksym-vanilla-arm-smccc-get-version \
ksym-vanilla-arm-smccc-hypervisor-has-uuid \
ksym-vanilla-arm64-mm-context-get \
ksym-vanilla-arm64-mm-context-put \
ksym-vanilla-arm64-rsi-is-protected \
ksym-vanilla-arm64-use-ng-mappings \
ksym-vanilla-arp-create \
ksym-vanilla-arp-send \
ksym-vanilla-arp-tbl \
ksym-vanilla-arp-xmit \
ksym-vanilla-arpt-alloc-initial-table \
ksym-vanilla-arpt-do-table \
ksym-vanilla-arpt-register-table \
ksym-vanilla-arpt-unregister-table \
ksym-vanilla-as102-attach \
ksym-vanilla-ascot2e-attach \
ksym-vanilla-asn1-ber-decoder \
ksym-vanilla-asn1-encode-boolean \
ksym-vanilla-asn1-encode-integer \
ksym-vanilla-asn1-encode-octet-string \
ksym-vanilla-asn1-encode-oid \
ksym-vanilla-asn1-encode-sequence \
ksym-vanilla-asn1-encode-tag \
ksym-vanilla-asoc-qcom-lpass-cdc-dma-dai-ops \
ksym-vanilla-asoc-qcom-lpass-cpu-dai-ops \
ksym-vanilla-asoc-qcom-lpass-cpu-dai-ops2 \
ksym-vanilla-asoc-qcom-lpass-cpu-platform-probe \
ksym-vanilla-asoc-qcom-lpass-cpu-platform-remove \
ksym-vanilla-asoc-qcom-lpass-cpu-platform-shutdown \
ksym-vanilla-asoc-qcom-lpass-hdmi-dai-ops \
ksym-vanilla-asoc-qcom-lpass-platform-register \
ksym-vanilla-aspeed-gpio-copro-grab-gpio \
ksym-vanilla-aspeed-gpio-copro-release-gpio \
ksym-vanilla-aspeed-gpio-copro-set-ops \
ksym-vanilla-asymmetric-key-generate-id \
ksym-vanilla-asymmetric-key-id-partial \
ksym-vanilla-asymmetric-key-id-same \
ksym-vanilla-async-gen-syndrome \
ksym-vanilla-async-memcpy \
ksym-vanilla-async-pmem-flush \
ksym-vanilla-async-raid6-2data-recov \
ksym-vanilla-async-raid6-datap-recov \
ksym-vanilla-async-schedule-node \
ksym-vanilla-async-schedule-node-domain \
ksym-vanilla-async-synchronize-cookie \
ksym-vanilla-async-synchronize-cookie-domain \
ksym-vanilla-async-synchronize-full \
ksym-vanilla-async-synchronize-full-domain \
ksym-vanilla-async-syndrome-val \
ksym-vanilla-async-trigger-callback \
ksym-vanilla-async-tx-quiesce \
ksym-vanilla-async-tx-submit \
ksym-vanilla-async-xor \
ksym-vanilla-async-xor-offs \
ksym-vanilla-async-xor-val-offs \
ksym-vanilla-at8031-set-wol \
ksym-vanilla-at803x-ack-interrupt \
ksym-vanilla-at803x-cdt-fault-length \
ksym-vanilla-at803x-cdt-start \
ksym-vanilla-at803x-cdt-wait-for-completion \
ksym-vanilla-at803x-config-intr \
ksym-vanilla-at803x-config-mdix \
ksym-vanilla-at803x-debug-reg-mask \
ksym-vanilla-at803x-debug-reg-read \
ksym-vanilla-at803x-debug-reg-write \
ksym-vanilla-at803x-get-tunable \
ksym-vanilla-at803x-get-wol \
ksym-vanilla-at803x-handle-interrupt \
ksym-vanilla-at803x-prepare-config-aneg \
ksym-vanilla-at803x-read-specific-status \
ksym-vanilla-at803x-read-status \
ksym-vanilla-at803x-set-tunable \
ksym-vanilla-at803x-set-wol \
ksym-vanilla-ata-acpi-cbl-pata-type \
ksym-vanilla-ata-acpi-gtm \
ksym-vanilla-ata-acpi-gtm-xfermask \
ksym-vanilla-ata-acpi-stm \
ksym-vanilla-ata-bmdma-dumb-qc-prep \
ksym-vanilla-ata-bmdma-error-handler \
ksym-vanilla-ata-bmdma-interrupt \
ksym-vanilla-ata-bmdma-irq-clear \
ksym-vanilla-ata-bmdma-port-intr \
ksym-vanilla-ata-bmdma-port-ops \
ksym-vanilla-ata-bmdma-port-start \
ksym-vanilla-ata-bmdma-port-start32 \
ksym-vanilla-ata-bmdma-post-internal-cmd \
ksym-vanilla-ata-bmdma-qc-issue \
ksym-vanilla-ata-bmdma-qc-prep \
ksym-vanilla-ata-bmdma-setup \
ksym-vanilla-ata-bmdma-start \
ksym-vanilla-ata-bmdma-status \
ksym-vanilla-ata-bmdma-stop \
ksym-vanilla-ata-bmdma32-port-ops \
ksym-vanilla-ata-cable-40wire \
ksym-vanilla-ata-cable-80wire \
ksym-vanilla-ata-cable-ignore \
ksym-vanilla-ata-cable-sata \
ksym-vanilla-ata-cable-unknown \
ksym-vanilla-ata-change-queue-depth \
ksym-vanilla-ata-common-sdev-groups \
ksym-vanilla-ata-dev-classify \
ksym-vanilla-ata-dev-disable \
ksym-vanilla-ata-dev-next \
ksym-vanilla-ata-dev-pair \
ksym-vanilla-ata-dev-set-feature \
ksym-vanilla-ata-do-dev-read-id \
ksym-vanilla-ata-dummy-port-info \
ksym-vanilla-ata-dummy-port-ops \
ksym-vanilla-ata-eh-analyze-ncq-error \
ksym-vanilla-ata-eh-freeze-port \
ksym-vanilla-ata-ehi-clear-desc \
ksym-vanilla-ata-ehi-push-desc \
ksym-vanilla-ata-get-cmd-name \
ksym-vanilla-ata-host-activate \
ksym-vanilla-ata-host-alloc \
ksym-vanilla-ata-host-alloc-pinfo \
ksym-vanilla-ata-host-detach \
ksym-vanilla-ata-host-init \
ksym-vanilla-ata-host-put \
ksym-vanilla-ata-host-register \
ksym-vanilla-ata-host-resume \
ksym-vanilla-ata-host-start \
ksym-vanilla-ata-host-suspend \
ksym-vanilla-ata-id-c-string \
ksym-vanilla-ata-id-string \
ksym-vanilla-ata-id-xfermask \
ksym-vanilla-ata-link-abort \
ksym-vanilla-ata-link-next \
ksym-vanilla-ata-link-offline \
ksym-vanilla-ata-link-online \
ksym-vanilla-ata-mode-string \
ksym-vanilla-ata-msleep \
ksym-vanilla-ata-ncq-prio-enable \
ksym-vanilla-ata-ncq-prio-enabled \
ksym-vanilla-ata-ncq-prio-supported \
ksym-vanilla-ata-ncq-sdev-groups \
ksym-vanilla-ata-pack-xfermask \
ksym-vanilla-ata-pci-bmdma-clear-simplex \
ksym-vanilla-ata-pci-bmdma-init \
ksym-vanilla-ata-pci-bmdma-init-one \
ksym-vanilla-ata-pci-bmdma-prepare-host \
ksym-vanilla-ata-pci-device-do-resume \
ksym-vanilla-ata-pci-device-do-suspend \
ksym-vanilla-ata-pci-device-resume \
ksym-vanilla-ata-pci-device-suspend \
ksym-vanilla-ata-pci-remove-one \
ksym-vanilla-ata-pci-sff-activate-host \
ksym-vanilla-ata-pci-sff-init-host \
ksym-vanilla-ata-pci-sff-init-one \
ksym-vanilla-ata-pci-sff-prepare-host \
ksym-vanilla-ata-pci-shutdown-one \
ksym-vanilla-ata-pio-need-iordy \
ksym-vanilla-ata-platform-remove-one \
ksym-vanilla-ata-port-abort \
ksym-vanilla-ata-port-alloc \
ksym-vanilla-ata-port-classify \
ksym-vanilla-ata-port-desc \
ksym-vanilla-ata-port-free \
ksym-vanilla-ata-port-freeze \
ksym-vanilla-ata-port-pbar-desc \
ksym-vanilla-ata-port-probe \
ksym-vanilla-ata-port-schedule-eh \
ksym-vanilla-ata-port-wait-eh \
ksym-vanilla-ata-qc-complete \
ksym-vanilla-ata-qc-complete-multiple \
ksym-vanilla-ata-qc-get-active \
ksym-vanilla-ata-ratelimit \
ksym-vanilla-ata-sas-port-resume \
ksym-vanilla-ata-sas-port-suspend \
ksym-vanilla-ata-sas-queuecmd \
ksym-vanilla-ata-sas-scsi-ioctl \
ksym-vanilla-ata-sas-sdev-configure \
ksym-vanilla-ata-scsi-change-queue-depth \
ksym-vanilla-ata-scsi-cmd-error-handler \
ksym-vanilla-ata-scsi-dma-need-drain \
ksym-vanilla-ata-scsi-eh-timed-out \
ksym-vanilla-ata-scsi-ioctl \
ksym-vanilla-ata-scsi-port-error-handler \
ksym-vanilla-ata-scsi-queuecmd \
ksym-vanilla-ata-scsi-retry-deferred-qc \
ksym-vanilla-ata-scsi-sdev-configure \
ksym-vanilla-ata-scsi-sdev-destroy \
ksym-vanilla-ata-scsi-sdev-init \
ksym-vanilla-ata-scsi-unlock-native-capacity \
ksym-vanilla-ata-set-mode \
ksym-vanilla-ata-sff-check-status \
ksym-vanilla-ata-sff-data-xfer \
ksym-vanilla-ata-sff-data-xfer32 \
ksym-vanilla-ata-sff-dev-classify \
ksym-vanilla-ata-sff-dev-select \
ksym-vanilla-ata-sff-dma-pause \
ksym-vanilla-ata-sff-drain-fifo \
ksym-vanilla-ata-sff-error-handler \
ksym-vanilla-ata-sff-exec-command \
ksym-vanilla-ata-sff-freeze \
ksym-vanilla-ata-sff-hsm-move \
ksym-vanilla-ata-sff-interrupt \
ksym-vanilla-ata-sff-irq-on \
ksym-vanilla-ata-sff-lost-interrupt \
ksym-vanilla-ata-sff-pause \
ksym-vanilla-ata-sff-port-intr \
ksym-vanilla-ata-sff-port-ops \
ksym-vanilla-ata-sff-postreset \
ksym-vanilla-ata-sff-prereset \
ksym-vanilla-ata-sff-qc-fill-rtf \
ksym-vanilla-ata-sff-qc-issue \
ksym-vanilla-ata-sff-queue-delayed-work \
ksym-vanilla-ata-sff-queue-pio-task \
ksym-vanilla-ata-sff-queue-work \
ksym-vanilla-ata-sff-softreset \
ksym-vanilla-ata-sff-std-ports \
ksym-vanilla-ata-sff-tf-load \
ksym-vanilla-ata-sff-tf-read \
ksym-vanilla-ata-sff-thaw \
ksym-vanilla-ata-sff-wait-after-reset \
ksym-vanilla-ata-sff-wait-ready \
ksym-vanilla-ata-slave-link-init \
ksym-vanilla-ata-std-bios-param \
ksym-vanilla-ata-std-end-eh \
ksym-vanilla-ata-std-error-handler \
ksym-vanilla-ata-std-postreset \
ksym-vanilla-ata-std-prereset \
ksym-vanilla-ata-std-qc-defer \
ksym-vanilla-ata-std-sched-eh \
ksym-vanilla-ata-tf-from-fis \
ksym-vanilla-ata-tf-to-fis \
ksym-vanilla-ata-timing-compute \
ksym-vanilla-ata-timing-find-mode \
ksym-vanilla-ata-timing-merge \
ksym-vanilla-ata-tport-add \
ksym-vanilla-ata-tport-delete \
ksym-vanilla-ata-wait-after-reset \
ksym-vanilla-ata-wait-register \
ksym-vanilla-ata-xfer-mask2mode \
ksym-vanilla-ata-xfer-mode2mask \
ksym-vanilla-ata-xfer-mode2shift \
ksym-vanilla-atapi-cmd-type \
ksym-vanilla-atbm8830-attach \
ksym-vanilla-atc260x-device-probe \
ksym-vanilla-atc260x-match-device \
ksym-vanilla-ath-bus-type-strings \
ksym-vanilla-ath-gen-timer-alloc \
ksym-vanilla-ath-gen-timer-free \
ksym-vanilla-ath-gen-timer-isr \
ksym-vanilla-ath-hw-cycle-counters-update \
ksym-vanilla-ath-hw-get-listen-time \
ksym-vanilla-ath-hw-keyreset \
ksym-vanilla-ath-hw-keysetmac \
ksym-vanilla-ath-hw-setbssidmask \
ksym-vanilla-ath-is-49ghz-allowed \
ksym-vanilla-ath-is-mybeacon \
ksym-vanilla-ath-is-world-regd \
ksym-vanilla-ath-key-config \
ksym-vanilla-ath-key-delete \
ksym-vanilla-ath-printk \
ksym-vanilla-ath-reg-notifier-apply \
ksym-vanilla-ath-regd-find-country-by-name \
ksym-vanilla-ath-regd-get-band-ctl \
ksym-vanilla-ath-regd-init \
ksym-vanilla-ath-rxbuf-alloc \
ksym-vanilla-ath10k-bmi-read-memory \
ksym-vanilla-ath10k-bmi-start \
ksym-vanilla-ath10k-ce-alloc-pipe \
ksym-vanilla-ath10k-ce-alloc-rri \
ksym-vanilla-ath10k-ce-cancel-send-next \
ksym-vanilla-ath10k-ce-completed-recv-next \
ksym-vanilla-ath10k-ce-completed-recv-next-nolock \
ksym-vanilla-ath10k-ce-completed-send-next \
ksym-vanilla-ath10k-ce-completed-send-next-nolock \
ksym-vanilla-ath10k-ce-deinit-pipe \
ksym-vanilla-ath10k-ce-disable-interrupt \
ksym-vanilla-ath10k-ce-disable-interrupts \
ksym-vanilla-ath10k-ce-dump-registers \
ksym-vanilla-ath10k-ce-enable-interrupt \
ksym-vanilla-ath10k-ce-enable-interrupts \
ksym-vanilla-ath10k-ce-free-pipe \
ksym-vanilla-ath10k-ce-free-rri \
ksym-vanilla-ath10k-ce-init-pipe \
ksym-vanilla-ath10k-ce-num-free-src-entries \
ksym-vanilla-ath10k-ce-per-engine-service \
ksym-vanilla-ath10k-ce-per-engine-service-any \
ksym-vanilla-ath10k-ce-revoke-recv-next \
ksym-vanilla-ath10k-ce-rx-post-buf \
ksym-vanilla-ath10k-ce-rx-update-write-idx \
ksym-vanilla-ath10k-ce-send \
ksym-vanilla-ath10k-ce-send-nolock \
ksym-vanilla-ath10k-core-check-dt \
ksym-vanilla-ath10k-core-create \
ksym-vanilla-ath10k-core-destroy \
ksym-vanilla-ath10k-core-fetch-board-file \
ksym-vanilla-ath10k-core-free-board-files \
ksym-vanilla-ath10k-core-napi-enable \
ksym-vanilla-ath10k-core-napi-sync-disable \
ksym-vanilla-ath10k-core-register \
ksym-vanilla-ath10k-core-start \
ksym-vanilla-ath10k-core-start-recovery \
ksym-vanilla-ath10k-core-stop \
ksym-vanilla-ath10k-core-unregister \
ksym-vanilla-ath10k-coredump-get-mem-layout \
ksym-vanilla-ath10k-coredump-new \
ksym-vanilla-ath10k-debug-mask \
ksym-vanilla-ath10k-err \
ksym-vanilla-ath10k-htc-notify-tx-completion \
ksym-vanilla-ath10k-htc-process-trailer \
ksym-vanilla-ath10k-htc-rx-completion-handler \
ksym-vanilla-ath10k-htc-tx-completion-handler \
ksym-vanilla-ath10k-htt-hif-tx-complete \
ksym-vanilla-ath10k-htt-rx-hl-indication \
ksym-vanilla-ath10k-htt-rx-pktlog-completion-handler \
ksym-vanilla-ath10k-htt-t2h-msg-handler \
ksym-vanilla-ath10k-htt-txrx-compl-task \
ksym-vanilla-ath10k-info \
ksym-vanilla-ath10k-mac-tx-push-pending \
ksym-vanilla-ath10k-print-driver-info \
ksym-vanilla-ath10k-warn \
ksym-vanilla-ath11k-ce-alloc-pipes \
ksym-vanilla-ath11k-ce-cleanup-pipes \
ksym-vanilla-ath11k-ce-free-pipes \
ksym-vanilla-ath11k-ce-get-attr-flags \
ksym-vanilla-ath11k-ce-get-shadow-config \
ksym-vanilla-ath11k-ce-per-engine-service \
ksym-vanilla-ath11k-ce-rx-post-buf \
ksym-vanilla-ath11k-cold-boot-cal \
ksym-vanilla-ath11k-core-alloc \
ksym-vanilla-ath11k-core-deinit \
ksym-vanilla-ath11k-core-free \
ksym-vanilla-ath11k-core-get-usecase-firmware \
ksym-vanilla-ath11k-core-init \
ksym-vanilla-ath11k-core-pm-notifier-unregister \
ksym-vanilla-ath11k-core-pre-init \
ksym-vanilla-ath11k-core-resume \
ksym-vanilla-ath11k-core-resume-early \
ksym-vanilla-ath11k-core-suspend \
ksym-vanilla-ath11k-core-suspend-late \
ksym-vanilla-ath11k-coredump-get-dump-type \
ksym-vanilla-ath11k-debug-mask \
ksym-vanilla-ath11k-dp-service-srng \
ksym-vanilla-ath11k-err \
ksym-vanilla-ath11k-fw-destroy \
ksym-vanilla-ath11k-hal-srng-clear \
ksym-vanilla-ath11k-hal-srng-deinit \
ksym-vanilla-ath11k-hal-srng-init \
ksym-vanilla-ath11k-info \
ksym-vanilla-ath11k-pci-disable-ce-irqs-except-wake-irq \
ksym-vanilla-ath11k-pci-enable-ce-irqs-except-wake-irq \
ksym-vanilla-ath11k-pcic-ce-irq-disable-sync \
ksym-vanilla-ath11k-pcic-ce-irqs-enable \
ksym-vanilla-ath11k-pcic-config-irq \
ksym-vanilla-ath11k-pcic-ext-irq-disable \
ksym-vanilla-ath11k-pcic-ext-irq-enable \
ksym-vanilla-ath11k-pcic-free-irq \
ksym-vanilla-ath11k-pcic-get-ce-msi-idx \
ksym-vanilla-ath11k-pcic-get-msi-address \
ksym-vanilla-ath11k-pcic-get-user-msi-assignment \
ksym-vanilla-ath11k-pcic-init-msi-config \
ksym-vanilla-ath11k-pcic-map-service-to-pipe \
ksym-vanilla-ath11k-pcic-read \
ksym-vanilla-ath11k-pcic-read32 \
ksym-vanilla-ath11k-pcic-register-pci-ops \
ksym-vanilla-ath11k-pcic-start \
ksym-vanilla-ath11k-pcic-stop \
ksym-vanilla-ath11k-pcic-write32 \
ksym-vanilla-ath11k-qmi-deinit-service \
ksym-vanilla-ath11k-qmi-fwreset-from-cold-boot \
ksym-vanilla-ath11k-warn \
ksym-vanilla-ath12k-core-get-max-peers-per-radio \
ksym-vanilla-ath12k-core-get-memory-mode \
ksym-vanilla-ath12k-core-resume \
ksym-vanilla-ath12k-core-resume-early \
ksym-vanilla-ath12k-core-suspend \
ksym-vanilla-ath12k-core-suspend-late \
ksym-vanilla-ath12k-debug-mask \
ksym-vanilla-ath12k-dp-get-rx-desc \
ksym-vanilla-ath12k-dp-get-tx-desc \
ksym-vanilla-ath12k-dp-htt-htc-t2h-msg-handler \
ksym-vanilla-ath12k-dp-init-rx-tid-rxq \
ksym-vanilla-ath12k-dp-link-peer-find-by-addr \
ksym-vanilla-ath12k-dp-link-peer-find-by-peerid \
ksym-vanilla-ath12k-dp-mark-tid-as-inactive \
ksym-vanilla-ath12k-dp-metadata-align-skb \
ksym-vanilla-ath12k-dp-mon-buf-replenish \
ksym-vanilla-ath12k-dp-mon-comp-ppduid \
ksym-vanilla-ath12k-dp-mon-parse-status-buf \
ksym-vanilla-ath12k-dp-mon-rx-deliver-msdu \
ksym-vanilla-ath12k-dp-mon-rx-merg-msdus \
ksym-vanilla-ath12k-dp-mon-rx-process-ulofdma \
ksym-vanilla-ath12k-dp-mon-rx-update-peer-mu-stats \
ksym-vanilla-ath12k-dp-mon-rx-update-peer-su-stats \
ksym-vanilla-ath12k-dp-mon-update-radiotap \
ksym-vanilla-ath12k-dp-peer-find-by-addr \
ksym-vanilla-ath12k-dp-peer-find-by-peerid \
ksym-vanilla-ath12k-dp-pkt-set-pktlen \
ksym-vanilla-ath12k-dp-reo-cmd-free \
ksym-vanilla-ath12k-dp-rx-alloc-mon-status-buf \
ksym-vanilla-ath12k-dp-rx-bufs-replenish \
ksym-vanilla-ath12k-dp-rx-check-nwifi-hdr-len-valid \
ksym-vanilla-ath12k-dp-rx-deliver-msdu \
ksym-vanilla-ath12k-dp-rx-get-msdu-last-buf \
ksym-vanilla-ath12k-dp-rx-h-get-pn \
ksym-vanilla-ath12k-dp-rx-h-ppdu \
ksym-vanilla-ath12k-dp-rx-h-sort-frags \
ksym-vanilla-ath12k-dp-rx-h-undecap \
ksym-vanilla-ath12k-dp-rx-h-undecap-frag \
ksym-vanilla-ath12k-dp-rx-process-reo-cmd-update-rx-queue-list \
ksym-vanilla-ath12k-dp-rx-tid-del-func \
ksym-vanilla-ath12k-dp-tx-align-payload \
ksym-vanilla-ath12k-dp-tx-assign-buffer \
ksym-vanilla-ath12k-dp-tx-encap-nwifi \
ksym-vanilla-ath12k-dp-tx-free-txbuf \
ksym-vanilla-ath12k-dp-tx-get-encap-type \
ksym-vanilla-ath12k-dp-tx-get-encrypt-type \
ksym-vanilla-ath12k-dp-tx-get-tid \
ksym-vanilla-ath12k-dp-tx-htt-rx-filter-setup \
ksym-vanilla-ath12k-dp-tx-release-txbuf \
ksym-vanilla-ath12k-err \
ksym-vanilla-ath12k-ftm-mode \
ksym-vanilla-ath12k-hal-decode-tlv32-hdr \
ksym-vanilla-ath12k-hal-decode-tlv64-hdr \
ksym-vanilla-ath12k-hal-encode-tlv32-hdr \
ksym-vanilla-ath12k-hal-encode-tlv64-hdr \
ksym-vanilla-ath12k-hal-reo-shared-qaddr-cache-clear \
ksym-vanilla-ath12k-hal-srng-access-begin \
ksym-vanilla-ath12k-hal-srng-access-end \
ksym-vanilla-ath12k-hal-srng-dst-get-next-entry \
ksym-vanilla-ath12k-hal-srng-dst-num-free \
ksym-vanilla-ath12k-hal-srng-dst-peek \
ksym-vanilla-ath12k-hal-srng-get-entrysize \
ksym-vanilla-ath12k-hal-srng-get-params \
ksym-vanilla-ath12k-hal-srng-src-get-next-entry \
ksym-vanilla-ath12k-hal-srng-src-next-peek \
ksym-vanilla-ath12k-hal-srng-src-peek \
ksym-vanilla-ath12k-htc-rx-completion-handler \
ksym-vanilla-ath12k-info \
ksym-vanilla-ath12k-mac-add-p2p-noa-ie \
ksym-vanilla-ath12k-mac-bw-to-mac80211-bw \
ksym-vanilla-ath12k-mac-eht-gi-to-nl80211-eht-gi \
ksym-vanilla-ath12k-mac-eht-ru-tones-to-nl80211-eht-ru-alloc \
ksym-vanilla-ath12k-mac-get-tx-link \
ksym-vanilla-ath12k-mac-he-convert-tones-to-ru-tones \
ksym-vanilla-ath12k-mac-hw-ratecode-to-legacy-rate \
ksym-vanilla-ath12k-mac-mgmt-tx \
ksym-vanilla-ath12k-mac-op-add-chanctx \
ksym-vanilla-ath12k-mac-op-add-interface \
ksym-vanilla-ath12k-mac-op-ampdu-action \
ksym-vanilla-ath12k-mac-op-assign-vif-chanctx \
ksym-vanilla-ath12k-mac-op-can-activate-links \
ksym-vanilla-ath12k-mac-op-cancel-hw-scan \
ksym-vanilla-ath12k-mac-op-cancel-remain-on-channel \
ksym-vanilla-ath12k-mac-op-change-chanctx \
ksym-vanilla-ath12k-mac-op-change-sta-links \
ksym-vanilla-ath12k-mac-op-change-vif-links \
ksym-vanilla-ath12k-mac-op-conf-tx \
ksym-vanilla-ath12k-mac-op-config \
ksym-vanilla-ath12k-mac-op-configure-filter \
ksym-vanilla-ath12k-mac-op-flush \
ksym-vanilla-ath12k-mac-op-get-antenna \
ksym-vanilla-ath12k-mac-op-get-survey \
ksym-vanilla-ath12k-mac-op-get-txpower \
ksym-vanilla-ath12k-mac-op-hw-scan \
ksym-vanilla-ath12k-mac-op-link-info-changed \
ksym-vanilla-ath12k-mac-op-link-sta-rc-update \
ksym-vanilla-ath12k-mac-op-link-sta-statistics \
ksym-vanilla-ath12k-mac-op-reconfig-complete \
ksym-vanilla-ath12k-mac-op-remain-on-channel \
ksym-vanilla-ath12k-mac-op-remove-chanctx \
ksym-vanilla-ath12k-mac-op-remove-interface \
ksym-vanilla-ath12k-mac-op-set-antenna \
ksym-vanilla-ath12k-mac-op-set-bitrate-mask \
ksym-vanilla-ath12k-mac-op-set-frag-threshold \
ksym-vanilla-ath12k-mac-op-set-key \
ksym-vanilla-ath12k-mac-op-set-rekey-data \
ksym-vanilla-ath12k-mac-op-set-rts-threshold \
ksym-vanilla-ath12k-mac-op-sta-set-4addr \
ksym-vanilla-ath12k-mac-op-sta-set-txpwr \
ksym-vanilla-ath12k-mac-op-sta-state \
ksym-vanilla-ath12k-mac-op-sta-statistics \
ksym-vanilla-ath12k-mac-op-start \
ksym-vanilla-ath12k-mac-op-stop \
ksym-vanilla-ath12k-mac-op-switch-vif-chanctx \
ksym-vanilla-ath12k-mac-op-unassign-vif-chanctx \
ksym-vanilla-ath12k-mac-op-update-vif-offload \
ksym-vanilla-ath12k-mac-op-vif-cfg-changed \
ksym-vanilla-ath12k-mlo-mcast-update-tx-link-address \
ksym-vanilla-ath12k-pci-read32 \
ksym-vanilla-ath12k-pci-register-driver \
ksym-vanilla-ath12k-pci-unregister-driver \
ksym-vanilla-ath12k-wow-op-resume \
ksym-vanilla-ath12k-wow-op-set-wakeup \
ksym-vanilla-ath12k-wow-op-suspend \
ksym-vanilla-ath6kl-cfg80211-resume \
ksym-vanilla-ath6kl-cfg80211-suspend \
ksym-vanilla-ath6kl-core-cleanup \
ksym-vanilla-ath6kl-core-create \
ksym-vanilla-ath6kl-core-destroy \
ksym-vanilla-ath6kl-core-init \
ksym-vanilla-ath6kl-core-rx-complete \
ksym-vanilla-ath6kl-core-tx-complete \
ksym-vanilla-ath6kl-err \
ksym-vanilla-ath6kl-hif-intr-bh-handler \
ksym-vanilla-ath6kl-hif-rw-comp-handler \
ksym-vanilla-ath6kl-info \
ksym-vanilla-ath6kl-printk \
ksym-vanilla-ath6kl-read-tgt-stats \
ksym-vanilla-ath6kl-stop-txrx \
ksym-vanilla-ath6kl-warn \
ksym-vanilla-ath9k-cmn-beacon-config-adhoc \
ksym-vanilla-ath9k-cmn-beacon-config-ap \
ksym-vanilla-ath9k-cmn-beacon-config-sta \
ksym-vanilla-ath9k-cmn-count-streams \
ksym-vanilla-ath9k-cmn-get-channel \
ksym-vanilla-ath9k-cmn-get-hw-crypto-keytype \
ksym-vanilla-ath9k-cmn-init-channels-rates \
ksym-vanilla-ath9k-cmn-init-crypto \
ksym-vanilla-ath9k-cmn-process-rate \
ksym-vanilla-ath9k-cmn-process-rssi \
ksym-vanilla-ath9k-cmn-reload-chainmask \
ksym-vanilla-ath9k-cmn-rx-accept \
ksym-vanilla-ath9k-cmn-rx-skb-postprocess \
ksym-vanilla-ath9k-cmn-setup-ht-cap \
ksym-vanilla-ath9k-cmn-update-txpow \
ksym-vanilla-ath9k-hw-abort-tx-dma \
ksym-vanilla-ath9k-hw-abortpcurecv \
ksym-vanilla-ath9k-hw-addrxbuf-edma \
ksym-vanilla-ath9k-hw-ani-monitor \
ksym-vanilla-ath9k-hw-beaconinit \
ksym-vanilla-ath9k-hw-beaconq-setup \
ksym-vanilla-ath9k-hw-bstuck-nfcal \
ksym-vanilla-ath9k-hw-btcoex-bt-stomp \
ksym-vanilla-ath9k-hw-btcoex-deinit \
ksym-vanilla-ath9k-hw-btcoex-disable \
ksym-vanilla-ath9k-hw-btcoex-enable \
ksym-vanilla-ath9k-hw-btcoex-init-2wire \
ksym-vanilla-ath9k-hw-btcoex-init-3wire \
ksym-vanilla-ath9k-hw-btcoex-init-mci \
ksym-vanilla-ath9k-hw-btcoex-init-scheme \
ksym-vanilla-ath9k-hw-btcoex-set-concur-txprio \
ksym-vanilla-ath9k-hw-btcoex-set-weight \
ksym-vanilla-ath9k-hw-check-alive \
ksym-vanilla-ath9k-hw-check-nav \
ksym-vanilla-ath9k-hw-computetxtime \
ksym-vanilla-ath9k-hw-deinit \
ksym-vanilla-ath9k-hw-disable \
ksym-vanilla-ath9k-hw-disable-interrupts \
ksym-vanilla-ath9k-hw-disable-mib-counters \
ksym-vanilla-ath9k-hw-enable-interrupts \
ksym-vanilla-ath9k-hw-gen-timer-start \
ksym-vanilla-ath9k-hw-gen-timer-stop \
ksym-vanilla-ath9k-hw-get-tsf-offset \
ksym-vanilla-ath9k-hw-get-txq-props \
ksym-vanilla-ath9k-hw-getchan-noise \
ksym-vanilla-ath9k-hw-getnf \
ksym-vanilla-ath9k-hw-getrxfilter \
ksym-vanilla-ath9k-hw-gettsf32 \
ksym-vanilla-ath9k-hw-gettsf64 \
ksym-vanilla-ath9k-hw-gettxbuf \
ksym-vanilla-ath9k-hw-gpio-free \
ksym-vanilla-ath9k-hw-gpio-get \
ksym-vanilla-ath9k-hw-gpio-request-in \
ksym-vanilla-ath9k-hw-gpio-request-out \
ksym-vanilla-ath9k-hw-init \
ksym-vanilla-ath9k-hw-init-btcoex-hw \
ksym-vanilla-ath9k-hw-init-global-settings \
ksym-vanilla-ath9k-hw-intrpend \
ksym-vanilla-ath9k-hw-kill-interrupts \
ksym-vanilla-ath9k-hw-loadnf \
ksym-vanilla-ath9k-hw-name \
ksym-vanilla-ath9k-hw-numtxpending \
ksym-vanilla-ath9k-hw-phy-disable \
ksym-vanilla-ath9k-hw-process-rxdesc-edma \
ksym-vanilla-ath9k-hw-putrxbuf \
ksym-vanilla-ath9k-hw-puttxbuf \
ksym-vanilla-ath9k-hw-releasetxqueue \
ksym-vanilla-ath9k-hw-reset \
ksym-vanilla-ath9k-hw-reset-calvalid \
ksym-vanilla-ath9k-hw-reset-tsf \
ksym-vanilla-ath9k-hw-resettxqueue \
ksym-vanilla-ath9k-hw-resume-interrupts \
ksym-vanilla-ath9k-hw-rxprocdesc \
ksym-vanilla-ath9k-hw-set-gpio \
ksym-vanilla-ath9k-hw-set-interrupts \
ksym-vanilla-ath9k-hw-set-rx-bufsize \
ksym-vanilla-ath9k-hw-set-sta-beacon-timers \
ksym-vanilla-ath9k-hw-set-tsfadjust \
ksym-vanilla-ath9k-hw-set-tx-filter \
ksym-vanilla-ath9k-hw-set-txpowerlimit \
ksym-vanilla-ath9k-hw-set-txq-props \
ksym-vanilla-ath9k-hw-setantenna \
ksym-vanilla-ath9k-hw-setmcastfilter \
ksym-vanilla-ath9k-hw-setopmode \
ksym-vanilla-ath9k-hw-setpower \
ksym-vanilla-ath9k-hw-setrxabort \
ksym-vanilla-ath9k-hw-setrxfilter \
ksym-vanilla-ath9k-hw-settsf64 \
ksym-vanilla-ath9k-hw-setup-statusring \
ksym-vanilla-ath9k-hw-setuprxdesc \
ksym-vanilla-ath9k-hw-setuptxqueue \
ksym-vanilla-ath9k-hw-startpcureceive \
ksym-vanilla-ath9k-hw-stop-dma-queue \
ksym-vanilla-ath9k-hw-stopdmarecv \
ksym-vanilla-ath9k-hw-txstart \
ksym-vanilla-ath9k-hw-updatetxtriglevel \
ksym-vanilla-ath9k-hw-wait \
ksym-vanilla-ath9k-hw-wow-apply-pattern \
ksym-vanilla-ath9k-hw-wow-enable \
ksym-vanilla-ath9k-hw-wow-wakeup \
ksym-vanilla-ath9k-hw-write-associd \
ksym-vanilla-atm-alloc-charge \
ksym-vanilla-atm-charge \
ksym-vanilla-atm-dev-deregister \
ksym-vanilla-atm-dev-lookup \
ksym-vanilla-atm-dev-register \
ksym-vanilla-atm-dev-release-vccs \
ksym-vanilla-atm-dev-signal-change \
ksym-vanilla-atm-init-aal5 \
ksym-vanilla-atm-pcr-goal \
ksym-vanilla-atm-proc-root \
ksym-vanilla-atmel-i2c-enqueue \
ksym-vanilla-atmel-i2c-flush-queue \
ksym-vanilla-atmel-i2c-init-ecdh-cmd \
ksym-vanilla-atmel-i2c-init-genkey-cmd \
ksym-vanilla-atmel-i2c-init-random-cmd \
ksym-vanilla-atmel-i2c-init-read-config-cmd \
ksym-vanilla-atmel-i2c-init-read-otp-cmd \
ksym-vanilla-atmel-i2c-probe \
ksym-vanilla-atmel-i2c-send-receive \
ksym-vanilla-atomic-dec-and-lock \
ksym-vanilla-atomic-dec-and-mutex-lock \
ksym-vanilla-atomic-dec-and-raw-lock \
ksym-vanilla-atomic-notifier-call-chain \
ksym-vanilla-atomic-notifier-chain-register \
ksym-vanilla-atomic-notifier-chain-register-unique-prio \
ksym-vanilla-atomic-notifier-chain-unregister \
ksym-vanilla-attach-hdlc-protocol \
ksym-vanilla-attribute-container-classdev-to-container \
ksym-vanilla-attribute-container-find-class-device \
ksym-vanilla-attribute-container-register \
ksym-vanilla-attribute-container-unregister \
ksym-vanilla-au8522-analog-i2c-gate-ctrl \
ksym-vanilla-au8522-attach \
ksym-vanilla-au8522-get-state \
ksym-vanilla-au8522-i2c-gate-ctrl \
ksym-vanilla-au8522-init \
ksym-vanilla-au8522-led-ctrl \
ksym-vanilla-au8522-readreg \
ksym-vanilla-au8522-release-state \
ksym-vanilla-au8522-sleep \
ksym-vanilla-au8522-writereg \
ksym-vanilla-audio-graph-parse-of \
ksym-vanilla-audio-graph2-link-c2c \
ksym-vanilla-audio-graph2-link-dpcm \
ksym-vanilla-audio-graph2-link-normal \
ksym-vanilla-audio-graph2-parse-of \
ksym-vanilla-audioreach-alloc-apm-cmd-pkt \
ksym-vanilla-audioreach-alloc-apm-pkt \
ksym-vanilla-audioreach-alloc-cmd-pkt \
ksym-vanilla-audioreach-alloc-graph-pkt \
ksym-vanilla-audioreach-alloc-pkt \
ksym-vanilla-audioreach-compr-set-param \
ksym-vanilla-audioreach-gain-set-vol-ctrl \
ksym-vanilla-audioreach-graph-free-buf \
ksym-vanilla-audioreach-graph-send-cmd-sync \
ksym-vanilla-audioreach-send-cmd-sync \
ksym-vanilla-audioreach-send-u32-param \
ksym-vanilla-audioreach-set-default-channel-mapping \
ksym-vanilla-audioreach-set-media-format \
ksym-vanilla-audioreach-setup-push-pull \
ksym-vanilla-audioreach-shared-memory-send-eos \
ksym-vanilla-audioreach-shmem-register-event \
ksym-vanilla-audioreach-tplg-init \
ksym-vanilla-audit-enabled \
ksym-vanilla-audit-log \
ksym-vanilla-audit-log-end \
ksym-vanilla-audit-log-format \
ksym-vanilla-audit-log-nf-skb \
ksym-vanilla-audit-log-start \
ksym-vanilla-audit-log-subj-ctx \
ksym-vanilla-audit-log-task-context \
ksym-vanilla-audit-log-task-info \
ksym-vanilla-auth-domain-find \
ksym-vanilla-auth-domain-lookup \
ksym-vanilla-auth-domain-put \
ksym-vanilla-autoremove-wake-function \
ksym-vanilla-auxiliary-device-create \
ksym-vanilla-auxiliary-device-destroy \
ksym-vanilla-auxiliary-device-init \
ksym-vanilla-auxiliary-device-sysfs-irq-add \
ksym-vanilla-auxiliary-device-sysfs-irq-remove \
ksym-vanilla-auxiliary-driver-unregister \
ksym-vanilla-avc-general-get-plug-info \
ksym-vanilla-avc-general-get-sig-fmt \
ksym-vanilla-avc-general-set-sig-fmt \
ksym-vanilla-avenrun \
ksym-vanilla-aw-dev-dsp-read \
ksym-vanilla-aw-dev-dsp-write \
ksym-vanilla-aw88395-dev-cfg-load \
ksym-vanilla-aw88395-dev-fw-update \
ksym-vanilla-aw88395-dev-get-prof-data \
ksym-vanilla-aw88395-dev-get-prof-name \
ksym-vanilla-aw88395-dev-get-profile-count \
ksym-vanilla-aw88395-dev-get-profile-index \
ksym-vanilla-aw88395-dev-init \
ksym-vanilla-aw88395-dev-load-acf-check \
ksym-vanilla-aw88395-dev-mute \
ksym-vanilla-aw88395-dev-set-profile-index \
ksym-vanilla-aw88395-dev-set-volume \
ksym-vanilla-aw88395-dev-start \
ksym-vanilla-aw88395-dev-stop \
ksym-vanilla-aw88395-init \
ksym-vanilla-axg-fifo-pcm-close \
ksym-vanilla-axg-fifo-pcm-hw-free \
ksym-vanilla-axg-fifo-pcm-hw-params \
ksym-vanilla-axg-fifo-pcm-new \
ksym-vanilla-axg-fifo-pcm-open \
ksym-vanilla-axg-fifo-pcm-pointer \
ksym-vanilla-axg-fifo-pcm-trigger \
ksym-vanilla-axg-fifo-probe \
ksym-vanilla-axg-tdm-formatter-event \
ksym-vanilla-axg-tdm-formatter-probe \
ksym-vanilla-axg-tdm-formatter-set-channel-masks \
ksym-vanilla-axg-tdm-set-tdm-slots \
ksym-vanilla-axg-tdm-stream-alloc \
ksym-vanilla-axg-tdm-stream-free \
ksym-vanilla-axg-tdm-stream-set-cont-clocks \
ksym-vanilla-axg-tdm-stream-start \
ksym-vanilla-axg-tdm-stream-stop \
ksym-vanilla-axp20x-device-probe \
ksym-vanilla-axp20x-device-remove \
ksym-vanilla-axp20x-match-device \
ksym-vanilla-azx-add-stream \
ksym-vanilla-azx-bus-init \
ksym-vanilla-azx-codec-configure \
ksym-vanilla-azx-free-streams \
ksym-vanilla-azx-get-pos-lpib \
ksym-vanilla-azx-get-pos-posbuf \
ksym-vanilla-azx-get-position \
ksym-vanilla-azx-init-chip \
ksym-vanilla-azx-init-streams \
ksym-vanilla-azx-interrupt \
ksym-vanilla-azx-probe-codecs \
ksym-vanilla-azx-stop-all-streams \
ksym-vanilla-azx-stop-chip \
ksym-vanilla-b2c2-flexcop-debug \
ksym-vanilla-b53-br-fast-age \
ksym-vanilla-b53-br-flags \
ksym-vanilla-b53-br-flags-pre \
ksym-vanilla-b53-br-join \
ksym-vanilla-b53-br-leave \
ksym-vanilla-b53-br-set-stp-state \
ksym-vanilla-b53-brcm-hdr-setup \
ksym-vanilla-b53-configure-vlan \
ksym-vanilla-b53-disable-port \
ksym-vanilla-b53-eee-init \
ksym-vanilla-b53-enable-port \
ksym-vanilla-b53-fdb-add \
ksym-vanilla-b53-fdb-del \
ksym-vanilla-b53-fdb-dump \
ksym-vanilla-b53-get-ethtool-phy-stats \
ksym-vanilla-b53-get-ethtool-stats \
ksym-vanilla-b53-get-sset-count \
ksym-vanilla-b53-get-strings \
ksym-vanilla-b53-get-tag-protocol \
ksym-vanilla-b53-imp-vlan-setup \
ksym-vanilla-b53-mdb-add \
ksym-vanilla-b53-mdb-del \
ksym-vanilla-b53-mirror-add \
ksym-vanilla-b53-mirror-del \
ksym-vanilla-b53-port-event \
ksym-vanilla-b53-serdes-init \
ksym-vanilla-b53-serdes-link-set \
ksym-vanilla-b53-serdes-phylink-get-caps \
ksym-vanilla-b53-serdes-phylink-mac-select-pcs \
ksym-vanilla-b53-set-ageing-time \
ksym-vanilla-b53-set-mac-eee \
ksym-vanilla-b53-setup-devlink-resources \
ksym-vanilla-b53-setup-port \
ksym-vanilla-b53-support-eee \
ksym-vanilla-b53-switch-alloc \
ksym-vanilla-b53-switch-detect \
ksym-vanilla-b53-switch-register \
ksym-vanilla-b53-vlan-add \
ksym-vanilla-b53-vlan-del \
ksym-vanilla-b53-vlan-filtering \
ksym-vanilla-backing-file-mmap \
ksym-vanilla-backing-file-open \
ksym-vanilla-backing-file-read-iter \
ksym-vanilla-backing-file-set-user-path \
ksym-vanilla-backing-file-splice-read \
ksym-vanilla-backing-file-splice-write \
ksym-vanilla-backing-file-user-path \
ksym-vanilla-backing-file-write-iter \
ksym-vanilla-backing-tmpfile-open \
ksym-vanilla-backlight-device-get-by-name \
ksym-vanilla-backlight-device-get-by-type \
ksym-vanilla-backlight-device-register \
ksym-vanilla-backlight-device-set-brightness \
ksym-vanilla-backlight-device-unregister \
ksym-vanilla-backlight-force-update \
ksym-vanilla-backlight-notify-blank \
ksym-vanilla-backlight-notify-blank-all \
ksym-vanilla-badblocks-check \
ksym-vanilla-badblocks-clear \
ksym-vanilla-badblocks-exit \
ksym-vanilla-badblocks-init \
ksym-vanilla-badblocks-set \
ksym-vanilla-badblocks-show \
ksym-vanilla-badblocks-store \
ksym-vanilla-badrange-add \
ksym-vanilla-badrange-forget \
ksym-vanilla-badrange-init \
ksym-vanilla-balance-dirty-pages-ratelimited \
ksym-vanilla-balance-dirty-pages-ratelimited-flags \
ksym-vanilla-balloon-page-alloc \
ksym-vanilla-balloon-page-dequeue \
ksym-vanilla-balloon-page-enqueue \
ksym-vanilla-balloon-page-list-dequeue \
ksym-vanilla-balloon-page-list-enqueue \
ksym-vanilla-bar-max-size \
ksym-vanilla-base64-decode \
ksym-vanilla-base64-encode \
ksym-vanilla-baswap \
ksym-vanilla-battery-hook-register \
ksym-vanilla-battery-hook-unregister \
ksym-vanilla-bch-decode \
ksym-vanilla-bch-encode \
ksym-vanilla-bch-free \
ksym-vanilla-bch-init \
ksym-vanilla-bcm-config-lre-advert \
ksym-vanilla-bcm-config-lre-aneg \
ksym-vanilla-bcm-phy-28nm-a0b0-afe-config-init \
ksym-vanilla-bcm-phy-ack-intr \
ksym-vanilla-bcm-phy-cable-test-get-status \
ksym-vanilla-bcm-phy-cable-test-get-status-rdb \
ksym-vanilla-bcm-phy-cable-test-start \
ksym-vanilla-bcm-phy-cable-test-start-rdb \
ksym-vanilla-bcm-phy-config-intr \
ksym-vanilla-bcm-phy-downshift-get \
ksym-vanilla-bcm-phy-downshift-set \
ksym-vanilla-bcm-phy-enable-apd \
ksym-vanilla-bcm-phy-enable-jumbo \
ksym-vanilla-bcm-phy-get-sset-count \
ksym-vanilla-bcm-phy-get-stats \
ksym-vanilla-bcm-phy-get-strings \
ksym-vanilla-bcm-phy-get-wol \
ksym-vanilla-bcm-phy-handle-interrupt \
ksym-vanilla-bcm-phy-led-brightness-set \
ksym-vanilla-bcm-phy-modify-exp \
ksym-vanilla-bcm-phy-modify-rdb \
ksym-vanilla-bcm-phy-r-rc-cal-reset \
ksym-vanilla-bcm-phy-read-exp \
ksym-vanilla-bcm-phy-read-misc \
ksym-vanilla-bcm-phy-read-rdb \
ksym-vanilla-bcm-phy-read-shadow \
ksym-vanilla-bcm-phy-set-eee \
ksym-vanilla-bcm-phy-set-wol \
ksym-vanilla-bcm-phy-update-stats-shadow \
ksym-vanilla-bcm-phy-wol-isr \
ksym-vanilla-bcm-phy-write-exp \
ksym-vanilla-bcm-phy-write-misc \
ksym-vanilla-bcm-phy-write-rdb \
ksym-vanilla-bcm-phy-write-shadow \
ksym-vanilla-bcm-qspi-pm-ops \
ksym-vanilla-bcm-qspi-probe \
ksym-vanilla-bcm-qspi-remove \
ksym-vanilla-bcm-setup-lre-master-slave \
ksym-vanilla-bcm3510-attach \
ksym-vanilla-bcm54xx-auxctl-read \
ksym-vanilla-bcm54xx-auxctl-write \
ksym-vanilla-bcma-chipco-b-mii-write \
ksym-vanilla-bcma-chipco-chipctl-maskset \
ksym-vanilla-bcma-chipco-get-alp-clock \
ksym-vanilla-bcma-chipco-gpio-control \
ksym-vanilla-bcma-chipco-gpio-out \
ksym-vanilla-bcma-chipco-gpio-outen \
ksym-vanilla-bcma-chipco-pll-maskset \
ksym-vanilla-bcma-chipco-pll-read \
ksym-vanilla-bcma-chipco-pll-write \
ksym-vanilla-bcma-chipco-regctl-maskset \
ksym-vanilla-bcma-core-disable \
ksym-vanilla-bcma-core-dma-translation \
ksym-vanilla-bcma-core-enable \
ksym-vanilla-bcma-core-irq \
ksym-vanilla-bcma-core-is-enabled \
ksym-vanilla-bcma-core-pci-power-save \
ksym-vanilla-bcma-core-pll-ctl \
ksym-vanilla-bcma-core-set-clockmode \
ksym-vanilla-bcma-driver-unregister \
ksym-vanilla-bcma-find-core-unit \
ksym-vanilla-bcma-host-pci-down \
ksym-vanilla-bcma-host-pci-irq-ctl \
ksym-vanilla-bcma-host-pci-up \
ksym-vanilla-bcma-pmu-get-bus-clock \
ksym-vanilla-bcma-pmu-spuravoid-pllupdate \
ksym-vanilla-bcmasp-enable-rx-irq \
ksym-vanilla-bcmasp-enable-tx-irq \
ksym-vanilla-bcmp \
ksym-vanilla-bd-abort-claiming \
ksym-vanilla-bd-link-disk-holder \
ksym-vanilla-bd-prepare-to-claim \
ksym-vanilla-bd-unlink-disk-holder \
ksym-vanilla-bdev-alignment-offset \
ksym-vanilla-bdev-count-inflight \
ksym-vanilla-bdev-discard-alignment \
ksym-vanilla-bdev-disk-changed \
ksym-vanilla-bdev-end-io-acct \
ksym-vanilla-bdev-file-open-by-dev \
ksym-vanilla-bdev-file-open-by-path \
ksym-vanilla-bdev-fput \
ksym-vanilla-bdev-freeze \
ksym-vanilla-bdev-getblk \
ksym-vanilla-bdev-mark-dead \
ksym-vanilla-bdev-rw-virt \
ksym-vanilla-bdev-start-io-acct \
ksym-vanilla-bdev-thaw \
ksym-vanilla-bdev-validate-blocksize \
ksym-vanilla-bdev-zone-is-seq \
ksym-vanilla-bdi-alloc \
ksym-vanilla-bdi-dev-name \
ksym-vanilla-bdi-put \
ksym-vanilla-bdi-register \
ksym-vanilla-bdi-set-max-ratio \
ksym-vanilla-bdi-unregister \
ksym-vanilla-be-roce-mcc-cmd \
ksym-vanilla-be-roce-register-driver \
ksym-vanilla-be-roce-unregister-driver \
ksym-vanilla-begin-new-exec \
ksym-vanilla-bfifo-qdisc-ops \
ksym-vanilla-bgmac-adjust-link \
ksym-vanilla-bgmac-alloc \
ksym-vanilla-bgmac-enet-probe \
ksym-vanilla-bgmac-enet-remove \
ksym-vanilla-bgmac-enet-resume \
ksym-vanilla-bgmac-enet-suspend \
ksym-vanilla-bgmac-phy-connect-direct \
ksym-vanilla-bgx-config-timestamping \
ksym-vanilla-bgx-get-lmac-count \
ksym-vanilla-bgx-get-lmac-link-state \
ksym-vanilla-bgx-get-lmac-mac \
ksym-vanilla-bgx-get-map \
ksym-vanilla-bgx-get-rx-stats \
ksym-vanilla-bgx-get-tx-stats \
ksym-vanilla-bgx-lmac-get-pfc \
ksym-vanilla-bgx-lmac-internal-loopback \
ksym-vanilla-bgx-lmac-rx-tx-enable \
ksym-vanilla-bgx-lmac-set-pfc \
ksym-vanilla-bgx-reset-xcast-mode \
ksym-vanilla-bgx-set-dmac-cam-filter \
ksym-vanilla-bgx-set-lmac-mac \
ksym-vanilla-bgx-set-xcast-mode \
ksym-vanilla-bh-end-async-write \
ksym-vanilla-bh-end-read \
ksym-vanilla-bh-end-write \
ksym-vanilla-bh-submit \
ksym-vanilla-bh-uptodate-or-lock \
ksym-vanilla-bimc-clk \
ksym-vanilla-bin2hex \
ksym-vanilla-bio-add-folio \
ksym-vanilla-bio-add-folio-nofail \
ksym-vanilla-bio-add-page \
ksym-vanilla-bio-add-virt-nofail \
ksym-vanilla-bio-add-vmalloc \
ksym-vanilla-bio-add-vmalloc-chunk \
ksym-vanilla-bio-alloc-bioset \
ksym-vanilla-bio-alloc-clone \
ksym-vanilla-bio-associate-blkg \
ksym-vanilla-bio-associate-blkg-from-css \
ksym-vanilla-bio-await \
ksym-vanilla-bio-blkcg-css \
ksym-vanilla-bio-chain \
ksym-vanilla-bio-clone-blkg-association \
ksym-vanilla-bio-copy-data \
ksym-vanilla-bio-crypt-set-ctx \
ksym-vanilla-bio-end-io-acct-remapped \
ksym-vanilla-bio-endio \
ksym-vanilla-bio-endio-bh \
ksym-vanilla-bio-free-pages \
ksym-vanilla-bio-init \
ksym-vanilla-bio-init-clone \
ksym-vanilla-bio-integrity-add-page \
ksym-vanilla-bio-integrity-alloc \
ksym-vanilla-bio-integrity-prep \
ksym-vanilla-bio-integrity-trim \
ksym-vanilla-bio-kmalloc \
ksym-vanilla-bio-poll \
ksym-vanilla-bio-put \
ksym-vanilla-bio-reset \
ksym-vanilla-bio-reuse \
ksym-vanilla-bio-split \
ksym-vanilla-bio-split-io-at \
ksym-vanilla-bio-split-to-limits \
ksym-vanilla-bio-start-io-acct \
ksym-vanilla-bio-submit-split-bioset \
ksym-vanilla-bio-trim \
ksym-vanilla-bio-uninit \
ksym-vanilla-bioset-exit \
ksym-vanilla-bioset-init \
ksym-vanilla-bit-wait \
ksym-vanilla-bit-wait-io \
ksym-vanilla-bit-wait-timeout \
ksym-vanilla-bit-waitqueue \
ksym-vanilla-bitmap-alloc \
ksym-vanilla-bitmap-alloc-node \
ksym-vanilla-bitmap-bitremap \
ksym-vanilla-bitmap-cut \
ksym-vanilla-bitmap-find-next-zero-area-off \
ksym-vanilla-bitmap-free \
ksym-vanilla-bitmap-from-arr32 \
ksym-vanilla-bitmap-parse \
ksym-vanilla-bitmap-parse-user \
ksym-vanilla-bitmap-parselist \
ksym-vanilla-bitmap-parselist-user \
ksym-vanilla-bitmap-print-bitmask-to-buf \
ksym-vanilla-bitmap-print-list-to-buf \
ksym-vanilla-bitmap-remap \
ksym-vanilla-bitmap-to-arr32 \
ksym-vanilla-bitmap-zalloc \
ksym-vanilla-bitmap-zalloc-node \
ksym-vanilla-blackhole-netdev \
ksym-vanilla-blake2b-final \
ksym-vanilla-blake2b-update \
ksym-vanilla-blake2s-final \
ksym-vanilla-blake2s-update \
ksym-vanilla-blk-abort-request \
ksym-vanilla-blk-add-driver-data \
ksym-vanilla-blk-bio-list-merge \
ksym-vanilla-blk-check-plugged \
ksym-vanilla-blk-clear-pm-only \
ksym-vanilla-blk-crypto-derive-sw-secret \
ksym-vanilla-blk-crypto-evict-key \
ksym-vanilla-blk-crypto-generate-key \
ksym-vanilla-blk-crypto-has-capabilities \
ksym-vanilla-blk-crypto-import-key \
ksym-vanilla-blk-crypto-init-key \
ksym-vanilla-blk-crypto-intersect-capabilities \
ksym-vanilla-blk-crypto-keyslot-index \
ksym-vanilla-blk-crypto-prepare-key \
ksym-vanilla-blk-crypto-profile-destroy \
ksym-vanilla-blk-crypto-profile-init \
ksym-vanilla-blk-crypto-register \
ksym-vanilla-blk-crypto-reprogram-all-keys \
ksym-vanilla-blk-crypto-start-using-key \
ksym-vanilla-blk-crypto-update-capabilities \
ksym-vanilla-blk-dump-rq-flags \
ksym-vanilla-blk-execute-rq \
ksym-vanilla-blk-execute-rq-nowait \
ksym-vanilla-blk-fill-rwbs \
ksym-vanilla-blk-finish-plug \
ksym-vanilla-blk-freeze-queue-start \
ksym-vanilla-blk-freeze-queue-start-non-owner \
ksym-vanilla-blk-get-queue \
ksym-vanilla-blk-insert-cloned-request \
ksym-vanilla-blk-integrity-profile-name \
ksym-vanilla-blk-lld-busy \
ksym-vanilla-blk-mark-disk-dead \
ksym-vanilla-blk-mq-alloc-disk-for-queue \
ksym-vanilla-blk-mq-alloc-queue \
ksym-vanilla-blk-mq-alloc-request \
ksym-vanilla-blk-mq-alloc-request-hctx \
ksym-vanilla-blk-mq-alloc-sq-tag-set \
ksym-vanilla-blk-mq-alloc-tag-set \
ksym-vanilla-blk-mq-complete-request \
ksym-vanilla-blk-mq-complete-request-remote \
ksym-vanilla-blk-mq-debugfs-rq-show \
ksym-vanilla-blk-mq-delay-kick-requeue-list \
ksym-vanilla-blk-mq-delay-run-hw-queue \
ksym-vanilla-blk-mq-delay-run-hw-queues \
ksym-vanilla-blk-mq-destroy-queue \
ksym-vanilla-blk-mq-end-request \
ksym-vanilla-blk-mq-end-request-batch \
ksym-vanilla-blk-mq-free-request \
ksym-vanilla-blk-mq-free-tag-set \
ksym-vanilla-blk-mq-freeze-queue-nomemsave \
ksym-vanilla-blk-mq-freeze-queue-wait \
ksym-vanilla-blk-mq-freeze-queue-wait-timeout \
ksym-vanilla-blk-mq-hctx-set-fq-lock-class \
ksym-vanilla-blk-mq-init-allocated-queue \
ksym-vanilla-blk-mq-kick-requeue-list \
ksym-vanilla-blk-mq-map-hw-queues \
ksym-vanilla-blk-mq-map-queues \
ksym-vanilla-blk-mq-num-online-queues \
ksym-vanilla-blk-mq-num-possible-queues \
ksym-vanilla-blk-mq-queue-inflight \
ksym-vanilla-blk-mq-quiesce-queue \
ksym-vanilla-blk-mq-quiesce-queue-nowait \
ksym-vanilla-blk-mq-quiesce-tagset \
ksym-vanilla-blk-mq-requeue-request \
ksym-vanilla-blk-mq-rq-cpu \
ksym-vanilla-blk-mq-run-hw-queue \
ksym-vanilla-blk-mq-run-hw-queues \
ksym-vanilla-blk-mq-sched-mark-restart-hctx \
ksym-vanilla-blk-mq-sched-try-insert-merge \
ksym-vanilla-blk-mq-sched-try-merge \
ksym-vanilla-blk-mq-start-hw-queue \
ksym-vanilla-blk-mq-start-hw-queues \
ksym-vanilla-blk-mq-start-request \
ksym-vanilla-blk-mq-start-stopped-hw-queue \
ksym-vanilla-blk-mq-start-stopped-hw-queues \
ksym-vanilla-blk-mq-stop-hw-queue \
ksym-vanilla-blk-mq-stop-hw-queues \
ksym-vanilla-blk-mq-tagset-busy-iter \
ksym-vanilla-blk-mq-tagset-wait-completed-request \
ksym-vanilla-blk-mq-unfreeze-queue-nomemrestore \
ksym-vanilla-blk-mq-unfreeze-queue-non-owner \
ksym-vanilla-blk-mq-unique-tag \
ksym-vanilla-blk-mq-unquiesce-queue \
ksym-vanilla-blk-mq-unquiesce-tagset \
ksym-vanilla-blk-mq-update-nr-hw-queues \
ksym-vanilla-blk-mq-wait-quiesce-done \
ksym-vanilla-blk-next-bio \
ksym-vanilla-blk-op-str \
ksym-vanilla-blk-pm-runtime-init \
ksym-vanilla-blk-post-runtime-resume \
ksym-vanilla-blk-post-runtime-suspend \
ksym-vanilla-blk-pre-runtime-resume \
ksym-vanilla-blk-pre-runtime-suspend \
ksym-vanilla-blk-put-queue \
ksym-vanilla-blk-queue-flag-clear \
ksym-vanilla-blk-queue-flag-set \
ksym-vanilla-blk-queue-rq-timeout \
ksym-vanilla-blk-revalidate-disk-zones \
ksym-vanilla-blk-rq-append-bio \
ksym-vanilla-blk-rq-dma-map-iter-next \
ksym-vanilla-blk-rq-dma-map-iter-start \
ksym-vanilla-blk-rq-init \
ksym-vanilla-blk-rq-integrity-dma-map-iter-next \
ksym-vanilla-blk-rq-integrity-dma-map-iter-start \
ksym-vanilla-blk-rq-integrity-map-user \
ksym-vanilla-blk-rq-is-poll \
ksym-vanilla-blk-rq-map-integrity-sg \
ksym-vanilla-blk-rq-map-kern \
ksym-vanilla-blk-rq-map-user \
ksym-vanilla-blk-rq-map-user-io \
ksym-vanilla-blk-rq-map-user-iov \
ksym-vanilla-blk-rq-poll \
ksym-vanilla-blk-rq-prep-clone \
ksym-vanilla-blk-rq-unmap-user \
ksym-vanilla-blk-rq-unprep-clone \
ksym-vanilla-blk-set-pm-only \
ksym-vanilla-blk-set-queue-depth \
ksym-vanilla-blk-set-stacking-limits \
ksym-vanilla-blk-stack-limits \
ksym-vanilla-blk-start-plug \
ksym-vanilla-blk-stat-disable-accounting \
ksym-vanilla-blk-stat-enable-accounting \
ksym-vanilla-blk-status-to-errno \
ksym-vanilla-blk-steal-bios \
ksym-vanilla-blk-sync-queue \
ksym-vanilla-blk-trace-remove \
ksym-vanilla-blk-trace-setup \
ksym-vanilla-blk-trace-startstop \
ksym-vanilla-blk-update-request \
ksym-vanilla-blk-validate-limits \
ksym-vanilla-blk-zone-cond-str \
ksym-vanilla-blk-zone-issue-zeroout \
ksym-vanilla-blk-zone-plug-bio \
ksym-vanilla-blkcg-activate-policy \
ksym-vanilla-blkcg-deactivate-policy \
ksym-vanilla-blkcg-get-fc-appid \
ksym-vanilla-blkcg-policy-register \
ksym-vanilla-blkcg-policy-unregister \
ksym-vanilla-blkcg-print-blkgs \
ksym-vanilla-blkcg-punt-bio-submit \
ksym-vanilla-blkcg-root \
ksym-vanilla-blkcg-root-css \
ksym-vanilla-blkcg-set-fc-appid \
ksym-vanilla-blkdev-compat-ptr-ioctl \
ksym-vanilla-blkdev-get-zone-info \
ksym-vanilla-blkdev-issue-discard \
ksym-vanilla-blkdev-issue-flush \
ksym-vanilla-blkdev-issue-secure-erase \
ksym-vanilla-blkdev-issue-zeroout \
ksym-vanilla-blkdev-report-zones \
ksym-vanilla-blkdev-report-zones-cached \
ksym-vanilla-blkdev-zone-mgmt \
ksym-vanilla-blkg-conf-close-bdev \
ksym-vanilla-blkg-conf-init \
ksym-vanilla-blkg-conf-open-bdev \
ksym-vanilla-blkg-conf-prep \
ksym-vanilla-blkg-conf-unprep \
ksym-vanilla-blkg-prfill-rwstat \
ksym-vanilla-blkg-rwstat-exit \
ksym-vanilla-blkg-rwstat-init \
ksym-vanilla-blkg-rwstat-recursive-sum \
ksym-vanilla-block-commit-write \
ksym-vanilla-block-dirty-folio \
ksym-vanilla-block-invalidate-folio \
ksym-vanilla-block-is-partially-uptodate \
ksym-vanilla-block-page-mkwrite \
ksym-vanilla-block-pr-type-to-scsi \
ksym-vanilla-block-read-full-folio \
ksym-vanilla-block-size \
ksym-vanilla-block-truncate-page \
ksym-vanilla-block-write-begin \
ksym-vanilla-block-write-end \
ksym-vanilla-blockdev-superblock \
ksym-vanilla-blocking-notifier-call-chain \
ksym-vanilla-blocking-notifier-call-chain-robust \
ksym-vanilla-blocking-notifier-chain-register \
ksym-vanilla-blocking-notifier-chain-register-unique-prio \
ksym-vanilla-blocking-notifier-chain-unregister \
ksym-vanilla-blowfish-setkey \
ksym-vanilla-bma220-common-probe \
ksym-vanilla-bma220-i2c-regmap-config \
ksym-vanilla-bma220-pm-ops \
ksym-vanilla-bma220-spi-regmap-config \
ksym-vanilla-bma400-probe \
ksym-vanilla-bma400-regmap-config \
ksym-vanilla-bman-acquire \
ksym-vanilla-bman-free-pool \
ksym-vanilla-bman-get-bpid \
ksym-vanilla-bman-ip-rev \
ksym-vanilla-bman-is-probed \
ksym-vanilla-bman-new-pool \
ksym-vanilla-bman-portals-probed \
ksym-vanilla-bman-release \
ksym-vanilla-bmap \
ksym-vanilla-bmc150-accel-core-probe \
ksym-vanilla-bmc150-accel-core-remove \
ksym-vanilla-bmc150-accel-pm-ops \
ksym-vanilla-bmc150-regmap-conf \
ksym-vanilla-bme280-chip-info \
ksym-vanilla-bme280-regmap-config \
ksym-vanilla-bme680-core-probe \
ksym-vanilla-bme680-dev-pm-ops \
ksym-vanilla-bme680-regmap-config \
ksym-vanilla-bmi088-accel-core-probe \
ksym-vanilla-bmi088-accel-core-remove \
ksym-vanilla-bmi088-accel-pm-ops \
ksym-vanilla-bmi088-regmap-conf \
ksym-vanilla-bmi160-core-pm-ops \
ksym-vanilla-bmi160-core-probe \
ksym-vanilla-bmi160-enable-irq \
ksym-vanilla-bmi160-regmap-config \
ksym-vanilla-bmi260-chip-info \
ksym-vanilla-bmi270-chip-info \
ksym-vanilla-bmi270-core-pm-ops \
ksym-vanilla-bmi270-core-probe \
ksym-vanilla-bmi323-core-pm-ops \
ksym-vanilla-bmi323-core-probe \
ksym-vanilla-bmp085-chip-info \
ksym-vanilla-bmp180-chip-info \
ksym-vanilla-bmp180-regmap-config \
ksym-vanilla-bmp280-chip-info \
ksym-vanilla-bmp280-common-probe \
ksym-vanilla-bmp280-dev-pm-ops \
ksym-vanilla-bmp280-regmap-config \
ksym-vanilla-bmp380-chip-info \
ksym-vanilla-bmp380-regmap-config \
ksym-vanilla-bmp580-chip-info \
ksym-vanilla-bmp580-regmap-config \
ksym-vanilla-bnge-register-dev \
ksym-vanilla-bnge-send-msg \
ksym-vanilla-bnge-unregister-dev \
ksym-vanilla-bnxt-register-async-events \
ksym-vanilla-bnxt-register-dev \
ksym-vanilla-bnxt-send-msg \
ksym-vanilla-bnxt-unregister-dev \
ksym-vanilla-bpf-base-func-proto \
ksym-vanilla-bpf-crypto-register-type \
ksym-vanilla-bpf-crypto-unregister-type \
ksym-vanilla-bpf-dispatcher-xdp-func \
ksym-vanilla-bpf-empty-prog-array \
ksym-vanilla-bpf-event-output \
ksym-vanilla-bpf-fentry-test1 \
ksym-vanilla-bpf-find-btf-id \
ksym-vanilla-bpf-link-get-from-fd \
ksym-vanilla-bpf-link-inc-not-zero \
ksym-vanilla-bpf-link-put \
ksym-vanilla-bpf-log \
ksym-vanilla-bpf-map-get \
ksym-vanilla-bpf-map-inc \
ksym-vanilla-bpf-map-inc-not-zero \
ksym-vanilla-bpf-map-inc-with-uref \
ksym-vanilla-bpf-map-put \
ksym-vanilla-bpf-master-redirect-enabled-key \
ksym-vanilla-bpf-obj-name-cpy \
ksym-vanilla-bpf-offload-dev-create \
ksym-vanilla-bpf-offload-dev-destroy \
ksym-vanilla-bpf-offload-dev-match \
ksym-vanilla-bpf-offload-dev-netdev-register \
ksym-vanilla-bpf-offload-dev-netdev-unregister \
ksym-vanilla-bpf-offload-dev-priv \
ksym-vanilla-bpf-preload-ops \
ksym-vanilla-bpf-prog-add \
ksym-vanilla-bpf-prog-alloc \
ksym-vanilla-bpf-prog-create \
ksym-vanilla-bpf-prog-create-from-user \
ksym-vanilla-bpf-prog-destroy \
ksym-vanilla-bpf-prog-free \
ksym-vanilla-bpf-prog-get-assoc-struct-ops \
ksym-vanilla-bpf-prog-get-type-dev \
ksym-vanilla-bpf-prog-get-type-path \
ksym-vanilla-bpf-prog-inc \
ksym-vanilla-bpf-prog-inc-not-zero \
ksym-vanilla-bpf-prog-put \
ksym-vanilla-bpf-prog-select-runtime \
ksym-vanilla-bpf-prog-sub \
ksym-vanilla-bpf-sk-lookup-enabled \
ksym-vanilla-bpf-sk-storage-diag-alloc \
ksym-vanilla-bpf-sk-storage-diag-free \
ksym-vanilla-bpf-sk-storage-diag-put \
ksym-vanilla-bpf-stats-enabled-key \
ksym-vanilla-bpf-struct-ops-for-each-prog \
ksym-vanilla-bpf-struct-ops-get \
ksym-vanilla-bpf-struct-ops-id \
ksym-vanilla-bpf-struct-ops-put \
ksym-vanilla-bpf-trace-run1 \
ksym-vanilla-bpf-trace-run10 \
ksym-vanilla-bpf-trace-run11 \
ksym-vanilla-bpf-trace-run12 \
ksym-vanilla-bpf-trace-run2 \
ksym-vanilla-bpf-trace-run3 \
ksym-vanilla-bpf-trace-run4 \
ksym-vanilla-bpf-trace-run5 \
ksym-vanilla-bpf-trace-run6 \
ksym-vanilla-bpf-trace-run7 \
ksym-vanilla-bpf-trace-run8 \
ksym-vanilla-bpf-trace-run9 \
ksym-vanilla-bpf-verifier-log-write \
ksym-vanilla-bpf-warn-invalid-xdp-action \
ksym-vanilla-bprm-change-interp \
ksym-vanilla-bq27xxx-battery-battery-pm-ops \
ksym-vanilla-bq27xxx-battery-setup \
ksym-vanilla-bq27xxx-battery-teardown \
ksym-vanilla-bq27xxx-battery-update \
ksym-vanilla-br-dev-queue-push-xmit \
ksym-vanilla-br-fdb-clear-offload \
ksym-vanilla-br-fdb-find-port \
ksym-vanilla-br-forward \
ksym-vanilla-br-forward-finish \
ksym-vanilla-br-get-ageing-time \
ksym-vanilla-br-handle-frame-finish \
ksym-vanilla-br-ip6-fragment \
ksym-vanilla-br-mst-enabled \
ksym-vanilla-br-mst-get-info \
ksym-vanilla-br-mst-get-state \
ksym-vanilla-br-multicast-enabled \
ksym-vanilla-br-multicast-has-querier-adjacent \
ksym-vanilla-br-multicast-has-querier-anywhere \
ksym-vanilla-br-multicast-has-router-adjacent \
ksym-vanilla-br-multicast-list-adjacent \
ksym-vanilla-br-multicast-router \
ksym-vanilla-br-port-flag-is-set \
ksym-vanilla-br-port-get-stp-state \
ksym-vanilla-br-vlan-enabled \
ksym-vanilla-br-vlan-get-info \
ksym-vanilla-br-vlan-get-info-rcu \
ksym-vanilla-br-vlan-get-proto \
ksym-vanilla-br-vlan-get-pvid \
ksym-vanilla-br-vlan-get-pvid-rcu \
ksym-vanilla-brcmf-cfg80211-mgmt-tx \
ksym-vanilla-brcmf-fil-bsscfg-data-get \
ksym-vanilla-brcmf-fil-bsscfg-data-set \
ksym-vanilla-brcmf-fil-cmd-data-get \
ksym-vanilla-brcmf-fil-cmd-data-set \
ksym-vanilla-brcmf-fil-iovar-data-get \
ksym-vanilla-brcmf-fil-iovar-data-set \
ksym-vanilla-brcmf-fil-xtlv-data-get \
ksym-vanilla-brcmf-fil-xtlv-data-set \
ksym-vanilla-brcmf-fweh-event-name \
ksym-vanilla-brcmf-fweh-register \
ksym-vanilla-brcmf-fwvid-register-vendor \
ksym-vanilla-brcmf-fwvid-unregister-vendor \
ksym-vanilla-brcmf-set-wsec \
ksym-vanilla-brcmstb-get-family-id \
ksym-vanilla-brcmstb-get-product-id \
ksym-vanilla-brcmstb-pinctrl-probe \
ksym-vanilla-brcmu-boardrev-str \
ksym-vanilla-brcmu-d11-attach \
ksym-vanilla-brcmu-dotrev-str \
ksym-vanilla-brcmu-pkt-buf-free-skb \
ksym-vanilla-brcmu-pkt-buf-get-skb \
ksym-vanilla-brcmu-pktq-flush \
ksym-vanilla-brcmu-pktq-init \
ksym-vanilla-brcmu-pktq-mdeq \
ksym-vanilla-brcmu-pktq-mlen \
ksym-vanilla-brcmu-pktq-pdeq \
ksym-vanilla-brcmu-pktq-pdeq-match \
ksym-vanilla-brcmu-pktq-pdeq-tail \
ksym-vanilla-brcmu-pktq-peek-tail \
ksym-vanilla-brcmu-pktq-penq \
ksym-vanilla-brcmu-pktq-penq-head \
ksym-vanilla-brcmu-pktq-pflush \
ksym-vanilla-bridge-tunnel-header \
ksym-vanilla-brioctl-set \
ksym-vanilla-bsearch \
ksym-vanilla-bsg-job-done \
ksym-vanilla-bsg-job-get \
ksym-vanilla-bsg-job-put \
ksym-vanilla-bsg-register-queue \
ksym-vanilla-bsg-remove-queue \
ksym-vanilla-bsg-setup-queue \
ksym-vanilla-bsg-unregister-queue \
ksym-vanilla-bstr-printf \
ksym-vanilla-bt-accept-dequeue \
ksym-vanilla-bt-accept-enqueue \
ksym-vanilla-bt-accept-unlink \
ksym-vanilla-bt-debugfs \
ksym-vanilla-bt-err \
ksym-vanilla-bt-err-ratelimited \
ksym-vanilla-bt-info \
ksym-vanilla-bt-procfs-cleanup \
ksym-vanilla-bt-procfs-init \
ksym-vanilla-bt-sock-alloc \
ksym-vanilla-bt-sock-ioctl \
ksym-vanilla-bt-sock-link \
ksym-vanilla-bt-sock-linked \
ksym-vanilla-bt-sock-poll \
ksym-vanilla-bt-sock-reclassify-lock \
ksym-vanilla-bt-sock-recvmsg \
ksym-vanilla-bt-sock-register \
ksym-vanilla-bt-sock-stream-recvmsg \
ksym-vanilla-bt-sock-unlink \
ksym-vanilla-bt-sock-unregister \
ksym-vanilla-bt-sock-wait-ready \
ksym-vanilla-bt-sock-wait-state \
ksym-vanilla-bt-status \
ksym-vanilla-bt-to-errno \
ksym-vanilla-bt-warn \
ksym-vanilla-bt-warn-ratelimited \
ksym-vanilla-bt878 \
ksym-vanilla-bt878-device-control \
ksym-vanilla-bt878-num \
ksym-vanilla-bt878-start \
ksym-vanilla-bt878-stop \
ksym-vanilla-btbcm-check-bdaddr \
ksym-vanilla-btbcm-finalize \
ksym-vanilla-btbcm-initialize \
ksym-vanilla-btbcm-patchram \
ksym-vanilla-btbcm-read-pcm-int-params \
ksym-vanilla-btbcm-set-bdaddr \
ksym-vanilla-btbcm-setup-apple \
ksym-vanilla-btbcm-setup-patchram \
ksym-vanilla-btbcm-write-pcm-int-params \
ksym-vanilla-btf-ctx-access \
ksym-vanilla-btf-type-by-id \
ksym-vanilla-btintel-acpi-reset-method \
ksym-vanilla-btintel-bootloader-setup-tlv \
ksym-vanilla-btintel-bootup \
ksym-vanilla-btintel-check-bdaddr \
ksym-vanilla-btintel-configure-setup \
ksym-vanilla-btintel-download-firmware \
ksym-vanilla-btintel-enter-mfg \
ksym-vanilla-btintel-exit-mfg \
ksym-vanilla-btintel-guid-dsm \
ksym-vanilla-btintel-hw-error \
ksym-vanilla-btintel-load-ddc-config \
ksym-vanilla-btintel-parse-version-tlv \
ksym-vanilla-btintel-print-fseq-info \
ksym-vanilla-btintel-read-boot-params \
ksym-vanilla-btintel-read-version \
ksym-vanilla-btintel-recv-event \
ksym-vanilla-btintel-regmap-init \
ksym-vanilla-btintel-secure-send-result \
ksym-vanilla-btintel-send-intel-reset \
ksym-vanilla-btintel-set-bdaddr \
ksym-vanilla-btintel-set-diag \
ksym-vanilla-btintel-set-event-mask-mfg \
ksym-vanilla-btintel-set-msft-opcode \
ksym-vanilla-btintel-set-quality-report \
ksym-vanilla-btintel-shutdown-combined \
ksym-vanilla-btintel-version-info \
ksym-vanilla-btintel-version-info-tlv \
ksym-vanilla-btmrvl-add-card \
ksym-vanilla-btmrvl-check-evtpkt \
ksym-vanilla-btmrvl-enable-hs \
ksym-vanilla-btmrvl-enable-ps \
ksym-vanilla-btmrvl-interrupt \
ksym-vanilla-btmrvl-process-event \
ksym-vanilla-btmrvl-pscan-window-reporting \
ksym-vanilla-btmrvl-register-hdev \
ksym-vanilla-btmrvl-remove-card \
ksym-vanilla-btmrvl-send-hscfg-cmd \
ksym-vanilla-btmrvl-send-module-cfg-cmd \
ksym-vanilla-btmtk-fw-get-filename \
ksym-vanilla-btmtk-process-coredump \
ksym-vanilla-btmtk-recv-event \
ksym-vanilla-btmtk-register-coredump \
ksym-vanilla-btmtk-reset-sync \
ksym-vanilla-btmtk-set-bdaddr \
ksym-vanilla-btmtk-setup-firmware \
ksym-vanilla-btmtk-setup-firmware-79xx \
ksym-vanilla-btmtk-usb-recv-acl \
ksym-vanilla-btmtk-usb-resume \
ksym-vanilla-btmtk-usb-setup \
ksym-vanilla-btmtk-usb-shutdown \
ksym-vanilla-btmtk-usb-subsys-reset \
ksym-vanilla-btmtk-usb-suspend \
ksym-vanilla-btracker-complete \
ksym-vanilla-btracker-create \
ksym-vanilla-btracker-destroy \
ksym-vanilla-btracker-issue \
ksym-vanilla-btracker-nr-demotions-queued \
ksym-vanilla-btracker-promotion-already-present \
ksym-vanilla-btracker-queue \
ksym-vanilla-btree-alloc \
ksym-vanilla-btree-destroy \
ksym-vanilla-btree-free \
ksym-vanilla-btree-geo128 \
ksym-vanilla-btree-geo32 \
ksym-vanilla-btree-geo64 \
ksym-vanilla-btree-get-prev \
ksym-vanilla-btree-grim-visitor \
ksym-vanilla-btree-init \
ksym-vanilla-btree-init-mempool \
ksym-vanilla-btree-insert \
ksym-vanilla-btree-last \
ksym-vanilla-btree-lookup \
ksym-vanilla-btree-merge \
ksym-vanilla-btree-remove \
ksym-vanilla-btree-update \
ksym-vanilla-btree-visitor \
ksym-vanilla-btrtl-download-firmware \
ksym-vanilla-btrtl-free \
ksym-vanilla-btrtl-get-uart-settings \
ksym-vanilla-btrtl-initialize \
ksym-vanilla-btrtl-set-driver-name \
ksym-vanilla-btrtl-set-quirks \
ksym-vanilla-btrtl-setup-realtek \
ksym-vanilla-btrtl-shutdown-realtek \
ksym-vanilla-bttv-get-pcidev \
ksym-vanilla-bttv-gpio-enable \
ksym-vanilla-bttv-read-gpio \
ksym-vanilla-bttv-sub-register \
ksym-vanilla-bttv-sub-unregister \
ksym-vanilla-bttv-write-gpio \
ksym-vanilla-budget-debug \
ksym-vanilla-buffer-migrate-folio \
ksym-vanilla-buffer-migrate-folio-norefs \
ksym-vanilla-build-skb \
ksym-vanilla-build-skb-around \
ksym-vanilla-bus-0-clk \
ksym-vanilla-bus-1-clk \
ksym-vanilla-bus-2-clk \
ksym-vanilla-bus-create-file \
ksym-vanilla-bus-find-device \
ksym-vanilla-bus-find-device-reverse \
ksym-vanilla-bus-for-each-dev \
ksym-vanilla-bus-for-each-drv \
ksym-vanilla-bus-get-dev-root \
ksym-vanilla-bus-get-kset \
ksym-vanilla-bus-register \
ksym-vanilla-bus-register-notifier \
ksym-vanilla-bus-remove-file \
ksym-vanilla-bus-rescan-devices \
ksym-vanilla-bus-sort-breadthfirst \
ksym-vanilla-bus-unregister \
ksym-vanilla-bus-unregister-notifier \
ksym-vanilla-c-can-power-down \
ksym-vanilla-c-can-power-up \
ksym-vanilla-c2port-device-register \
ksym-vanilla-c2port-device-unregister \
ksym-vanilla-caam-blob-gen-exit \
ksym-vanilla-caam-blob-gen-init \
ksym-vanilla-caam-congested \
ksym-vanilla-caam-dpaa2 \
ksym-vanilla-caam-drv-ctx-init \
ksym-vanilla-caam-drv-ctx-rel \
ksym-vanilla-caam-drv-ctx-update \
ksym-vanilla-caam-dump-sg \
ksym-vanilla-caam-imx \
ksym-vanilla-caam-jr-alloc \
ksym-vanilla-caam-jr-enqueue \
ksym-vanilla-caam-jr-free \
ksym-vanilla-caam-little-end \
ksym-vanilla-caam-process-blob \
ksym-vanilla-caam-ptr-sz \
ksym-vanilla-caam-qi-enqueue \
ksym-vanilla-caam-strstatus \
ksym-vanilla-cache-check \
ksym-vanilla-cache-check-rcu \
ksym-vanilla-cache-coherency-ops-instance-put \
ksym-vanilla-cache-coherency-ops-instance-register \
ksym-vanilla-cache-coherency-ops-instance-unregister \
ksym-vanilla-cache-create-net \
ksym-vanilla-cache-destroy-net \
ksym-vanilla-cache-flush \
ksym-vanilla-cache-line-size \
ksym-vanilla-cache-purge \
ksym-vanilla-cache-register-net \
ksym-vanilla-cache-seq-next-rcu \
ksym-vanilla-cache-seq-start-rcu \
ksym-vanilla-cache-seq-stop-rcu \
ksym-vanilla-cache-unregister-net \
ksym-vanilla-caches-clean-inval-pou \
ksym-vanilla-cad-pid \
ksym-vanilla-call-blocking-lsm-notifier \
ksym-vanilla-call-fib-notifier \
ksym-vanilla-call-fib-notifiers \
ksym-vanilla-call-hid-bpf-rdesc-fixup \
ksym-vanilla-call-netdevice-notifiers \
ksym-vanilla-call-netevent-notifiers \
ksym-vanilla-call-rcu \
ksym-vanilla-call-rcu-tasks \
ksym-vanilla-call-srcu \
ksym-vanilla-call-switchdev-blocking-notifiers \
ksym-vanilla-call-switchdev-notifiers \
ksym-vanilla-call-usermodehelper \
ksym-vanilla-call-usermodehelper-exec \
ksym-vanilla-call-usermodehelper-setup \
ksym-vanilla-can-bus-off \
ksym-vanilla-can-change-state \
ksym-vanilla-can-do-mlock \
ksym-vanilla-can-dropped-invalid-skb \
ksym-vanilla-can-ethtool-op-get-ts-info-hwts \
ksym-vanilla-can-fd-dlc2len \
ksym-vanilla-can-fd-len2dlc \
ksym-vanilla-can-free-echo-skb \
ksym-vanilla-can-get-ctrlmode-str \
ksym-vanilla-can-get-echo-skb \
ksym-vanilla-can-get-state-str \
ksym-vanilla-can-hwtstamp-get \
ksym-vanilla-can-hwtstamp-set \
ksym-vanilla-can-proto-register \
ksym-vanilla-can-proto-unregister \
ksym-vanilla-can-put-echo-skb \
ksym-vanilla-can-rx-offload-add-fifo \
ksym-vanilla-can-rx-offload-add-manual \
ksym-vanilla-can-rx-offload-add-timestamp \
ksym-vanilla-can-rx-offload-del \
ksym-vanilla-can-rx-offload-enable \
ksym-vanilla-can-rx-offload-get-echo-skb-queue-tail \
ksym-vanilla-can-rx-offload-get-echo-skb-queue-timestamp \
ksym-vanilla-can-rx-offload-irq-finish \
ksym-vanilla-can-rx-offload-irq-offload-fifo \
ksym-vanilla-can-rx-offload-irq-offload-timestamp \
ksym-vanilla-can-rx-offload-queue-tail \
ksym-vanilla-can-rx-offload-queue-timestamp \
ksym-vanilla-can-rx-offload-threaded-irq-finish \
ksym-vanilla-can-rx-register \
ksym-vanilla-can-rx-unregister \
ksym-vanilla-can-send \
ksym-vanilla-can-set-skb-uid \
ksym-vanilla-can-set-static-ctrlmode \
ksym-vanilla-can-skb-get-frame-len \
ksym-vanilla-can-sock-destruct \
ksym-vanilla-can-state-get-by-berr-counter \
ksym-vanilla-cancel-delayed-work \
ksym-vanilla-cancel-delayed-work-sync \
ksym-vanilla-cancel-work \
ksym-vanilla-cancel-work-sync \
ksym-vanilla-capable \
ksym-vanilla-capable-wrt-inode-uidgid \
ksym-vanilla-capacity-freq-ref \
ksym-vanilla-cast-s1 \
ksym-vanilla-cast-s2 \
ksym-vanilla-cast-s3 \
ksym-vanilla-cast-s4 \
ksym-vanilla-cast5-setkey \
ksym-vanilla-cast6-setkey \
ksym-vanilla-cavium-mdiobus-read-c22 \
ksym-vanilla-cavium-mdiobus-read-c45 \
ksym-vanilla-cavium-mdiobus-write-c22 \
ksym-vanilla-cavium-mdiobus-write-c45 \
ksym-vanilla-cavium-ptp-get \
ksym-vanilla-cavium-ptp-put \
ksym-vanilla-cb710-pci-update-config-reg \
ksym-vanilla-cb710-set-irq-handler \
ksym-vanilla-cb710-sg-dwiter-read-next-block \
ksym-vanilla-cb710-sg-dwiter-write-next-block \
ksym-vanilla-cc-platform-has \
ksym-vanilla-cci-multi-reg-write \
ksym-vanilla-cci-probed \
ksym-vanilla-cci-read \
ksym-vanilla-cci-update-bits \
ksym-vanilla-cci-write \
ksym-vanilla-ccp-enqueue-cmd \
ksym-vanilla-ccp-present \
ksym-vanilla-ccp-version \
ksym-vanilla-ccs-pll-calculate \
ksym-vanilla-ccu-div-ops \
ksym-vanilla-ccu-frac-helper-disable \
ksym-vanilla-ccu-frac-helper-enable \
ksym-vanilla-ccu-frac-helper-has-rate \
ksym-vanilla-ccu-frac-helper-is-enabled \
ksym-vanilla-ccu-frac-helper-read-rate \
ksym-vanilla-ccu-frac-helper-set-rate \
ksym-vanilla-ccu-gate-helper-disable \
ksym-vanilla-ccu-gate-helper-enable \
ksym-vanilla-ccu-gate-helper-is-enabled \
ksym-vanilla-ccu-gate-ops \
ksym-vanilla-ccu-helper-wait-for-lock \
ksym-vanilla-ccu-is-better-rate \
ksym-vanilla-ccu-mp-mmc-ops \
ksym-vanilla-ccu-mp-ops \
ksym-vanilla-ccu-mult-ops \
ksym-vanilla-ccu-mux-helper-apply-prediv \
ksym-vanilla-ccu-mux-helper-determine-rate \
ksym-vanilla-ccu-mux-helper-get-parent \
ksym-vanilla-ccu-mux-helper-set-parent \
ksym-vanilla-ccu-mux-notifier-register \
ksym-vanilla-ccu-mux-ops \
ksym-vanilla-ccu-nk-ops \
ksym-vanilla-ccu-nkm-ops \
ksym-vanilla-ccu-nkmp-ops \
ksym-vanilla-ccu-nm-ops \
ksym-vanilla-ccu-phase-ops \
ksym-vanilla-ccu-pll-notifier-register \
ksym-vanilla-ccu-reset-ops \
ksym-vanilla-ccu-sdm-helper-disable \
ksym-vanilla-ccu-sdm-helper-enable \
ksym-vanilla-ccu-sdm-helper-get-factors \
ksym-vanilla-ccu-sdm-helper-has-rate \
ksym-vanilla-ccu-sdm-helper-is-enabled \
ksym-vanilla-ccu-sdm-helper-read-rate \
ksym-vanilla-cdat-table-parse \
ksym-vanilla-cdc-ncm-bind-common \
ksym-vanilla-cdc-ncm-change-mtu \
ksym-vanilla-cdc-ncm-fill-tx-frame \
ksym-vanilla-cdc-ncm-rx-fixup \
ksym-vanilla-cdc-ncm-rx-verify-ndp16 \
ksym-vanilla-cdc-ncm-rx-verify-ndp32 \
ksym-vanilla-cdc-ncm-rx-verify-nth16 \
ksym-vanilla-cdc-ncm-rx-verify-nth32 \
ksym-vanilla-cdc-ncm-select-altsetting \
ksym-vanilla-cdc-ncm-tx-fixup \
ksym-vanilla-cdc-ncm-unbind \
ksym-vanilla-cdc-parse-cdc-header \
ksym-vanilla-cdev-add \
ksym-vanilla-cdev-alloc \
ksym-vanilla-cdev-del \
ksym-vanilla-cdev-device-add \
ksym-vanilla-cdev-device-del \
ksym-vanilla-cdev-init \
ksym-vanilla-cdev-set-parent \
ksym-vanilla-cdns-clear-vbus \
ksym-vanilla-cdns-core-init-role \
ksym-vanilla-cdns-csi2rx-negotiate-ppc \
ksym-vanilla-cdns-drd-gadget-off \
ksym-vanilla-cdns-drd-gadget-on \
ksym-vanilla-cdns-init \
ksym-vanilla-cdns-pci-map-bus \
ksym-vanilla-cdns-pcie-detect-quiet-min-delay-set \
ksym-vanilla-cdns-pcie-disable-phy \
ksym-vanilla-cdns-pcie-enable-phy \
ksym-vanilla-cdns-pcie-ep-disable \
ksym-vanilla-cdns-pcie-ep-setup \
ksym-vanilla-cdns-pcie-find-capability \
ksym-vanilla-cdns-pcie-find-ext-capability \
ksym-vanilla-cdns-pcie-host-disable \
ksym-vanilla-cdns-pcie-host-dma-ranges-cmp \
ksym-vanilla-cdns-pcie-host-find-max-bar \
ksym-vanilla-cdns-pcie-host-find-min-bar \
ksym-vanilla-cdns-pcie-host-init \
ksym-vanilla-cdns-pcie-host-link-setup \
ksym-vanilla-cdns-pcie-host-setup \
ksym-vanilla-cdns-pcie-host-start-link \
ksym-vanilla-cdns-pcie-host-training-complete \
ksym-vanilla-cdns-pcie-host-wait-for-link \
ksym-vanilla-cdns-pcie-hpa-detect-quiet-min-delay-set \
ksym-vanilla-cdns-pcie-hpa-host-link-setup \
ksym-vanilla-cdns-pcie-hpa-host-setup \
ksym-vanilla-cdns-pcie-hpa-link-up \
ksym-vanilla-cdns-pcie-hpa-set-outbound-region \
ksym-vanilla-cdns-pcie-hpa-set-outbound-region-for-normal-msg \
ksym-vanilla-cdns-pcie-init-phy \
ksym-vanilla-cdns-pcie-linkup \
ksym-vanilla-cdns-pcie-pm-ops \
ksym-vanilla-cdns-pcie-reset-outbound-region \
ksym-vanilla-cdns-pcie-retrain \
ksym-vanilla-cdns-pcie-set-outbound-region \
ksym-vanilla-cdns-pcie-set-outbound-region-for-normal-msg \
ksym-vanilla-cdns-power-is-lost \
ksym-vanilla-cdns-remove \
ksym-vanilla-cdns-resume \
ksym-vanilla-cdns-set-active \
ksym-vanilla-cdns-set-vbus \
ksym-vanilla-cdns-suspend \
ksym-vanilla-cdns3-gadget-init \
ksym-vanilla-cdnsp-gadget-init \
ksym-vanilla-cdrom-check-events \
ksym-vanilla-cdrom-dummy-generic-packet \
ksym-vanilla-cdrom-get-last-written \
ksym-vanilla-cdrom-get-media-event \
ksym-vanilla-cdrom-ioctl \
ksym-vanilla-cdrom-mode-select \
ksym-vanilla-cdrom-mode-sense \
ksym-vanilla-cdrom-multisession \
ksym-vanilla-cdrom-number-of-slots \
ksym-vanilla-cdrom-open \
ksym-vanilla-cdrom-probe-write-features \
ksym-vanilla-cdrom-read-tocentry \
ksym-vanilla-cdrom-release \
ksym-vanilla-cdx-bus-add \
ksym-vanilla-cdx-bus-type \
ksym-vanilla-cdx-clear-master \
ksym-vanilla-cdx-dev-reset \
ksym-vanilla-cdx-device-add \
ksym-vanilla-cdx-disable-msi \
ksym-vanilla-cdx-driver-unregister \
ksym-vanilla-cdx-enable-msi \
ksym-vanilla-cdx-mcdi-finish \
ksym-vanilla-cdx-mcdi-init \
ksym-vanilla-cdx-mcdi-process-cmd \
ksym-vanilla-cdx-mcdi-rpc \
ksym-vanilla-cdx-msi-domain-init \
ksym-vanilla-cdx-register-controller \
ksym-vanilla-cdx-set-master \
ksym-vanilla-cdx-unregister-controller \
ksym-vanilla-ce-aes-cbc-cts-decrypt \
ksym-vanilla-ce-aes-cbc-cts-encrypt \
ksym-vanilla-ce-aes-cbc-decrypt \
ksym-vanilla-ce-aes-cbc-encrypt \
ksym-vanilla-ce-aes-ctr-encrypt \
ksym-vanilla-ce-aes-ecb-decrypt \
ksym-vanilla-ce-aes-ecb-encrypt \
ksym-vanilla-ce-aes-essiv-cbc-decrypt \
ksym-vanilla-ce-aes-essiv-cbc-encrypt \
ksym-vanilla-ce-aes-expandkey \
ksym-vanilla-ce-aes-mac-update \
ksym-vanilla-ce-aes-xctr-encrypt \
ksym-vanilla-ce-aes-xts-decrypt \
ksym-vanilla-ce-aes-xts-encrypt \
ksym-vanilla-cec-allocate-adapter \
ksym-vanilla-cec-delete-adapter \
ksym-vanilla-cec-fill-conn-info-from-drm \
ksym-vanilla-cec-get-edid-phys-addr \
ksym-vanilla-cec-notifier-cec-adap-register \
ksym-vanilla-cec-notifier-cec-adap-unregister \
ksym-vanilla-cec-notifier-conn-register \
ksym-vanilla-cec-notifier-conn-unregister \
ksym-vanilla-cec-notifier-parse-hdmi-phandle \
ksym-vanilla-cec-notifier-set-phys-addr \
ksym-vanilla-cec-notifier-set-phys-addr-from-edid \
ksym-vanilla-cec-pin-allocate-adapter \
ksym-vanilla-cec-pin-changed \
ksym-vanilla-cec-queue-pin-5v-event \
ksym-vanilla-cec-queue-pin-cec-event \
ksym-vanilla-cec-queue-pin-hpd-event \
ksym-vanilla-cec-received-msg-ts \
ksym-vanilla-cec-register-adapter \
ksym-vanilla-cec-s-conn-info \
ksym-vanilla-cec-s-log-addrs \
ksym-vanilla-cec-s-phys-addr \
ksym-vanilla-cec-s-phys-addr-from-edid \
ksym-vanilla-cec-transmit-attempt-done-ts \
ksym-vanilla-cec-transmit-done-ts \
ksym-vanilla-cec-transmit-msg \
ksym-vanilla-cec-unregister-adapter \
ksym-vanilla-ceph-addr-is-blank \
ksym-vanilla-ceph-alloc-options \
ksym-vanilla-ceph-alloc-page-vector \
ksym-vanilla-ceph-auth-add-authorizer-challenge \
ksym-vanilla-ceph-auth-destroy-authorizer \
ksym-vanilla-ceph-auth-get-authorizer \
ksym-vanilla-ceph-auth-handle-bad-authorizer \
ksym-vanilla-ceph-auth-handle-svc-reply-done \
ksym-vanilla-ceph-auth-handle-svc-reply-more \
ksym-vanilla-ceph-auth-invalidate-authorizer \
ksym-vanilla-ceph-auth-is-authenticated \
ksym-vanilla-ceph-auth-verify-authorizer-reply \
ksym-vanilla-ceph-buffer-new \
ksym-vanilla-ceph-buffer-release \
ksym-vanilla-ceph-calc-file-object-mapping \
ksym-vanilla-ceph-check-fsid \
ksym-vanilla-ceph-client-addr \
ksym-vanilla-ceph-client-gid \
ksym-vanilla-ceph-cls-assert-locked \
ksym-vanilla-ceph-cls-break-lock \
ksym-vanilla-ceph-cls-lock \
ksym-vanilla-ceph-cls-lock-info \
ksym-vanilla-ceph-cls-set-cookie \
ksym-vanilla-ceph-cls-unlock \
ksym-vanilla-ceph-compare-options \
ksym-vanilla-ceph-con-close \
ksym-vanilla-ceph-con-init \
ksym-vanilla-ceph-con-keepalive \
ksym-vanilla-ceph-con-open \
ksym-vanilla-ceph-con-send \
ksym-vanilla-ceph-copy-from-page-vector \
ksym-vanilla-ceph-create-client \
ksym-vanilla-ceph-create-snap-context \
ksym-vanilla-ceph-decode-entity-addr \
ksym-vanilla-ceph-decode-entity-addrvec \
ksym-vanilla-ceph-destroy-client \
ksym-vanilla-ceph-destroy-options \
ksym-vanilla-ceph-entity-type-name \
ksym-vanilla-ceph-extent-to-file \
ksym-vanilla-ceph-file-to-extents \
ksym-vanilla-ceph-find-or-create-string \
ksym-vanilla-ceph-free-lockers \
ksym-vanilla-ceph-get-num-objects \
ksym-vanilla-ceph-get-snap-context \
ksym-vanilla-ceph-iterate-extents \
ksym-vanilla-ceph-monc-blocklist-add \
ksym-vanilla-ceph-monc-do-statfs \
ksym-vanilla-ceph-monc-get-version \
ksym-vanilla-ceph-monc-get-version-async \
ksym-vanilla-ceph-monc-got-map \
ksym-vanilla-ceph-monc-init \
ksym-vanilla-ceph-monc-open-session \
ksym-vanilla-ceph-monc-renew-subs \
ksym-vanilla-ceph-monc-stop \
ksym-vanilla-ceph-monc-validate-auth \
ksym-vanilla-ceph-monc-wait-osdmap \
ksym-vanilla-ceph-monc-want-map \
ksym-vanilla-ceph-msg-data-add-bio \
ksym-vanilla-ceph-msg-data-add-bvecs \
ksym-vanilla-ceph-msg-data-add-pagelist \
ksym-vanilla-ceph-msg-data-add-pages \
ksym-vanilla-ceph-msg-dump \
ksym-vanilla-ceph-msg-get \
ksym-vanilla-ceph-msg-new \
ksym-vanilla-ceph-msg-new2 \
ksym-vanilla-ceph-msg-put \
ksym-vanilla-ceph-msg-type-name \
ksym-vanilla-ceph-msgr-flush \
ksym-vanilla-ceph-object-locator-to-pg \
ksym-vanilla-ceph-oid-aprintf \
ksym-vanilla-ceph-oid-copy \
ksym-vanilla-ceph-oid-destroy \
ksym-vanilla-ceph-oid-printf \
ksym-vanilla-ceph-oloc-copy \
ksym-vanilla-ceph-oloc-destroy \
ksym-vanilla-ceph-open-session \
ksym-vanilla-ceph-osdc-abort-requests \
ksym-vanilla-ceph-osdc-alloc-messages \
ksym-vanilla-ceph-osdc-alloc-request \
ksym-vanilla-ceph-osdc-call \
ksym-vanilla-ceph-osdc-cancel-request \
ksym-vanilla-ceph-osdc-clear-abort-err \
ksym-vanilla-ceph-osdc-flush-notifies \
ksym-vanilla-ceph-osdc-get-request \
ksym-vanilla-ceph-osdc-list-watchers \
ksym-vanilla-ceph-osdc-maybe-request-map \
ksym-vanilla-ceph-osdc-new-request \
ksym-vanilla-ceph-osdc-notify \
ksym-vanilla-ceph-osdc-notify-ack \
ksym-vanilla-ceph-osdc-put-request \
ksym-vanilla-ceph-osdc-start-request \
ksym-vanilla-ceph-osdc-sync \
ksym-vanilla-ceph-osdc-unwatch \
ksym-vanilla-ceph-osdc-update-epoch-barrier \
ksym-vanilla-ceph-osdc-wait-request \
ksym-vanilla-ceph-osdc-watch \
ksym-vanilla-ceph-pagelist-alloc \
ksym-vanilla-ceph-pagelist-append \
ksym-vanilla-ceph-pagelist-free-reserve \
ksym-vanilla-ceph-pagelist-release \
ksym-vanilla-ceph-pagelist-reserve \
ksym-vanilla-ceph-parse-fsid \
ksym-vanilla-ceph-parse-mon-ips \
ksym-vanilla-ceph-parse-param \
ksym-vanilla-ceph-pg-pool-flags \
ksym-vanilla-ceph-pg-pool-name-by-id \
ksym-vanilla-ceph-pg-poolid-by-name \
ksym-vanilla-ceph-pg-to-acting-primary \
ksym-vanilla-ceph-pr-addr \
ksym-vanilla-ceph-print-client-options \
ksym-vanilla-ceph-put-page-vector \
ksym-vanilla-ceph-put-snap-context \
ksym-vanilla-ceph-release-page-vector \
ksym-vanilla-ceph-release-string \
ksym-vanilla-ceph-reset-client-addr \
ksym-vanilla-ceph-str-hash \
ksym-vanilla-ceph-str-hash-name \
ksym-vanilla-ceph-wait-for-latest-osdmap \
ksym-vanilla-ceph-zero-page-vector-range \
ksym-vanilla-cfb-copyarea \
ksym-vanilla-cfb-fillrect \
ksym-vanilla-cfb-imageblit \
ksym-vanilla-cfg80211-any-usable-channels \
ksym-vanilla-cfg80211-assoc-comeback \
ksym-vanilla-cfg80211-assoc-failure \
ksym-vanilla-cfg80211-auth-timeout \
ksym-vanilla-cfg80211-background-cac-abort \
ksym-vanilla-cfg80211-bss-color-notify \
ksym-vanilla-cfg80211-bss-flush \
ksym-vanilla-cfg80211-bss-iter \
ksym-vanilla-cfg80211-cac-event \
ksym-vanilla-cfg80211-calculate-bitrate \
ksym-vanilla-cfg80211-ch-switch-notify \
ksym-vanilla-cfg80211-ch-switch-started-notify \
ksym-vanilla-cfg80211-chandef-add-dbe \
ksym-vanilla-cfg80211-chandef-add-npca \
ksym-vanilla-cfg80211-chandef-compatible \
ksym-vanilla-cfg80211-chandef-create \
ksym-vanilla-cfg80211-chandef-dfs-cac-time \
ksym-vanilla-cfg80211-chandef-dfs-required \
ksym-vanilla-cfg80211-chandef-dfs-usable \
ksym-vanilla-cfg80211-chandef-npca-valid \
ksym-vanilla-cfg80211-chandef-primary \
ksym-vanilla-cfg80211-chandef-usable \
ksym-vanilla-cfg80211-chandef-valid \
ksym-vanilla-cfg80211-check-combinations \
ksym-vanilla-cfg80211-check-station-change \
ksym-vanilla-cfg80211-classify8021d \
ksym-vanilla-cfg80211-conn-failed \
ksym-vanilla-cfg80211-connect-done \
ksym-vanilla-cfg80211-control-port-tx-status \
ksym-vanilla-cfg80211-cqm-beacon-loss-notify \
ksym-vanilla-cfg80211-cqm-pktloss-notify \
ksym-vanilla-cfg80211-cqm-rssi-notify \
ksym-vanilla-cfg80211-cqm-txe-notify \
ksym-vanilla-cfg80211-crit-proto-stopped \
ksym-vanilla-cfg80211-defragment-element \
ksym-vanilla-cfg80211-del-sta-sinfo \
ksym-vanilla-cfg80211-disconnected \
ksym-vanilla-cfg80211-epcs-changed \
ksym-vanilla-cfg80211-external-auth-request \
ksym-vanilla-cfg80211-find-elem-match \
ksym-vanilla-cfg80211-find-vendor-elem \
ksym-vanilla-cfg80211-free-nan-func \
ksym-vanilla-cfg80211-ft-event \
ksym-vanilla-cfg80211-get-drvinfo \
ksym-vanilla-cfg80211-get-ies-channel-number \
ksym-vanilla-cfg80211-get-iftype-ext-capa \
ksym-vanilla-cfg80211-get-p2p-attr \
ksym-vanilla-cfg80211-get-radio-idx-by-chan \
ksym-vanilla-cfg80211-get-station \
ksym-vanilla-cfg80211-gtk-rekey-notify \
ksym-vanilla-cfg80211-ibss-joined \
ksym-vanilla-cfg80211-iftype-allowed \
ksym-vanilla-cfg80211-incumbent-signal-notify \
ksym-vanilla-cfg80211-inform-bss-data \
ksym-vanilla-cfg80211-inform-bss-frame-data \
ksym-vanilla-cfg80211-is-element-inherited \
ksym-vanilla-cfg80211-iter-combinations \
ksym-vanilla-cfg80211-iter-rnr \
ksym-vanilla-cfg80211-link-sinfo-alloc-tid-stats \
ksym-vanilla-cfg80211-links-removed \
ksym-vanilla-cfg80211-merge-profile \
ksym-vanilla-cfg80211-mgmt-tx-status-ext \
ksym-vanilla-cfg80211-michael-mic-failure \
ksym-vanilla-cfg80211-mlo-reconf-add-done \
ksym-vanilla-cfg80211-nan-channel-evac \
ksym-vanilla-cfg80211-nan-cluster-joined \
ksym-vanilla-cfg80211-nan-func-terminated \
ksym-vanilla-cfg80211-nan-match \
ksym-vanilla-cfg80211-nan-sched-update-done \
ksym-vanilla-cfg80211-nan-ulw-update \
ksym-vanilla-cfg80211-new-sta \
ksym-vanilla-cfg80211-next-nan-dw-notif \
ksym-vanilla-cfg80211-notify-new-peer-candidate \
ksym-vanilla-cfg80211-pmksa-candidate-notify \
ksym-vanilla-cfg80211-pmsr-complete \
ksym-vanilla-cfg80211-pmsr-report \
ksym-vanilla-cfg80211-port-authorized \
ksym-vanilla-cfg80211-probe-status \
ksym-vanilla-cfg80211-put-bss \
ksym-vanilla-cfg80211-radio-chandef-valid \
ksym-vanilla-cfg80211-ready-on-channel \
ksym-vanilla-cfg80211-ref-bss \
ksym-vanilla-cfg80211-reg-check-beaconing \
ksym-vanilla-cfg80211-register-netdevice \
ksym-vanilla-cfg80211-remain-on-channel-expired \
ksym-vanilla-cfg80211-report-obss-beacon-khz \
ksym-vanilla-cfg80211-report-wowlan-wakeup \
ksym-vanilla-cfg80211-roamed \
ksym-vanilla-cfg80211-rx-assoc-resp \
ksym-vanilla-cfg80211-rx-control-port \
ksym-vanilla-cfg80211-rx-mgmt-ext \
ksym-vanilla-cfg80211-rx-mlme-mgmt \
ksym-vanilla-cfg80211-rx-spurious-frame \
ksym-vanilla-cfg80211-rx-unexpected-4addr-frame \
ksym-vanilla-cfg80211-rx-unprot-mlme-mgmt \
ksym-vanilla-cfg80211-scan-done \
ksym-vanilla-cfg80211-sched-scan-results \
ksym-vanilla-cfg80211-sched-scan-stopped \
ksym-vanilla-cfg80211-sched-scan-stopped-locked \
ksym-vanilla-cfg80211-schedule-channels-check \
ksym-vanilla-cfg80211-send-layer2-update \
ksym-vanilla-cfg80211-shutdown-all-interfaces \
ksym-vanilla-cfg80211-sinfo-alloc-tid-stats \
ksym-vanilla-cfg80211-sta-opmode-change-notify \
ksym-vanilla-cfg80211-stop-link \
ksym-vanilla-cfg80211-tdls-oper-request \
ksym-vanilla-cfg80211-tx-mgmt-expired \
ksym-vanilla-cfg80211-tx-mlme-mgmt \
ksym-vanilla-cfg80211-unlink-bss \
ksym-vanilla-cfg80211-unregister-wdev \
ksym-vanilla-cfg80211-update-owe-info-event \
ksym-vanilla-cfg80211-vendor-cmd-get-sender \
ksym-vanilla-cfg80211-vendor-cmd-reply \
ksym-vanilla-cfg80211-wdev-channel-allowed \
ksym-vanilla-cfg802154-device-is-child \
ksym-vanilla-cfg802154-device-is-parent \
ksym-vanilla-cfg802154-get-free-short-addr \
ksym-vanilla-cfg802154-set-max-associations \
ksym-vanilla-cfi-build-cmd \
ksym-vanilla-cfi-build-cmd-addr \
ksym-vanilla-cfi-cmdset-0001 \
ksym-vanilla-cfi-cmdset-0002 \
ksym-vanilla-cfi-cmdset-0003 \
ksym-vanilla-cfi-cmdset-0006 \
ksym-vanilla-cfi-cmdset-0020 \
ksym-vanilla-cfi-cmdset-0200 \
ksym-vanilla-cfi-cmdset-0701 \
ksym-vanilla-cfi-fixup \
ksym-vanilla-cfi-merge-status \
ksym-vanilla-cfi-qry-mode-off \
ksym-vanilla-cfi-qry-mode-on \
ksym-vanilla-cfi-qry-present \
ksym-vanilla-cfi-read-pri \
ksym-vanilla-cfi-send-gen-cmd \
ksym-vanilla-cfi-udelay \
ksym-vanilla-cfi-varsize-frob \
ksym-vanilla-cg-regs-dummy \
ksym-vanilla-cgroup-attach-task-all \
ksym-vanilla-cgroup-bpf-enabled-key \
ksym-vanilla-cgroup-file-notify \
ksym-vanilla-cgroup-get-e-css \
ksym-vanilla-cgroup-get-from-fd \
ksym-vanilla-cgroup-get-from-id \
ksym-vanilla-cgroup-get-from-path \
ksym-vanilla-cgroup-path-ns \
ksym-vanilla-cgrp-dfl-root \
ksym-vanilla-chacha-block-generic \
ksym-vanilla-chacha-crypt \
ksym-vanilla-chacha20poly1305-decrypt \
ksym-vanilla-chacha20poly1305-decrypt-sg-inplace \
ksym-vanilla-chacha20poly1305-encrypt \
ksym-vanilla-chacha20poly1305-encrypt-sg-inplace \
ksym-vanilla-channel5g \
ksym-vanilla-channel5g-80m \
ksym-vanilla-charlcd-alloc \
ksym-vanilla-charlcd-backlight \
ksym-vanilla-charlcd-free \
ksym-vanilla-charlcd-poke \
ksym-vanilla-charlcd-register \
ksym-vanilla-charlcd-unregister \
ksym-vanilla-check-hw-ready \
ksym-vanilla-check-move-unevictable-folios \
ksym-vanilla-check-signature \
ksym-vanilla-check-zeroed-user \
ksym-vanilla-ci-hdrc-add-device \
ksym-vanilla-ci-hdrc-query-available-role \
ksym-vanilla-ci-hdrc-remove-device \
ksym-vanilla-cifs-md4-final \
ksym-vanilla-cifs-md4-init \
ksym-vanilla-cifs-md4-update \
ksym-vanilla-cirrus-scodec-get-speaker-id \
ksym-vanilla-class-compat-create-link \
ksym-vanilla-class-compat-register \
ksym-vanilla-class-compat-remove-link \
ksym-vanilla-class-compat-unregister \
ksym-vanilla-class-create \
ksym-vanilla-class-create-file-ns \
ksym-vanilla-class-destroy \
ksym-vanilla-class-dev-iter-exit \
ksym-vanilla-class-dev-iter-init \
ksym-vanilla-class-dev-iter-next \
ksym-vanilla-class-find-device \
ksym-vanilla-class-for-each-device \
ksym-vanilla-class-interface-register \
ksym-vanilla-class-interface-unregister \
ksym-vanilla-class-is-registered \
ksym-vanilla-class-register \
ksym-vanilla-class-remove-file-ns \
ksym-vanilla-class-unregister \
ksym-vanilla-clean-acked-data-disable \
ksym-vanilla-clean-acked-data-enable \
ksym-vanilla-clean-acked-data-flush \
ksym-vanilla-clean-bdev-aliases \
ksym-vanilla-clean-card-reference \
ksym-vanilla-clean-record-shared-mapping-range \
ksym-vanilla-cleanup-rx-oom-poll-fn \
ksym-vanilla-cleanup-srcu-struct \
ksym-vanilla-clear-exclusive-cxl-commands \
ksym-vanilla-clear-inode \
ksym-vanilla-clear-nlink \
ksym-vanilla-clear-node-memory-type \
ksym-vanilla-clear-page \
ksym-vanilla-clear-page-dirty-for-io \
ksym-vanilla-clear-selection \
ksym-vanilla-clk-add-alias \
ksym-vanilla-clk-agera-pll-configure \
ksym-vanilla-clk-alpha-pll-agera-ops \
ksym-vanilla-clk-alpha-pll-configure \
ksym-vanilla-clk-alpha-pll-fabia-ops \
ksym-vanilla-clk-alpha-pll-fixed-fabia-ops \
ksym-vanilla-clk-alpha-pll-fixed-lucid-5lpe-ops \
ksym-vanilla-clk-alpha-pll-fixed-lucid-evo-ops \
ksym-vanilla-clk-alpha-pll-fixed-ops \
ksym-vanilla-clk-alpha-pll-fixed-trion-ops \
ksym-vanilla-clk-alpha-pll-huayra-ops \
ksym-vanilla-clk-alpha-pll-hwfsm-ops \
ksym-vanilla-clk-alpha-pll-lucid-5lpe-ops \
ksym-vanilla-clk-alpha-pll-lucid-evo-ops \
ksym-vanilla-clk-alpha-pll-lucid-ops \
ksym-vanilla-clk-alpha-pll-ops \
ksym-vanilla-clk-alpha-pll-pongo-elu-ops \
ksym-vanilla-clk-alpha-pll-postdiv-fabia-ops \
ksym-vanilla-clk-alpha-pll-postdiv-lucid-5lpe-ops \
ksym-vanilla-clk-alpha-pll-postdiv-lucid-evo-ops \
ksym-vanilla-clk-alpha-pll-postdiv-lucid-ops \
ksym-vanilla-clk-alpha-pll-postdiv-ops \
ksym-vanilla-clk-alpha-pll-postdiv-ro-ops \
ksym-vanilla-clk-alpha-pll-postdiv-trion-ops \
ksym-vanilla-clk-alpha-pll-regera-ops \
ksym-vanilla-clk-alpha-pll-regs \
ksym-vanilla-clk-alpha-pll-reset-lucid-evo-ops \
ksym-vanilla-clk-alpha-pll-rivian-evo-ops \
ksym-vanilla-clk-alpha-pll-slew-ops \
ksym-vanilla-clk-alpha-pll-stromer-ops \
ksym-vanilla-clk-alpha-pll-stromer-plus-ops \
ksym-vanilla-clk-alpha-pll-trion-ops \
ksym-vanilla-clk-alpha-pll-zonda-ops \
ksym-vanilla-clk-branch-ops \
ksym-vanilla-clk-branch-simple-ops \
ksym-vanilla-clk-branch2-aon-ops \
ksym-vanilla-clk-branch2-mem-ops \
ksym-vanilla-clk-branch2-ops \
ksym-vanilla-clk-branch2-prepare-ops \
ksym-vanilla-clk-bulk-disable \
ksym-vanilla-clk-bulk-enable \
ksym-vanilla-clk-bulk-get \
ksym-vanilla-clk-bulk-get-all \
ksym-vanilla-clk-bulk-get-optional \
ksym-vanilla-clk-bulk-prepare \
ksym-vanilla-clk-bulk-put \
ksym-vanilla-clk-bulk-put-all \
ksym-vanilla-clk-bulk-unprepare \
ksym-vanilla-clk-byte-ops \
ksym-vanilla-clk-byte2-ops \
ksym-vanilla-clk-disable \
ksym-vanilla-clk-disable-regmap \
ksym-vanilla-clk-divider-ops \
ksym-vanilla-clk-divider-ro-ops \
ksym-vanilla-clk-dp-ops \
ksym-vanilla-clk-dyn-rcg-ops \
ksym-vanilla-clk-edp-pixel-ops \
ksym-vanilla-clk-enable \
ksym-vanilla-clk-enable-regmap \
ksym-vanilla-clk-fabia-pll-configure \
ksym-vanilla-clk-fixed-factor-ops \
ksym-vanilla-clk-fixed-rate-ops \
ksym-vanilla-clk-fractional-divider-general-approximation \
ksym-vanilla-clk-fractional-divider-ops \
ksym-vanilla-clk-gate-is-enabled \
ksym-vanilla-clk-gate-ops \
ksym-vanilla-clk-gate-restore-context \
ksym-vanilla-clk-get \
ksym-vanilla-clk-get-accuracy \
ksym-vanilla-clk-get-parent \
ksym-vanilla-clk-get-phase \
ksym-vanilla-clk-get-rate \
ksym-vanilla-clk-get-scaled-duty-cycle \
ksym-vanilla-clk-get-sys \
ksym-vanilla-clk-gfx3d-ops \
ksym-vanilla-clk-has-parent \
ksym-vanilla-clk-huayra-2290-pll-configure \
ksym-vanilla-clk-hw-determine-rate-no-reparent \
ksym-vanilla-clk-hw-forward-rate-request \
ksym-vanilla-clk-hw-get-clk \
ksym-vanilla-clk-hw-get-dev \
ksym-vanilla-clk-hw-get-flags \
ksym-vanilla-clk-hw-get-name \
ksym-vanilla-clk-hw-get-num-parents \
ksym-vanilla-clk-hw-get-of-node \
ksym-vanilla-clk-hw-get-parent \
ksym-vanilla-clk-hw-get-parent-by-index \
ksym-vanilla-clk-hw-get-parent-index \
ksym-vanilla-clk-hw-get-rate \
ksym-vanilla-clk-hw-get-rate-range \
ksym-vanilla-clk-hw-init-rate-request \
ksym-vanilla-clk-hw-is-enabled \
ksym-vanilla-clk-hw-is-prepared \
ksym-vanilla-clk-hw-register \
ksym-vanilla-clk-hw-register-clkdev \
ksym-vanilla-clk-hw-register-composite \
ksym-vanilla-clk-hw-register-fixed-factor \
ksym-vanilla-clk-hw-register-fixed-factor-fwname \
ksym-vanilla-clk-hw-register-fixed-factor-index \
ksym-vanilla-clk-hw-register-fixed-factor-parent-hw \
ksym-vanilla-clk-hw-register-fixed-factor-with-accuracy-fwname \
ksym-vanilla-clk-hw-register-fractional-divider \
ksym-vanilla-clk-hw-register-gate2 \
ksym-vanilla-clk-hw-round-rate \
ksym-vanilla-clk-hw-set-parent \
ksym-vanilla-clk-hw-set-rate-range \
ksym-vanilla-clk-hw-unregister \
ksym-vanilla-clk-hw-unregister-composite \
ksym-vanilla-clk-hw-unregister-divider \
ksym-vanilla-clk-hw-unregister-fixed-factor \
ksym-vanilla-clk-hw-unregister-fixed-rate \
ksym-vanilla-clk-hw-unregister-gate \
ksym-vanilla-clk-hw-unregister-mux \
ksym-vanilla-clk-is-enabled-regmap \
ksym-vanilla-clk-is-enabled-when-prepared \
ksym-vanilla-clk-is-match \
ksym-vanilla-clk-lucid-5lpe-pll-configure \
ksym-vanilla-clk-lucid-evo-pll-configure \
ksym-vanilla-clk-lucid-ole-pll-configure \
ksym-vanilla-clk-multiplier-ops \
ksym-vanilla-clk-mux-determine-rate-flags \
ksym-vanilla-clk-mux-index-to-val \
ksym-vanilla-clk-mux-ops \
ksym-vanilla-clk-mux-ro-ops \
ksym-vanilla-clk-mux-val-to-index \
ksym-vanilla-clk-notifier-register \
ksym-vanilla-clk-notifier-unregister \
ksym-vanilla-clk-ops-hfpll \
ksym-vanilla-clk-pixel-ops \
ksym-vanilla-clk-pll-configure-sr \
ksym-vanilla-clk-pll-configure-sr-hpm-lp \
ksym-vanilla-clk-pll-ops \
ksym-vanilla-clk-pll-sr2-ops \
ksym-vanilla-clk-pll-vote-ops \
ksym-vanilla-clk-pongo-elu-pll-configure \
ksym-vanilla-clk-prepare \
ksym-vanilla-clk-put \
ksym-vanilla-clk-rate-exclusive-get \
ksym-vanilla-clk-rate-exclusive-put \
ksym-vanilla-clk-rcg-bypass-ops \
ksym-vanilla-clk-rcg-bypass2-ops \
ksym-vanilla-clk-rcg-esc-ops \
ksym-vanilla-clk-rcg-floor-ops \
ksym-vanilla-clk-rcg-lcc-ops \
ksym-vanilla-clk-rcg-ops \
ksym-vanilla-clk-rcg-pixel-ops \
ksym-vanilla-clk-rcg2-floor-ops \
ksym-vanilla-clk-rcg2-fm-ops \
ksym-vanilla-clk-rcg2-gp-ops \
ksym-vanilla-clk-rcg2-mux-closest-ops \
ksym-vanilla-clk-rcg2-ops \
ksym-vanilla-clk-rcg2-shared-floor-ops \
ksym-vanilla-clk-rcg2-shared-no-init-park-ops \
ksym-vanilla-clk-rcg2-shared-ops \
ksym-vanilla-clk-regera-pll-configure \
ksym-vanilla-clk-register \
ksym-vanilla-clk-register-clkdev \
ksym-vanilla-clk-register-composite \
ksym-vanilla-clk-register-divider-table \
ksym-vanilla-clk-register-fixed-factor \
ksym-vanilla-clk-register-fixed-rate \
ksym-vanilla-clk-register-fractional-divider \
ksym-vanilla-clk-register-gate \
ksym-vanilla-clk-register-hisi-phase \
ksym-vanilla-clk-register-mux-table \
ksym-vanilla-clk-regmap-div-ops \
ksym-vanilla-clk-regmap-div-ro-ops \
ksym-vanilla-clk-regmap-divider-ops \
ksym-vanilla-clk-regmap-divider-ro-ops \
ksym-vanilla-clk-regmap-gate-ops \
ksym-vanilla-clk-regmap-gate-ro-ops \
ksym-vanilla-clk-regmap-init \
ksym-vanilla-clk-regmap-mux-closest-ops \
ksym-vanilla-clk-regmap-mux-div-ops \
ksym-vanilla-clk-regmap-mux-ops \
ksym-vanilla-clk-regmap-mux-ro-ops \
ksym-vanilla-clk-regmap-phy-mux-ops \
ksym-vanilla-clk-restore-context \
ksym-vanilla-clk-rivian-evo-pll-configure \
ksym-vanilla-clk-round-rate \
ksym-vanilla-clk-save-context \
ksym-vanilla-clk-set-duty-cycle \
ksym-vanilla-clk-set-max-rate \
ksym-vanilla-clk-set-min-rate \
ksym-vanilla-clk-set-parent \
ksym-vanilla-clk-set-phase \
ksym-vanilla-clk-set-rate \
ksym-vanilla-clk-set-rate-exclusive \
ksym-vanilla-clk-set-rate-range \
ksym-vanilla-clk-stromer-pll-configure \
ksym-vanilla-clk-trion-pll-configure \
ksym-vanilla-clk-unprepare \
ksym-vanilla-clk-unregister \
ksym-vanilla-clk-unregister-divider \
ksym-vanilla-clk-unregister-fixed-factor \
ksym-vanilla-clk-unregister-fixed-rate \
ksym-vanilla-clk-unregister-gate \
ksym-vanilla-clk-unregister-mux \
ksym-vanilla-clk-zonda-pll-configure \
ksym-vanilla-clkdev-add \
ksym-vanilla-clkdev-create \
ksym-vanilla-clkdev-drop \
ksym-vanilla-clkdev-hw-create \
ksym-vanilla-clock-t-to-jiffies \
ksym-vanilla-clockevent-delta2ns \
ksym-vanilla-clockevents-config-and-register \
ksym-vanilla-clockevents-register-device \
ksym-vanilla-clockevents-unbind-device \
ksym-vanilla-clocks-calc-mult-shift \
ksym-vanilla-clocksource-mmio-init \
ksym-vanilla-clocksource-mmio-readl-down \
ksym-vanilla-clocksource-mmio-readl-up \
ksym-vanilla-clocksource-mmio-readw-down \
ksym-vanilla-clocksource-mmio-readw-up \
ksym-vanilla-clocksource-unregister \
ksym-vanilla-clone-private-mount \
ksym-vanilla-close-candev \
ksym-vanilla-close-fd \
ksym-vanilla-closure-put \
ksym-vanilla-closure-return-sync \
ksym-vanilla-closure-sub \
ksym-vanilla-closure-wait \
ksym-vanilla-cma-alloc \
ksym-vanilla-cma-get-name \
ksym-vanilla-cma-release \
ksym-vanilla-cma3000-exit \
ksym-vanilla-cma3000-init \
ksym-vanilla-cma3000-resume \
ksym-vanilla-cma3000-suspend \
ksym-vanilla-cmd-db-match-resource-addr \
ksym-vanilla-cmd-db-read-addr \
ksym-vanilla-cmd-db-read-aux-data \
ksym-vanilla-cmd-db-read-slave-id \
ksym-vanilla-cmd-db-ready \
ksym-vanilla-cmdq-dev-get-client-reg \
ksym-vanilla-cmdq-get-mbox-priv \
ksym-vanilla-cmdq-get-shift-pa \
ksym-vanilla-cmdq-mbox-create \
ksym-vanilla-cmdq-mbox-destroy \
ksym-vanilla-cmdq-pkt-acquire-event \
ksym-vanilla-cmdq-pkt-assign \
ksym-vanilla-cmdq-pkt-clear-event \
ksym-vanilla-cmdq-pkt-create \
ksym-vanilla-cmdq-pkt-destroy \
ksym-vanilla-cmdq-pkt-eoc \
ksym-vanilla-cmdq-pkt-jump-abs \
ksym-vanilla-cmdq-pkt-jump-rel \
ksym-vanilla-cmdq-pkt-logic-command \
ksym-vanilla-cmdq-pkt-mem-move \
ksym-vanilla-cmdq-pkt-poll \
ksym-vanilla-cmdq-pkt-poll-addr \
ksym-vanilla-cmdq-pkt-poll-mask \
ksym-vanilla-cmdq-pkt-read-s \
ksym-vanilla-cmdq-pkt-set-event \
ksym-vanilla-cmdq-pkt-wfe \
ksym-vanilla-cmdq-pkt-write \
ksym-vanilla-cmdq-pkt-write-mask \
ksym-vanilla-cmdq-pkt-write-mask-pa \
ksym-vanilla-cmdq-pkt-write-mask-subsys \
ksym-vanilla-cmdq-pkt-write-pa \
ksym-vanilla-cmdq-pkt-write-s \
ksym-vanilla-cmdq-pkt-write-s-mask \
ksym-vanilla-cmdq-pkt-write-s-mask-value \
ksym-vanilla-cmdq-pkt-write-s-value \
ksym-vanilla-cmdq-pkt-write-subsys \
ksym-vanilla-cmp-connection-break \
ksym-vanilla-cmp-connection-check-used \
ksym-vanilla-cmp-connection-destroy \
ksym-vanilla-cmp-connection-establish \
ksym-vanilla-cmp-connection-init \
ksym-vanilla-cmp-connection-release \
ksym-vanilla-cmp-connection-reserve \
ksym-vanilla-cmxgcr-lock \
ksym-vanilla-cn-add-callback \
ksym-vanilla-cn-del-callback \
ksym-vanilla-cn-netlink-send \
ksym-vanilla-cn-netlink-send-mult \
ksym-vanilla-cn10k-cpt-ctx-flush \
ksym-vanilla-cn10k-cpt-hw-ctx-clear \
ksym-vanilla-cn10k-cpt-hw-ctx-init \
ksym-vanilla-cn10k-cpt-hw-ctx-set \
ksym-vanilla-cn10k-cpt-lmtst-free \
ksym-vanilla-cn10k-cptpf-lmtst-init \
ksym-vanilla-cn10k-cptvf-lmtst-init \
ksym-vanilla-cn10k-ipsec-clean \
ksym-vanilla-cn10k-ipsec-init \
ksym-vanilla-cn10k-lmtst-init \
ksym-vanilla-cn20k-init \
ksym-vanilla-cn23xx-fw-loaded \
ksym-vanilla-cn23xx-get-vf-stats \
ksym-vanilla-cn23xx-octeon-pfvf-handshake \
ksym-vanilla-cn23xx-setup-octeon-vf-device \
ksym-vanilla-cn23xx-tell-vf-its-macaddr-changed \
ksym-vanilla-cn23xx-vf-ask-pf-to-do-flr \
ksym-vanilla-cnic-register-driver \
ksym-vanilla-cnic-unregister-driver \
ksym-vanilla-cnstr-desc-protected-blob-decap \
ksym-vanilla-cnstr-desc-skcipher-enc-dec \
ksym-vanilla-cnstr-shdsc-aead-decap \
ksym-vanilla-cnstr-shdsc-aead-encap \
ksym-vanilla-cnstr-shdsc-aead-givencap \
ksym-vanilla-cnstr-shdsc-aead-null-decap \
ksym-vanilla-cnstr-shdsc-aead-null-encap \
ksym-vanilla-cnstr-shdsc-ahash \
ksym-vanilla-cnstr-shdsc-chachapoly \
ksym-vanilla-cnstr-shdsc-gcm-decap \
ksym-vanilla-cnstr-shdsc-gcm-encap \
ksym-vanilla-cnstr-shdsc-rfc4106-decap \
ksym-vanilla-cnstr-shdsc-rfc4106-encap \
ksym-vanilla-cnstr-shdsc-rfc4543-decap \
ksym-vanilla-cnstr-shdsc-rfc4543-encap \
ksym-vanilla-cnstr-shdsc-sk-hash \
ksym-vanilla-cnstr-shdsc-skcipher-decap \
ksym-vanilla-cnstr-shdsc-skcipher-encap \
ksym-vanilla-cnstr-shdsc-xts-skcipher-decap \
ksym-vanilla-cnstr-shdsc-xts-skcipher-encap \
ksym-vanilla-cnum32-umax \
ksym-vanilla-cnum32-umin \
ksym-vanilla-cnum64-umax \
ksym-vanilla-cnum64-umin \
ksym-vanilla-codec-hevc-fill-mmu-map \
ksym-vanilla-codec-hevc-free-fbc-buffers \
ksym-vanilla-codec-hevc-free-mmu-headers \
ksym-vanilla-codec-hevc-setup-buffers \
ksym-vanilla-codec-hevc-setup-decode-head \
ksym-vanilla-color-table \
ksym-vanilla-comedi-alloc-devpriv \
ksym-vanilla-comedi-alloc-spriv \
ksym-vanilla-comedi-alloc-subdev-readback \
ksym-vanilla-comedi-alloc-subdevices \
ksym-vanilla-comedi-auto-config \
ksym-vanilla-comedi-auto-unconfig \
ksym-vanilla-comedi-buf-read-alloc \
ksym-vanilla-comedi-buf-read-free \
ksym-vanilla-comedi-buf-read-n-available \
ksym-vanilla-comedi-buf-read-samples \
ksym-vanilla-comedi-buf-write-alloc \
ksym-vanilla-comedi-buf-write-free \
ksym-vanilla-comedi-buf-write-samples \
ksym-vanilla-comedi-bytes-per-scan \
ksym-vanilla-comedi-bytes-per-scan-cmd \
ksym-vanilla-comedi-check-chanlist \
ksym-vanilla-comedi-check-request-region \
ksym-vanilla-comedi-close-from \
ksym-vanilla-comedi-dev-get-from-minor \
ksym-vanilla-comedi-dev-put \
ksym-vanilla-comedi-dio-bitfield2 \
ksym-vanilla-comedi-dio-config \
ksym-vanilla-comedi-dio-get-config \
ksym-vanilla-comedi-dio-insn-config \
ksym-vanilla-comedi-dio-update-state \
ksym-vanilla-comedi-driver-register \
ksym-vanilla-comedi-driver-unregister \
ksym-vanilla-comedi-event \
ksym-vanilla-comedi-find-subdevice-by-type \
ksym-vanilla-comedi-get-is-subdevice-running \
ksym-vanilla-comedi-get-n-channels \
ksym-vanilla-comedi-handle-events \
ksym-vanilla-comedi-inc-scan-progress \
ksym-vanilla-comedi-is-subdevice-running \
ksym-vanilla-comedi-legacy-detach \
ksym-vanilla-comedi-load-firmware \
ksym-vanilla-comedi-nsamples-left \
ksym-vanilla-comedi-nscans-left \
ksym-vanilla-comedi-open-from \
ksym-vanilla-comedi-put-is-subdevice-running \
ksym-vanilla-comedi-readback-insn-read \
ksym-vanilla-comedi-set-hw-dev \
ksym-vanilla-comedi-set-spriv-auto-free \
ksym-vanilla-comedi-timeout \
ksym-vanilla-comedi-to-usb-dev \
ksym-vanilla-comedi-to-usb-interface \
ksym-vanilla-comedi-usb-auto-config \
ksym-vanilla-comedi-usb-auto-unconfig \
ksym-vanilla-comedi-usb-driver-register \
ksym-vanilla-comedi-usb-driver-unregister \
ksym-vanilla-commit-creds \
ksym-vanilla-compat-only-sysfs-link-entry-to-kobj \
ksym-vanilla-compat-ptr-ioctl \
ksym-vanilla-compat-set-desc-from-vma \
ksym-vanilla-compat-vma-mmap \
ksym-vanilla-complete \
ksym-vanilla-complete-all \
ksym-vanilla-complete-request-key \
ksym-vanilla-completion-done \
ksym-vanilla-component-add \
ksym-vanilla-component-add-typed \
ksym-vanilla-component-bind-all \
ksym-vanilla-component-compare-dev \
ksym-vanilla-component-compare-dev-name \
ksym-vanilla-component-compare-of \
ksym-vanilla-component-del \
ksym-vanilla-component-master-add-with-match \
ksym-vanilla-component-master-del \
ksym-vanilla-component-master-is-bound \
ksym-vanilla-component-match-add-release \
ksym-vanilla-component-match-add-typed \
ksym-vanilla-component-release-of \
ksym-vanilla-component-unbind-all \
ksym-vanilla-con-copy-unimap \
ksym-vanilla-con-debug-enter \
ksym-vanilla-con-debug-leave \
ksym-vanilla-con-is-bound \
ksym-vanilla-con-is-visible \
ksym-vanilla-con-set-default-unimap \
ksym-vanilla-cond-synchronize-rcu \
ksym-vanilla-cond-synchronize-rcu-expedited \
ksym-vanilla-cond-synchronize-rcu-expedited-full \
ksym-vanilla-cond-synchronize-rcu-full \
ksym-vanilla-config-ep-by-speed \
ksym-vanilla-config-ep-by-speed-and-alt \
ksym-vanilla-config-group-find-item \
ksym-vanilla-config-group-init \
ksym-vanilla-config-group-init-type-name \
ksym-vanilla-config-item-get \
ksym-vanilla-config-item-get-unless-zero \
ksym-vanilla-config-item-init-type-name \
ksym-vanilla-config-item-put \
ksym-vanilla-config-item-set-name \
ksym-vanilla-configfs-depend-item \
ksym-vanilla-configfs-depend-item-unlocked \
ksym-vanilla-configfs-register-default-group \
ksym-vanilla-configfs-register-group \
ksym-vanilla-configfs-register-subsystem \
ksym-vanilla-configfs-remove-default-groups \
ksym-vanilla-configfs-undepend-item \
ksym-vanilla-configfs-unregister-default-group \
ksym-vanilla-configfs-unregister-group \
ksym-vanilla-configfs-unregister-subsystem \
ksym-vanilla-console-blank-hook \
ksym-vanilla-console-blanked \
ksym-vanilla-console-force-preferred-locked \
ksym-vanilla-console-list \
ksym-vanilla-console-list-lock \
ksym-vanilla-console-list-unlock \
ksym-vanilla-console-lock \
ksym-vanilla-console-printk \
ksym-vanilla-console-resume \
ksym-vanilla-console-set-on-cmdline \
ksym-vanilla-console-srcu-read-lock \
ksym-vanilla-console-srcu-read-unlock \
ksym-vanilla-console-suspend \
ksym-vanilla-console-suspend-enabled \
ksym-vanilla-console-trylock \
ksym-vanilla-console-unlock \
ksym-vanilla-console-verbose \
ksym-vanilla-consume-skb \
ksym-vanilla-cont-write-begin \
ksym-vanilla-context-tracking \
ksym-vanilla-context-tracking-key \
ksym-vanilla-contpte-clear-flush-young-ptes \
ksym-vanilla-contpte-clear-full-ptes \
ksym-vanilla-contpte-clear-young-dirty-ptes \
ksym-vanilla-contpte-get-and-clear-full-ptes \
ksym-vanilla-contpte-ptep-get \
ksym-vanilla-contpte-ptep-get-lockless \
ksym-vanilla-contpte-ptep-set-access-flags \
ksym-vanilla-contpte-set-ptes \
ksym-vanilla-contpte-test-and-clear-young-ptes \
ksym-vanilla-contpte-wrprotect-ptes \
ksym-vanilla-convert-ifc-address \
ksym-vanilla-copy-bpf-fprog-from-user \
ksym-vanilla-copy-folio-from-iter-atomic \
ksym-vanilla-copy-from-iter-toio \
ksym-vanilla-copy-from-kernel-nofault \
ksym-vanilla-copy-from-user-nofault \
ksym-vanilla-copy-from-user-toio \
ksym-vanilla-copy-fsxattr-to-user \
ksym-vanilla-copy-highpage \
ksym-vanilla-copy-page \
ksym-vanilla-copy-page-from-iter \
ksym-vanilla-copy-page-to-iter \
ksym-vanilla-copy-page-to-iter-nofault \
ksym-vanilla-copy-remote-vm-str \
ksym-vanilla-copy-splice-read \
ksym-vanilla-copy-string-kernel \
ksym-vanilla-copy-to-iter-fromio \
ksym-vanilla-copy-to-user-fromio \
ksym-vanilla-copy-to-user-nofault \
ksym-vanilla-copy-user-highpage \
ksym-vanilla-cordic-calc-iq \
ksym-vanilla-core-allocate-nexus-loss-ua \
ksym-vanilla-core-tmr-alloc-req \
ksym-vanilla-core-tpg-check-initiator-node-acl \
ksym-vanilla-core-tpg-deregister \
ksym-vanilla-core-tpg-get-initiator-node-acl \
ksym-vanilla-core-tpg-register \
ksym-vanilla-core-tpg-set-initiator-node-queue-depth \
ksym-vanilla-core-tpg-set-initiator-node-tag \
ksym-vanilla-coreboot-driver-unregister \
ksym-vanilla-coresight-add-helper \
ksym-vanilla-coresight-add-in-conn \
ksym-vanilla-coresight-add-out-conn \
ksym-vanilla-coresight-add-sysfs-link \
ksym-vanilla-coresight-alloc-device-name \
ksym-vanilla-coresight-barrier-pkt \
ksym-vanilla-coresight-claim-device \
ksym-vanilla-coresight-claim-device-unlocked \
ksym-vanilla-coresight-clear-self-claim-tag \
ksym-vanilla-coresight-clear-self-claim-tag-unlocked \
ksym-vanilla-coresight-disable-path \
ksym-vanilla-coresight-disable-source \
ksym-vanilla-coresight-disable-sysfs \
ksym-vanilla-coresight-disclaim-device \
ksym-vanilla-coresight-disclaim-device-unlocked \
ksym-vanilla-coresight-enable-sysfs \
ksym-vanilla-coresight-etm-get-trace-id \
ksym-vanilla-coresight-find-csdev-by-fwnode \
ksym-vanilla-coresight-find-default-sink \
ksym-vanilla-coresight-find-input-type \
ksym-vanilla-coresight-find-output-type \
ksym-vanilla-coresight-get-cpu \
ksym-vanilla-coresight-get-enable-clocks \
ksym-vanilla-coresight-get-percpu-sink \
ksym-vanilla-coresight-get-platform-data \
ksym-vanilla-coresight-get-sink \
ksym-vanilla-coresight-get-static-trace-id \
ksym-vanilla-coresight-init-driver-with-owner \
ksym-vanilla-coresight-loses-context-with-cpu \
ksym-vanilla-coresight-pause-source \
ksym-vanilla-coresight-register \
ksym-vanilla-coresight-remove-cti-ops \
ksym-vanilla-coresight-remove-driver \
ksym-vanilla-coresight-remove-sysfs-link \
ksym-vanilla-coresight-resume-source \
ksym-vanilla-coresight-set-cti-ops \
ksym-vanilla-coresight-set-percpu-sink \
ksym-vanilla-coresight-simple-show-pair \
ksym-vanilla-coresight-simple-show32 \
ksym-vanilla-coresight-timeout \
ksym-vanilla-coresight-timeout-action \
ksym-vanilla-coresight-trace-id-get-cpu-id \
ksym-vanilla-coresight-trace-id-get-cpu-id-map \
ksym-vanilla-coresight-trace-id-get-static-system-id \
ksym-vanilla-coresight-trace-id-get-system-id \
ksym-vanilla-coresight-trace-id-perf-start \
ksym-vanilla-coresight-trace-id-perf-stop \
ksym-vanilla-coresight-trace-id-put-cpu-id \
ksym-vanilla-coresight-trace-id-put-cpu-id-map \
ksym-vanilla-coresight-trace-id-put-system-id \
ksym-vanilla-coresight-trace-id-read-cpu-id \
ksym-vanilla-coresight-trace-id-read-cpu-id-map \
ksym-vanilla-coresight-unregister \
ksym-vanilla-counter-add \
ksym-vanilla-counter-alloc \
ksym-vanilla-counter-priv \
ksym-vanilla-counter-push-event \
ksym-vanilla-counter-put \
ksym-vanilla-counter-unregister \
ksym-vanilla-cpcap-sense-virq \
ksym-vanilla-cpci-hp-register-bus \
ksym-vanilla-cpci-hp-register-controller \
ksym-vanilla-cpci-hp-start \
ksym-vanilla-cpci-hp-stop \
ksym-vanilla-cpci-hp-unregister-bus \
ksym-vanilla-cpci-hp-unregister-controller \
ksym-vanilla-cper-bits-to-str \
ksym-vanilla-cper-dimm-err-location \
ksym-vanilla-cper-estatus-check \
ksym-vanilla-cper-estatus-check-header \
ksym-vanilla-cper-estatus-print \
ksym-vanilla-cper-mem-err-location \
ksym-vanilla-cper-mem-err-pack \
ksym-vanilla-cper-mem-err-status-str \
ksym-vanilla-cper-mem-err-type-str \
ksym-vanilla-cper-next-record-id \
ksym-vanilla-cper-severity-str \
ksym-vanilla-cper-severity-to-aer \
ksym-vanilla-cpm-muram-addr \
ksym-vanilla-cpm-muram-alloc \
ksym-vanilla-cpm-muram-alloc-fixed \
ksym-vanilla-cpm-muram-dma \
ksym-vanilla-cpm-muram-free \
ksym-vanilla-cpm-muram-free-addr \
ksym-vanilla-cpm-muram-offset \
ksym-vanilla-cppc-allow-fast-switch \
ksym-vanilla-cppc-get-auto-act-window \
ksym-vanilla-cppc-get-auto-sel \
ksym-vanilla-cppc-get-desired-perf \
ksym-vanilla-cppc-get-dmi-max-khz \
ksym-vanilla-cppc-get-epp-perf \
ksym-vanilla-cppc-get-highest-perf \
ksym-vanilla-cppc-get-perf \
ksym-vanilla-cppc-get-perf-caps \
ksym-vanilla-cppc-get-perf-ctrs \
ksym-vanilla-cppc-get-perf-limited \
ksym-vanilla-cppc-get-transition-latency \
ksym-vanilla-cppc-khz-to-perf \
ksym-vanilla-cppc-perf-ctrs-in-pcc \
ksym-vanilla-cppc-perf-ctrs-in-pcc-cpu \
ksym-vanilla-cppc-perf-to-khz \
ksym-vanilla-cppc-set-auto-act-window \
ksym-vanilla-cppc-set-auto-sel \
ksym-vanilla-cppc-set-enable \
ksym-vanilla-cppc-set-epp \
ksym-vanilla-cppc-set-epp-perf \
ksym-vanilla-cppc-set-perf \
ksym-vanilla-cppc-set-perf-limited \
ksym-vanilla-cptvf-hw-ops-get \
ksym-vanilla-cpu-all-bits \
ksym-vanilla-cpu-bit-bitmap \
ksym-vanilla-cpu-cache-has-invalidate-memregion \
ksym-vanilla-cpu-cache-invalidate-memregion \
ksym-vanilla-cpu-cgrp-subsys-enabled-key \
ksym-vanilla-cpu-cgrp-subsys-on-dfl-key \
ksym-vanilla-cpu-cluster-pm-enter \
ksym-vanilla-cpu-cluster-pm-exit \
ksym-vanilla-cpu-device-create \
ksym-vanilla-cpu-have-feature \
ksym-vanilla-cpu-hotplug-disable \
ksym-vanilla-cpu-hotplug-enable \
ksym-vanilla-cpu-is-hotpluggable \
ksym-vanilla-cpu-latency-qos-add-request \
ksym-vanilla-cpu-latency-qos-remove-request \
ksym-vanilla-cpu-latency-qos-request-active \
ksym-vanilla-cpu-latency-qos-update-request \
ksym-vanilla-cpu-mitigations-auto-nosmt \
ksym-vanilla-cpu-mitigations-off \
ksym-vanilla-cpu-pm-enter \
ksym-vanilla-cpu-pm-exit \
ksym-vanilla-cpu-pm-register-notifier \
ksym-vanilla-cpu-pm-unregister-notifier \
ksym-vanilla-cpu-rmap-add \
ksym-vanilla-cpu-rmap-put \
ksym-vanilla-cpu-rmap-update \
ksym-vanilla-cpu-scale \
ksym-vanilla-cpu-smt-possible \
ksym-vanilla-cpu-subsys \
ksym-vanilla-cpu-topology \
ksym-vanilla-cpufreq-add-update-util-hook \
ksym-vanilla-cpufreq-boost-enabled \
ksym-vanilla-cpufreq-boost-set-sw \
ksym-vanilla-cpufreq-cooling-register \
ksym-vanilla-cpufreq-cooling-unregister \
ksym-vanilla-cpufreq-cpu-get \
ksym-vanilla-cpufreq-cpu-get-raw \
ksym-vanilla-cpufreq-cpu-policy \
ksym-vanilla-cpufreq-cpu-put \
ksym-vanilla-cpufreq-dbs-governor-exit \
ksym-vanilla-cpufreq-dbs-governor-init \
ksym-vanilla-cpufreq-dbs-governor-limits \
ksym-vanilla-cpufreq-dbs-governor-start \
ksym-vanilla-cpufreq-dbs-governor-stop \
ksym-vanilla-cpufreq-disable-fast-switch \
ksym-vanilla-cpufreq-driver-fast-switch \
ksym-vanilla-cpufreq-driver-resolve-freq \
ksym-vanilla-cpufreq-driver-target \
ksym-vanilla-cpufreq-dt-pdev-register \
ksym-vanilla-cpufreq-enable-fast-switch \
ksym-vanilla-cpufreq-freq-transition-begin \
ksym-vanilla-cpufreq-freq-transition-end \
ksym-vanilla-cpufreq-frequency-table-get-index \
ksym-vanilla-cpufreq-frequency-table-verify \
ksym-vanilla-cpufreq-generic-frequency-table-verify \
ksym-vanilla-cpufreq-generic-get \
ksym-vanilla-cpufreq-generic-init \
ksym-vanilla-cpufreq-generic-suspend \
ksym-vanilla-cpufreq-get \
ksym-vanilla-cpufreq-get-current-driver \
ksym-vanilla-cpufreq-get-driver-data \
ksym-vanilla-cpufreq-get-hw-max-freq \
ksym-vanilla-cpufreq-policy-transition-delay-us \
ksym-vanilla-cpufreq-quick-get \
ksym-vanilla-cpufreq-quick-get-max \
ksym-vanilla-cpufreq-register-driver \
ksym-vanilla-cpufreq-register-governor \
ksym-vanilla-cpufreq-register-notifier \
ksym-vanilla-cpufreq-remove-update-util-hook \
ksym-vanilla-cpufreq-show-cpus \
ksym-vanilla-cpufreq-table-index-unsorted \
ksym-vanilla-cpufreq-unregister-driver \
ksym-vanilla-cpufreq-unregister-governor \
ksym-vanilla-cpufreq-unregister-notifier \
ksym-vanilla-cpufreq-update-limits \
ksym-vanilla-cpufreq-update-policy \
ksym-vanilla-cpuhp-tasks-frozen \
ksym-vanilla-cpuidle-disable-device \
ksym-vanilla-cpuidle-enable-device \
ksym-vanilla-cpuidle-get-cpu-driver \
ksym-vanilla-cpuidle-get-driver \
ksym-vanilla-cpuidle-pause-and-lock \
ksym-vanilla-cpuidle-register \
ksym-vanilla-cpuidle-register-device \
ksym-vanilla-cpuidle-register-driver \
ksym-vanilla-cpuidle-resume-and-unlock \
ksym-vanilla-cpuidle-unregister \
ksym-vanilla-cpuidle-unregister-device \
ksym-vanilla-cpuidle-unregister-device-no-lock \
ksym-vanilla-cpuidle-unregister-driver \
ksym-vanilla-cpumask-any-and-distribute \
ksym-vanilla-cpumask-any-distribute \
ksym-vanilla-cpumask-local-spread \
ksym-vanilla-cpus-read-lock \
ksym-vanilla-cpus-read-trylock \
ksym-vanilla-cpus-read-unlock \
ksym-vanilla-cpuset-cgrp-subsys-enabled-key \
ksym-vanilla-cpuset-cgrp-subsys-on-dfl-key \
ksym-vanilla-cqhci-deactivate \
ksym-vanilla-cqhci-init \
ksym-vanilla-cqhci-irq \
ksym-vanilla-cqhci-pltfm-init \
ksym-vanilla-cqhci-resume \
ksym-vanilla-cqhci-set-tran-desc \
ksym-vanilla-crash-exclude-mem-range \
ksym-vanilla-crc-ccitt \
ksym-vanilla-crc-ccitt-table \
ksym-vanilla-crc-itu-t \
ksym-vanilla-crc-itu-t-table \
ksym-vanilla-crc-t10dif-update \
ksym-vanilla-crc16 \
ksym-vanilla-crc32-be \
ksym-vanilla-crc32-le \
ksym-vanilla-crc32-optimizations \
ksym-vanilla-crc32c \
ksym-vanilla-crc64-be \
ksym-vanilla-crc64-nvme \
ksym-vanilla-crc7-be \
ksym-vanilla-crc8 \
ksym-vanilla-crc8-populate-lsb \
ksym-vanilla-crc8-populate-msb \
ksym-vanilla-create-empty-buffers \
ksym-vanilla-cred-fscmp \
ksym-vanilla-cros-ec-check-features \
ksym-vanilla-cros-ec-check-result \
ksym-vanilla-cros-ec-cmd \
ksym-vanilla-cros-ec-cmd-readmem \
ksym-vanilla-cros-ec-cmd-xfer \
ksym-vanilla-cros-ec-cmd-xfer-status \
ksym-vanilla-cros-ec-device-alloc \
ksym-vanilla-cros-ec-device-registered \
ksym-vanilla-cros-ec-get-cmd-versions \
ksym-vanilla-cros-ec-get-host-event \
ksym-vanilla-cros-ec-get-next-event \
ksym-vanilla-cros-ec-get-sensor-count \
ksym-vanilla-cros-ec-irq-thread \
ksym-vanilla-cros-ec-motion-send-host-cmd \
ksym-vanilla-cros-ec-prepare-tx \
ksym-vanilla-cros-ec-query-all \
ksym-vanilla-cros-ec-register \
ksym-vanilla-cros-ec-resume \
ksym-vanilla-cros-ec-resume-complete \
ksym-vanilla-cros-ec-resume-early \
ksym-vanilla-cros-ec-rwsig-continue \
ksym-vanilla-cros-ec-sensorhub-register-push-data \
ksym-vanilla-cros-ec-sensorhub-unregister-push-data \
ksym-vanilla-cros-ec-sensors-capture \
ksym-vanilla-cros-ec-sensors-core-init \
ksym-vanilla-cros-ec-sensors-core-read \
ksym-vanilla-cros-ec-sensors-core-read-avail \
ksym-vanilla-cros-ec-sensors-core-register \
ksym-vanilla-cros-ec-sensors-core-write \
ksym-vanilla-cros-ec-sensors-ext-info \
ksym-vanilla-cros-ec-sensors-limited-info \
ksym-vanilla-cros-ec-sensors-pm-ops \
ksym-vanilla-cros-ec-sensors-push-data \
ksym-vanilla-cros-ec-sensors-read-cmd \
ksym-vanilla-cros-ec-sensors-read-lpc \
ksym-vanilla-cros-ec-suspend \
ksym-vanilla-cros-ec-suspend-late \
ksym-vanilla-cros-ec-suspend-prepare \
ksym-vanilla-cros-ec-unregister \
ksym-vanilla-cros-usbpd-register-notify \
ksym-vanilla-cros-usbpd-unregister-notify \
ksym-vanilla-cryptd-aead-child \
ksym-vanilla-cryptd-aead-queued \
ksym-vanilla-cryptd-alloc-aead \
ksym-vanilla-cryptd-free-aead \
ksym-vanilla-crypto-acomp-alloc-streams \
ksym-vanilla-crypto-acomp-compress \
ksym-vanilla-crypto-acomp-decompress \
ksym-vanilla-crypto-acomp-free-streams \
ksym-vanilla-crypto-aead-decrypt \
ksym-vanilla-crypto-aead-encrypt \
ksym-vanilla-crypto-aead-setauthsize \
ksym-vanilla-crypto-aead-setkey \
ksym-vanilla-crypto-aes-inv-sbox \
ksym-vanilla-crypto-aes-sbox \
ksym-vanilla-crypto-ahash-digest \
ksym-vanilla-crypto-ahash-export \
ksym-vanilla-crypto-ahash-export-core \
ksym-vanilla-crypto-ahash-finup \
ksym-vanilla-crypto-ahash-import \
ksym-vanilla-crypto-ahash-import-core \
ksym-vanilla-crypto-ahash-init \
ksym-vanilla-crypto-ahash-setkey \
ksym-vanilla-crypto-ahash-update \
ksym-vanilla-crypto-akcipher-sync-decrypt \
ksym-vanilla-crypto-akcipher-sync-encrypt \
ksym-vanilla-crypto-alg-extsize \
ksym-vanilla-crypto-alg-list \
ksym-vanilla-crypto-alg-mod-lookup \
ksym-vanilla-crypto-alg-sem \
ksym-vanilla-crypto-alg-tested \
ksym-vanilla-crypto-alloc-acomp \
ksym-vanilla-crypto-alloc-acomp-node \
ksym-vanilla-crypto-alloc-aead \
ksym-vanilla-crypto-alloc-ahash \
ksym-vanilla-crypto-alloc-akcipher \
ksym-vanilla-crypto-alloc-base \
ksym-vanilla-crypto-alloc-kpp \
ksym-vanilla-crypto-alloc-lskcipher \
ksym-vanilla-crypto-alloc-rng \
ksym-vanilla-crypto-alloc-shash \
ksym-vanilla-crypto-alloc-sig \
ksym-vanilla-crypto-alloc-skcipher \
ksym-vanilla-crypto-alloc-sync-aead \
ksym-vanilla-crypto-alloc-sync-skcipher \
ksym-vanilla-crypto-alloc-tfm-node \
ksym-vanilla-crypto-attr-alg-name \
ksym-vanilla-crypto-authenc-extractkeys \
ksym-vanilla-crypto-chain \
ksym-vanilla-crypto-check-attr-type \
ksym-vanilla-crypto-cipher-decrypt-one \
ksym-vanilla-crypto-cipher-encrypt-one \
ksym-vanilla-crypto-cipher-setkey \
ksym-vanilla-crypto-create-tfm-node \
ksym-vanilla-crypto-del-default-rng \
ksym-vanilla-crypto-dequeue-request \
ksym-vanilla-crypto-destroy-alg \
ksym-vanilla-crypto-destroy-tfm \
ksym-vanilla-crypto-dh-decode-key \
ksym-vanilla-crypto-dh-encode-key \
ksym-vanilla-crypto-dh-key-len \
ksym-vanilla-crypto-drop-spawn \
ksym-vanilla-crypto-ecdh-decode-key \
ksym-vanilla-crypto-ecdh-encode-key \
ksym-vanilla-crypto-ecdh-key-len \
ksym-vanilla-crypto-ecdh-shared-secret \
ksym-vanilla-crypto-engine-alloc-init \
ksym-vanilla-crypto-engine-alloc-init-and-set \
ksym-vanilla-crypto-engine-exit \
ksym-vanilla-crypto-engine-register-aead \
ksym-vanilla-crypto-engine-register-aeads \
ksym-vanilla-crypto-engine-register-ahash \
ksym-vanilla-crypto-engine-register-ahashes \
ksym-vanilla-crypto-engine-register-akcipher \
ksym-vanilla-crypto-engine-register-kpp \
ksym-vanilla-crypto-engine-register-skcipher \
ksym-vanilla-crypto-engine-register-skciphers \
ksym-vanilla-crypto-engine-start \
ksym-vanilla-crypto-engine-stop \
ksym-vanilla-crypto-engine-unregister-aead \
ksym-vanilla-crypto-engine-unregister-aeads \
ksym-vanilla-crypto-engine-unregister-ahash \
ksym-vanilla-crypto-engine-unregister-ahashes \
ksym-vanilla-crypto-engine-unregister-akcipher \
ksym-vanilla-crypto-engine-unregister-kpp \
ksym-vanilla-crypto-engine-unregister-skcipher \
ksym-vanilla-crypto-engine-unregister-skciphers \
ksym-vanilla-crypto-enqueue-request \
ksym-vanilla-crypto-enqueue-request-head \
ksym-vanilla-crypto-finalize-aead-request \
ksym-vanilla-crypto-finalize-akcipher-request \
ksym-vanilla-crypto-finalize-hash-request \
ksym-vanilla-crypto-finalize-kpp-request \
ksym-vanilla-crypto-finalize-skcipher-request \
ksym-vanilla-crypto-find-alg \
ksym-vanilla-crypto-get-attr-type \
ksym-vanilla-crypto-grab-aead \
ksym-vanilla-crypto-grab-ahash \
ksym-vanilla-crypto-grab-akcipher \
ksym-vanilla-crypto-grab-kpp \
ksym-vanilla-crypto-grab-lskcipher \
ksym-vanilla-crypto-grab-shash \
ksym-vanilla-crypto-grab-sig \
ksym-vanilla-crypto-grab-skcipher \
ksym-vanilla-crypto-grab-spawn \
ksym-vanilla-crypto-has-aead \
ksym-vanilla-crypto-has-ahash \
ksym-vanilla-crypto-has-alg \
ksym-vanilla-crypto-has-kpp \
ksym-vanilla-crypto-has-shash \
ksym-vanilla-crypto-has-skcipher \
ksym-vanilla-crypto-hash-alg-has-setkey \
ksym-vanilla-crypto-hash-digest \
ksym-vanilla-crypto-hash-walk-done \
ksym-vanilla-crypto-hash-walk-first \
ksym-vanilla-crypto-inc \
ksym-vanilla-crypto-init-queue \
ksym-vanilla-crypto-kdf108-ctr-generate \
ksym-vanilla-crypto-kdf108-setkey \
ksym-vanilla-crypto-krb5-calc-PRFplus \
ksym-vanilla-crypto-krb5-check-data-len \
ksym-vanilla-crypto-krb5-decrypt \
ksym-vanilla-crypto-krb5-encrypt \
ksym-vanilla-crypto-krb5-find-enctype \
ksym-vanilla-crypto-krb5-get-mic \
ksym-vanilla-crypto-krb5-how-much-buffer \
ksym-vanilla-crypto-krb5-how-much-data \
ksym-vanilla-crypto-krb5-prepare-checksum \
ksym-vanilla-crypto-krb5-prepare-encryption \
ksym-vanilla-crypto-krb5-verify-mic \
ksym-vanilla-crypto-krb5-where-is-the-data \
ksym-vanilla-crypto-krb5enc-extractkeys \
ksym-vanilla-crypto-larval-alloc \
ksym-vanilla-crypto-lookup-template \
ksym-vanilla-crypto-lskcipher-decrypt \
ksym-vanilla-crypto-lskcipher-encrypt \
ksym-vanilla-crypto-lskcipher-setkey \
ksym-vanilla-crypto-mod-get \
ksym-vanilla-crypto-mod-put \
ksym-vanilla-crypto-probing-notify \
ksym-vanilla-crypto-register-acomp \
ksym-vanilla-crypto-register-acomps \
ksym-vanilla-crypto-register-aead \
ksym-vanilla-crypto-register-aeads \
ksym-vanilla-crypto-register-ahash \
ksym-vanilla-crypto-register-ahashes \
ksym-vanilla-crypto-register-akcipher \
ksym-vanilla-crypto-register-alg \
ksym-vanilla-crypto-register-algs \
ksym-vanilla-crypto-register-instance \
ksym-vanilla-crypto-register-kpp \
ksym-vanilla-crypto-register-lskcipher \
ksym-vanilla-crypto-register-lskciphers \
ksym-vanilla-crypto-register-notifier \
ksym-vanilla-crypto-register-rng \
ksym-vanilla-crypto-register-rngs \
ksym-vanilla-crypto-register-scomp \
ksym-vanilla-crypto-register-scomps \
ksym-vanilla-crypto-register-shash \
ksym-vanilla-crypto-register-shashes \
ksym-vanilla-crypto-register-sig \
ksym-vanilla-crypto-register-skcipher \
ksym-vanilla-crypto-register-skciphers \
ksym-vanilla-crypto-register-template \
ksym-vanilla-crypto-register-templates \
ksym-vanilla-crypto-remove-final \
ksym-vanilla-crypto-remove-spawns \
ksym-vanilla-crypto-req-done \
ksym-vanilla-crypto-request-clone \
ksym-vanilla-crypto-rng-reset \
ksym-vanilla-crypto-schedule-test \
ksym-vanilla-crypto-shash-digest \
ksym-vanilla-crypto-shash-export \
ksym-vanilla-crypto-shash-export-core \
ksym-vanilla-crypto-shash-finup \
ksym-vanilla-crypto-shash-import \
ksym-vanilla-crypto-shash-import-core \
ksym-vanilla-crypto-shash-init \
ksym-vanilla-crypto-shash-setkey \
ksym-vanilla-crypto-shash-tfm-digest \
ksym-vanilla-crypto-shoot-alg \
ksym-vanilla-crypto-skcipher-decrypt \
ksym-vanilla-crypto-skcipher-encrypt \
ksym-vanilla-crypto-skcipher-export \
ksym-vanilla-crypto-skcipher-import \
ksym-vanilla-crypto-skcipher-setkey \
ksym-vanilla-crypto-sm4-ck \
ksym-vanilla-crypto-sm4-fk \
ksym-vanilla-crypto-sm4-sbox \
ksym-vanilla-crypto-spawn-tfm \
ksym-vanilla-crypto-spawn-tfm2 \
ksym-vanilla-crypto-transfer-aead-request-to-engine \
ksym-vanilla-crypto-transfer-akcipher-request-to-engine \
ksym-vanilla-crypto-transfer-hash-request-to-engine \
ksym-vanilla-crypto-transfer-kpp-request-to-engine \
ksym-vanilla-crypto-transfer-skcipher-request-to-engine \
ksym-vanilla-crypto-type-has-alg \
ksym-vanilla-crypto-unregister-acomp \
ksym-vanilla-crypto-unregister-acomps \
ksym-vanilla-crypto-unregister-aead \
ksym-vanilla-crypto-unregister-aeads \
ksym-vanilla-crypto-unregister-ahash \
ksym-vanilla-crypto-unregister-ahashes \
ksym-vanilla-crypto-unregister-akcipher \
ksym-vanilla-crypto-unregister-alg \
ksym-vanilla-crypto-unregister-algs \
ksym-vanilla-crypto-unregister-instance \
ksym-vanilla-crypto-unregister-kpp \
ksym-vanilla-crypto-unregister-lskcipher \
ksym-vanilla-crypto-unregister-lskciphers \
ksym-vanilla-crypto-unregister-notifier \
ksym-vanilla-crypto-unregister-rng \
ksym-vanilla-crypto-unregister-rngs \
ksym-vanilla-crypto-unregister-scomp \
ksym-vanilla-crypto-unregister-scomps \
ksym-vanilla-crypto-unregister-shash \
ksym-vanilla-crypto-unregister-shashes \
ksym-vanilla-crypto-unregister-sig \
ksym-vanilla-crypto-unregister-skcipher \
ksym-vanilla-crypto-unregister-skciphers \
ksym-vanilla-crypto-unregister-template \
ksym-vanilla-crypto-unregister-templates \
ksym-vanilla-cs-amp-create-debugfs \
ksym-vanilla-cs-amp-devm-get-vendor-specific-variant-id \
ksym-vanilla-cs-amp-get-efi-calibration-data \
ksym-vanilla-cs-amp-get-vendor-spkid \
ksym-vanilla-cs-amp-read-cal-coeffs \
ksym-vanilla-cs-amp-set-efi-calibration-data \
ksym-vanilla-cs-amp-test-hooks \
ksym-vanilla-cs-amp-write-ambient-temp \
ksym-vanilla-cs-amp-write-cal-coeffs \
ksym-vanilla-cs-dsp-adsp1-init \
ksym-vanilla-cs-dsp-adsp1-power-down \
ksym-vanilla-cs-dsp-adsp1-power-up \
ksym-vanilla-cs-dsp-adsp2-bus-error \
ksym-vanilla-cs-dsp-adsp2-init \
ksym-vanilla-cs-dsp-chunk-flush \
ksym-vanilla-cs-dsp-chunk-read \
ksym-vanilla-cs-dsp-chunk-write \
ksym-vanilla-cs-dsp-cleanup-debugfs \
ksym-vanilla-cs-dsp-coeff-lock-and-read-ctrl \
ksym-vanilla-cs-dsp-coeff-lock-and-write-ctrl \
ksym-vanilla-cs-dsp-coeff-read-ctrl \
ksym-vanilla-cs-dsp-coeff-write-acked-control \
ksym-vanilla-cs-dsp-coeff-write-ctrl \
ksym-vanilla-cs-dsp-find-alg-region \
ksym-vanilla-cs-dsp-get-ctl \
ksym-vanilla-cs-dsp-halo-bus-error \
ksym-vanilla-cs-dsp-halo-init \
ksym-vanilla-cs-dsp-halo-wdt-expire \
ksym-vanilla-cs-dsp-hibernate \
ksym-vanilla-cs-dsp-init-debugfs \
ksym-vanilla-cs-dsp-mem-region-name \
ksym-vanilla-cs-dsp-power-down \
ksym-vanilla-cs-dsp-power-up \
ksym-vanilla-cs-dsp-read-data-word \
ksym-vanilla-cs-dsp-read-raw-data-block \
ksym-vanilla-cs-dsp-remove \
ksym-vanilla-cs-dsp-remove-padding \
ksym-vanilla-cs-dsp-run \
ksym-vanilla-cs-dsp-set-dspclk \
ksym-vanilla-cs-dsp-stop \
ksym-vanilla-cs-dsp-write-data-word \
ksym-vanilla-cs-dsp-wseq-init \
ksym-vanilla-cs-dsp-wseq-multi-write \
ksym-vanilla-cs-dsp-wseq-write \
ksym-vanilla-cs35l41-configure-cs-dsp \
ksym-vanilla-cs35l41-enter-hibernate \
ksym-vanilla-cs35l41-exit-hibernate \
ksym-vanilla-cs35l41-global-enable \
ksym-vanilla-cs35l41-gpio-config \
ksym-vanilla-cs35l41-hda-pm-ops \
ksym-vanilla-cs35l41-hda-probe \
ksym-vanilla-cs35l41-hda-remove \
ksym-vanilla-cs35l41-init-boost \
ksym-vanilla-cs35l41-mdsync-up \
ksym-vanilla-cs35l41-otp-unpack \
ksym-vanilla-cs35l41-pm-ops \
ksym-vanilla-cs35l41-probe \
ksym-vanilla-cs35l41-register-errata-patch \
ksym-vanilla-cs35l41-regmap-i2c \
ksym-vanilla-cs35l41-regmap-spi \
ksym-vanilla-cs35l41-remove \
ksym-vanilla-cs35l41-safe-reset \
ksym-vanilla-cs35l41-set-channels \
ksym-vanilla-cs35l41-set-cspl-mbox-cmd \
ksym-vanilla-cs35l41-test-key-lock \
ksym-vanilla-cs35l41-test-key-unlock \
ksym-vanilla-cs35l41-write-fs-errata \
ksym-vanilla-cs35l45-apply-patch \
ksym-vanilla-cs35l45-get-clk-freq-id \
ksym-vanilla-cs35l45-i2c-regmap \
ksym-vanilla-cs35l45-pm-ops \
ksym-vanilla-cs35l45-probe \
ksym-vanilla-cs35l45-remove \
ksym-vanilla-cs35l45-spi-regmap \
ksym-vanilla-cs35l56-cal-ambient-debugfs-write \
ksym-vanilla-cs35l56-cal-data-debugfs-read \
ksym-vanilla-cs35l56-cal-data-debugfs-write \
ksym-vanilla-cs35l56-cal-set-status-get \
ksym-vanilla-cs35l56-cal-set-status-text \
ksym-vanilla-cs35l56-calibrate-debugfs-write \
ksym-vanilla-cs35l56-calibration-controls \
ksym-vanilla-cs35l56-check-and-save-onchip-spkid-gpios \
ksym-vanilla-cs35l56-common-probe \
ksym-vanilla-cs35l56-configure-onchip-spkid-pads \
ksym-vanilla-cs35l56-create-cal-debugfs \
ksym-vanilla-cs35l56-disable-sdw-interrupts \
ksym-vanilla-cs35l56-enable-sdw-interrupts \
ksym-vanilla-cs35l56-factory-calibrate \
ksym-vanilla-cs35l56-fill-supply-names \
ksym-vanilla-cs35l56-firmware-shutdown \
ksym-vanilla-cs35l56-get-bclk-freq-id \
ksym-vanilla-cs35l56-get-calibration \
ksym-vanilla-cs35l56-get-speaker-id \
ksym-vanilla-cs35l56-hda-common-probe \
ksym-vanilla-cs35l56-hda-pm-ops \
ksym-vanilla-cs35l56-hda-remove \
ksym-vanilla-cs35l56-hw-init \
ksym-vanilla-cs35l56-init \
ksym-vanilla-cs35l56-init-cs-dsp \
ksym-vanilla-cs35l56-irq \
ksym-vanilla-cs35l56-irq-request \
ksym-vanilla-cs35l56-is-fw-reload-needed \
ksym-vanilla-cs35l56-log-tuning \
ksym-vanilla-cs35l56-mask-soundwire-interrupts \
ksym-vanilla-cs35l56-mbox-send \
ksym-vanilla-cs35l56-pm-ops-i2c-spi \
ksym-vanilla-cs35l56-read-onchip-spkid \
ksym-vanilla-cs35l56-read-prot-status \
ksym-vanilla-cs35l56-regmap-i2c \
ksym-vanilla-cs35l56-regmap-sdw \
ksym-vanilla-cs35l56-regmap-spi \
ksym-vanilla-cs35l56-remove \
ksym-vanilla-cs35l56-remove-cal-debugfs \
ksym-vanilla-cs35l56-runtime-resume-common \
ksym-vanilla-cs35l56-runtime-suspend-common \
ksym-vanilla-cs35l56-set-asp-patch \
ksym-vanilla-cs35l56-set-patch \
ksym-vanilla-cs35l56-stash-calibration \
ksym-vanilla-cs35l56-system-reset \
ksym-vanilla-cs35l56-system-resume \
ksym-vanilla-cs35l56-system-resume-early \
ksym-vanilla-cs35l56-system-resume-no-irq \
ksym-vanilla-cs35l56-system-suspend \
ksym-vanilla-cs35l56-system-suspend-late \
ksym-vanilla-cs35l56-system-suspend-no-irq \
ksym-vanilla-cs35l56-tx-input-texts \
ksym-vanilla-cs35l56-tx-input-values \
ksym-vanilla-cs35l56-unmask-soundwire-interrupts \
ksym-vanilla-cs35l56-wait-control-port-ready \
ksym-vanilla-cs35l56-wait-for-firmware-boot \
ksym-vanilla-cs35l56-wait-min-reset-pulse \
ksym-vanilla-cs35l56-warn-if-firmware-missing \
ksym-vanilla-cs35l63-regmap-i2c \
ksym-vanilla-cs35l63-regmap-sdw \
ksym-vanilla-cs42448-data \
ksym-vanilla-cs4271-dt-ids \
ksym-vanilla-cs4271-probe \
ksym-vanilla-cs4271-regmap-config \
ksym-vanilla-cs42888-data \
ksym-vanilla-cs42l42-common-probe \
ksym-vanilla-cs42l42-common-remove \
ksym-vanilla-cs42l42-dai \
ksym-vanilla-cs42l42-init \
ksym-vanilla-cs42l42-irq-thread \
ksym-vanilla-cs42l42-mute-stream \
ksym-vanilla-cs42l42-page-range \
ksym-vanilla-cs42l42-pll-config \
ksym-vanilla-cs42l42-readable-register \
ksym-vanilla-cs42l42-regmap \
ksym-vanilla-cs42l42-resume \
ksym-vanilla-cs42l42-resume-restore \
ksym-vanilla-cs42l42-soc-component \
ksym-vanilla-cs42l42-src-config \
ksym-vanilla-cs42l42-suspend \
ksym-vanilla-cs42l42-volatile-register \
ksym-vanilla-cs42l43-dev-probe \
ksym-vanilla-cs42l43-pm-ops \
ksym-vanilla-cs42l43-precious-register \
ksym-vanilla-cs42l43-readable-register \
ksym-vanilla-cs42l43-reg-default \
ksym-vanilla-cs42l43-sdw-add-peripheral \
ksym-vanilla-cs42l43-sdw-remove-peripheral \
ksym-vanilla-cs42l43-sdw-set-stream \
ksym-vanilla-cs42l43-volatile-register \
ksym-vanilla-cs42l51-probe \
ksym-vanilla-cs42l51-regmap \
ksym-vanilla-cs42l51-remove \
ksym-vanilla-cs42l51-resume \
ksym-vanilla-cs42l51-suspend \
ksym-vanilla-cs42xx8-pm \
ksym-vanilla-cs42xx8-probe \
ksym-vanilla-cs42xx8-regmap-config \
ksym-vanilla-cs47l15-16bit-i2c-regmap \
ksym-vanilla-cs47l15-16bit-spi-regmap \
ksym-vanilla-cs47l15-32bit-i2c-regmap \
ksym-vanilla-cs47l15-32bit-spi-regmap \
ksym-vanilla-cs47l15-patch \
ksym-vanilla-cs47l35-16bit-i2c-regmap \
ksym-vanilla-cs47l35-16bit-spi-regmap \
ksym-vanilla-cs47l35-32bit-i2c-regmap \
ksym-vanilla-cs47l35-32bit-spi-regmap \
ksym-vanilla-cs47l35-patch \
ksym-vanilla-cs47l85-16bit-i2c-regmap \
ksym-vanilla-cs47l85-16bit-spi-regmap \
ksym-vanilla-cs47l85-32bit-i2c-regmap \
ksym-vanilla-cs47l85-32bit-spi-regmap \
ksym-vanilla-cs47l85-patch \
ksym-vanilla-cs47l90-16bit-i2c-regmap \
ksym-vanilla-cs47l90-16bit-spi-regmap \
ksym-vanilla-cs47l90-32bit-i2c-regmap \
ksym-vanilla-cs47l90-32bit-spi-regmap \
ksym-vanilla-cs47l90-patch \
ksym-vanilla-cs47l92-16bit-i2c-regmap \
ksym-vanilla-cs47l92-16bit-spi-regmap \
ksym-vanilla-cs47l92-32bit-i2c-regmap \
ksym-vanilla-cs47l92-32bit-spi-regmap \
ksym-vanilla-cs47l92-patch \
ksym-vanilla-cscfg-activate-config \
ksym-vanilla-cscfg-config-sysfs-get-active-cfg \
ksym-vanilla-cscfg-csdev-disable-active-config \
ksym-vanilla-cscfg-csdev-enable-active-config \
ksym-vanilla-cscfg-csdev-reset-feats \
ksym-vanilla-cscfg-deactivate-config \
ksym-vanilla-cscfg-load-config-sets \
ksym-vanilla-cscfg-register-csdev \
ksym-vanilla-cscfg-unload-config-sets \
ksym-vanilla-cscfg-unregister-csdev \
ksym-vanilla-css-next-descendant-pre \
ksym-vanilla-csum-and-copy-from-iter-full \
ksym-vanilla-csum-ipv6-magic \
ksym-vanilla-csum-partial \
ksym-vanilla-csum-tcpudp-nofold \
ksym-vanilla-ct-idle-enter \
ksym-vanilla-ct-idle-exit \
ksym-vanilla-ct-sip-get-header \
ksym-vanilla-ct-sip-get-sdp-header \
ksym-vanilla-ct-sip-parse-address-param \
ksym-vanilla-ct-sip-parse-header-uri \
ksym-vanilla-ct-sip-parse-numerical-param \
ksym-vanilla-ct-sip-parse-request \
ksym-vanilla-ct-user-enter \
ksym-vanilla-ct-user-exit \
ksym-vanilla-ctucan-probe-common \
ksym-vanilla-ctucan-resume \
ksym-vanilla-ctucan-suspend \
ksym-vanilla-current-in-userns \
ksym-vanilla-current-is-async \
ksym-vanilla-current-time \
ksym-vanilla-current-work \
ksym-vanilla-curve25519 \
ksym-vanilla-curve25519-generate-public \
ksym-vanilla-cv1800-cfg-ops \
ksym-vanilla-cv1800-pconf-ops \
ksym-vanilla-cv1800-pctrl-ops \
ksym-vanilla-cv1800-pmx-ops \
ksym-vanilla-cw1200-can-suspend \
ksym-vanilla-cw1200-core-probe \
ksym-vanilla-cw1200-core-release \
ksym-vanilla-cw1200-irq-handler \
ksym-vanilla-cx18-claim-stream \
ksym-vanilla-cx18-ext-init \
ksym-vanilla-cx18-release-stream \
ksym-vanilla-cx18-start-v4l2-encode-stream \
ksym-vanilla-cx18-stop-v4l2-encode-stream \
ksym-vanilla-cx22700-attach \
ksym-vanilla-cx22702-attach \
ksym-vanilla-cx231xx-capture-start \
ksym-vanilla-cx231xx-demod-reset \
ksym-vanilla-cx231xx-dev-init \
ksym-vanilla-cx231xx-dev-uninit \
ksym-vanilla-cx231xx-disable656 \
ksym-vanilla-cx231xx-enable-i2c-port-3 \
ksym-vanilla-cx231xx-enable656 \
ksym-vanilla-cx231xx-get-i2c-adap \
ksym-vanilla-cx231xx-init-bulk \
ksym-vanilla-cx231xx-init-isoc \
ksym-vanilla-cx231xx-init-vbi-isoc \
ksym-vanilla-cx231xx-register-extension \
ksym-vanilla-cx231xx-send-gpio-cmd \
ksym-vanilla-cx231xx-send-usb-command \
ksym-vanilla-cx231xx-set-alt-setting \
ksym-vanilla-cx231xx-set-mode \
ksym-vanilla-cx231xx-tuner-callback \
ksym-vanilla-cx231xx-uninit-bulk \
ksym-vanilla-cx231xx-uninit-isoc \
ksym-vanilla-cx231xx-uninit-vbi-isoc \
ksym-vanilla-cx231xx-unmute-audio \
ksym-vanilla-cx231xx-unregister-extension \
ksym-vanilla-cx2341x-ctrl-get-menu \
ksym-vanilla-cx2341x-ctrl-query \
ksym-vanilla-cx2341x-ext-ctrls \
ksym-vanilla-cx2341x-fill-defaults \
ksym-vanilla-cx2341x-handler-init \
ksym-vanilla-cx2341x-handler-set-50hz \
ksym-vanilla-cx2341x-handler-set-busy \
ksym-vanilla-cx2341x-handler-setup \
ksym-vanilla-cx2341x-log-status \
ksym-vanilla-cx2341x-mpeg-ctrls \
ksym-vanilla-cx2341x-update \
ksym-vanilla-cx24110-attach \
ksym-vanilla-cx24113-agc-callback \
ksym-vanilla-cx24113-attach \
ksym-vanilla-cx24116-attach \
ksym-vanilla-cx24117-attach \
ksym-vanilla-cx24120-attach \
ksym-vanilla-cx24123-attach \
ksym-vanilla-cx24123-get-tuner-i2c-adapter \
ksym-vanilla-cx25821-dev-get \
ksym-vanilla-cx25821-dev-unregister \
ksym-vanilla-cx25821-print-irqbits \
ksym-vanilla-cx25821-risc-databuffer-audio \
ksym-vanilla-cx25821-riscmem-alloc \
ksym-vanilla-cx25821-set-gpiopin-direction \
ksym-vanilla-cx25821-sram-channel-dump-audio \
ksym-vanilla-cx25821-sram-channel-setup-audio \
ksym-vanilla-cx25821-sram-channels \
ksym-vanilla-cx88-audio-thread \
ksym-vanilla-cx88-core-get \
ksym-vanilla-cx88-core-irq \
ksym-vanilla-cx88-core-put \
ksym-vanilla-cx88-dsp-detect-stereo-sap \
ksym-vanilla-cx88-enum-input \
ksym-vanilla-cx88-get-stereo \
ksym-vanilla-cx88-ir-start \
ksym-vanilla-cx88-ir-stop \
ksym-vanilla-cx88-newstation \
ksym-vanilla-cx88-print-irqbits \
ksym-vanilla-cx88-querycap \
ksym-vanilla-cx88-reset \
ksym-vanilla-cx88-risc-buffer \
ksym-vanilla-cx88-risc-databuffer \
ksym-vanilla-cx88-set-freq \
ksym-vanilla-cx88-set-scale \
ksym-vanilla-cx88-set-stereo \
ksym-vanilla-cx88-set-tvaudio \
ksym-vanilla-cx88-set-tvnorm \
ksym-vanilla-cx88-setup-xc3028 \
ksym-vanilla-cx88-shutdown \
ksym-vanilla-cx88-sram-channel-dump \
ksym-vanilla-cx88-sram-channel-setup \
ksym-vanilla-cx88-sram-channels \
ksym-vanilla-cx88-tuner-callback \
ksym-vanilla-cx88-vdev-init \
ksym-vanilla-cx88-video-mux \
ksym-vanilla-cx88-wakeup \
ksym-vanilla-cx8802-buf-prepare \
ksym-vanilla-cx8802-buf-queue \
ksym-vanilla-cx8802-cancel-buffers \
ksym-vanilla-cx8802-get-driver \
ksym-vanilla-cx8802-register-driver \
ksym-vanilla-cx8802-start-dma \
ksym-vanilla-cx8802-unregister-driver \
ksym-vanilla-cxd2820r-attach \
ksym-vanilla-cxd2841er-attach-s \
ksym-vanilla-cxd2841er-attach-t-c \
ksym-vanilla-cxd2880-attach \
ksym-vanilla-cxgb-find-route \
ksym-vanilla-cxgb-find-route6 \
ksym-vanilla-cxgb-get-4tuple \
ksym-vanilla-cxgb3-alloc-atid \
ksym-vanilla-cxgb3-free-atid \
ksym-vanilla-cxgb3-insert-tid \
ksym-vanilla-cxgb3-ofld-send \
ksym-vanilla-cxgb3-queue-tid-release \
ksym-vanilla-cxgb3-register-client \
ksym-vanilla-cxgb3-remove-tid \
ksym-vanilla-cxgb3-unregister-client \
ksym-vanilla-cxgb4-alloc-atid \
ksym-vanilla-cxgb4-alloc-sftid \
ksym-vanilla-cxgb4-alloc-stid \
ksym-vanilla-cxgb4-bar2-sge-qregs \
ksym-vanilla-cxgb4-best-aligned-mtu \
ksym-vanilla-cxgb4-best-mtu \
ksym-vanilla-cxgb4-check-l2t-valid \
ksym-vanilla-cxgb4-clip-get \
ksym-vanilla-cxgb4-clip-release \
ksym-vanilla-cxgb4-create-server \
ksym-vanilla-cxgb4-create-server-filter \
ksym-vanilla-cxgb4-create-server6 \
ksym-vanilla-cxgb4-crypto-send \
ksym-vanilla-cxgb4-dbfifo-count \
ksym-vanilla-cxgb4-flush-eq-cache \
ksym-vanilla-cxgb4-free-atid \
ksym-vanilla-cxgb4-free-stid \
ksym-vanilla-cxgb4-get-tcp-stats \
ksym-vanilla-cxgb4-immdata-send \
ksym-vanilla-cxgb4-inline-tx-skb \
ksym-vanilla-cxgb4-l2t-get \
ksym-vanilla-cxgb4-l2t-release \
ksym-vanilla-cxgb4-l2t-send \
ksym-vanilla-cxgb4-map-skb \
ksym-vanilla-cxgb4-ofld-send \
ksym-vanilla-cxgb4-pktgl-to-skb \
ksym-vanilla-cxgb4-port-chan \
ksym-vanilla-cxgb4-port-e2cchan \
ksym-vanilla-cxgb4-port-idx \
ksym-vanilla-cxgb4-port-viid \
ksym-vanilla-cxgb4-read-sge-timestamp \
ksym-vanilla-cxgb4-read-tpte \
ksym-vanilla-cxgb4-reclaim-completed-tx \
ksym-vanilla-cxgb4-register-uld \
ksym-vanilla-cxgb4-remove-server \
ksym-vanilla-cxgb4-remove-server-filter \
ksym-vanilla-cxgb4-remove-tid \
ksym-vanilla-cxgb4-ring-tx-db \
ksym-vanilla-cxgb4-select-ntuple \
ksym-vanilla-cxgb4-smt-alloc-switching \
ksym-vanilla-cxgb4-smt-release \
ksym-vanilla-cxgb4-sync-txq-pidx \
ksym-vanilla-cxgb4-unregister-uld \
ksym-vanilla-cxgb4-update-root-dev-clip \
ksym-vanilla-cxgb4-write-partial-sgl \
ksym-vanilla-cxgb4-write-sgl \
ksym-vanilla-cxgbi-attr-is-visible \
ksym-vanilla-cxgbi-bind-conn \
ksym-vanilla-cxgbi-cleanup-task \
ksym-vanilla-cxgbi-conn-alloc-pdu \
ksym-vanilla-cxgbi-conn-init-pdu \
ksym-vanilla-cxgbi-conn-pdu-ready \
ksym-vanilla-cxgbi-conn-tx-open \
ksym-vanilla-cxgbi-conn-xmit-pdu \
ksym-vanilla-cxgbi-create-conn \
ksym-vanilla-cxgbi-create-session \
ksym-vanilla-cxgbi-ddp-ppm-setup \
ksym-vanilla-cxgbi-ddp-set-one-ppod \
ksym-vanilla-cxgbi-destroy-session \
ksym-vanilla-cxgbi-device-find-by-lldev \
ksym-vanilla-cxgbi-device-find-by-netdev \
ksym-vanilla-cxgbi-device-find-by-netdev-rcu \
ksym-vanilla-cxgbi-device-portmap-cleanup \
ksym-vanilla-cxgbi-device-portmap-create \
ksym-vanilla-cxgbi-device-register \
ksym-vanilla-cxgbi-device-unregister \
ksym-vanilla-cxgbi-device-unregister-all \
ksym-vanilla-cxgbi-ep-connect \
ksym-vanilla-cxgbi-ep-disconnect \
ksym-vanilla-cxgbi-ep-poll \
ksym-vanilla-cxgbi-get-conn-stats \
ksym-vanilla-cxgbi-get-ep-param \
ksym-vanilla-cxgbi-get-host-param \
ksym-vanilla-cxgbi-hbas-add \
ksym-vanilla-cxgbi-hbas-remove \
ksym-vanilla-cxgbi-iscsi-cleanup \
ksym-vanilla-cxgbi-iscsi-init \
ksym-vanilla-cxgbi-parse-pdu-itt \
ksym-vanilla-cxgbi-ppm-init \
ksym-vanilla-cxgbi-ppm-make-ppod-hdr \
ksym-vanilla-cxgbi-ppm-ppod-release \
ksym-vanilla-cxgbi-ppm-ppods-reserve \
ksym-vanilla-cxgbi-ppm-release \
ksym-vanilla-cxgbi-set-conn-param \
ksym-vanilla-cxgbi-set-host-param \
ksym-vanilla-cxgbi-sock-act-open-req-arp-failure \
ksym-vanilla-cxgbi-sock-check-wr-invariants \
ksym-vanilla-cxgbi-sock-closed \
ksym-vanilla-cxgbi-sock-established \
ksym-vanilla-cxgbi-sock-fail-act-open \
ksym-vanilla-cxgbi-sock-free-cpl-skbs \
ksym-vanilla-cxgbi-sock-purge-wr-queue \
ksym-vanilla-cxgbi-sock-rcv-abort-rpl \
ksym-vanilla-cxgbi-sock-rcv-close-conn-rpl \
ksym-vanilla-cxgbi-sock-rcv-peer-close \
ksym-vanilla-cxgbi-sock-rcv-wr-ack \
ksym-vanilla-cxgbi-sock-select-mss \
ksym-vanilla-cxgbi-sock-skb-entail \
ksym-vanilla-cxgbi-tagmask-set \
ksym-vanilla-cxl-add-to-region \
ksym-vanilla-cxl-arm-dirty-shutdown \
ksym-vanilla-cxl-await-media-ready \
ksym-vanilla-cxl-bus-drain \
ksym-vanilla-cxl-bus-rescan \
ksym-vanilla-cxl-bus-type \
ksym-vanilla-cxl-calculate-dpa-offset \
ksym-vanilla-cxl-calculate-hpa-offset \
ksym-vanilla-cxl-calculate-position \
ksym-vanilla-cxl-clear-poison \
ksym-vanilla-cxl-cor-error-detected \
ksym-vanilla-cxl-count-regblock \
ksym-vanilla-cxl-cper-handle-prot-err \
ksym-vanilla-cxl-cper-kfifo-get \
ksym-vanilla-cxl-cper-prot-err-kfifo-get \
ksym-vanilla-cxl-cper-register-prot-err-work \
ksym-vanilla-cxl-cper-register-work \
ksym-vanilla-cxl-cper-sec-prot-err-valid \
ksym-vanilla-cxl-cper-setup-prot-err-work-data \
ksym-vanilla-cxl-cper-unregister-prot-err-work \
ksym-vanilla-cxl-cper-unregister-work \
ksym-vanilla-cxl-debugfs-create-dir \
ksym-vanilla-cxl-decoder-add \
ksym-vanilla-cxl-decoder-add-locked \
ksym-vanilla-cxl-decoder-autoremove \
ksym-vanilla-cxl-dev-state-identify \
ksym-vanilla-cxl-do-xormap-calc \
ksym-vanilla-cxl-dpa-debug \
ksym-vanilla-cxl-dpa-setup \
ksym-vanilla-cxl-dport-map-rcd-linkcap \
ksym-vanilla-cxl-driver-unregister \
ksym-vanilla-cxl-dvsec-rr-decode \
ksym-vanilla-cxl-endpoint-autoremove \
ksym-vanilla-cxl-endpoint-decoder-alloc \
ksym-vanilla-cxl-endpoint-decoder-reset-detected \
ksym-vanilla-cxl-endpoint-get-perf-coordinates \
ksym-vanilla-cxl-endpoint-parse-cdat \
ksym-vanilla-cxl-enumerate-cmds \
ksym-vanilla-cxl-error-detected \
ksym-vanilla-cxl-event-trace-record \
ksym-vanilla-cxl-find-nvdimm-bridge \
ksym-vanilla-cxl-find-regblock \
ksym-vanilla-cxl-find-regblock-instance \
ksym-vanilla-cxl-get-dirty-count \
ksym-vanilla-cxl-gpf-get-dvsec \
ksym-vanilla-cxl-hdm-decode-init \
ksym-vanilla-cxl-inject-poison \
ksym-vanilla-cxl-internal-send-cmd \
ksym-vanilla-cxl-mailbox-init \
ksym-vanilla-cxl-map-component-regs \
ksym-vanilla-cxl-map-device-regs \
ksym-vanilla-cxl-map-pmu-regs \
ksym-vanilla-cxl-mem-active-dec \
ksym-vanilla-cxl-mem-active-inc \
ksym-vanilla-cxl-mem-dpa-fetch \
ksym-vanilla-cxl-mem-find-port \
ksym-vanilla-cxl-mem-get-event-records \
ksym-vanilla-cxl-mem-get-poison \
ksym-vanilla-cxl-memdev-attach-region \
ksym-vanilla-cxl-memdev-state-create \
ksym-vanilla-cxl-memdev-update-perf \
ksym-vanilla-cxl-pci-find-port \
ksym-vanilla-cxl-pci-setup-regs \
ksym-vanilla-cxl-poison-state-init \
ksym-vanilla-cxl-port-commit-reap \
ksym-vanilla-cxl-port-setup-regs \
ksym-vanilla-cxl-port-to-pci-bus \
ksym-vanilla-cxl-port-update-decoder-targets \
ksym-vanilla-cxl-probe-component-regs \
ksym-vanilla-cxl-probe-device-regs \
ksym-vanilla-cxl-region-contains-resource \
ksym-vanilla-cxl-root-decoder-alloc \
ksym-vanilla-cxl-set-timestamp \
ksym-vanilla-cxl-setup-regs \
ksym-vanilla-cxl-store-rec-dram \
ksym-vanilla-cxl-store-rec-gen-media \
ksym-vanilla-cxl-switch-decoder-alloc \
ksym-vanilla-cxl-switch-parse-cdat \
ksym-vanilla-cxl-trigger-poison-list \
ksym-vanilla-cxl-validate-translation-params \
ksym-vanilla-cypress-load-firmware \
ksym-vanilla-cyttsp-pm-ops \
ksym-vanilla-cyttsp-probe \
ksym-vanilla-d-add \
ksym-vanilla-d-add-ci \
ksym-vanilla-d-alloc \
ksym-vanilla-d-alloc-anon \
ksym-vanilla-d-alloc-name \
ksym-vanilla-d-alloc-parallel \
ksym-vanilla-d-delete \
ksym-vanilla-d-drop \
ksym-vanilla-d-exchange \
ksym-vanilla-d-find-alias \
ksym-vanilla-d-find-any-alias \
ksym-vanilla-d-instantiate \
ksym-vanilla-d-instantiate-new \
ksym-vanilla-d-invalidate \
ksym-vanilla-d-lookup \
ksym-vanilla-d-make-discardable \
ksym-vanilla-d-make-persistent \
ksym-vanilla-d-make-root \
ksym-vanilla-d-mark-dontcache \
ksym-vanilla-d-mark-tmpfile \
ksym-vanilla-d-mark-tmpfile-name \
ksym-vanilla-d-move \
ksym-vanilla-d-obtain-alias \
ksym-vanilla-d-obtain-root \
ksym-vanilla-d-parent-ino \
ksym-vanilla-d-path \
ksym-vanilla-d-prune-aliases \
ksym-vanilla-d-rehash \
ksym-vanilla-d-same-name \
ksym-vanilla-d-splice-alias \
ksym-vanilla-d-tmpfile \
ksym-vanilla-datagram-poll \
ksym-vanilla-datagram-poll-queue \
ksym-vanilla-dax-add-host \
ksym-vanilla-dax-alive \
ksym-vanilla-dax-break-layout \
ksym-vanilla-dax-break-layout-final \
ksym-vanilla-dax-delete-mapping-range \
ksym-vanilla-dax-dev-get \
ksym-vanilla-dax-direct-access \
ksym-vanilla-dax-driver-unregister \
ksym-vanilla-dax-file-unshare \
ksym-vanilla-dax-finish-sync-fault \
ksym-vanilla-dax-flush \
ksym-vanilla-dax-folio-reset-order \
ksym-vanilla-dax-get-private \
ksym-vanilla-dax-hmem-flush-work \
ksym-vanilla-dax-holder \
ksym-vanilla-dax-holder-notify-failure \
ksym-vanilla-dax-inode \
ksym-vanilla-dax-iomap-fault \
ksym-vanilla-dax-iomap-rw \
ksym-vanilla-dax-layout-busy-page \
ksym-vanilla-dax-layout-busy-page-range \
ksym-vanilla-dax-pgoff-to-phys \
ksym-vanilla-dax-read-lock \
ksym-vanilla-dax-read-unlock \
ksym-vanilla-dax-recovery-write \
ksym-vanilla-dax-remap-file-range-prep \
ksym-vanilla-dax-remove-host \
ksym-vanilla-dax-set-ops \
ksym-vanilla-dax-synchronous \
ksym-vanilla-dax-truncate-page \
ksym-vanilla-dax-write-cache \
ksym-vanilla-dax-write-cache-enabled \
ksym-vanilla-dax-writeback-mapping-range \
ksym-vanilla-dax-zero-page-range \
ksym-vanilla-dax-zero-range \
ksym-vanilla-dbs-update \
ksym-vanilla-dcache-dir-close \
ksym-vanilla-dcache-dir-lseek \
ksym-vanilla-dcache-dir-open \
ksym-vanilla-dcache-readdir \
ksym-vanilla-dcb-delrewr \
ksym-vanilla-dcb-getapp \
ksym-vanilla-dcb-getrewr \
ksym-vanilla-dcb-getrewr-prio-dscp-mask-map \
ksym-vanilla-dcb-getrewr-prio-pcp-mask-map \
ksym-vanilla-dcb-ieee-delapp \
ksym-vanilla-dcb-ieee-getapp-default-prio-mask \
ksym-vanilla-dcb-ieee-getapp-dscp-prio-mask-map \
ksym-vanilla-dcb-ieee-getapp-mask \
ksym-vanilla-dcb-ieee-getapp-prio-dscp-mask-map \
ksym-vanilla-dcb-ieee-setapp \
ksym-vanilla-dcb-setapp \
ksym-vanilla-dcb-setrewr \
ksym-vanilla-dcbnl-cee-notify \
ksym-vanilla-dcbnl-ieee-notify \
ksym-vanilla-dcss-dev-pm-ops \
ksym-vanilla-ddbridge-dummy-fe-qam-attach \
ksym-vanilla-deactivate-locked-super \
ksym-vanilla-deactivate-super \
ksym-vanilla-debounce-time-mt2701 \
ksym-vanilla-debounce-time-mt6765 \
ksym-vanilla-debounce-time-mt6795 \
ksym-vanilla-debounce-time-mt6878 \
ksym-vanilla-debug-locks \
ksym-vanilla-debug-locks-off \
ksym-vanilla-debug-locks-silent \
ksym-vanilla-debugfs-attr-read \
ksym-vanilla-debugfs-attr-write \
ksym-vanilla-debugfs-attr-write-signed \
ksym-vanilla-debugfs-change-name \
ksym-vanilla-debugfs-create-atomic-t \
ksym-vanilla-debugfs-create-automount \
ksym-vanilla-debugfs-create-blob \
ksym-vanilla-debugfs-create-bool \
ksym-vanilla-debugfs-create-devm-seqfile \
ksym-vanilla-debugfs-create-dir \
ksym-vanilla-debugfs-create-file-full \
ksym-vanilla-debugfs-create-file-short \
ksym-vanilla-debugfs-create-file-size \
ksym-vanilla-debugfs-create-file-unsafe \
ksym-vanilla-debugfs-create-regset32 \
ksym-vanilla-debugfs-create-size-t \
ksym-vanilla-debugfs-create-str \
ksym-vanilla-debugfs-create-symlink \
ksym-vanilla-debugfs-create-u16 \
ksym-vanilla-debugfs-create-u32 \
ksym-vanilla-debugfs-create-u32-array \
ksym-vanilla-debugfs-create-u64 \
ksym-vanilla-debugfs-create-u8 \
ksym-vanilla-debugfs-create-ulong \
ksym-vanilla-debugfs-create-x16 \
ksym-vanilla-debugfs-create-x32 \
ksym-vanilla-debugfs-create-x64 \
ksym-vanilla-debugfs-create-x8 \
ksym-vanilla-debugfs-enter-cancellation \
ksym-vanilla-debugfs-file-get \
ksym-vanilla-debugfs-file-put \
ksym-vanilla-debugfs-get-aux \
ksym-vanilla-debugfs-initialized \
ksym-vanilla-debugfs-leave-cancellation \
ksym-vanilla-debugfs-lookup \
ksym-vanilla-debugfs-lookup-and-remove \
ksym-vanilla-debugfs-print-regs32 \
ksym-vanilla-debugfs-read-file-bool \
ksym-vanilla-debugfs-remove \
ksym-vanilla-debugfs-write-file-bool \
ksym-vanilla-dec-node-page-state \
ksym-vanilla-dec-zone-page-state \
ksym-vanilla-decode-rs16 \
ksym-vanilla-decode-rs8 \
ksym-vanilla-default-blu \
ksym-vanilla-default-grn \
ksym-vanilla-default-llseek \
ksym-vanilla-default-qdisc-ops \
ksym-vanilla-default-red \
ksym-vanilla-default-wake-function \
ksym-vanilla-del-gendisk \
ksym-vanilla-del-mtd-blktrans-dev \
ksym-vanilla-delayed-work-timer-fn \
ksym-vanilla-denali-calc-ecc-bytes \
ksym-vanilla-denali-chip-init \
ksym-vanilla-denali-init \
ksym-vanilla-denali-remove \
ksym-vanilla-dentry-create \
ksym-vanilla-dentry-open \
ksym-vanilla-dentry-path-raw \
ksym-vanilla-dequeue-signal \
ksym-vanilla-deregister-atm-ioctl \
ksym-vanilla-deregister-mtd-blktrans \
ksym-vanilla-deregister-mtd-parser \
ksym-vanilla-des-decrypt \
ksym-vanilla-des-encrypt \
ksym-vanilla-des-expand-key \
ksym-vanilla-des3-ede-decrypt \
ksym-vanilla-des3-ede-encrypt \
ksym-vanilla-des3-ede-expand-key \
ksym-vanilla-desc-to-gpio \
ksym-vanilla-destroy-workqueue \
ksym-vanilla-detach-hdlc-protocol \
ksym-vanilla-dev-activate \
ksym-vanilla-dev-add-offload \
ksym-vanilla-dev-add-pack \
ksym-vanilla-dev-addr-add \
ksym-vanilla-dev-addr-del \
ksym-vanilla-dev-addr-mod \
ksym-vanilla-dev-alloc-name \
ksym-vanilla-dev-attr-em-message \
ksym-vanilla-dev-attr-em-message-type \
ksym-vanilla-dev-attr-link-power-management-policy \
ksym-vanilla-dev-attr-link-power-management-supported \
ksym-vanilla-dev-attr-ncq-prio-enable \
ksym-vanilla-dev-attr-ncq-prio-supported \
ksym-vanilla-dev-attr-phy-event-threshold \
ksym-vanilla-dev-attr-sw-activity \
ksym-vanilla-dev-attr-unload-heads \
ksym-vanilla-dev-attr-usbip-debug \
ksym-vanilla-dev-change-flags \
ksym-vanilla-dev-change-net-namespace \
ksym-vanilla-dev-close \
ksym-vanilla-dev-coredump-put \
ksym-vanilla-dev-coredumpm-timeout \
ksym-vanilla-dev-coredumpsg \
ksym-vanilla-dev-coredumpv \
ksym-vanilla-dev-deactivate \
ksym-vanilla-dev-disable-lro \
ksym-vanilla-dev-driver-string \
ksym-vanilla-dev-err-probe \
ksym-vanilla-dev-eth-ioctl \
ksym-vanilla-dev-fetch-sw-netstats \
ksym-vanilla-dev-fill-forward-path \
ksym-vanilla-dev-fill-metadata-dst \
ksym-vanilla-dev-forward-skb \
ksym-vanilla-dev-get-by-index \
ksym-vanilla-dev-get-by-index-rcu \
ksym-vanilla-dev-get-by-name \
ksym-vanilla-dev-get-by-name-rcu \
ksym-vanilla-dev-get-cma-area \
ksym-vanilla-dev-get-iflink \
ksym-vanilla-dev-get-regmap \
ksym-vanilla-dev-get-stats \
ksym-vanilla-dev-get-tstats64 \
ksym-vanilla-dev-getbyhwaddr \
ksym-vanilla-dev-getbyhwaddr-rcu \
ksym-vanilla-dev-getfirstbyhwtype \
ksym-vanilla-dev-graft-qdisc \
ksym-vanilla-dev-iommu-priv-set \
ksym-vanilla-dev-is-amba \
ksym-vanilla-dev-is-auxiliary \
ksym-vanilla-dev-is-pnp \
ksym-vanilla-dev-kfree-skb-any-reason \
ksym-vanilla-dev-kfree-skb-irq-reason \
ksym-vanilla-dev-load \
ksym-vanilla-dev-loopback-xmit \
ksym-vanilla-dev-lstats-read \
ksym-vanilla-dev-mc-add \
ksym-vanilla-dev-mc-add-excl \
ksym-vanilla-dev-mc-add-global \
ksym-vanilla-dev-mc-del \
ksym-vanilla-dev-mc-del-global \
ksym-vanilla-dev-mc-flush \
ksym-vanilla-dev-mc-init \
ksym-vanilla-dev-mc-sync \
ksym-vanilla-dev-mc-sync-multiple \
ksym-vanilla-dev-mc-unsync \
ksym-vanilla-dev-nit-active-rcu \
ksym-vanilla-dev-open \
ksym-vanilla-dev-pick-tx-zero \
ksym-vanilla-dev-pm-clear-wake-irq \
ksym-vanilla-dev-pm-domain-attach \
ksym-vanilla-dev-pm-domain-attach-by-id \
ksym-vanilla-dev-pm-domain-attach-by-name \
ksym-vanilla-dev-pm-domain-attach-list \
ksym-vanilla-dev-pm-domain-detach \
ksym-vanilla-dev-pm-domain-detach-list \
ksym-vanilla-dev-pm-domain-set \
ksym-vanilla-dev-pm-domain-set-performance-state \
ksym-vanilla-dev-pm-domain-start \
ksym-vanilla-dev-pm-genpd-add-notifier \
ksym-vanilla-dev-pm-genpd-get-hwmode \
ksym-vanilla-dev-pm-genpd-get-next-hrtimer \
ksym-vanilla-dev-pm-genpd-is-on \
ksym-vanilla-dev-pm-genpd-remove-notifier \
ksym-vanilla-dev-pm-genpd-resume \
ksym-vanilla-dev-pm-genpd-rpm-always-on \
ksym-vanilla-dev-pm-genpd-set-hwmode \
ksym-vanilla-dev-pm-genpd-set-next-wakeup \
ksym-vanilla-dev-pm-genpd-set-performance-state \
ksym-vanilla-dev-pm-genpd-suspend \
ksym-vanilla-dev-pm-genpd-synced-poweroff \
ksym-vanilla-dev-pm-get-subsys-data \
ksym-vanilla-dev-pm-opp-add-dynamic \
ksym-vanilla-dev-pm-opp-adjust-voltage \
ksym-vanilla-dev-pm-opp-calc-power \
ksym-vanilla-dev-pm-opp-clear-config \
ksym-vanilla-dev-pm-opp-config-clks-simple \
ksym-vanilla-dev-pm-opp-cpumask-remove-table \
ksym-vanilla-dev-pm-opp-disable \
ksym-vanilla-dev-pm-opp-enable \
ksym-vanilla-dev-pm-opp-find-bw-ceil \
ksym-vanilla-dev-pm-opp-find-bw-floor \
ksym-vanilla-dev-pm-opp-find-freq-ceil \
ksym-vanilla-dev-pm-opp-find-freq-ceil-indexed \
ksym-vanilla-dev-pm-opp-find-freq-exact \
ksym-vanilla-dev-pm-opp-find-freq-exact-indexed \
ksym-vanilla-dev-pm-opp-find-freq-floor \
ksym-vanilla-dev-pm-opp-find-freq-floor-indexed \
ksym-vanilla-dev-pm-opp-find-key-exact \
ksym-vanilla-dev-pm-opp-find-level-ceil \
ksym-vanilla-dev-pm-opp-find-level-exact \
ksym-vanilla-dev-pm-opp-find-level-floor \
ksym-vanilla-dev-pm-opp-free-cpufreq-table \
ksym-vanilla-dev-pm-opp-get \
ksym-vanilla-dev-pm-opp-get-bw \
ksym-vanilla-dev-pm-opp-get-freq-indexed \
ksym-vanilla-dev-pm-opp-get-level \
ksym-vanilla-dev-pm-opp-get-max-clock-latency \
ksym-vanilla-dev-pm-opp-get-max-transition-latency \
ksym-vanilla-dev-pm-opp-get-max-volt-latency \
ksym-vanilla-dev-pm-opp-get-of-node \
ksym-vanilla-dev-pm-opp-get-opp-count \
ksym-vanilla-dev-pm-opp-get-opp-table \
ksym-vanilla-dev-pm-opp-get-opp-table-ref \
ksym-vanilla-dev-pm-opp-get-power \
ksym-vanilla-dev-pm-opp-get-required-pstate \
ksym-vanilla-dev-pm-opp-get-sharing-cpus \
ksym-vanilla-dev-pm-opp-get-supplies \
ksym-vanilla-dev-pm-opp-get-suspend-opp-freq \
ksym-vanilla-dev-pm-opp-get-voltage \
ksym-vanilla-dev-pm-opp-init-cpufreq-table \
ksym-vanilla-dev-pm-opp-is-turbo \
ksym-vanilla-dev-pm-opp-of-add-table \
ksym-vanilla-dev-pm-opp-of-add-table-indexed \
ksym-vanilla-dev-pm-opp-of-cpumask-add-table \
ksym-vanilla-dev-pm-opp-of-cpumask-remove-table \
ksym-vanilla-dev-pm-opp-of-find-icc-paths \
ksym-vanilla-dev-pm-opp-of-get-opp-desc-node \
ksym-vanilla-dev-pm-opp-of-get-sharing-cpus \
ksym-vanilla-dev-pm-opp-of-register-em \
ksym-vanilla-dev-pm-opp-of-remove-table \
ksym-vanilla-dev-pm-opp-put \
ksym-vanilla-dev-pm-opp-put-opp-table \
ksym-vanilla-dev-pm-opp-register-notifier \
ksym-vanilla-dev-pm-opp-remove \
ksym-vanilla-dev-pm-opp-remove-all-dynamic \
ksym-vanilla-dev-pm-opp-remove-table \
ksym-vanilla-dev-pm-opp-set-config \
ksym-vanilla-dev-pm-opp-set-opp \
ksym-vanilla-dev-pm-opp-set-rate \
ksym-vanilla-dev-pm-opp-set-sharing-cpus \
ksym-vanilla-dev-pm-opp-sync-regulators \
ksym-vanilla-dev-pm-opp-unregister-notifier \
ksym-vanilla-dev-pm-opp-xlate-required-opp \
ksym-vanilla-dev-pm-put-subsys-data \
ksym-vanilla-dev-pm-qos-add-ancestor-request \
ksym-vanilla-dev-pm-qos-add-notifier \
ksym-vanilla-dev-pm-qos-add-request \
ksym-vanilla-dev-pm-qos-expose-flags \
ksym-vanilla-dev-pm-qos-expose-latency-limit \
ksym-vanilla-dev-pm-qos-expose-latency-tolerance \
ksym-vanilla-dev-pm-qos-flags \
ksym-vanilla-dev-pm-qos-hide-flags \
ksym-vanilla-dev-pm-qos-hide-latency-limit \
ksym-vanilla-dev-pm-qos-hide-latency-tolerance \
ksym-vanilla-dev-pm-qos-read-value \
ksym-vanilla-dev-pm-qos-remove-notifier \
ksym-vanilla-dev-pm-qos-remove-request \
ksym-vanilla-dev-pm-qos-update-request \
ksym-vanilla-dev-pm-qos-update-user-latency-tolerance \
ksym-vanilla-dev-pm-set-dedicated-wake-irq \
ksym-vanilla-dev-pm-set-dedicated-wake-irq-reverse \
ksym-vanilla-dev-pm-set-wake-irq \
ksym-vanilla-dev-printk-emit \
ksym-vanilla-dev-queue-xmit-nit \
ksym-vanilla-dev-remove-offload \
ksym-vanilla-dev-remove-pack \
ksym-vanilla-dev-set-alias \
ksym-vanilla-dev-set-allmulti \
ksym-vanilla-dev-set-mac-address \
ksym-vanilla-dev-set-mac-address-user \
ksym-vanilla-dev-set-mtu \
ksym-vanilla-dev-set-name \
ksym-vanilla-dev-set-promiscuity \
ksym-vanilla-dev-set-threaded \
ksym-vanilla-dev-trans-start \
ksym-vanilla-dev-uc-add \
ksym-vanilla-dev-uc-add-excl \
ksym-vanilla-dev-uc-del \
ksym-vanilla-dev-uc-flush \
ksym-vanilla-dev-uc-init \
ksym-vanilla-dev-uc-sync \
ksym-vanilla-dev-uc-sync-multiple \
ksym-vanilla-dev-uc-unsync \
ksym-vanilla-dev-valid-name \
ksym-vanilla-dev-vprintk-emit \
ksym-vanilla-dev-warn-probe \
ksym-vanilla-dev-xdp-prog-count \
ksym-vanilla-dev-xdp-propagate \
ksym-vanilla-dev2t3cdev \
ksym-vanilla-devcgroup-check-permission \
ksym-vanilla-devfreq-add-device \
ksym-vanilla-devfreq-add-governor \
ksym-vanilla-devfreq-cooling-em-register \
ksym-vanilla-devfreq-cooling-register \
ksym-vanilla-devfreq-cooling-unregister \
ksym-vanilla-devfreq-event-add-edev \
ksym-vanilla-devfreq-event-disable-edev \
ksym-vanilla-devfreq-event-enable-edev \
ksym-vanilla-devfreq-event-get-edev-by-phandle \
ksym-vanilla-devfreq-event-get-edev-count \
ksym-vanilla-devfreq-event-get-event \
ksym-vanilla-devfreq-event-is-enabled \
ksym-vanilla-devfreq-event-remove-edev \
ksym-vanilla-devfreq-event-reset-event \
ksym-vanilla-devfreq-event-set-event \
ksym-vanilla-devfreq-get-devfreq-by-node \
ksym-vanilla-devfreq-get-devfreq-by-phandle \
ksym-vanilla-devfreq-get-freq-range \
ksym-vanilla-devfreq-monitor-resume \
ksym-vanilla-devfreq-monitor-start \
ksym-vanilla-devfreq-monitor-stop \
ksym-vanilla-devfreq-monitor-suspend \
ksym-vanilla-devfreq-recommended-opp \
ksym-vanilla-devfreq-register-notifier \
ksym-vanilla-devfreq-register-opp-notifier \
ksym-vanilla-devfreq-remove-device \
ksym-vanilla-devfreq-remove-governor \
ksym-vanilla-devfreq-resume-device \
ksym-vanilla-devfreq-suspend-device \
ksym-vanilla-devfreq-unregister-notifier \
ksym-vanilla-devfreq-unregister-opp-notifier \
ksym-vanilla-devfreq-update-interval \
ksym-vanilla-devfreq-update-status \
ksym-vanilla-devfreq-update-target \
ksym-vanilla-device-add \
ksym-vanilla-device-add-disk \
ksym-vanilla-device-add-groups \
ksym-vanilla-device-add-of-node \
ksym-vanilla-device-add-software-node \
ksym-vanilla-device-attach \
ksym-vanilla-device-bind-driver \
ksym-vanilla-device-create \
ksym-vanilla-device-create-bin-file \
ksym-vanilla-device-create-file \
ksym-vanilla-device-create-managed-software-node \
ksym-vanilla-device-create-with-groups \
ksym-vanilla-device-del \
ksym-vanilla-device-destroy \
ksym-vanilla-device-dma-supported \
ksym-vanilla-device-driver-attach \
ksym-vanilla-device-find-child \
ksym-vanilla-device-for-each-child \
ksym-vanilla-device-for-each-child-reverse \
ksym-vanilla-device-for-each-child-reverse-from \
ksym-vanilla-device-get-dma-attr \
ksym-vanilla-device-get-ethdev-address \
ksym-vanilla-device-get-mac-address \
ksym-vanilla-device-get-match-data \
ksym-vanilla-device-get-named-child-node \
ksym-vanilla-device-get-next-child-node \
ksym-vanilla-device-get-phy-mode \
ksym-vanilla-device-initialize \
ksym-vanilla-device-iommu-capable \
ksym-vanilla-device-is-bound \
ksym-vanilla-device-link-add \
ksym-vanilla-device-link-del \
ksym-vanilla-device-link-remove \
ksym-vanilla-device-link-wait-removal \
ksym-vanilla-device-match-acpi-dev \
ksym-vanilla-device-match-acpi-handle \
ksym-vanilla-device-match-any \
ksym-vanilla-device-match-devt \
ksym-vanilla-device-match-fwnode \
ksym-vanilla-device-match-name \
ksym-vanilla-device-match-of-node \
ksym-vanilla-device-match-type \
ksym-vanilla-device-move \
ksym-vanilla-device-node-to-regmap \
ksym-vanilla-device-pm-wait-for-dev \
ksym-vanilla-device-property-match-string \
ksym-vanilla-device-property-present \
ksym-vanilla-device-property-read-bool \
ksym-vanilla-device-property-read-string \
ksym-vanilla-device-property-read-string-array \
ksym-vanilla-device-property-read-u16-array \
ksym-vanilla-device-property-read-u32-array \
ksym-vanilla-device-property-read-u64-array \
ksym-vanilla-device-property-read-u8-array \
ksym-vanilla-device-register \
ksym-vanilla-device-release-driver \
ksym-vanilla-device-remove-bin-file \
ksym-vanilla-device-remove-file \
ksym-vanilla-device-remove-file-self \
ksym-vanilla-device-remove-groups \
ksym-vanilla-device-remove-of-node \
ksym-vanilla-device-remove-software-node \
ksym-vanilla-device-rename \
ksym-vanilla-device-reprobe \
ksym-vanilla-device-set-node \
ksym-vanilla-device-set-of-node-from-dev \
ksym-vanilla-device-set-wakeup-capable \
ksym-vanilla-device-set-wakeup-enable \
ksym-vanilla-device-show-bool \
ksym-vanilla-device-show-int \
ksym-vanilla-device-show-string \
ksym-vanilla-device-show-ulong \
ksym-vanilla-device-store-bool \
ksym-vanilla-device-store-int \
ksym-vanilla-device-store-ulong \
ksym-vanilla-device-unregister \
ksym-vanilla-device-wakeup-disable \
ksym-vanilla-device-wakeup-enable \
ksym-vanilla-devl-assert-locked \
ksym-vanilla-devl-dpipe-headers-register \
ksym-vanilla-devl-dpipe-headers-unregister \
ksym-vanilla-devl-dpipe-table-register \
ksym-vanilla-devl-dpipe-table-resource-set \
ksym-vanilla-devl-dpipe-table-unregister \
ksym-vanilla-devl-health-reporter-create \
ksym-vanilla-devl-health-reporter-destroy \
ksym-vanilla-devl-linecard-create \
ksym-vanilla-devl-linecard-destroy \
ksym-vanilla-devl-lock \
ksym-vanilla-devl-nested-devlink-set \
ksym-vanilla-devl-param-driverinit-value-get \
ksym-vanilla-devl-param-driverinit-value-set \
ksym-vanilla-devl-param-value-changed \
ksym-vanilla-devl-params-register \
ksym-vanilla-devl-params-unregister \
ksym-vanilla-devl-port-fn-devlink-set \
ksym-vanilla-devl-port-health-reporter-create \
ksym-vanilla-devl-port-register-with-ops \
ksym-vanilla-devl-port-resource-register \
ksym-vanilla-devl-port-resources-unregister \
ksym-vanilla-devl-port-unregister \
ksym-vanilla-devl-rate-leaf-create \
ksym-vanilla-devl-rate-leaf-destroy \
ksym-vanilla-devl-rate-node-create \
ksym-vanilla-devl-rate-nodes-destroy \
ksym-vanilla-devl-region-create \
ksym-vanilla-devl-region-destroy \
ksym-vanilla-devl-register \
ksym-vanilla-devl-resource-occ-get-register \
ksym-vanilla-devl-resource-occ-get-unregister \
ksym-vanilla-devl-resource-register \
ksym-vanilla-devl-resource-size-get \
ksym-vanilla-devl-resources-unregister \
ksym-vanilla-devl-sb-register \
ksym-vanilla-devl-sb-unregister \
ksym-vanilla-devl-trap-groups-register \
ksym-vanilla-devl-trap-groups-unregister \
ksym-vanilla-devl-trap-policers-register \
ksym-vanilla-devl-trap-policers-unregister \
ksym-vanilla-devl-traps-register \
ksym-vanilla-devl-traps-unregister \
ksym-vanilla-devl-trylock \
ksym-vanilla-devl-unlock \
ksym-vanilla-devl-unregister \
ksym-vanilla-devlink-alloc-ns \
ksym-vanilla-devlink-bus-name \
ksym-vanilla-devlink-dev-driver-name \
ksym-vanilla-devlink-dev-name \
ksym-vanilla-devlink-dpipe-action-put \
ksym-vanilla-devlink-dpipe-entry-clear \
ksym-vanilla-devlink-dpipe-entry-ctx-append \
ksym-vanilla-devlink-dpipe-entry-ctx-close \
ksym-vanilla-devlink-dpipe-entry-ctx-prepare \
ksym-vanilla-devlink-dpipe-header-ethernet \
ksym-vanilla-devlink-dpipe-header-ipv4 \
ksym-vanilla-devlink-dpipe-header-ipv6 \
ksym-vanilla-devlink-dpipe-match-put \
ksym-vanilla-devlink-dpipe-table-counter-enabled \
ksym-vanilla-devlink-flash-update-status-notify \
ksym-vanilla-devlink-flash-update-timeout-notify \
ksym-vanilla-devlink-fmsg-arr-pair-nest-end \
ksym-vanilla-devlink-fmsg-arr-pair-nest-start \
ksym-vanilla-devlink-fmsg-binary-pair-nest-end \
ksym-vanilla-devlink-fmsg-binary-pair-nest-start \
ksym-vanilla-devlink-fmsg-binary-pair-put \
ksym-vanilla-devlink-fmsg-binary-put \
ksym-vanilla-devlink-fmsg-bool-pair-put \
ksym-vanilla-devlink-fmsg-dump-skb \
ksym-vanilla-devlink-fmsg-obj-nest-end \
ksym-vanilla-devlink-fmsg-obj-nest-start \
ksym-vanilla-devlink-fmsg-pair-nest-end \
ksym-vanilla-devlink-fmsg-pair-nest-start \
ksym-vanilla-devlink-fmsg-string-pair-put \
ksym-vanilla-devlink-fmsg-string-put \
ksym-vanilla-devlink-fmsg-u32-pair-put \
ksym-vanilla-devlink-fmsg-u32-put \
ksym-vanilla-devlink-fmsg-u64-pair-put \
ksym-vanilla-devlink-fmsg-u8-pair-put \
ksym-vanilla-devlink-free \
ksym-vanilla-devlink-health-report \
ksym-vanilla-devlink-health-reporter-create \
ksym-vanilla-devlink-health-reporter-destroy \
ksym-vanilla-devlink-health-reporter-priv \
ksym-vanilla-devlink-health-reporter-recovery-done \
ksym-vanilla-devlink-health-reporter-state-update \
ksym-vanilla-devlink-info-board-serial-number-put \
ksym-vanilla-devlink-info-serial-number-put \
ksym-vanilla-devlink-info-version-fixed-put \
ksym-vanilla-devlink-info-version-running-put \
ksym-vanilla-devlink-info-version-running-put-ext \
ksym-vanilla-devlink-info-version-stored-put \
ksym-vanilla-devlink-info-version-stored-put-ext \
ksym-vanilla-devlink-is-reload-failed \
ksym-vanilla-devlink-linecard-activate \
ksym-vanilla-devlink-linecard-deactivate \
ksym-vanilla-devlink-linecard-nested-dl-set \
ksym-vanilla-devlink-linecard-provision-clear \
ksym-vanilla-devlink-linecard-provision-fail \
ksym-vanilla-devlink-linecard-provision-set \
ksym-vanilla-devlink-net \
ksym-vanilla-devlink-params-register \
ksym-vanilla-devlink-params-unregister \
ksym-vanilla-devlink-port-attrs-pci-pf-set \
ksym-vanilla-devlink-port-attrs-pci-sf-set \
ksym-vanilla-devlink-port-attrs-pci-vf-set \
ksym-vanilla-devlink-port-attrs-set \
ksym-vanilla-devlink-port-fini \
ksym-vanilla-devlink-port-health-reporter-create \
ksym-vanilla-devlink-port-init \
ksym-vanilla-devlink-port-linecard-set \
ksym-vanilla-devlink-port-region-create \
ksym-vanilla-devlink-port-register-with-ops \
ksym-vanilla-devlink-port-type-clear \
ksym-vanilla-devlink-port-type-eth-set \
ksym-vanilla-devlink-port-type-ib-set \
ksym-vanilla-devlink-port-unregister \
ksym-vanilla-devlink-priv \
ksym-vanilla-devlink-region-create \
ksym-vanilla-devlink-region-destroy \
ksym-vanilla-devlink-region-snapshot-create \
ksym-vanilla-devlink-region-snapshot-id-get \
ksym-vanilla-devlink-region-snapshot-id-put \
ksym-vanilla-devlink-register \
ksym-vanilla-devlink-remote-reload-actions-performed \
ksym-vanilla-devlink-resources-unregister \
ksym-vanilla-devlink-sb-register \
ksym-vanilla-devlink-sb-unregister \
ksym-vanilla-devlink-shd-get \
ksym-vanilla-devlink-shd-get-priv \
ksym-vanilla-devlink-shd-put \
ksym-vanilla-devlink-to-dev \
ksym-vanilla-devlink-trap-ctx-priv \
ksym-vanilla-devlink-trap-groups-register \
ksym-vanilla-devlink-trap-groups-unregister \
ksym-vanilla-devlink-trap-report \
ksym-vanilla-devlink-traps-register \
ksym-vanilla-devlink-traps-unregister \
ksym-vanilla-devlink-unregister \
ksym-vanilla-devm-acpi-dev-add-driver-gpios \
ksym-vanilla-devm-acpi-dma-controller-register \
ksym-vanilla-devm-acpi-install-notify-handler \
ksym-vanilla-devm-ad-sd-setup-buffer-and-trigger \
ksym-vanilla-devm-adis-probe-trigger \
ksym-vanilla-devm-adis-setup-buffer-and-trigger-with-attrs \
ksym-vanilla-devm-alloc-etherdev-mqs \
ksym-vanilla-devm-alloc-workqueue-noprof \
ksym-vanilla-devm-aperture-acquire-for-platform-device \
ksym-vanilla-devm-apple-rtkit-init \
ksym-vanilla-devm-apple-sart-get \
ksym-vanilla-devm-apple-tunable-parse \
ksym-vanilla-devm-arch-io-reserve-memtype-wc \
ksym-vanilla-devm-arch-phys-wc-add \
ksym-vanilla-devm-backlight-device-register \
ksym-vanilla-devm-backlight-device-unregister \
ksym-vanilla-devm-battery-hook-register \
ksym-vanilla-devm-bitmap-alloc \
ksym-vanilla-devm-bitmap-zalloc \
ksym-vanilla-devm-blk-crypto-profile-init \
ksym-vanilla-devm-cci-regmap-init-i2c \
ksym-vanilla-devm-clk-bulk-get \
ksym-vanilla-devm-clk-bulk-get-all \
ksym-vanilla-devm-clk-bulk-get-all-enabled \
ksym-vanilla-devm-clk-bulk-get-optional \
ksym-vanilla-devm-clk-bulk-get-optional-enable \
ksym-vanilla-devm-clk-get \
ksym-vanilla-devm-clk-get-enabled \
ksym-vanilla-devm-clk-get-optional \
ksym-vanilla-devm-clk-get-optional-enabled \
ksym-vanilla-devm-clk-get-optional-enabled-with-rate \
ksym-vanilla-devm-clk-get-optional-prepared \
ksym-vanilla-devm-clk-get-prepared \
ksym-vanilla-devm-clk-hw-get-clk \
ksym-vanilla-devm-clk-hw-register \
ksym-vanilla-devm-clk-hw-register-clkdev \
ksym-vanilla-devm-clk-hw-register-fixed-factor \
ksym-vanilla-devm-clk-hw-register-fixed-factor-fwname \
ksym-vanilla-devm-clk-hw-register-fixed-factor-index \
ksym-vanilla-devm-clk-hw-register-fixed-factor-parent-hw \
ksym-vanilla-devm-clk-hw-register-fixed-factor-with-accuracy-fwname \
ksym-vanilla-devm-clk-notifier-register \
ksym-vanilla-devm-clk-put \
ksym-vanilla-devm-clk-rate-exclusive-get \
ksym-vanilla-devm-clk-register \
ksym-vanilla-devm-clk-register-regmap \
ksym-vanilla-devm-counter-add \
ksym-vanilla-devm-counter-alloc \
ksym-vanilla-devm-cpm-muram-alloc \
ksym-vanilla-devm-cpm-muram-alloc-fixed \
ksym-vanilla-devm-create-dev-dax \
ksym-vanilla-devm-cxl-add-classdev \
ksym-vanilla-devm-cxl-add-dport \
ksym-vanilla-devm-cxl-add-dport-by-dev \
ksym-vanilla-devm-cxl-add-endpoint \
ksym-vanilla-devm-cxl-add-nvdimm \
ksym-vanilla-devm-cxl-add-nvdimm-bridge \
ksym-vanilla-devm-cxl-add-port \
ksym-vanilla-devm-cxl-add-rch-dport \
ksym-vanilla-devm-cxl-add-root \
ksym-vanilla-devm-cxl-dpa-reserve \
ksym-vanilla-devm-cxl-dport-rch-ras-setup \
ksym-vanilla-devm-cxl-endpoint-decoders-setup \
ksym-vanilla-devm-cxl-enumerate-ports \
ksym-vanilla-devm-cxl-memdev-edac-register \
ksym-vanilla-devm-cxl-pmu-add \
ksym-vanilla-devm-cxl-port-ras-setup \
ksym-vanilla-devm-cxl-probe-mem \
ksym-vanilla-devm-cxl-region-edac-register \
ksym-vanilla-devm-cxl-register-pci-bus \
ksym-vanilla-devm-cxl-sanitize-setup-notifier \
ksym-vanilla-devm-cxl-setup-features \
ksym-vanilla-devm-cxl-setup-fw-upload \
ksym-vanilla-devm-cxl-setup-fwctl \
ksym-vanilla-devm-cxl-switch-port-decoders-setup \
ksym-vanilla-devm-devfreq-add-device \
ksym-vanilla-devm-devfreq-add-governor \
ksym-vanilla-devm-devfreq-event-add-edev \
ksym-vanilla-devm-devfreq-event-remove-edev \
ksym-vanilla-devm-devfreq-register-notifier \
ksym-vanilla-devm-devfreq-register-opp-notifier \
ksym-vanilla-devm-devfreq-remove-device \
ksym-vanilla-devm-devfreq-unregister-notifier \
ksym-vanilla-devm-devfreq-unregister-opp-notifier \
ksym-vanilla-devm-device-add-group \
ksym-vanilla-devm-dma-request-chan \
ksym-vanilla-devm-drm-bridge-add \
ksym-vanilla-devm-drm-dp-hpd-bridge-add \
ksym-vanilla-devm-drm-dp-hpd-bridge-alloc \
ksym-vanilla-devm-drm-of-get-bridge \
ksym-vanilla-devm-drm-panel-add \
ksym-vanilla-devm-drm-panel-add-follower \
ksym-vanilla-devm-drm-panel-bridge-add \
ksym-vanilla-devm-drm-panel-bridge-add-typed \
ksym-vanilla-devm-drm-put-bridge \
ksym-vanilla-devm-extcon-dev-allocate \
ksym-vanilla-devm-extcon-dev-free \
ksym-vanilla-devm-extcon-dev-register \
ksym-vanilla-devm-extcon-dev-unregister \
ksym-vanilla-devm-extcon-register-notifier \
ksym-vanilla-devm-extcon-register-notifier-all \
ksym-vanilla-devm-extcon-unregister-notifier \
ksym-vanilla-devm-extcon-unregister-notifier-all \
ksym-vanilla-devm-framer-create \
ksym-vanilla-devm-framer-get \
ksym-vanilla-devm-framer-optional-get \
ksym-vanilla-devm-free-irq \
ksym-vanilla-devm-free-pages \
ksym-vanilla-devm-fwnode-gpiod-get-index \
ksym-vanilla-devm-fwnode-iio-channel-get-by-name \
ksym-vanilla-devm-fwnode-pwm-get \
ksym-vanilla-devm-gen-pool-create \
ksym-vanilla-devm-get-clk-from-child \
ksym-vanilla-devm-get-free-pages \
ksym-vanilla-devm-ghes-register-vendor-record-notifier \
ksym-vanilla-devm-gpio-regmap-register \
ksym-vanilla-devm-gpio-request-one \
ksym-vanilla-devm-gpiochip-add-data-with-key \
ksym-vanilla-devm-gpiochip-fwd-alloc \
ksym-vanilla-devm-gpiod-get \
ksym-vanilla-devm-gpiod-get-array \
ksym-vanilla-devm-gpiod-get-array-optional \
ksym-vanilla-devm-gpiod-get-index \
ksym-vanilla-devm-gpiod-get-index-optional \
ksym-vanilla-devm-gpiod-get-optional \
ksym-vanilla-devm-gpiod-put \
ksym-vanilla-devm-gpiod-put-array \
ksym-vanilla-devm-gpiod-shared-get \
ksym-vanilla-devm-gpiod-unhinge \
ksym-vanilla-devm-hte-register-chip \
ksym-vanilla-devm-hte-request-ts-ns \
ksym-vanilla-devm-hwmon-device-register-with-groups \
ksym-vanilla-devm-hwmon-device-register-with-info \
ksym-vanilla-devm-hwmon-sanitize-name \
ksym-vanilla-devm-hwrng-register \
ksym-vanilla-devm-hwrng-unregister \
ksym-vanilla-devm-hwspin-lock-free \
ksym-vanilla-devm-hwspin-lock-register \
ksym-vanilla-devm-hwspin-lock-request-specific \
ksym-vanilla-devm-hwspin-lock-unregister \
ksym-vanilla-devm-i2c-add-adapter \
ksym-vanilla-devm-i2c-new-dummy-device \
ksym-vanilla-devm-icc-clk-register \
ksym-vanilla-devm-idio-16-regmap-register \
ksym-vanilla-devm-iio-adc-device-alloc-chaninfo-se \
ksym-vanilla-devm-iio-backend-enable \
ksym-vanilla-devm-iio-backend-fwnode-get \
ksym-vanilla-devm-iio-backend-get \
ksym-vanilla-devm-iio-backend-get-by-index \
ksym-vanilla-devm-iio-backend-register \
ksym-vanilla-devm-iio-backend-request-buffer \
ksym-vanilla-devm-iio-channel-get \
ksym-vanilla-devm-iio-channel-get-all \
ksym-vanilla-devm-iio-device-alloc \
ksym-vanilla-devm-iio-dmaengine-buffer-setup-ext \
ksym-vanilla-devm-iio-dmaengine-buffer-setup-with-handle \
ksym-vanilla-devm-iio-hw-consumer-alloc \
ksym-vanilla-devm-iio-init-iio-gts \
ksym-vanilla-devm-iio-kfifo-buffer-setup-ext \
ksym-vanilla-devm-iio-map-array-register \
ksym-vanilla-devm-iio-trigger-register \
ksym-vanilla-devm-iio-triggered-buffer-setup-ext \
ksym-vanilla-devm-init-badblocks \
ksym-vanilla-devm-input-allocate-device \
ksym-vanilla-devm-ioport-map \
ksym-vanilla-devm-ioport-unmap \
ksym-vanilla-devm-ioremap \
ksym-vanilla-devm-ioremap-resource \
ksym-vanilla-devm-ioremap-resource-wc \
ksym-vanilla-devm-ioremap-uc \
ksym-vanilla-devm-ioremap-wc \
ksym-vanilla-devm-iounmap \
ksym-vanilla-devm-irq-alloc-generic-chip \
ksym-vanilla-devm-irq-domain-create-sim \
ksym-vanilla-devm-irq-domain-create-sim-full \
ksym-vanilla-devm-irq-domain-instantiate \
ksym-vanilla-devm-irq-setup-generic-chip \
ksym-vanilla-devm-is-action-added \
ksym-vanilla-devm-kasprintf \
ksym-vanilla-devm-kasprintf-strarray \
ksym-vanilla-devm-kfree \
ksym-vanilla-devm-kmalloc \
ksym-vanilla-devm-kmemdup \
ksym-vanilla-devm-kmemdup-const \
ksym-vanilla-devm-krealloc \
ksym-vanilla-devm-kstrdup \
ksym-vanilla-devm-kstrdup-const \
ksym-vanilla-devm-kvasprintf \
ksym-vanilla-devm-lcd-device-register \
ksym-vanilla-devm-lcd-device-unregister \
ksym-vanilla-devm-led-classdev-flash-register-ext \
ksym-vanilla-devm-led-classdev-flash-unregister \
ksym-vanilla-devm-led-classdev-multicolor-register-ext \
ksym-vanilla-devm-led-classdev-multicolor-unregister \
ksym-vanilla-devm-led-classdev-register-ext \
ksym-vanilla-devm-led-classdev-unregister \
ksym-vanilla-devm-led-get \
ksym-vanilla-devm-led-trigger-register \
ksym-vanilla-devm-mbox-controller-register \
ksym-vanilla-devm-mdio-regmap-register \
ksym-vanilla-devm-mdiobus-alloc-size \
ksym-vanilla-devm-memremap \
ksym-vanilla-devm-memremap-pages \
ksym-vanilla-devm-memunmap \
ksym-vanilla-devm-memunmap-pages \
ksym-vanilla-devm-mfd-add-devices \
ksym-vanilla-devm-mipi-dsi-attach \
ksym-vanilla-devm-mipi-dsi-device-register-full \
ksym-vanilla-devm-mmc-alloc-host \
ksym-vanilla-devm-mtk-clk-mux-notifier-register \
ksym-vanilla-devm-mux-chip-alloc \
ksym-vanilla-devm-mux-chip-register \
ksym-vanilla-devm-mux-control-get \
ksym-vanilla-devm-mux-state-get-from-np \
ksym-vanilla-devm-mux-state-get-optional \
ksym-vanilla-devm-mux-state-get-optional-selected \
ksym-vanilla-devm-mux-state-get-selected \
ksym-vanilla-devm-namespace-disable \
ksym-vanilla-devm-namespace-enable \
ksym-vanilla-devm-nvdimm-memremap \
ksym-vanilla-devm-nvmem-cell-get \
ksym-vanilla-devm-nvmem-cell-put \
ksym-vanilla-devm-nvmem-device-get \
ksym-vanilla-devm-nvmem-device-put \
ksym-vanilla-devm-nvmem-register \
ksym-vanilla-devm-of-clk-add-hw-provider \
ksym-vanilla-devm-of-dp-aux-populate-bus \
ksym-vanilla-devm-of-find-backlight \
ksym-vanilla-devm-of-icc-bulk-get \
ksym-vanilla-devm-of-icc-get \
ksym-vanilla-devm-of-icc-get-by-index \
ksym-vanilla-devm-of-iomap \
ksym-vanilla-devm-of-led-get \
ksym-vanilla-devm-of-led-get-optional \
ksym-vanilla-devm-of-phy-get \
ksym-vanilla-devm-of-phy-get-by-index \
ksym-vanilla-devm-of-phy-optional-get \
ksym-vanilla-devm-of-phy-package-join \
ksym-vanilla-devm-of-phy-provider-unregister \
ksym-vanilla-devm-of-platform-depopulate \
ksym-vanilla-devm-of-platform-populate \
ksym-vanilla-devm-of-qcom-ice-get \
ksym-vanilla-devm-of-regulator-get \
ksym-vanilla-devm-of-regulator-get-optional \
ksym-vanilla-devm-otg-ulpi-create \
ksym-vanilla-devm-pci-alloc-host-bridge \
ksym-vanilla-devm-pci-pwrctrl-device-set-ready \
ksym-vanilla-devm-pci-remap-cfg-resource \
ksym-vanilla-devm-pci-remap-cfgspace \
ksym-vanilla-devm-pci-remap-iospace \
ksym-vanilla-devm-phy-create \
ksym-vanilla-devm-phy-destroy \
ksym-vanilla-devm-phy-get \
ksym-vanilla-devm-phy-optional-get \
ksym-vanilla-devm-phy-package-join \
ksym-vanilla-devm-phy-put \
ksym-vanilla-devm-pinctrl-get \
ksym-vanilla-devm-pinctrl-put \
ksym-vanilla-devm-pinctrl-register \
ksym-vanilla-devm-pinctrl-register-and-init \
ksym-vanilla-devm-pinctrl-register-mappings \
ksym-vanilla-devm-platform-get-and-ioremap-resource \
ksym-vanilla-devm-platform-get-irqs-affinity \
ksym-vanilla-devm-platform-ioremap-resource \
ksym-vanilla-devm-platform-ioremap-resource-byname \
ksym-vanilla-devm-platform-profile-register \
ksym-vanilla-devm-pm-clk-create \
ksym-vanilla-devm-pm-domain-attach-list \
ksym-vanilla-devm-pm-opp-of-add-table \
ksym-vanilla-devm-pm-opp-of-add-table-indexed \
ksym-vanilla-devm-pm-opp-set-config \
ksym-vanilla-devm-pm-runtime-enable \
ksym-vanilla-devm-pm-runtime-get-noresume \
ksym-vanilla-devm-pm-runtime-set-active-enabled \
ksym-vanilla-devm-pm-set-wake-irq \
ksym-vanilla-devm-pmic-glink-client-alloc \
ksym-vanilla-devm-power-supply-get-by-reference \
ksym-vanilla-devm-power-supply-register \
ksym-vanilla-devm-pse-controller-register \
ksym-vanilla-devm-pse-irq-helper \
ksym-vanilla-devm-pvpanic-probe \
ksym-vanilla-devm-pwm-get \
ksym-vanilla-devm-pwmchip-alloc \
ksym-vanilla-devm-pwrseq-device-register \
ksym-vanilla-devm-pwrseq-get \
ksym-vanilla-devm-qcom-scm-pas-context-alloc \
ksym-vanilla-devm-qcom-smem-state-get \
ksym-vanilla-devm-qcom-tzmem-pool-new \
ksym-vanilla-devm-rc-allocate-device \
ksym-vanilla-devm-rc-register-device \
ksym-vanilla-devm-reboot-mode-register \
ksym-vanilla-devm-reboot-mode-unregister \
ksym-vanilla-devm-register-framebuffer \
ksym-vanilla-devm-register-netdev \
ksym-vanilla-devm-register-power-off-handler \
ksym-vanilla-devm-register-reboot-notifier \
ksym-vanilla-devm-register-restart-handler \
ksym-vanilla-devm-register-sys-off-handler \
ksym-vanilla-devm-regmap-add-irq-chip \
ksym-vanilla-devm-regmap-add-irq-chip-fwnode \
ksym-vanilla-devm-regmap-del-irq-chip \
ksym-vanilla-devm-regmap-field-alloc \
ksym-vanilla-devm-regmap-field-bulk-alloc \
ksym-vanilla-devm-regmap-field-bulk-free \
ksym-vanilla-devm-regmap-field-free \
ksym-vanilla-devm-regmap-init-encx24j600 \
ksym-vanilla-devm-regmap-init-sch56xx \
ksym-vanilla-devm-regmap-init-vexpress-config \
ksym-vanilla-devm-regulator-bulk-get \
ksym-vanilla-devm-regulator-bulk-get-const \
ksym-vanilla-devm-regulator-bulk-get-enable \
ksym-vanilla-devm-regulator-bulk-get-exclusive \
ksym-vanilla-devm-regulator-bulk-put \
ksym-vanilla-devm-regulator-bulk-register-supply-alias \
ksym-vanilla-devm-regulator-get \
ksym-vanilla-devm-regulator-get-enable \
ksym-vanilla-devm-regulator-get-enable-optional \
ksym-vanilla-devm-regulator-get-enable-read-voltage \
ksym-vanilla-devm-regulator-get-exclusive \
ksym-vanilla-devm-regulator-get-optional \
ksym-vanilla-devm-regulator-irq-helper \
ksym-vanilla-devm-regulator-put \
ksym-vanilla-devm-regulator-register \
ksym-vanilla-devm-regulator-register-notifier \
ksym-vanilla-devm-regulator-register-supply-alias \
ksym-vanilla-devm-regulator-unregister-notifier \
ksym-vanilla-devm-release-action \
ksym-vanilla-devm-release-resource \
ksym-vanilla-devm-remove-action-nowarn \
ksym-vanilla-devm-request-any-context-irq \
ksym-vanilla-devm-request-free-mem-region \
ksym-vanilla-devm-request-pci-bus-resources \
ksym-vanilla-devm-request-resource \
ksym-vanilla-devm-request-threaded-irq \
ksym-vanilla-devm-reset-control-array-get \
ksym-vanilla-devm-reset-controller-register \
ksym-vanilla-devm-rpi-firmware-get \
ksym-vanilla-devm-rproc-add \
ksym-vanilla-devm-rproc-alloc \
ksym-vanilla-devm-rtc-allocate-device \
ksym-vanilla-devm-rtc-device-register \
ksym-vanilla-devm-rtc-nvmem-register \
ksym-vanilla-devm-sdca-irq-allocate \
ksym-vanilla-devm-serdev-device-open \
ksym-vanilla-devm-sigmadsp-init \
ksym-vanilla-devm-sigmadsp-init-i2c \
ksym-vanilla-devm-sigmadsp-init-regmap \
ksym-vanilla-devm-snd-dmaengine-pcm-register \
ksym-vanilla-devm-snd-soc-register-card \
ksym-vanilla-devm-snd-soc-register-component \
ksym-vanilla-devm-spi-mem-dirmap-create \
ksym-vanilla-devm-spi-mem-dirmap-destroy \
ksym-vanilla-devm-spi-new-ancillary-device \
ksym-vanilla-devm-spi-offload-alloc \
ksym-vanilla-devm-spi-offload-get \
ksym-vanilla-devm-spi-offload-rx-stream-request-dma-chan \
ksym-vanilla-devm-spi-offload-trigger-get \
ksym-vanilla-devm-spi-offload-trigger-register \
ksym-vanilla-devm-spi-offload-tx-stream-request-dma-chan \
ksym-vanilla-devm-spi-optimize-message \
ksym-vanilla-devm-spi-register-controller \
ksym-vanilla-devm-spmi-controller-add \
ksym-vanilla-devm-spmi-controller-alloc \
ksym-vanilla-devm-stmmac-pltfr-probe \
ksym-vanilla-devm-stmmac-probe-config-dt \
ksym-vanilla-devm-sunxi-ccu-probe \
ksym-vanilla-devm-tegra-core-dev-init-opp-table \
ksym-vanilla-devm-tegra-memory-controller-get \
ksym-vanilla-devm-tegra-mipi-add-provider \
ksym-vanilla-devm-tegra-pcm-platform-register \
ksym-vanilla-devm-tegra-pmc-get \
ksym-vanilla-devm-thermal-add-hwmon-sysfs \
ksym-vanilla-devm-thermal-cooling-device-register \
ksym-vanilla-devm-thermal-of-child-cooling-device-register \
ksym-vanilla-devm-thermal-of-cooling-device-register \
ksym-vanilla-devm-thermal-of-zone-register \
ksym-vanilla-devm-thermal-of-zone-unregister \
ksym-vanilla-devm-tsa-serial-get-byphandle \
ksym-vanilla-devm-turris-signing-key-create \
ksym-vanilla-devm-usb-get-phy \
ksym-vanilla-devm-usb-get-phy-by-node \
ksym-vanilla-devm-usb-get-phy-by-phandle \
ksym-vanilla-devm-watchdog-register-device \
ksym-vanilla-devres-add \
ksym-vanilla-devres-close-group \
ksym-vanilla-devres-destroy \
ksym-vanilla-devres-find \
ksym-vanilla-devres-for-each-res \
ksym-vanilla-devres-free \
ksym-vanilla-devres-get \
ksym-vanilla-devres-open-group \
ksym-vanilla-devres-release \
ksym-vanilla-devres-release-group \
ksym-vanilla-devres-remove \
ksym-vanilla-devres-remove-group \
ksym-vanilla-dfh-find-param \
ksym-vanilla-dfl-driver-unregister \
ksym-vanilla-dfl-feature-ioctl-get-num-irqs \
ksym-vanilla-dfl-feature-ioctl-set-irq \
ksym-vanilla-dfl-fpga-cdev-assign-port \
ksym-vanilla-dfl-fpga-cdev-config-ports-pf \
ksym-vanilla-dfl-fpga-cdev-config-ports-vf \
ksym-vanilla-dfl-fpga-cdev-release-port \
ksym-vanilla-dfl-fpga-check-port-id \
ksym-vanilla-dfl-fpga-dev-feature-init \
ksym-vanilla-dfl-fpga-dev-feature-uinit \
ksym-vanilla-dfl-fpga-dev-ops-register \
ksym-vanilla-dfl-fpga-dev-ops-unregister \
ksym-vanilla-dfl-fpga-enum-info-add-dfl \
ksym-vanilla-dfl-fpga-enum-info-add-irq \
ksym-vanilla-dfl-fpga-enum-info-alloc \
ksym-vanilla-dfl-fpga-enum-info-free \
ksym-vanilla-dfl-fpga-feature-devs-enumerate \
ksym-vanilla-dfl-fpga-feature-devs-remove \
ksym-vanilla-dfl-fpga-port-ops-add \
ksym-vanilla-dfl-fpga-port-ops-del \
ksym-vanilla-dfl-fpga-port-ops-get \
ksym-vanilla-dfl-fpga-port-ops-put \
ksym-vanilla-dfl-fpga-set-irq-triggers \
ksym-vanilla-dfs-pattern-detector-init \
ksym-vanilla-dget-parent \
ksym-vanilla-dib0070-attach \
ksym-vanilla-dib0070-ctrl-agc-filter \
ksym-vanilla-dib0070-get-rf-output \
ksym-vanilla-dib0070-set-rf-output \
ksym-vanilla-dib0070-wbd-offset \
ksym-vanilla-dib0090-dcc-freq \
ksym-vanilla-dib0090-fw-register \
ksym-vanilla-dib0090-gain-control \
ksym-vanilla-dib0090-get-current-gain \
ksym-vanilla-dib0090-get-tune-state \
ksym-vanilla-dib0090-get-wbd-offset \
ksym-vanilla-dib0090-get-wbd-target \
ksym-vanilla-dib0090-pwm-gain-reset \
ksym-vanilla-dib0090-register \
ksym-vanilla-dib0090-set-dc-servo \
ksym-vanilla-dib0090-set-switch \
ksym-vanilla-dib0090-set-tune-state \
ksym-vanilla-dib0090-set-vga \
ksym-vanilla-dib0090-update-rframp-7090 \
ksym-vanilla-dib0090-update-tuning-table-7090 \
ksym-vanilla-dib3000mb-attach \
ksym-vanilla-dib3000mc-attach \
ksym-vanilla-dib3000mc-get-tuner-i2c-master \
ksym-vanilla-dib3000mc-i2c-enumeration \
ksym-vanilla-dib3000mc-pid-control \
ksym-vanilla-dib3000mc-pid-parse \
ksym-vanilla-dib3000mc-set-config \
ksym-vanilla-dib7000m-attach \
ksym-vanilla-dib7000m-get-i2c-master \
ksym-vanilla-dib7000m-pid-filter \
ksym-vanilla-dib7000m-pid-filter-ctrl \
ksym-vanilla-dib7000p-attach \
ksym-vanilla-dib8000-attach \
ksym-vanilla-dib9000-attach \
ksym-vanilla-dib9000-firmware-post-pll-init \
ksym-vanilla-dib9000-fw-pid-filter \
ksym-vanilla-dib9000-fw-pid-filter-ctrl \
ksym-vanilla-dib9000-fw-set-component-bus-speed \
ksym-vanilla-dib9000-get-component-bus-interface \
ksym-vanilla-dib9000-get-i2c-master \
ksym-vanilla-dib9000-get-slave-frontend \
ksym-vanilla-dib9000-get-tuner-interface \
ksym-vanilla-dib9000-i2c-enumeration \
ksym-vanilla-dib9000-set-gpio \
ksym-vanilla-dib9000-set-i2c-adapter \
ksym-vanilla-dib9000-set-slave-frontend \
ksym-vanilla-dibs-dev-add \
ksym-vanilla-dibs-dev-alloc \
ksym-vanilla-dibs-dev-del \
ksym-vanilla-dibs-register-client \
ksym-vanilla-dibs-unregister-client \
ksym-vanilla-dibusb-dib3000mc-frontend-attach \
ksym-vanilla-dibusb-dib3000mc-tuner-attach \
ksym-vanilla-dibusb-i2c-algo \
ksym-vanilla-dibusb-pid-filter \
ksym-vanilla-dibusb-pid-filter-ctrl \
ksym-vanilla-dibusb-power-ctrl \
ksym-vanilla-dibusb-rc-query \
ksym-vanilla-dibusb-read-eeprom-byte \
ksym-vanilla-dibusb-streaming-ctrl \
ksym-vanilla-dibusb2-0-power-ctrl \
ksym-vanilla-dibusb2-0-streaming-ctrl \
ksym-vanilla-dibx000-exit-i2c-master \
ksym-vanilla-dibx000-get-i2c-adapter \
ksym-vanilla-dibx000-i2c-set-speed \
ksym-vanilla-dibx000-init-i2c-master \
ksym-vanilla-dibx000-reset-i2c-master \
ksym-vanilla-digsig-verify \
ksym-vanilla-dim-calc-stats \
ksym-vanilla-dim-on-top \
ksym-vanilla-dim-park-on-top \
ksym-vanilla-dim-park-tired \
ksym-vanilla-dim-turn \
ksym-vanilla-direct-write-fallback \
ksym-vanilla-dirty-writeback-interval \
ksym-vanilla-disable-cpufreq \
ksym-vanilla-disable-delayed-work \
ksym-vanilla-disable-delayed-work-sync \
ksym-vanilla-disable-hardirq \
ksym-vanilla-disable-ipv6-mod \
ksym-vanilla-disable-irq \
ksym-vanilla-disable-irq-nosync \
ksym-vanilla-disable-kprobe \
ksym-vanilla-disable-percpu-irq \
ksym-vanilla-disable-work \
ksym-vanilla-disable-work-sync \
ksym-vanilla-discard-new-inode \
ksym-vanilla-disk-alloc-independent-access-ranges \
ksym-vanilla-disk-check-media-change \
ksym-vanilla-disk-force-media-change \
ksym-vanilla-disk-live \
ksym-vanilla-disk-report-zone \
ksym-vanilla-disk-set-independent-access-ranges \
ksym-vanilla-disk-uevent \
ksym-vanilla-dispatch-hid-bpf-device-event \
ksym-vanilla-dispatch-hid-bpf-output-report \
ksym-vanilla-dispatch-hid-bpf-raw-requests \
ksym-vanilla-display-timings-release \
ksym-vanilla-divider-determine-rate \
ksym-vanilla-divider-get-val \
ksym-vanilla-divider-recalc-rate \
ksym-vanilla-divider-ro-determine-rate \
ksym-vanilla-dlm-errname \
ksym-vanilla-dlm-lock \
ksym-vanilla-dlm-new-lockspace \
ksym-vanilla-dlm-posix-cancel \
ksym-vanilla-dlm-posix-get \
ksym-vanilla-dlm-posix-lock \
ksym-vanilla-dlm-posix-unlock \
ksym-vanilla-dlm-print-one-lock \
ksym-vanilla-dlm-register-domain \
ksym-vanilla-dlm-register-eviction-cb \
ksym-vanilla-dlm-release-lockspace \
ksym-vanilla-dlm-setup-eviction-cb \
ksym-vanilla-dlm-unlock \
ksym-vanilla-dlm-unregister-domain \
ksym-vanilla-dlm-unregister-eviction-cb \
ksym-vanilla-dlmlock \
ksym-vanilla-dlmunlock \
ksym-vanilla-dln2-register-event-cb \
ksym-vanilla-dln2-transfer \
ksym-vanilla-dln2-unregister-event-cb \
ksym-vanilla-dm-accept-partial-bio \
ksym-vanilla-dm-array-cursor-begin \
ksym-vanilla-dm-array-cursor-end \
ksym-vanilla-dm-array-cursor-get-value \
ksym-vanilla-dm-array-cursor-next \
ksym-vanilla-dm-array-cursor-skip \
ksym-vanilla-dm-array-del \
ksym-vanilla-dm-array-empty \
ksym-vanilla-dm-array-get-value \
ksym-vanilla-dm-array-info-init \
ksym-vanilla-dm-array-new \
ksym-vanilla-dm-array-resize \
ksym-vanilla-dm-array-set-value \
ksym-vanilla-dm-array-walk \
ksym-vanilla-dm-audit-log-bio \
ksym-vanilla-dm-audit-log-ti \
ksym-vanilla-dm-bio-detain \
ksym-vanilla-dm-bio-from-per-bio-data \
ksym-vanilla-dm-bio-get-target-bio-nr \
ksym-vanilla-dm-bio-prison-alloc-cell \
ksym-vanilla-dm-bio-prison-alloc-cell-v2 \
ksym-vanilla-dm-bio-prison-create \
ksym-vanilla-dm-bio-prison-create-v2 \
ksym-vanilla-dm-bio-prison-destroy \
ksym-vanilla-dm-bio-prison-destroy-v2 \
ksym-vanilla-dm-bio-prison-free-cell \
ksym-vanilla-dm-bio-prison-free-cell-v2 \
ksym-vanilla-dm-bitset-clear-bit \
ksym-vanilla-dm-bitset-cursor-begin \
ksym-vanilla-dm-bitset-cursor-end \
ksym-vanilla-dm-bitset-cursor-get-value \
ksym-vanilla-dm-bitset-cursor-next \
ksym-vanilla-dm-bitset-cursor-skip \
ksym-vanilla-dm-bitset-del \
ksym-vanilla-dm-bitset-empty \
ksym-vanilla-dm-bitset-flush \
ksym-vanilla-dm-bitset-new \
ksym-vanilla-dm-bitset-resize \
ksym-vanilla-dm-bitset-set-bit \
ksym-vanilla-dm-bitset-test-bit \
ksym-vanilla-dm-block-data \
ksym-vanilla-dm-block-location \
ksym-vanilla-dm-block-manager-create \
ksym-vanilla-dm-block-manager-destroy \
ksym-vanilla-dm-block-manager-reset \
ksym-vanilla-dm-bm-block-size \
ksym-vanilla-dm-bm-checksum \
ksym-vanilla-dm-bm-flush \
ksym-vanilla-dm-bm-is-read-only \
ksym-vanilla-dm-bm-read-lock \
ksym-vanilla-dm-bm-set-read-only \
ksym-vanilla-dm-bm-set-read-write \
ksym-vanilla-dm-bm-unlock \
ksym-vanilla-dm-bm-write-lock \
ksym-vanilla-dm-bm-write-lock-zero \
ksym-vanilla-dm-btree-cursor-begin \
ksym-vanilla-dm-btree-cursor-end \
ksym-vanilla-dm-btree-cursor-get-value \
ksym-vanilla-dm-btree-cursor-next \
ksym-vanilla-dm-btree-cursor-skip \
ksym-vanilla-dm-btree-del \
ksym-vanilla-dm-btree-empty \
ksym-vanilla-dm-btree-find-highest-key \
ksym-vanilla-dm-btree-find-lowest-key \
ksym-vanilla-dm-btree-insert \
ksym-vanilla-dm-btree-insert-notify \
ksym-vanilla-dm-btree-lookup \
ksym-vanilla-dm-btree-lookup-next \
ksym-vanilla-dm-btree-remove \
ksym-vanilla-dm-btree-remove-leaves \
ksym-vanilla-dm-btree-walk \
ksym-vanilla-dm-bufio-client-create \
ksym-vanilla-dm-bufio-client-destroy \
ksym-vanilla-dm-bufio-client-reset \
ksym-vanilla-dm-bufio-forget \
ksym-vanilla-dm-bufio-forget-buffers \
ksym-vanilla-dm-bufio-get \
ksym-vanilla-dm-bufio-get-aux-data \
ksym-vanilla-dm-bufio-get-block-data \
ksym-vanilla-dm-bufio-get-block-number \
ksym-vanilla-dm-bufio-get-block-size \
ksym-vanilla-dm-bufio-get-client \
ksym-vanilla-dm-bufio-get-device-size \
ksym-vanilla-dm-bufio-get-dm-io-client \
ksym-vanilla-dm-bufio-issue-discard \
ksym-vanilla-dm-bufio-issue-flush \
ksym-vanilla-dm-bufio-mark-buffer-dirty \
ksym-vanilla-dm-bufio-mark-partial-buffer-dirty \
ksym-vanilla-dm-bufio-new \
ksym-vanilla-dm-bufio-prefetch \
ksym-vanilla-dm-bufio-prefetch-with-ioprio \
ksym-vanilla-dm-bufio-read \
ksym-vanilla-dm-bufio-read-with-ioprio \
ksym-vanilla-dm-bufio-release \
ksym-vanilla-dm-bufio-set-minimum-buffers \
ksym-vanilla-dm-bufio-set-sector-offset \
ksym-vanilla-dm-bufio-write-dirty-buffers \
ksym-vanilla-dm-bufio-write-dirty-buffers-async \
ksym-vanilla-dm-cache-policy-create \
ksym-vanilla-dm-cache-policy-destroy \
ksym-vanilla-dm-cache-policy-get-hint-size \
ksym-vanilla-dm-cache-policy-get-name \
ksym-vanilla-dm-cache-policy-get-version \
ksym-vanilla-dm-cache-policy-register \
ksym-vanilla-dm-cache-policy-unregister \
ksym-vanilla-dm-cell-error \
ksym-vanilla-dm-cell-get-v2 \
ksym-vanilla-dm-cell-key-has-valid-range \
ksym-vanilla-dm-cell-lock-promote-v2 \
ksym-vanilla-dm-cell-lock-v2 \
ksym-vanilla-dm-cell-put-v2 \
ksym-vanilla-dm-cell-quiesce-v2 \
ksym-vanilla-dm-cell-release \
ksym-vanilla-dm-cell-release-no-holder \
ksym-vanilla-dm-cell-unlock-v2 \
ksym-vanilla-dm-cell-visit-release \
ksym-vanilla-dm-consume-args \
ksym-vanilla-dm-copy-name-and-uuid \
ksym-vanilla-dm-crypt-keys-addr \
ksym-vanilla-dm-deferred-entry-dec \
ksym-vanilla-dm-deferred-entry-inc \
ksym-vanilla-dm-deferred-set-add-work \
ksym-vanilla-dm-deferred-set-create \
ksym-vanilla-dm-deferred-set-destroy \
ksym-vanilla-dm-device-name \
ksym-vanilla-dm-devt-from-path \
ksym-vanilla-dm-dirty-log-create \
ksym-vanilla-dm-dirty-log-destroy \
ksym-vanilla-dm-dirty-log-type-register \
ksym-vanilla-dm-dirty-log-type-unregister \
ksym-vanilla-dm-disk \
ksym-vanilla-dm-disk-bitset-init \
ksym-vanilla-dm-exception-store-create \
ksym-vanilla-dm-exception-store-destroy \
ksym-vanilla-dm-exception-store-type-register \
ksym-vanilla-dm-exception-store-type-unregister \
ksym-vanilla-dm-get-device \
ksym-vanilla-dm-get-md \
ksym-vanilla-dm-get-reserved-bio-based-ios \
ksym-vanilla-dm-hold \
ksym-vanilla-dm-internal-resume \
ksym-vanilla-dm-internal-resume-fast \
ksym-vanilla-dm-internal-suspend-fast \
ksym-vanilla-dm-internal-suspend-noflush \
ksym-vanilla-dm-io \
ksym-vanilla-dm-io-client-create \
ksym-vanilla-dm-io-client-destroy \
ksym-vanilla-dm-kcopyd-client-create \
ksym-vanilla-dm-kcopyd-client-destroy \
ksym-vanilla-dm-kcopyd-client-flush \
ksym-vanilla-dm-kcopyd-copy \
ksym-vanilla-dm-kcopyd-do-callback \
ksym-vanilla-dm-kcopyd-prepare-callback \
ksym-vanilla-dm-kcopyd-zero \
ksym-vanilla-dm-kobject-release \
ksym-vanilla-dm-mq-kick-requeue-list \
ksym-vanilla-dm-noflush-suspending \
ksym-vanilla-dm-path-uevent \
ksym-vanilla-dm-per-bio-data \
ksym-vanilla-dm-post-suspending \
ksym-vanilla-dm-put \
ksym-vanilla-dm-put-device \
ksym-vanilla-dm-read-arg \
ksym-vanilla-dm-read-arg-group \
ksym-vanilla-dm-region-hash-create \
ksym-vanilla-dm-region-hash-destroy \
ksym-vanilla-dm-register-path-selector \
ksym-vanilla-dm-register-target \
ksym-vanilla-dm-report-zones \
ksym-vanilla-dm-restorepowerindex \
ksym-vanilla-dm-rh-bio-to-region \
ksym-vanilla-dm-rh-dec \
ksym-vanilla-dm-rh-delay \
ksym-vanilla-dm-rh-dirty-log \
ksym-vanilla-dm-rh-flush \
ksym-vanilla-dm-rh-get-region-key \
ksym-vanilla-dm-rh-get-region-size \
ksym-vanilla-dm-rh-get-state \
ksym-vanilla-dm-rh-inc-pending \
ksym-vanilla-dm-rh-mark-nosync \
ksym-vanilla-dm-rh-recovery-end \
ksym-vanilla-dm-rh-recovery-in-flight \
ksym-vanilla-dm-rh-recovery-prepare \
ksym-vanilla-dm-rh-recovery-start \
ksym-vanilla-dm-rh-region-context \
ksym-vanilla-dm-rh-region-to-sector \
ksym-vanilla-dm-rh-start-recovery \
ksym-vanilla-dm-rh-stop-recovery \
ksym-vanilla-dm-rh-update-states \
ksym-vanilla-dm-savepowerindex \
ksym-vanilla-dm-send-uevents \
ksym-vanilla-dm-set-target-max-io-len \
ksym-vanilla-dm-shift-arg \
ksym-vanilla-dm-sm-disk-create \
ksym-vanilla-dm-sm-disk-open \
ksym-vanilla-dm-snap-cow \
ksym-vanilla-dm-snap-origin \
ksym-vanilla-dm-start-time-ns-from-clone \
ksym-vanilla-dm-submit-bio-remap \
ksym-vanilla-dm-suspended \
ksym-vanilla-dm-table-device-name \
ksym-vanilla-dm-table-event \
ksym-vanilla-dm-table-get-md \
ksym-vanilla-dm-table-get-mode \
ksym-vanilla-dm-table-get-size \
ksym-vanilla-dm-table-run-md-queue-async \
ksym-vanilla-dm-table-set-type \
ksym-vanilla-dm-tm-commit \
ksym-vanilla-dm-tm-create-non-blocking-clone \
ksym-vanilla-dm-tm-create-with-sm \
ksym-vanilla-dm-tm-dec \
ksym-vanilla-dm-tm-dec-range \
ksym-vanilla-dm-tm-destroy \
ksym-vanilla-dm-tm-inc \
ksym-vanilla-dm-tm-inc-range \
ksym-vanilla-dm-tm-issue-prefetches \
ksym-vanilla-dm-tm-open-with-sm \
ksym-vanilla-dm-tm-pre-commit \
ksym-vanilla-dm-tm-read-lock \
ksym-vanilla-dm-tm-shadow-block \
ksym-vanilla-dm-tm-unlock \
ksym-vanilla-dm-tm-with-runs \
ksym-vanilla-dm-unregister-path-selector \
ksym-vanilla-dm-unregister-target \
ksym-vanilla-dm-writepowerindex \
ksym-vanilla-dma-addressing-limited \
ksym-vanilla-dma-alloc-attrs \
ksym-vanilla-dma-alloc-noncontiguous \
ksym-vanilla-dma-alloc-pages \
ksym-vanilla-dma-async-device-channel-register \
ksym-vanilla-dma-async-device-channel-unregister \
ksym-vanilla-dma-async-device-register \
ksym-vanilla-dma-async-device-unregister \
ksym-vanilla-dma-async-tx-descriptor-init \
ksym-vanilla-dma-buf-attach \
ksym-vanilla-dma-buf-attach-revocable \
ksym-vanilla-dma-buf-begin-cpu-access \
ksym-vanilla-dma-buf-detach \
ksym-vanilla-dma-buf-dynamic-attach \
ksym-vanilla-dma-buf-end-cpu-access \
ksym-vanilla-dma-buf-export \
ksym-vanilla-dma-buf-fd \
ksym-vanilla-dma-buf-fd-install \
ksym-vanilla-dma-buf-free-sgt \
ksym-vanilla-dma-buf-get \
ksym-vanilla-dma-buf-invalidate-mappings \
ksym-vanilla-dma-buf-map-attachment \
ksym-vanilla-dma-buf-map-attachment-unlocked \
ksym-vanilla-dma-buf-mmap \
ksym-vanilla-dma-buf-phys-vec-to-sgt \
ksym-vanilla-dma-buf-pin \
ksym-vanilla-dma-buf-put \
ksym-vanilla-dma-buf-unmap-attachment \
ksym-vanilla-dma-buf-unmap-attachment-unlocked \
ksym-vanilla-dma-buf-unpin \
ksym-vanilla-dma-buf-vmap \
ksym-vanilla-dma-buf-vmap-unlocked \
ksym-vanilla-dma-buf-vunmap \
ksym-vanilla-dma-buf-vunmap-unlocked \
ksym-vanilla-dma-can-mmap \
ksym-vanilla-dma-contiguous-get-area-by-idx \
ksym-vanilla-dma-fence-add-callback \
ksym-vanilla-dma-fence-allocate-private-stub \
ksym-vanilla-dma-fence-array-alloc \
ksym-vanilla-dma-fence-array-create \
ksym-vanilla-dma-fence-array-first \
ksym-vanilla-dma-fence-array-init \
ksym-vanilla-dma-fence-array-next \
ksym-vanilla-dma-fence-array-ops \
ksym-vanilla-dma-fence-chain-find-seqno \
ksym-vanilla-dma-fence-chain-init \
ksym-vanilla-dma-fence-chain-ops \
ksym-vanilla-dma-fence-chain-walk \
ksym-vanilla-dma-fence-check-and-signal \
ksym-vanilla-dma-fence-check-and-signal-locked \
ksym-vanilla-dma-fence-context-alloc \
ksym-vanilla-dma-fence-dedup-array \
ksym-vanilla-dma-fence-default-wait \
ksym-vanilla-dma-fence-describe \
ksym-vanilla-dma-fence-driver-name \
ksym-vanilla-dma-fence-enable-sw-signaling \
ksym-vanilla-dma-fence-free \
ksym-vanilla-dma-fence-get-status \
ksym-vanilla-dma-fence-get-stub \
ksym-vanilla-dma-fence-init \
ksym-vanilla-dma-fence-init64 \
ksym-vanilla-dma-fence-match-context \
ksym-vanilla-dma-fence-release \
ksym-vanilla-dma-fence-remove-callback \
ksym-vanilla-dma-fence-set-deadline \
ksym-vanilla-dma-fence-signal \
ksym-vanilla-dma-fence-signal-locked \
ksym-vanilla-dma-fence-signal-timestamp \
ksym-vanilla-dma-fence-signal-timestamp-locked \
ksym-vanilla-dma-fence-timeline-name \
ksym-vanilla-dma-fence-unwrap-first \
ksym-vanilla-dma-fence-unwrap-next \
ksym-vanilla-dma-fence-wait-any-timeout \
ksym-vanilla-dma-fence-wait-timeout \
ksym-vanilla-dma-find-channel \
ksym-vanilla-dma-free-attrs \
ksym-vanilla-dma-free-noncontiguous \
ksym-vanilla-dma-free-pages \
ksym-vanilla-dma-get-any-slave-channel \
ksym-vanilla-dma-get-merge-boundary \
ksym-vanilla-dma-get-required-mask \
ksym-vanilla-dma-get-sgtable-attrs \
ksym-vanilla-dma-get-slave-caps \
ksym-vanilla-dma-get-slave-channel \
ksym-vanilla-dma-heap-add \
ksym-vanilla-dma-heap-get-drvdata \
ksym-vanilla-dma-heap-get-name \
ksym-vanilla-dma-iova-destroy \
ksym-vanilla-dma-iova-free \
ksym-vanilla-dma-iova-link \
ksym-vanilla-dma-iova-sync \
ksym-vanilla-dma-iova-try-alloc \
ksym-vanilla-dma-iova-unlink \
ksym-vanilla-dma-issue-pending-all \
ksym-vanilla-dma-map-page-attrs \
ksym-vanilla-dma-map-phys \
ksym-vanilla-dma-map-resource \
ksym-vanilla-dma-map-sg-attrs \
ksym-vanilla-dma-map-sgtable \
ksym-vanilla-dma-max-mapping-size \
ksym-vanilla-dma-mmap-attrs \
ksym-vanilla-dma-mmap-noncontiguous \
ksym-vanilla-dma-mmap-pages \
ksym-vanilla-dma-need-unmap \
ksym-vanilla-dma-opt-mapping-size \
ksym-vanilla-dma-pci-p2pdma-supported \
ksym-vanilla-dma-pool-alloc \
ksym-vanilla-dma-pool-create-node \
ksym-vanilla-dma-pool-destroy \
ksym-vanilla-dma-pool-free \
ksym-vanilla-dma-release-channel \
ksym-vanilla-dma-request-chan \
ksym-vanilla-dma-request-chan-by-mask \
ksym-vanilla-dma-resv-add-fence \
ksym-vanilla-dma-resv-copy-fences \
ksym-vanilla-dma-resv-describe \
ksym-vanilla-dma-resv-fini \
ksym-vanilla-dma-resv-get-fences \
ksym-vanilla-dma-resv-get-singleton \
ksym-vanilla-dma-resv-init \
ksym-vanilla-dma-resv-iter-first \
ksym-vanilla-dma-resv-iter-first-unlocked \
ksym-vanilla-dma-resv-iter-next \
ksym-vanilla-dma-resv-iter-next-unlocked \
ksym-vanilla-dma-resv-replace-fences \
ksym-vanilla-dma-resv-reserve-fences \
ksym-vanilla-dma-resv-set-deadline \
ksym-vanilla-dma-resv-test-signaled \
ksym-vanilla-dma-resv-wait-timeout \
ksym-vanilla-dma-run-dependencies \
ksym-vanilla-dma-set-coherent-mask \
ksym-vanilla-dma-set-mask \
ksym-vanilla-dma-sync-wait \
ksym-vanilla-dma-unmap-page-attrs \
ksym-vanilla-dma-unmap-phys \
ksym-vanilla-dma-unmap-resource \
ksym-vanilla-dma-unmap-sg-attrs \
ksym-vanilla-dma-vmap-noncontiguous \
ksym-vanilla-dma-vunmap-noncontiguous \
ksym-vanilla-dma-wait-for-async-tx \
ksym-vanilla-dmaengine-desc-attach-metadata \
ksym-vanilla-dmaengine-desc-get-metadata-ptr \
ksym-vanilla-dmaengine-desc-set-metadata-len \
ksym-vanilla-dmaengine-get \
ksym-vanilla-dmaengine-get-unmap-data \
ksym-vanilla-dmaengine-put \
ksym-vanilla-dmaengine-unmap-put \
ksym-vanilla-dmaenginem-async-device-register \
ksym-vanilla-dmam-alloc-attrs \
ksym-vanilla-dmam-free-coherent \
ksym-vanilla-dmam-pool-create \
ksym-vanilla-dmam-pool-destroy \
ksym-vanilla-dmem-cgroup-pool-state-put \
ksym-vanilla-dmem-cgroup-register-region \
ksym-vanilla-dmem-cgroup-state-evict-valuable \
ksym-vanilla-dmem-cgroup-try-charge \
ksym-vanilla-dmem-cgroup-uncharge \
ksym-vanilla-dmem-cgroup-unregister-region \
ksym-vanilla-dmem-cgrp-subsys-enabled-key \
ksym-vanilla-dmem-cgrp-subsys-on-dfl-key \
ksym-vanilla-dmi-available \
ksym-vanilla-dmi-check-system \
ksym-vanilla-dmi-find-device \
ksym-vanilla-dmi-first-match \
ksym-vanilla-dmi-get-bios-year \
ksym-vanilla-dmi-get-date \
ksym-vanilla-dmi-get-system-info \
ksym-vanilla-dmi-kobj \
ksym-vanilla-dmi-match \
ksym-vanilla-dmi-memdev-handle \
ksym-vanilla-dmi-memdev-name \
ksym-vanilla-dmi-memdev-size \
ksym-vanilla-dmi-memdev-type \
ksym-vanilla-dmi-name-in-vendors \
ksym-vanilla-dmi-string-nosave \
ksym-vanilla-dmi-walk \
ksym-vanilla-dmt-modes \
ksym-vanilla-dns-query \
ksym-vanilla-do-SAK \
ksym-vanilla-do-blank-screen \
ksym-vanilla-do-dw-dma-disable \
ksym-vanilla-do-dw-dma-enable \
ksym-vanilla-do-exit \
ksym-vanilla-do-map-probe \
ksym-vanilla-do-netpoll-cleanup \
ksym-vanilla-do-settimeofday64 \
ksym-vanilla-do-sock-getsockopt \
ksym-vanilla-do-sock-setsockopt \
ksym-vanilla-do-splice-direct \
ksym-vanilla-do-take-over-console \
ksym-vanilla-do-timens-ktime-to-host \
ksym-vanilla-do-trace-9p-fid-get \
ksym-vanilla-do-trace-9p-fid-put \
ksym-vanilla-do-trace-netlink-extack \
ksym-vanilla-do-trace-rcu-torture-read \
ksym-vanilla-do-unbind-con-driver \
ksym-vanilla-do-unblank-screen \
ksym-vanilla-do-unregister-con-driver \
ksym-vanilla-do-wait-intr \
ksym-vanilla-do-wait-intr-irq \
ksym-vanilla-do-xdp-generic \
ksym-vanilla-dotdot-name \
ksym-vanilla-down \
ksym-vanilla-down-interruptible \
ksym-vanilla-down-killable \
ksym-vanilla-down-read \
ksym-vanilla-down-read-interruptible \
ksym-vanilla-down-read-killable \
ksym-vanilla-down-read-trylock \
ksym-vanilla-down-timeout \
ksym-vanilla-down-trylock \
ksym-vanilla-down-write \
ksym-vanilla-down-write-killable \
ksym-vanilla-down-write-trylock \
ksym-vanilla-downgrade-write \
ksym-vanilla-dp-altmode-probe \
ksym-vanilla-dp-altmode-remove \
ksym-vanilla-dp-aux-dp-driver-unregister \
ksym-vanilla-dpaa2-caam-enqueue \
ksym-vanilla-dpaa2-io-get-adaptive-coalescing \
ksym-vanilla-dpaa2-io-get-cpu \
ksym-vanilla-dpaa2-io-get-irq-coalescing \
ksym-vanilla-dpaa2-io-query-bp-count \
ksym-vanilla-dpaa2-io-query-fq-count \
ksym-vanilla-dpaa2-io-service-acquire \
ksym-vanilla-dpaa2-io-service-deregister \
ksym-vanilla-dpaa2-io-service-enqueue-fq \
ksym-vanilla-dpaa2-io-service-enqueue-multiple-desc-fq \
ksym-vanilla-dpaa2-io-service-enqueue-multiple-fq \
ksym-vanilla-dpaa2-io-service-enqueue-qd \
ksym-vanilla-dpaa2-io-service-pull-channel \
ksym-vanilla-dpaa2-io-service-pull-fq \
ksym-vanilla-dpaa2-io-service-rearm \
ksym-vanilla-dpaa2-io-service-register \
ksym-vanilla-dpaa2-io-service-release \
ksym-vanilla-dpaa2-io-service-select \
ksym-vanilla-dpaa2-io-set-adaptive-coalescing \
ksym-vanilla-dpaa2-io-set-irq-coalescing \
ksym-vanilla-dpaa2-io-store-create \
ksym-vanilla-dpaa2-io-store-destroy \
ksym-vanilla-dpaa2-io-store-next \
ksym-vanilla-dpaa2-io-update-net-dim \
ksym-vanilla-dpaa2-mac-close \
ksym-vanilla-dpaa2-mac-connect \
ksym-vanilla-dpaa2-mac-disconnect \
ksym-vanilla-dpaa2-mac-get-ctrl-stats \
ksym-vanilla-dpaa2-mac-get-eth-mac-stats \
ksym-vanilla-dpaa2-mac-get-ethtool-stats \
ksym-vanilla-dpaa2-mac-get-pause-stats \
ksym-vanilla-dpaa2-mac-get-rmon-stats \
ksym-vanilla-dpaa2-mac-get-sset-count \
ksym-vanilla-dpaa2-mac-get-strings \
ksym-vanilla-dpaa2-mac-open \
ksym-vanilla-dpaa2-mac-start \
ksym-vanilla-dpaa2-mac-stop \
ksym-vanilla-dpaa2-phc-index \
ksym-vanilla-dpaa2-ptp \
ksym-vanilla-dpbp-close \
ksym-vanilla-dpbp-disable \
ksym-vanilla-dpbp-enable \
ksym-vanilla-dpbp-get-attributes \
ksym-vanilla-dpbp-open \
ksym-vanilla-dpbp-reset \
ksym-vanilla-dpcm-be-dai-trigger \
ksym-vanilla-dpcm-end-walk-at-be \
ksym-vanilla-dpcon-close \
ksym-vanilla-dpcon-disable \
ksym-vanilla-dpcon-enable \
ksym-vanilla-dpcon-get-attributes \
ksym-vanilla-dpcon-open \
ksym-vanilla-dpcon-reset \
ksym-vanilla-dpcon-set-notification \
ksym-vanilla-dpdmai-close \
ksym-vanilla-dpdmai-destroy \
ksym-vanilla-dpdmai-disable \
ksym-vanilla-dpdmai-enable \
ksym-vanilla-dpdmai-get-attributes \
ksym-vanilla-dpdmai-get-rx-queue \
ksym-vanilla-dpdmai-get-tx-queue \
ksym-vanilla-dpdmai-open \
ksym-vanilla-dpdmai-reset \
ksym-vanilla-dpdmai-set-rx-queue \
ksym-vanilla-dpll-device-change-ntf \
ksym-vanilla-dpll-device-get \
ksym-vanilla-dpll-device-put \
ksym-vanilla-dpll-device-register \
ksym-vanilla-dpll-device-unregister \
ksym-vanilla-dpll-netdev-pin-clear \
ksym-vanilla-dpll-netdev-pin-set \
ksym-vanilla-dpll-pin-change-ntf \
ksym-vanilla-dpll-pin-fwnode-set \
ksym-vanilla-dpll-pin-get \
ksym-vanilla-dpll-pin-on-pin-register \
ksym-vanilla-dpll-pin-on-pin-unregister \
ksym-vanilla-dpll-pin-put \
ksym-vanilla-dpll-pin-ref-sync-pair-add \
ksym-vanilla-dpll-pin-register \
ksym-vanilla-dpll-pin-unregister \
ksym-vanilla-dpm-for-each-dev \
ksym-vanilla-dpm-resume-end \
ksym-vanilla-dpm-resume-start \
ksym-vanilla-dpm-suspend-end \
ksym-vanilla-dpm-suspend-start \
ksym-vanilla-dprc-cleanup \
ksym-vanilla-dprc-close \
ksym-vanilla-dprc-get-obj \
ksym-vanilla-dprc-get-obj-count \
ksym-vanilla-dprc-get-obj-region \
ksym-vanilla-dprc-open \
ksym-vanilla-dprc-remove-devices \
ksym-vanilla-dprc-reset-container \
ksym-vanilla-dprc-scan-container \
ksym-vanilla-dprc-set-obj-irq \
ksym-vanilla-dprc-setup \
ksym-vanilla-dput \
ksym-vanilla-dq-data-lock \
ksym-vanilla-dqget \
ksym-vanilla-dqgrab \
ksym-vanilla-dql-completed \
ksym-vanilla-dql-init \
ksym-vanilla-dql-reset \
ksym-vanilla-dqput \
ksym-vanilla-dqstats \
ksym-vanilla-dquot-acquire \
ksym-vanilla-dquot-alloc \
ksym-vanilla-dquot-alloc-inode \
ksym-vanilla-dquot-claim-space-nodirty \
ksym-vanilla-dquot-commit \
ksym-vanilla-dquot-commit-info \
ksym-vanilla-dquot-destroy \
ksym-vanilla-dquot-disable \
ksym-vanilla-dquot-drop \
ksym-vanilla-dquot-file-open \
ksym-vanilla-dquot-free-inode \
ksym-vanilla-dquot-get-dqblk \
ksym-vanilla-dquot-get-next-dqblk \
ksym-vanilla-dquot-get-next-id \
ksym-vanilla-dquot-get-state \
ksym-vanilla-dquot-initialize \
ksym-vanilla-dquot-initialize-needed \
ksym-vanilla-dquot-load-quota-inode \
ksym-vanilla-dquot-load-quota-sb \
ksym-vanilla-dquot-mark-dquot-dirty \
ksym-vanilla-dquot-operations \
ksym-vanilla-dquot-quota-off \
ksym-vanilla-dquot-quota-on \
ksym-vanilla-dquot-quota-on-mount \
ksym-vanilla-dquot-quota-sync \
ksym-vanilla-dquot-quotactl-sysfile-ops \
ksym-vanilla-dquot-reclaim-space-nodirty \
ksym-vanilla-dquot-release \
ksym-vanilla-dquot-resume \
ksym-vanilla-dquot-scan-active \
ksym-vanilla-dquot-set-dqblk \
ksym-vanilla-dquot-set-dqinfo \
ksym-vanilla-dquot-transfer \
ksym-vanilla-dquot-writeback-dquots \
ksym-vanilla-drain-workqueue \
ksym-vanilla-drbd-conn-str \
ksym-vanilla-drbd-disk-str \
ksym-vanilla-drbd-role-str \
ksym-vanilla-drbd-set-st-err-str \
ksym-vanilla-driver-attach \
ksym-vanilla-driver-create-file \
ksym-vanilla-driver-deferred-probe-check-state \
ksym-vanilla-driver-find \
ksym-vanilla-driver-find-device \
ksym-vanilla-driver-for-each-device \
ksym-vanilla-driver-register \
ksym-vanilla-driver-remove-file \
ksym-vanilla-driver-unregister \
ksym-vanilla-drm-add-edid-modes \
ksym-vanilla-drm-add-modes-noedid \
ksym-vanilla-drm-analog-tv-mode \
ksym-vanilla-drm-any-plane-has-format \
ksym-vanilla-drm-atomic-add-affected-colorops \
ksym-vanilla-drm-atomic-add-affected-connectors \
ksym-vanilla-drm-atomic-add-affected-planes \
ksym-vanilla-drm-atomic-add-encoder-bridges \
ksym-vanilla-drm-atomic-bridge-chain-check \
ksym-vanilla-drm-atomic-bridge-chain-disable \
ksym-vanilla-drm-atomic-bridge-chain-enable \
ksym-vanilla-drm-atomic-bridge-chain-post-disable \
ksym-vanilla-drm-atomic-bridge-chain-pre-enable \
ksym-vanilla-drm-atomic-check-only \
ksym-vanilla-drm-atomic-commit \
ksym-vanilla-drm-atomic-commit-alloc \
ksym-vanilla-drm-atomic-commit-clear \
ksym-vanilla-drm-atomic-commit-default-clear \
ksym-vanilla-drm-atomic-commit-default-release \
ksym-vanilla-drm-atomic-commit-init \
ksym-vanilla-drm-atomic-get-bridge-state \
ksym-vanilla-drm-atomic-get-colorop-state \
ksym-vanilla-drm-atomic-get-connector-for-encoder \
ksym-vanilla-drm-atomic-get-connector-state \
ksym-vanilla-drm-atomic-get-crtc-state \
ksym-vanilla-drm-atomic-get-mst-payload-state \
ksym-vanilla-drm-atomic-get-mst-topology-state \
ksym-vanilla-drm-atomic-get-new-bridge-state \
ksym-vanilla-drm-atomic-get-new-colorop-state \
ksym-vanilla-drm-atomic-get-new-connector-for-encoder \
ksym-vanilla-drm-atomic-get-new-crtc-for-encoder \
ksym-vanilla-drm-atomic-get-new-mst-topology-state \
ksym-vanilla-drm-atomic-get-new-private-obj-state \
ksym-vanilla-drm-atomic-get-old-bridge-state \
ksym-vanilla-drm-atomic-get-old-colorop-state \
ksym-vanilla-drm-atomic-get-old-connector-for-encoder \
ksym-vanilla-drm-atomic-get-old-crtc-for-encoder \
ksym-vanilla-drm-atomic-get-old-mst-topology-state \
ksym-vanilla-drm-atomic-get-old-private-obj-state \
ksym-vanilla-drm-atomic-get-plane-state \
ksym-vanilla-drm-atomic-get-private-obj-state \
ksym-vanilla-drm-atomic-helper-async-check \
ksym-vanilla-drm-atomic-helper-async-commit \
ksym-vanilla-drm-atomic-helper-bridge-destroy-state \
ksym-vanilla-drm-atomic-helper-bridge-duplicate-state \
ksym-vanilla-drm-atomic-helper-bridge-propagate-bus-fmt \
ksym-vanilla-drm-atomic-helper-bridge-reset \
ksym-vanilla-drm-atomic-helper-calc-timestamping-constants \
ksym-vanilla-drm-atomic-helper-check \
ksym-vanilla-drm-atomic-helper-check-crtc-primary-plane \
ksym-vanilla-drm-atomic-helper-check-modeset \
ksym-vanilla-drm-atomic-helper-check-plane-damage \
ksym-vanilla-drm-atomic-helper-check-plane-state \
ksym-vanilla-drm-atomic-helper-check-planes \
ksym-vanilla-drm-atomic-helper-check-wb-connector-state \
ksym-vanilla-drm-atomic-helper-cleanup-planes \
ksym-vanilla-drm-atomic-helper-commit \
ksym-vanilla-drm-atomic-helper-commit-cleanup-done \
ksym-vanilla-drm-atomic-helper-commit-crtc-disable \
ksym-vanilla-drm-atomic-helper-commit-crtc-enable \
ksym-vanilla-drm-atomic-helper-commit-crtc-set-mode \
ksym-vanilla-drm-atomic-helper-commit-duplicated-state \
ksym-vanilla-drm-atomic-helper-commit-encoder-bridge-disable \
ksym-vanilla-drm-atomic-helper-commit-encoder-bridge-enable \
ksym-vanilla-drm-atomic-helper-commit-encoder-bridge-post-disable \
ksym-vanilla-drm-atomic-helper-commit-encoder-bridge-pre-enable \
ksym-vanilla-drm-atomic-helper-commit-hw-done \
ksym-vanilla-drm-atomic-helper-commit-modeset-disables \
ksym-vanilla-drm-atomic-helper-commit-modeset-enables \
ksym-vanilla-drm-atomic-helper-commit-planes \
ksym-vanilla-drm-atomic-helper-commit-planes-on-crtc \
ksym-vanilla-drm-atomic-helper-commit-tail \
ksym-vanilla-drm-atomic-helper-commit-tail-rpm \
ksym-vanilla-drm-atomic-helper-commit-writebacks \
ksym-vanilla-drm-atomic-helper-connector-destroy-state \
ksym-vanilla-drm-atomic-helper-connector-duplicate-state \
ksym-vanilla-drm-atomic-helper-connector-hdmi-check \
ksym-vanilla-drm-atomic-helper-connector-hdmi-clear-audio-infoframe \
ksym-vanilla-drm-atomic-helper-connector-hdmi-force \
ksym-vanilla-drm-atomic-helper-connector-hdmi-hotplug \
ksym-vanilla-drm-atomic-helper-connector-hdmi-update-audio-infoframe \
ksym-vanilla-drm-atomic-helper-connector-hdmi-update-infoframes \
ksym-vanilla-drm-atomic-helper-connector-reset \
ksym-vanilla-drm-atomic-helper-connector-tv-check \
ksym-vanilla-drm-atomic-helper-connector-tv-margins-reset \
ksym-vanilla-drm-atomic-helper-connector-tv-reset \
ksym-vanilla-drm-atomic-helper-crtc-destroy-state \
ksym-vanilla-drm-atomic-helper-crtc-duplicate-state \
ksym-vanilla-drm-atomic-helper-crtc-reset \
ksym-vanilla-drm-atomic-helper-damage-iter-init \
ksym-vanilla-drm-atomic-helper-damage-iter-next \
ksym-vanilla-drm-atomic-helper-damage-merged \
ksym-vanilla-drm-atomic-helper-dirtyfb \
ksym-vanilla-drm-atomic-helper-disable-all \
ksym-vanilla-drm-atomic-helper-disable-plane \
ksym-vanilla-drm-atomic-helper-disable-planes-on-crtc \
ksym-vanilla-drm-atomic-helper-duplicate-state \
ksym-vanilla-drm-atomic-helper-fake-vblank \
ksym-vanilla-drm-atomic-helper-page-flip \
ksym-vanilla-drm-atomic-helper-page-flip-target \
ksym-vanilla-drm-atomic-helper-plane-destroy-state \
ksym-vanilla-drm-atomic-helper-plane-duplicate-state \
ksym-vanilla-drm-atomic-helper-plane-reset \
ksym-vanilla-drm-atomic-helper-prepare-planes \
ksym-vanilla-drm-atomic-helper-reset-crtc \
ksym-vanilla-drm-atomic-helper-resume \
ksym-vanilla-drm-atomic-helper-set-config \
ksym-vanilla-drm-atomic-helper-setup-commit \
ksym-vanilla-drm-atomic-helper-shutdown \
ksym-vanilla-drm-atomic-helper-suspend \
ksym-vanilla-drm-atomic-helper-swap-state \
ksym-vanilla-drm-atomic-helper-unprepare-planes \
ksym-vanilla-drm-atomic-helper-update-legacy-modeset-state \
ksym-vanilla-drm-atomic-helper-update-plane \
ksym-vanilla-drm-atomic-helper-wait-for-dependencies \
ksym-vanilla-drm-atomic-helper-wait-for-fences \
ksym-vanilla-drm-atomic-helper-wait-for-flip-done \
ksym-vanilla-drm-atomic-helper-wait-for-vblanks \
ksym-vanilla-drm-atomic-nonblocking-commit \
ksym-vanilla-drm-atomic-normalize-zpos \
ksym-vanilla-drm-atomic-print-new-state \
ksym-vanilla-drm-atomic-private-obj-fini \
ksym-vanilla-drm-atomic-private-obj-init \
ksym-vanilla-drm-atomic-set-colorop-for-plane \
ksym-vanilla-drm-atomic-set-crtc-for-connector \
ksym-vanilla-drm-atomic-set-crtc-for-plane \
ksym-vanilla-drm-atomic-set-fb-for-plane \
ksym-vanilla-drm-atomic-set-mode-for-crtc \
ksym-vanilla-drm-atomic-set-mode-prop-for-crtc \
ksym-vanilla-drm-aux-bridge-register \
ksym-vanilla-drm-aux-hpd-bridge-notify \
ksym-vanilla-drm-av-sync-delay \
ksym-vanilla-drm-bridge-add \
ksym-vanilla-drm-bridge-attach \
ksym-vanilla-drm-bridge-chain-mode-set \
ksym-vanilla-drm-bridge-chain-mode-valid \
ksym-vanilla-drm-bridge-clear-and-put \
ksym-vanilla-drm-bridge-connector-init \
ksym-vanilla-drm-bridge-detect \
ksym-vanilla-drm-bridge-edid-read \
ksym-vanilla-drm-bridge-enter \
ksym-vanilla-drm-bridge-exit \
ksym-vanilla-drm-bridge-get \
ksym-vanilla-drm-bridge-get-modes \
ksym-vanilla-drm-bridge-helper-reset-crtc \
ksym-vanilla-drm-bridge-hpd-disable \
ksym-vanilla-drm-bridge-hpd-enable \
ksym-vanilla-drm-bridge-hpd-notify \
ksym-vanilla-drm-bridge-is-panel \
ksym-vanilla-drm-bridge-put \
ksym-vanilla-drm-bridge-remove \
ksym-vanilla-drm-bridge-unplug \
ksym-vanilla-drm-buddy-block-print \
ksym-vanilla-drm-buddy-print \
ksym-vanilla-drm-bus-flags-from-videomode \
ksym-vanilla-drm-calc-timestamping-constants \
ksym-vanilla-drm-class-device-register \
ksym-vanilla-drm-class-device-unregister \
ksym-vanilla-drm-clflush-pages \
ksym-vanilla-drm-clflush-sg \
ksym-vanilla-drm-clflush-virt-range \
ksym-vanilla-drm-client-buffer-create \
ksym-vanilla-drm-client-buffer-create-dumb \
ksym-vanilla-drm-client-buffer-delete \
ksym-vanilla-drm-client-buffer-flush \
ksym-vanilla-drm-client-buffer-vmap \
ksym-vanilla-drm-client-buffer-vmap-local \
ksym-vanilla-drm-client-buffer-vunmap \
ksym-vanilla-drm-client-buffer-vunmap-local \
ksym-vanilla-drm-client-dev-hotplug \
ksym-vanilla-drm-client-dev-resume \
ksym-vanilla-drm-client-dev-suspend \
ksym-vanilla-drm-client-dev-unregister \
ksym-vanilla-drm-client-init \
ksym-vanilla-drm-client-modeset-check \
ksym-vanilla-drm-client-modeset-commit \
ksym-vanilla-drm-client-modeset-commit-locked \
ksym-vanilla-drm-client-modeset-dpms \
ksym-vanilla-drm-client-modeset-probe \
ksym-vanilla-drm-client-modeset-wait-for-vblank \
ksym-vanilla-drm-client-register \
ksym-vanilla-drm-client-release \
ksym-vanilla-drm-client-rotation \
ksym-vanilla-drm-client-setup \
ksym-vanilla-drm-client-setup-with-color-mode \
ksym-vanilla-drm-client-setup-with-fourcc \
ksym-vanilla-drm-color-ctm-s31-32-to-qm-n \
ksym-vanilla-drm-color-lut-check \
ksym-vanilla-drm-color-lut32-check \
ksym-vanilla-drm-colorop-cleanup \
ksym-vanilla-drm-colorop-destroy \
ksym-vanilla-drm-colorop-pipeline-destroy \
ksym-vanilla-drm-colorop-set-next-property \
ksym-vanilla-drm-compat-ioctl \
ksym-vanilla-drm-connector-atomic-hdr-metadata-equal \
ksym-vanilla-drm-connector-attach-broadcast-rgb-property \
ksym-vanilla-drm-connector-attach-colorspace-property \
ksym-vanilla-drm-connector-attach-content-protection-property \
ksym-vanilla-drm-connector-attach-content-type-property \
ksym-vanilla-drm-connector-attach-dp-subconnector-property \
ksym-vanilla-drm-connector-attach-edid-property \
ksym-vanilla-drm-connector-attach-encoder \
ksym-vanilla-drm-connector-attach-hdr-output-metadata-property \
ksym-vanilla-drm-connector-attach-max-bpc-property \
ksym-vanilla-drm-connector-attach-panel-type-property \
ksym-vanilla-drm-connector-attach-privacy-screen-properties \
ksym-vanilla-drm-connector-attach-privacy-screen-provider \
ksym-vanilla-drm-connector-attach-scaling-mode-property \
ksym-vanilla-drm-connector-attach-tv-margin-properties \
ksym-vanilla-drm-connector-attach-vrr-capable-property \
ksym-vanilla-drm-connector-cec-phys-addr-invalidate \
ksym-vanilla-drm-connector-cec-phys-addr-set \
ksym-vanilla-drm-connector-cleanup \
ksym-vanilla-drm-connector-create-privacy-screen-properties \
ksym-vanilla-drm-connector-dynamic-init \
ksym-vanilla-drm-connector-dynamic-register \
ksym-vanilla-drm-connector-has-possible-encoder \
ksym-vanilla-drm-connector-hdmi-audio-init \
ksym-vanilla-drm-connector-hdmi-audio-plugged-notify \
ksym-vanilla-drm-connector-hdmi-cec-received-msg \
ksym-vanilla-drm-connector-hdmi-cec-transmit-attempt-done \
ksym-vanilla-drm-connector-hdmi-cec-transmit-done \
ksym-vanilla-drm-connector-helper-detect-from-ddc \
ksym-vanilla-drm-connector-helper-get-modes \
ksym-vanilla-drm-connector-helper-get-modes-fixed \
ksym-vanilla-drm-connector-helper-hpd-irq-event \
ksym-vanilla-drm-connector-helper-tv-get-modes \
ksym-vanilla-drm-connector-init \
ksym-vanilla-drm-connector-init-with-ddc \
ksym-vanilla-drm-connector-list-iter-begin \
ksym-vanilla-drm-connector-list-iter-end \
ksym-vanilla-drm-connector-list-iter-next \
ksym-vanilla-drm-connector-list-update \
ksym-vanilla-drm-connector-oob-hotplug-event \
ksym-vanilla-drm-connector-register \
ksym-vanilla-drm-connector-set-link-status-property \
ksym-vanilla-drm-connector-set-orientation-from-panel \
ksym-vanilla-drm-connector-set-panel-orientation \
ksym-vanilla-drm-connector-set-panel-orientation-with-quirk \
ksym-vanilla-drm-connector-set-path-property \
ksym-vanilla-drm-connector-set-tile-property \
ksym-vanilla-drm-connector-set-vrr-capable-property \
ksym-vanilla-drm-connector-unregister \
ksym-vanilla-drm-connector-update-edid-property \
ksym-vanilla-drm-connector-update-privacy-screen \
ksym-vanilla-drm-crtc-accurate-vblank-count \
ksym-vanilla-drm-crtc-add-crc-entry \
ksym-vanilla-drm-crtc-arm-vblank-event \
ksym-vanilla-drm-crtc-attach-background-color-property \
ksym-vanilla-drm-crtc-check-viewport \
ksym-vanilla-drm-crtc-cleanup \
ksym-vanilla-drm-crtc-commit-wait \
ksym-vanilla-drm-crtc-create-scaling-filter-property \
ksym-vanilla-drm-crtc-create-sharpness-strength-property \
ksym-vanilla-drm-crtc-enable-color-mgmt \
ksym-vanilla-drm-crtc-fill-gamma-555 \
ksym-vanilla-drm-crtc-fill-gamma-565 \
ksym-vanilla-drm-crtc-fill-gamma-888 \
ksym-vanilla-drm-crtc-fill-palette-332 \
ksym-vanilla-drm-crtc-fill-palette-8 \
ksym-vanilla-drm-crtc-from-index \
ksym-vanilla-drm-crtc-handle-vblank \
ksym-vanilla-drm-crtc-helper-atomic-check \
ksym-vanilla-drm-crtc-helper-mode-valid-fixed \
ksym-vanilla-drm-crtc-helper-set-config \
ksym-vanilla-drm-crtc-helper-set-mode \
ksym-vanilla-drm-crtc-in-clone-mode \
ksym-vanilla-drm-crtc-init \
ksym-vanilla-drm-crtc-init-with-planes \
ksym-vanilla-drm-crtc-load-gamma-555-from-888 \
ksym-vanilla-drm-crtc-load-gamma-565-from-888 \
ksym-vanilla-drm-crtc-load-gamma-888 \
ksym-vanilla-drm-crtc-load-palette-8 \
ksym-vanilla-drm-crtc-next-vblank-start \
ksym-vanilla-drm-crtc-send-vblank-event \
ksym-vanilla-drm-crtc-set-max-vblank-count \
ksym-vanilla-drm-crtc-vblank-atomic-disable \
ksym-vanilla-drm-crtc-vblank-atomic-enable \
ksym-vanilla-drm-crtc-vblank-atomic-flush \
ksym-vanilla-drm-crtc-vblank-cancel-timer \
ksym-vanilla-drm-crtc-vblank-count \
ksym-vanilla-drm-crtc-vblank-count-and-time \
ksym-vanilla-drm-crtc-vblank-crtc \
ksym-vanilla-drm-crtc-vblank-get \
ksym-vanilla-drm-crtc-vblank-get-vblank-timeout \
ksym-vanilla-drm-crtc-vblank-helper-disable-vblank-timer \
ksym-vanilla-drm-crtc-vblank-helper-enable-vblank-timer \
ksym-vanilla-drm-crtc-vblank-helper-get-vblank-timestamp \
ksym-vanilla-drm-crtc-vblank-helper-get-vblank-timestamp-from-timer \
ksym-vanilla-drm-crtc-vblank-helper-get-vblank-timestamp-internal \
ksym-vanilla-drm-crtc-vblank-off \
ksym-vanilla-drm-crtc-vblank-on \
ksym-vanilla-drm-crtc-vblank-on-config \
ksym-vanilla-drm-crtc-vblank-put \
ksym-vanilla-drm-crtc-vblank-reset \
ksym-vanilla-drm-crtc-vblank-restore \
ksym-vanilla-drm-crtc-vblank-start-timer \
ksym-vanilla-drm-crtc-vblank-waitqueue \
ksym-vanilla-drm-crtc-wait-one-vblank \
ksym-vanilla-drm-cvt-mode \
ksym-vanilla-drm-debugfs-add-file \
ksym-vanilla-drm-debugfs-add-files \
ksym-vanilla-drm-debugfs-create-files \
ksym-vanilla-drm-debugfs-gpuva-info \
ksym-vanilla-drm-debugfs-remove-files \
ksym-vanilla-drm-default-rgb-quant-range \
ksym-vanilla-drm-detect-hdmi-monitor \
ksym-vanilla-drm-detect-monitor-audio \
ksym-vanilla-drm-dev-alloc \
ksym-vanilla-drm-dev-enter \
ksym-vanilla-drm-dev-exit \
ksym-vanilla-drm-dev-get \
ksym-vanilla-drm-dev-has-vblank \
ksym-vanilla-drm-dev-printk \
ksym-vanilla-drm-dev-put \
ksym-vanilla-drm-dev-register \
ksym-vanilla-drm-dev-set-dma-dev \
ksym-vanilla-drm-dev-unplug \
ksym-vanilla-drm-dev-unregister \
ksym-vanilla-drm-dev-wedged-event \
ksym-vanilla-drm-display-info-set-bus-formats \
ksym-vanilla-drm-display-mode-from-cea-vic \
ksym-vanilla-drm-display-mode-from-videomode \
ksym-vanilla-drm-display-mode-to-videomode \
ksym-vanilla-drm-dp-128b132b-cds-interlane-align-done \
ksym-vanilla-drm-dp-128b132b-eq-interlane-align-done \
ksym-vanilla-drm-dp-128b132b-lane-channel-eq-done \
ksym-vanilla-drm-dp-128b132b-lane-symbol-locked \
ksym-vanilla-drm-dp-128b132b-link-training-failed \
ksym-vanilla-drm-dp-128b132b-read-aux-rd-interval \
ksym-vanilla-drm-dp-add-payload-part1 \
ksym-vanilla-drm-dp-add-payload-part2 \
ksym-vanilla-drm-dp-as-sdp-log \
ksym-vanilla-drm-dp-as-sdp-supported \
ksym-vanilla-drm-dp-atomic-find-time-slots \
ksym-vanilla-drm-dp-atomic-release-time-slots \
ksym-vanilla-drm-dp-aux-init \
ksym-vanilla-drm-dp-aux-register \
ksym-vanilla-drm-dp-aux-unregister \
ksym-vanilla-drm-dp-bw-channel-coding-efficiency \
ksym-vanilla-drm-dp-bw-code-to-link-rate \
ksym-vanilla-drm-dp-bw-overhead \
ksym-vanilla-drm-dp-calc-pbn-mode \
ksym-vanilla-drm-dp-cec-attach \
ksym-vanilla-drm-dp-cec-irq \
ksym-vanilla-drm-dp-cec-register-connector \
ksym-vanilla-drm-dp-cec-set-edid \
ksym-vanilla-drm-dp-cec-unregister-connector \
ksym-vanilla-drm-dp-cec-unset-edid \
ksym-vanilla-drm-dp-channel-eq-ok \
ksym-vanilla-drm-dp-check-act-status \
ksym-vanilla-drm-dp-clock-recovery-ok \
ksym-vanilla-drm-dp-downstream-420-passthrough \
ksym-vanilla-drm-dp-downstream-444-to-420-conversion \
ksym-vanilla-drm-dp-downstream-debug \
ksym-vanilla-drm-dp-downstream-id \
ksym-vanilla-drm-dp-downstream-is-tmds \
ksym-vanilla-drm-dp-downstream-is-type \
ksym-vanilla-drm-dp-downstream-max-bpc \
ksym-vanilla-drm-dp-downstream-max-dotclock \
ksym-vanilla-drm-dp-downstream-max-tmds-clock \
ksym-vanilla-drm-dp-downstream-min-tmds-clock \
ksym-vanilla-drm-dp-downstream-mode \
ksym-vanilla-drm-dp-downstream-rgb-to-ycbcr-conversion \
ksym-vanilla-drm-dp-dpcd-clear-payload \
ksym-vanilla-drm-dp-dpcd-poll-act-handled \
ksym-vanilla-drm-dp-dpcd-probe \
ksym-vanilla-drm-dp-dpcd-read \
ksym-vanilla-drm-dp-dpcd-read-link-status \
ksym-vanilla-drm-dp-dpcd-read-phy-link-status \
ksym-vanilla-drm-dp-dpcd-set-powered \
ksym-vanilla-drm-dp-dpcd-set-probe \
ksym-vanilla-drm-dp-dpcd-write \
ksym-vanilla-drm-dp-dpcd-write-payload \
ksym-vanilla-drm-dp-dsc-branch-max-line-width \
ksym-vanilla-drm-dp-dsc-branch-max-overall-throughput \
ksym-vanilla-drm-dp-dsc-sink-bpp-incr \
ksym-vanilla-drm-dp-dsc-sink-line-buf-depth \
ksym-vanilla-drm-dp-dsc-sink-max-slice-count \
ksym-vanilla-drm-dp-dsc-sink-max-slice-throughput \
ksym-vanilla-drm-dp-dsc-sink-slice-count-mask \
ksym-vanilla-drm-dp-dsc-sink-supported-input-bpcs \
ksym-vanilla-drm-dp-dsc-slice-count-to-mask \
ksym-vanilla-drm-dp-dual-mode-detect \
ksym-vanilla-drm-dp-dual-mode-get-tmds-output \
ksym-vanilla-drm-dp-dual-mode-max-tmds-clock \
ksym-vanilla-drm-dp-dual-mode-read \
ksym-vanilla-drm-dp-dual-mode-set-tmds-output \
ksym-vanilla-drm-dp-dual-mode-write \
ksym-vanilla-drm-dp-dump-lttpr-desc \
ksym-vanilla-drm-dp-get-adjust-request-pre-emphasis \
ksym-vanilla-drm-dp-get-adjust-request-voltage \
ksym-vanilla-drm-dp-get-adjust-tx-ffe-preset \
ksym-vanilla-drm-dp-get-dual-mode-type-name \
ksym-vanilla-drm-dp-get-pcon-max-frl-bw \
ksym-vanilla-drm-dp-get-phy-test-pattern \
ksym-vanilla-drm-dp-get-vc-payload-bw \
ksym-vanilla-drm-dp-hpd-bridge-register \
ksym-vanilla-drm-dp-link-power-down \
ksym-vanilla-drm-dp-link-power-up \
ksym-vanilla-drm-dp-link-rate-to-bw-code \
ksym-vanilla-drm-dp-link-symbol-cycles \
ksym-vanilla-drm-dp-link-train-channel-eq-delay \
ksym-vanilla-drm-dp-link-train-clock-recovery-delay \
ksym-vanilla-drm-dp-lttpr-count \
ksym-vanilla-drm-dp-lttpr-init \
ksym-vanilla-drm-dp-lttpr-link-train-channel-eq-delay \
ksym-vanilla-drm-dp-lttpr-link-train-clock-recovery-delay \
ksym-vanilla-drm-dp-lttpr-max-lane-count \
ksym-vanilla-drm-dp-lttpr-max-link-rate \
ksym-vanilla-drm-dp-lttpr-pre-emphasis-level-3-supported \
ksym-vanilla-drm-dp-lttpr-set-transparent-mode \
ksym-vanilla-drm-dp-lttpr-voltage-swing-level-3-supported \
ksym-vanilla-drm-dp-lttpr-wake-timeout-setup \
ksym-vanilla-drm-dp-max-dprx-data-rate \
ksym-vanilla-drm-dp-mst-add-affected-dsc-crtcs \
ksym-vanilla-drm-dp-mst-atomic-check \
ksym-vanilla-drm-dp-mst-atomic-check-mgr \
ksym-vanilla-drm-dp-mst-atomic-enable-dsc \
ksym-vanilla-drm-dp-mst-atomic-setup-commit \
ksym-vanilla-drm-dp-mst-atomic-wait-for-dependencies \
ksym-vanilla-drm-dp-mst-aux-for-parent \
ksym-vanilla-drm-dp-mst-connector-early-unregister \
ksym-vanilla-drm-dp-mst-connector-late-register \
ksym-vanilla-drm-dp-mst-detect-port \
ksym-vanilla-drm-dp-mst-dsc-aux-for-port \
ksym-vanilla-drm-dp-mst-dump-topology \
ksym-vanilla-drm-dp-mst-edid-read \
ksym-vanilla-drm-dp-mst-get-edid \
ksym-vanilla-drm-dp-mst-get-port-malloc \
ksym-vanilla-drm-dp-mst-hpd-irq-handle-event \
ksym-vanilla-drm-dp-mst-hpd-irq-send-new-request \
ksym-vanilla-drm-dp-mst-port-downstream-of-parent \
ksym-vanilla-drm-dp-mst-put-port-malloc \
ksym-vanilla-drm-dp-mst-root-conn-atomic-check \
ksym-vanilla-drm-dp-mst-topology-mgr-destroy \
ksym-vanilla-drm-dp-mst-topology-mgr-init \
ksym-vanilla-drm-dp-mst-topology-mgr-resume \
ksym-vanilla-drm-dp-mst-topology-mgr-set-mst \
ksym-vanilla-drm-dp-mst-topology-mgr-suspend \
ksym-vanilla-drm-dp-mst-topology-queue-probe \
ksym-vanilla-drm-dp-mst-topology-state-funcs \
ksym-vanilla-drm-dp-mst-update-slots \
ksym-vanilla-drm-dp-pcon-convert-rgb-to-ycbcr \
ksym-vanilla-drm-dp-pcon-dsc-bpp-incr \
ksym-vanilla-drm-dp-pcon-dsc-max-slice-width \
ksym-vanilla-drm-dp-pcon-dsc-max-slices \
ksym-vanilla-drm-dp-pcon-enc-is-dsc-1-2 \
ksym-vanilla-drm-dp-pcon-frl-configure-1 \
ksym-vanilla-drm-dp-pcon-frl-configure-2 \
ksym-vanilla-drm-dp-pcon-frl-enable \
ksym-vanilla-drm-dp-pcon-frl-prepare \
ksym-vanilla-drm-dp-pcon-hdmi-frl-link-error-count \
ksym-vanilla-drm-dp-pcon-hdmi-link-active \
ksym-vanilla-drm-dp-pcon-hdmi-link-mode \
ksym-vanilla-drm-dp-pcon-is-frl-ready \
ksym-vanilla-drm-dp-pcon-pps-default \
ksym-vanilla-drm-dp-pcon-pps-override-buf \
ksym-vanilla-drm-dp-pcon-pps-override-param \
ksym-vanilla-drm-dp-pcon-reset-frl-config \
ksym-vanilla-drm-dp-phy-name \
ksym-vanilla-drm-dp-post-lt-adj-req-in-progress \
ksym-vanilla-drm-dp-psr-setup-time \
ksym-vanilla-drm-dp-read-channel-eq-delay \
ksym-vanilla-drm-dp-read-clock-recovery-delay \
ksym-vanilla-drm-dp-read-desc \
ksym-vanilla-drm-dp-read-downstream-info \
ksym-vanilla-drm-dp-read-dpcd-caps \
ksym-vanilla-drm-dp-read-lttpr-common-caps \
ksym-vanilla-drm-dp-read-lttpr-phy-caps \
ksym-vanilla-drm-dp-read-mst-cap \
ksym-vanilla-drm-dp-read-sink-count \
ksym-vanilla-drm-dp-read-sink-count-cap \
ksym-vanilla-drm-dp-remote-aux-init \
ksym-vanilla-drm-dp-remove-payload-part1 \
ksym-vanilla-drm-dp-remove-payload-part2 \
ksym-vanilla-drm-dp-send-power-updown-phy \
ksym-vanilla-drm-dp-send-query-stream-enc-status \
ksym-vanilla-drm-dp-send-real-edid-checksum \
ksym-vanilla-drm-dp-set-phy-test-pattern \
ksym-vanilla-drm-dp-set-subconnector-property \
ksym-vanilla-drm-dp-start-crc \
ksym-vanilla-drm-dp-stop-crc \
ksym-vanilla-drm-dp-subconnector-type \
ksym-vanilla-drm-dp-tunnel-alloc-bw \
ksym-vanilla-drm-dp-tunnel-atomic-check-stream-bws \
ksym-vanilla-drm-dp-tunnel-atomic-get-group-streams-in-state \
ksym-vanilla-drm-dp-tunnel-atomic-get-new-state \
ksym-vanilla-drm-dp-tunnel-atomic-get-old-state \
ksym-vanilla-drm-dp-tunnel-atomic-get-required-bw \
ksym-vanilla-drm-dp-tunnel-atomic-get-state \
ksym-vanilla-drm-dp-tunnel-atomic-set-stream-bw \
ksym-vanilla-drm-dp-tunnel-available-bw \
ksym-vanilla-drm-dp-tunnel-bw-alloc-is-enabled \
ksym-vanilla-drm-dp-tunnel-destroy \
ksym-vanilla-drm-dp-tunnel-detect \
ksym-vanilla-drm-dp-tunnel-disable-bw-alloc \
ksym-vanilla-drm-dp-tunnel-enable-bw-alloc \
ksym-vanilla-drm-dp-tunnel-get \
ksym-vanilla-drm-dp-tunnel-get-allocated-bw \
ksym-vanilla-drm-dp-tunnel-handle-irq \
ksym-vanilla-drm-dp-tunnel-max-dprx-lane-count \
ksym-vanilla-drm-dp-tunnel-max-dprx-rate \
ksym-vanilla-drm-dp-tunnel-mgr-create \
ksym-vanilla-drm-dp-tunnel-mgr-destroy \
ksym-vanilla-drm-dp-tunnel-name \
ksym-vanilla-drm-dp-tunnel-pr-optimization-supported \
ksym-vanilla-drm-dp-tunnel-put \
ksym-vanilla-drm-dp-tunnel-set-io-error \
ksym-vanilla-drm-dp-tunnel-update-state \
ksym-vanilla-drm-dp-vsc-sdp-log \
ksym-vanilla-drm-dp-vsc-sdp-pack \
ksym-vanilla-drm-dp-vsc-sdp-supported \
ksym-vanilla-drm-draw-blit16 \
ksym-vanilla-drm-draw-blit24 \
ksym-vanilla-drm-draw-blit32 \
ksym-vanilla-drm-draw-can-convert-from-xrgb8888 \
ksym-vanilla-drm-draw-color-from-xrgb8888 \
ksym-vanilla-drm-draw-fill16 \
ksym-vanilla-drm-draw-fill24 \
ksym-vanilla-drm-draw-fill32 \
ksym-vanilla-drm-driver-color-mode-format \
ksym-vanilla-drm-driver-legacy-fb-format \
ksym-vanilla-drm-dsc-compute-rc-parameters \
ksym-vanilla-drm-dsc-dp-pps-header-init \
ksym-vanilla-drm-dsc-dp-rc-buffer-size \
ksym-vanilla-drm-dsc-dump-config \
ksym-vanilla-drm-dsc-flatness-det-thresh \
ksym-vanilla-drm-dsc-get-bpp-int \
ksym-vanilla-drm-dsc-initial-scale-value \
ksym-vanilla-drm-dsc-pps-payload-pack \
ksym-vanilla-drm-dsc-set-const-params \
ksym-vanilla-drm-dsc-set-rc-buf-thresh \
ksym-vanilla-drm-dsc-setup-rc-params \
ksym-vanilla-drm-edid-alloc \
ksym-vanilla-drm-edid-connector-add-modes \
ksym-vanilla-drm-edid-connector-update \
ksym-vanilla-drm-edid-dup \
ksym-vanilla-drm-edid-duplicate \
ksym-vanilla-drm-edid-free \
ksym-vanilla-drm-edid-get-monitor-name \
ksym-vanilla-drm-edid-get-panel-id \
ksym-vanilla-drm-edid-get-product-id \
ksym-vanilla-drm-edid-has-quirk \
ksym-vanilla-drm-edid-header-is-valid \
ksym-vanilla-drm-edid-is-digital \
ksym-vanilla-drm-edid-is-valid \
ksym-vanilla-drm-edid-match \
ksym-vanilla-drm-edid-override-connector-update \
ksym-vanilla-drm-edid-print-product-id \
ksym-vanilla-drm-edid-raw \
ksym-vanilla-drm-edid-read \
ksym-vanilla-drm-edid-read-base-block \
ksym-vanilla-drm-edid-read-custom \
ksym-vanilla-drm-edid-read-ddc \
ksym-vanilla-drm-edid-read-switcheroo \
ksym-vanilla-drm-edid-to-sad \
ksym-vanilla-drm-edid-to-speaker-allocation \
ksym-vanilla-drm-edid-valid \
ksym-vanilla-drm-edp-backlight-disable \
ksym-vanilla-drm-edp-backlight-enable \
ksym-vanilla-drm-edp-backlight-init \
ksym-vanilla-drm-edp-backlight-set-level \
ksym-vanilla-drm-eld-sad-get \
ksym-vanilla-drm-eld-sad-set \
ksym-vanilla-drm-encoder-cleanup \
ksym-vanilla-drm-encoder-init \
ksym-vanilla-drm-event-cancel-free \
ksym-vanilla-drm-event-reserve-init \
ksym-vanilla-drm-event-reserve-init-locked \
ksym-vanilla-drm-exec-cleanup \
ksym-vanilla-drm-exec-fini \
ksym-vanilla-drm-exec-init \
ksym-vanilla-drm-exec-lock-obj \
ksym-vanilla-drm-exec-prepare-array \
ksym-vanilla-drm-exec-prepare-obj \
ksym-vanilla-drm-exec-unlock-obj \
ksym-vanilla-drm-fb-argb8888-to-argb4444 \
ksym-vanilla-drm-fb-clip-offset \
ksym-vanilla-drm-fb-dma-get-gem-addr \
ksym-vanilla-drm-fb-dma-get-gem-obj \
ksym-vanilla-drm-fb-dma-get-scanout-buffer \
ksym-vanilla-drm-fb-dma-sync-non-coherent \
ksym-vanilla-drm-fb-helper-blank \
ksym-vanilla-drm-fb-helper-check-var \
ksym-vanilla-drm-fb-helper-damage-area \
ksym-vanilla-drm-fb-helper-damage-range \
ksym-vanilla-drm-fb-helper-deferred-io \
ksym-vanilla-drm-fb-helper-fill-info \
ksym-vanilla-drm-fb-helper-fini \
ksym-vanilla-drm-fb-helper-gem-is-fb \
ksym-vanilla-drm-fb-helper-hotplug-event \
ksym-vanilla-drm-fb-helper-init \
ksym-vanilla-drm-fb-helper-initial-config \
ksym-vanilla-drm-fb-helper-ioctl \
ksym-vanilla-drm-fb-helper-pan-display \
ksym-vanilla-drm-fb-helper-prepare \
ksym-vanilla-drm-fb-helper-restore-fbdev-mode-unlocked \
ksym-vanilla-drm-fb-helper-set-par \
ksym-vanilla-drm-fb-helper-set-suspend \
ksym-vanilla-drm-fb-helper-set-suspend-unlocked \
ksym-vanilla-drm-fb-helper-setcmap \
ksym-vanilla-drm-fb-helper-unprepare \
ksym-vanilla-drm-fb-helper-unregister-info \
ksym-vanilla-drm-fb-memcpy \
ksym-vanilla-drm-fb-swab \
ksym-vanilla-drm-fb-xrgb8888-to-abgr8888 \
ksym-vanilla-drm-fb-xrgb8888-to-argb1555 \
ksym-vanilla-drm-fb-xrgb8888-to-argb2101010 \
ksym-vanilla-drm-fb-xrgb8888-to-argb8888 \
ksym-vanilla-drm-fb-xrgb8888-to-bgr888 \
ksym-vanilla-drm-fb-xrgb8888-to-bgrx8888 \
ksym-vanilla-drm-fb-xrgb8888-to-gray2 \
ksym-vanilla-drm-fb-xrgb8888-to-gray8 \
ksym-vanilla-drm-fb-xrgb8888-to-mono \
ksym-vanilla-drm-fb-xrgb8888-to-rgb332 \
ksym-vanilla-drm-fb-xrgb8888-to-rgb565 \
ksym-vanilla-drm-fb-xrgb8888-to-rgb565be \
ksym-vanilla-drm-fb-xrgb8888-to-rgb888 \
ksym-vanilla-drm-fb-xrgb8888-to-rgba5551 \
ksym-vanilla-drm-fb-xrgb8888-to-xbgr8888 \
ksym-vanilla-drm-fb-xrgb8888-to-xrgb1555 \
ksym-vanilla-drm-fb-xrgb8888-to-xrgb2101010 \
ksym-vanilla-drm-fbdev-dma-driver-fbdev-probe \
ksym-vanilla-drm-fbdev-shmem-driver-fbdev-probe \
ksym-vanilla-drm-fbdev-ttm-driver-fbdev-probe \
ksym-vanilla-drm-fdinfo-print-size \
ksym-vanilla-drm-file-err \
ksym-vanilla-drm-file-get-master \
ksym-vanilla-drm-flip-work-cleanup \
ksym-vanilla-drm-flip-work-commit \
ksym-vanilla-drm-flip-work-init \
ksym-vanilla-drm-flip-work-queue \
ksym-vanilla-drm-format-conv-state-copy \
ksym-vanilla-drm-format-conv-state-init \
ksym-vanilla-drm-format-conv-state-release \
ksym-vanilla-drm-format-conv-state-reserve \
ksym-vanilla-drm-format-info \
ksym-vanilla-drm-format-info-block-height \
ksym-vanilla-drm-format-info-block-width \
ksym-vanilla-drm-format-info-bpp \
ksym-vanilla-drm-format-info-min-pitch \
ksym-vanilla-drm-framebuffer-cleanup \
ksym-vanilla-drm-framebuffer-init \
ksym-vanilla-drm-framebuffer-lookup \
ksym-vanilla-drm-framebuffer-remove \
ksym-vanilla-drm-framebuffer-unregister-private \
ksym-vanilla-drm-gem-begin-shadow-fb-access \
ksym-vanilla-drm-gem-create-mmap-offset \
ksym-vanilla-drm-gem-create-mmap-offset-size \
ksym-vanilla-drm-gem-destroy-shadow-plane-state \
ksym-vanilla-drm-gem-dma-create \
ksym-vanilla-drm-gem-dma-dumb-create \
ksym-vanilla-drm-gem-dma-dumb-create-internal \
ksym-vanilla-drm-gem-dma-free \
ksym-vanilla-drm-gem-dma-get-sg-table \
ksym-vanilla-drm-gem-dma-mmap \
ksym-vanilla-drm-gem-dma-prime-import-sg-table \
ksym-vanilla-drm-gem-dma-prime-import-sg-table-vmap \
ksym-vanilla-drm-gem-dma-print-info \
ksym-vanilla-drm-gem-dma-resv-wait \
ksym-vanilla-drm-gem-dma-vm-ops \
ksym-vanilla-drm-gem-dma-vmap \
ksym-vanilla-drm-gem-dmabuf-export \
ksym-vanilla-drm-gem-dmabuf-mmap \
ksym-vanilla-drm-gem-dmabuf-release \
ksym-vanilla-drm-gem-dmabuf-vmap \
ksym-vanilla-drm-gem-dmabuf-vunmap \
ksym-vanilla-drm-gem-dumb-map-offset \
ksym-vanilla-drm-gem-duplicate-shadow-plane-state \
ksym-vanilla-drm-gem-end-shadow-fb-access \
ksym-vanilla-drm-gem-evict-locked \
ksym-vanilla-drm-gem-fb-afbc-init \
ksym-vanilla-drm-gem-fb-begin-cpu-access \
ksym-vanilla-drm-gem-fb-create \
ksym-vanilla-drm-gem-fb-create-handle \
ksym-vanilla-drm-gem-fb-create-with-dirty \
ksym-vanilla-drm-gem-fb-create-with-funcs \
ksym-vanilla-drm-gem-fb-destroy \
ksym-vanilla-drm-gem-fb-end-cpu-access \
ksym-vanilla-drm-gem-fb-get-obj \
ksym-vanilla-drm-gem-fb-init-with-funcs \
ksym-vanilla-drm-gem-fb-vmap \
ksym-vanilla-drm-gem-fb-vunmap \
ksym-vanilla-drm-gem-free-mmap-offset \
ksym-vanilla-drm-gem-get-pages \
ksym-vanilla-drm-gem-get-unmapped-area \
ksym-vanilla-drm-gem-handle-create \
ksym-vanilla-drm-gem-handle-delete \
ksym-vanilla-drm-gem-huge-mnt-create \
ksym-vanilla-drm-gem-is-prime-exported-dma-buf \
ksym-vanilla-drm-gem-lock \
ksym-vanilla-drm-gem-lock-reservations \
ksym-vanilla-drm-gem-lru-init \
ksym-vanilla-drm-gem-lru-move-tail \
ksym-vanilla-drm-gem-lru-move-tail-locked \
ksym-vanilla-drm-gem-lru-remove \
ksym-vanilla-drm-gem-lru-scan \
ksym-vanilla-drm-gem-map-attach \
ksym-vanilla-drm-gem-map-detach \
ksym-vanilla-drm-gem-map-dma-buf \
ksym-vanilla-drm-gem-mmap \
ksym-vanilla-drm-gem-mmap-obj \
ksym-vanilla-drm-gem-object-free \
ksym-vanilla-drm-gem-object-init \
ksym-vanilla-drm-gem-object-lookup \
ksym-vanilla-drm-gem-object-release \
ksym-vanilla-drm-gem-objects-lookup \
ksym-vanilla-drm-gem-plane-helper-prepare-fb \
ksym-vanilla-drm-gem-prime-export \
ksym-vanilla-drm-gem-prime-fd-to-handle \
ksym-vanilla-drm-gem-prime-handle-to-dmabuf \
ksym-vanilla-drm-gem-prime-handle-to-fd \
ksym-vanilla-drm-gem-prime-import \
ksym-vanilla-drm-gem-prime-import-dev \
ksym-vanilla-drm-gem-prime-mmap \
ksym-vanilla-drm-gem-private-object-fini \
ksym-vanilla-drm-gem-private-object-init \
ksym-vanilla-drm-gem-put-pages \
ksym-vanilla-drm-gem-reset-shadow-plane \
ksym-vanilla-drm-gem-shmem-create \
ksym-vanilla-drm-gem-shmem-dumb-create \
ksym-vanilla-drm-gem-shmem-free \
ksym-vanilla-drm-gem-shmem-get-pages-sgt \
ksym-vanilla-drm-gem-shmem-get-sg-table \
ksym-vanilla-drm-gem-shmem-init \
ksym-vanilla-drm-gem-shmem-madvise-locked \
ksym-vanilla-drm-gem-shmem-mmap \
ksym-vanilla-drm-gem-shmem-pin \
ksym-vanilla-drm-gem-shmem-pin-locked \
ksym-vanilla-drm-gem-shmem-prime-import-no-map \
ksym-vanilla-drm-gem-shmem-prime-import-sg-table \
ksym-vanilla-drm-gem-shmem-print-info \
ksym-vanilla-drm-gem-shmem-purge-locked \
ksym-vanilla-drm-gem-shmem-put-pages-locked \
ksym-vanilla-drm-gem-shmem-release \
ksym-vanilla-drm-gem-shmem-unpin \
ksym-vanilla-drm-gem-shmem-unpin-locked \
ksym-vanilla-drm-gem-shmem-vm-ops \
ksym-vanilla-drm-gem-shmem-vmap-locked \
ksym-vanilla-drm-gem-shmem-vunmap-locked \
ksym-vanilla-drm-gem-simple-kms-begin-shadow-fb-access \
ksym-vanilla-drm-gem-simple-kms-destroy-shadow-plane-state \
ksym-vanilla-drm-gem-simple-kms-duplicate-shadow-plane-state \
ksym-vanilla-drm-gem-simple-kms-end-shadow-fb-access \
ksym-vanilla-drm-gem-simple-kms-reset-shadow-plane \
ksym-vanilla-drm-gem-ttm-dumb-map-offset \
ksym-vanilla-drm-gem-ttm-mmap \
ksym-vanilla-drm-gem-ttm-print-info \
ksym-vanilla-drm-gem-ttm-vmap \
ksym-vanilla-drm-gem-ttm-vunmap \
ksym-vanilla-drm-gem-unlock \
ksym-vanilla-drm-gem-unlock-reservations \
ksym-vanilla-drm-gem-unmap-dma-buf \
ksym-vanilla-drm-gem-vm-close \
ksym-vanilla-drm-gem-vm-open \
ksym-vanilla-drm-gem-vmap \
ksym-vanilla-drm-gem-vmap-locked \
ksym-vanilla-drm-gem-vram-create \
ksym-vanilla-drm-gem-vram-driver-dumb-create \
ksym-vanilla-drm-gem-vram-fill-create-dumb \
ksym-vanilla-drm-gem-vram-offset \
ksym-vanilla-drm-gem-vram-plane-helper-cleanup-fb \
ksym-vanilla-drm-gem-vram-plane-helper-prepare-fb \
ksym-vanilla-drm-gem-vram-put \
ksym-vanilla-drm-gem-vram-vmap \
ksym-vanilla-drm-gem-vram-vunmap \
ksym-vanilla-drm-gem-vunmap \
ksym-vanilla-drm-gem-vunmap-locked \
ksym-vanilla-drm-get-connector-status-name \
ksym-vanilla-drm-get-connector-type-name \
ksym-vanilla-drm-get-edid \
ksym-vanilla-drm-get-edid-switcheroo \
ksym-vanilla-drm-get-format-info \
ksym-vanilla-drm-get-panel-backlight-quirk \
ksym-vanilla-drm-get-panel-orientation-quirk \
ksym-vanilla-drm-get-subpixel-order-name \
ksym-vanilla-drm-get-tv-mode-from-name \
ksym-vanilla-drm-gpusvm-find-vma-start \
ksym-vanilla-drm-gpusvm-fini \
ksym-vanilla-drm-gpusvm-free-pages \
ksym-vanilla-drm-gpusvm-get-pages \
ksym-vanilla-drm-gpusvm-has-mapping \
ksym-vanilla-drm-gpusvm-init \
ksym-vanilla-drm-gpusvm-notifier-find \
ksym-vanilla-drm-gpusvm-range-evict \
ksym-vanilla-drm-gpusvm-range-find \
ksym-vanilla-drm-gpusvm-range-find-or-insert \
ksym-vanilla-drm-gpusvm-range-get \
ksym-vanilla-drm-gpusvm-range-get-pages \
ksym-vanilla-drm-gpusvm-range-pages-valid \
ksym-vanilla-drm-gpusvm-range-put \
ksym-vanilla-drm-gpusvm-range-remove \
ksym-vanilla-drm-gpusvm-range-set-unmapped \
ksym-vanilla-drm-gpusvm-range-unmap-pages \
ksym-vanilla-drm-gpusvm-scan-mm \
ksym-vanilla-drm-gpusvm-unmap-pages \
ksym-vanilla-drm-gpuva-find \
ksym-vanilla-drm-gpuva-find-first \
ksym-vanilla-drm-gpuva-find-next \
ksym-vanilla-drm-gpuva-find-prev \
ksym-vanilla-drm-gpuva-insert \
ksym-vanilla-drm-gpuva-link \
ksym-vanilla-drm-gpuva-map \
ksym-vanilla-drm-gpuva-ops-free \
ksym-vanilla-drm-gpuva-remap \
ksym-vanilla-drm-gpuva-remove \
ksym-vanilla-drm-gpuva-unlink \
ksym-vanilla-drm-gpuva-unlink-defer \
ksym-vanilla-drm-gpuva-unmap \
ksym-vanilla-drm-gpuvm-bo-create \
ksym-vanilla-drm-gpuvm-bo-deferred-cleanup \
ksym-vanilla-drm-gpuvm-bo-evict \
ksym-vanilla-drm-gpuvm-bo-extobj-add \
ksym-vanilla-drm-gpuvm-bo-find \
ksym-vanilla-drm-gpuvm-bo-obtain-locked \
ksym-vanilla-drm-gpuvm-bo-obtain-prealloc \
ksym-vanilla-drm-gpuvm-bo-put \
ksym-vanilla-drm-gpuvm-bo-put-deferred \
ksym-vanilla-drm-gpuvm-bo-unmap-ops-create \
ksym-vanilla-drm-gpuvm-exec-lock \
ksym-vanilla-drm-gpuvm-exec-lock-array \
ksym-vanilla-drm-gpuvm-exec-lock-range \
ksym-vanilla-drm-gpuvm-init \
ksym-vanilla-drm-gpuvm-interval-empty \
ksym-vanilla-drm-gpuvm-madvise-ops-create \
ksym-vanilla-drm-gpuvm-prefetch-ops-create \
ksym-vanilla-drm-gpuvm-prepare-objects \
ksym-vanilla-drm-gpuvm-prepare-range \
ksym-vanilla-drm-gpuvm-prepare-vm \
ksym-vanilla-drm-gpuvm-put \
ksym-vanilla-drm-gpuvm-range-valid \
ksym-vanilla-drm-gpuvm-resv-add-fence \
ksym-vanilla-drm-gpuvm-resv-object-alloc \
ksym-vanilla-drm-gpuvm-sm-map \
ksym-vanilla-drm-gpuvm-sm-map-exec-lock \
ksym-vanilla-drm-gpuvm-sm-map-ops-create \
ksym-vanilla-drm-gpuvm-sm-unmap \
ksym-vanilla-drm-gpuvm-sm-unmap-exec-lock \
ksym-vanilla-drm-gpuvm-sm-unmap-ops-create \
ksym-vanilla-drm-gpuvm-validate \
ksym-vanilla-drm-gtf-mode \
ksym-vanilla-drm-gtf-mode-complex \
ksym-vanilla-drm-handle-vblank \
ksym-vanilla-drm-hdcp-check-ksvs-revoked \
ksym-vanilla-drm-hdcp-update-content-protection \
ksym-vanilla-drm-hdmi-acr-get-n-cts \
ksym-vanilla-drm-hdmi-avi-infoframe-bars \
ksym-vanilla-drm-hdmi-avi-infoframe-colorimetry \
ksym-vanilla-drm-hdmi-avi-infoframe-content-type \
ksym-vanilla-drm-hdmi-avi-infoframe-from-display-mode \
ksym-vanilla-drm-hdmi-avi-infoframe-quant-range \
ksym-vanilla-drm-hdmi-compute-mode-clock \
ksym-vanilla-drm-hdmi-connector-get-broadcast-rgb-name \
ksym-vanilla-drm-hdmi-connector-get-output-format-name \
ksym-vanilla-drm-hdmi-connector-mode-valid \
ksym-vanilla-drm-hdmi-infoframe-set-hdr-metadata \
ksym-vanilla-drm-hdmi-vendor-infoframe-from-display-mode \
ksym-vanilla-drm-helper-connector-dpms \
ksym-vanilla-drm-helper-crtc-in-use \
ksym-vanilla-drm-helper-disable-unused-functions \
ksym-vanilla-drm-helper-encoder-in-use \
ksym-vanilla-drm-helper-force-disable-all \
ksym-vanilla-drm-helper-hpd-irq-event \
ksym-vanilla-drm-helper-mode-fill-fb-struct \
ksym-vanilla-drm-helper-move-panel-connectors-to-head \
ksym-vanilla-drm-helper-probe-detect \
ksym-vanilla-drm-helper-probe-single-connector-modes \
ksym-vanilla-drm-helper-resume-force-mode \
ksym-vanilla-drm-invalid-op \
ksym-vanilla-drm-ioctl \
ksym-vanilla-drm-ioctl-flags \
ksym-vanilla-drm-ioctl-kernel \
ksym-vanilla-drm-is-current-master \
ksym-vanilla-drm-is-panel-follower \
ksym-vanilla-drm-kms-helper-connector-hotplug-event \
ksym-vanilla-drm-kms-helper-hotplug-event \
ksym-vanilla-drm-kms-helper-is-poll-worker \
ksym-vanilla-drm-kms-helper-poll-disable \
ksym-vanilla-drm-kms-helper-poll-enable \
ksym-vanilla-drm-kms-helper-poll-fini \
ksym-vanilla-drm-kms-helper-poll-init \
ksym-vanilla-drm-kms-helper-poll-reschedule \
ksym-vanilla-drm-lspcon-get-mode \
ksym-vanilla-drm-lspcon-set-mode \
ksym-vanilla-drm-master-get \
ksym-vanilla-drm-master-internal-acquire \
ksym-vanilla-drm-master-internal-release \
ksym-vanilla-drm-master-put \
ksym-vanilla-drm-match-cea-mode \
ksym-vanilla-drm-memcpy-from-wc \
ksym-vanilla-drm-memory-stats-is-zero \
ksym-vanilla-drm-mipi-dbi-connector-helper-get-modes \
ksym-vanilla-drm-mipi-dbi-crtc-helper-atomic-check \
ksym-vanilla-drm-mipi-dbi-crtc-helper-atomic-disable \
ksym-vanilla-drm-mipi-dbi-crtc-helper-mode-valid \
ksym-vanilla-drm-mipi-dbi-dev-init \
ksym-vanilla-drm-mipi-dbi-plane-helper-atomic-check \
ksym-vanilla-drm-mipi-dbi-plane-helper-atomic-update \
ksym-vanilla-drm-mipi-dsi-get-input-bus-fmt \
ksym-vanilla-drm-mm-init \
ksym-vanilla-drm-mm-insert-node-in-range \
ksym-vanilla-drm-mm-print \
ksym-vanilla-drm-mm-remove-node \
ksym-vanilla-drm-mm-reserve-node \
ksym-vanilla-drm-mm-scan-add-block \
ksym-vanilla-drm-mm-scan-color-evict \
ksym-vanilla-drm-mm-scan-init-with-range \
ksym-vanilla-drm-mm-scan-remove-block \
ksym-vanilla-drm-mm-takedown \
ksym-vanilla-drm-mode-config-cleanup \
ksym-vanilla-drm-mode-config-helper-resume \
ksym-vanilla-drm-mode-config-helper-suspend \
ksym-vanilla-drm-mode-config-reset \
ksym-vanilla-drm-mode-copy \
ksym-vanilla-drm-mode-create \
ksym-vanilla-drm-mode-create-aspect-ratio-property \
ksym-vanilla-drm-mode-create-content-type-property \
ksym-vanilla-drm-mode-create-dp-colorspace-property \
ksym-vanilla-drm-mode-create-dvi-i-properties \
ksym-vanilla-drm-mode-create-from-cmdline-mode \
ksym-vanilla-drm-mode-create-hdmi-colorspace-property \
ksym-vanilla-drm-mode-create-scaling-mode-property \
ksym-vanilla-drm-mode-create-suggested-offset-properties \
ksym-vanilla-drm-mode-create-tile-group \
ksym-vanilla-drm-mode-create-tv-margin-properties \
ksym-vanilla-drm-mode-create-tv-properties \
ksym-vanilla-drm-mode-create-tv-properties-legacy \
ksym-vanilla-drm-mode-crtc-set-gamma-size \
ksym-vanilla-drm-mode-debug-printmodeline \
ksym-vanilla-drm-mode-destroy \
ksym-vanilla-drm-mode-duplicate \
ksym-vanilla-drm-mode-equal \
ksym-vanilla-drm-mode-equal-no-clocks \
ksym-vanilla-drm-mode-equal-no-clocks-no-stereo \
ksym-vanilla-drm-mode-find-dmt \
ksym-vanilla-drm-mode-get-hv-timing \
ksym-vanilla-drm-mode-get-tile-group \
ksym-vanilla-drm-mode-init \
ksym-vanilla-drm-mode-is-420 \
ksym-vanilla-drm-mode-is-420-also \
ksym-vanilla-drm-mode-is-420-only \
ksym-vanilla-drm-mode-legacy-fb-format \
ksym-vanilla-drm-mode-match \
ksym-vanilla-drm-mode-object-find \
ksym-vanilla-drm-mode-object-get \
ksym-vanilla-drm-mode-object-put \
ksym-vanilla-drm-mode-parse-command-line-for-connector \
ksym-vanilla-drm-mode-plane-set-obj-prop \
ksym-vanilla-drm-mode-probed-add \
ksym-vanilla-drm-mode-prune-invalid \
ksym-vanilla-drm-mode-put-tile-group \
ksym-vanilla-drm-mode-set-config-internal \
ksym-vanilla-drm-mode-set-crtcinfo \
ksym-vanilla-drm-mode-set-name \
ksym-vanilla-drm-mode-size-dumb \
ksym-vanilla-drm-mode-sort \
ksym-vanilla-drm-mode-validate-driver \
ksym-vanilla-drm-mode-validate-size \
ksym-vanilla-drm-mode-validate-ycbcr420 \
ksym-vanilla-drm-mode-vrefresh \
ksym-vanilla-drm-modeset-acquire-fini \
ksym-vanilla-drm-modeset-acquire-init \
ksym-vanilla-drm-modeset-backoff \
ksym-vanilla-drm-modeset-drop-locks \
ksym-vanilla-drm-modeset-lock \
ksym-vanilla-drm-modeset-lock-all \
ksym-vanilla-drm-modeset-lock-all-ctx \
ksym-vanilla-drm-modeset-lock-init \
ksym-vanilla-drm-modeset-lock-single-interruptible \
ksym-vanilla-drm-modeset-unlock \
ksym-vanilla-drm-modeset-unlock-all \
ksym-vanilla-drm-need-swiotlb \
ksym-vanilla-drm-noop \
ksym-vanilla-drm-object-attach-property \
ksym-vanilla-drm-object-immutable-property-get-value \
ksym-vanilla-drm-object-property-get-default-value \
ksym-vanilla-drm-object-property-get-value \
ksym-vanilla-drm-object-property-set-value \
ksym-vanilla-drm-of-component-match-add \
ksym-vanilla-drm-of-component-probe \
ksym-vanilla-drm-of-crtc-port-mask \
ksym-vanilla-drm-of-encoder-active-endpoint \
ksym-vanilla-drm-of-find-panel-or-bridge \
ksym-vanilla-drm-of-find-possible-crtcs \
ksym-vanilla-drm-of-get-data-lanes-count \
ksym-vanilla-drm-of-get-data-lanes-count-ep \
ksym-vanilla-drm-of-get-data-lanes-count-remote \
ksym-vanilla-drm-of-get-dsi-bus \
ksym-vanilla-drm-of-lvds-get-data-mapping \
ksym-vanilla-drm-of-lvds-get-dual-link-pixel-order \
ksym-vanilla-drm-of-lvds-get-dual-link-pixel-order-sink \
ksym-vanilla-drm-open \
ksym-vanilla-drm-pagemap-acquire-owner \
ksym-vanilla-drm-pagemap-cache-create-devm \
ksym-vanilla-drm-pagemap-cache-lock-lookup \
ksym-vanilla-drm-pagemap-cache-set-pagemap \
ksym-vanilla-drm-pagemap-cache-unlock-lookup \
ksym-vanilla-drm-pagemap-devmem-init \
ksym-vanilla-drm-pagemap-evict-to-ram \
ksym-vanilla-drm-pagemap-get-from-cache \
ksym-vanilla-drm-pagemap-get-from-cache-if-active \
ksym-vanilla-drm-pagemap-init \
ksym-vanilla-drm-pagemap-migrate-to-devmem \
ksym-vanilla-drm-pagemap-page-to-dpagemap \
ksym-vanilla-drm-pagemap-pagemap-ops-get \
ksym-vanilla-drm-pagemap-populate-mm \
ksym-vanilla-drm-pagemap-put \
ksym-vanilla-drm-pagemap-reinit \
ksym-vanilla-drm-pagemap-release-owner \
ksym-vanilla-drm-pagemap-shrinker-create-devm \
ksym-vanilla-drm-panel-add \
ksym-vanilla-drm-panel-add-follower \
ksym-vanilla-drm-panel-bridge-add \
ksym-vanilla-drm-panel-bridge-add-typed \
ksym-vanilla-drm-panel-bridge-connector \
ksym-vanilla-drm-panel-bridge-remove \
ksym-vanilla-drm-panel-bridge-set-orientation \
ksym-vanilla-drm-panel-disable \
ksym-vanilla-drm-panel-dp-aux-backlight \
ksym-vanilla-drm-panel-enable \
ksym-vanilla-drm-panel-get \
ksym-vanilla-drm-panel-get-modes \
ksym-vanilla-drm-panel-of-backlight \
ksym-vanilla-drm-panel-prepare \
ksym-vanilla-drm-panel-put \
ksym-vanilla-drm-panel-remove \
ksym-vanilla-drm-panel-remove-follower \
ksym-vanilla-drm-panel-unprepare \
ksym-vanilla-drm-panic-is-enabled \
ksym-vanilla-drm-plane-add-size-hints-property \
ksym-vanilla-drm-plane-cleanup \
ksym-vanilla-drm-plane-colorop-3dlut-init \
ksym-vanilla-drm-plane-colorop-ctm-3x4-init \
ksym-vanilla-drm-plane-colorop-curve-1d-init \
ksym-vanilla-drm-plane-colorop-curve-1d-lut-init \
ksym-vanilla-drm-plane-colorop-mult-init \
ksym-vanilla-drm-plane-create-alpha-property \
ksym-vanilla-drm-plane-create-blend-mode-property \
ksym-vanilla-drm-plane-create-color-pipeline-property \
ksym-vanilla-drm-plane-create-color-properties \
ksym-vanilla-drm-plane-create-rotation-property \
ksym-vanilla-drm-plane-create-scaling-filter-property \
ksym-vanilla-drm-plane-create-zpos-immutable-property \
ksym-vanilla-drm-plane-create-zpos-property \
ksym-vanilla-drm-plane-enable-fb-damage-clips \
ksym-vanilla-drm-plane-force-disable \
ksym-vanilla-drm-plane-from-index \
ksym-vanilla-drm-plane-get-damage-clips \
ksym-vanilla-drm-plane-get-damage-clips-count \
ksym-vanilla-drm-plane-has-format \
ksym-vanilla-drm-plane-helper-destroy \
ksym-vanilla-drm-plane-helper-disable-primary \
ksym-vanilla-drm-plane-helper-update-primary \
ksym-vanilla-drm-poll \
ksym-vanilla-drm-prime-gem-destroy \
ksym-vanilla-drm-prime-get-contiguous-size \
ksym-vanilla-drm-prime-pages-to-sg \
ksym-vanilla-drm-prime-sg-to-dma-addr-array \
ksym-vanilla-drm-prime-sg-to-page-array \
ksym-vanilla-drm-print-bits \
ksym-vanilla-drm-print-hex-dump \
ksym-vanilla-drm-print-memory-stats \
ksym-vanilla-drm-print-regset32 \
ksym-vanilla-drm-printf \
ksym-vanilla-drm-privacy-screen-call-notifier-chain \
ksym-vanilla-drm-privacy-screen-get \
ksym-vanilla-drm-privacy-screen-get-state \
ksym-vanilla-drm-privacy-screen-lookup-add \
ksym-vanilla-drm-privacy-screen-lookup-remove \
ksym-vanilla-drm-privacy-screen-put \
ksym-vanilla-drm-privacy-screen-register \
ksym-vanilla-drm-privacy-screen-register-notifier \
ksym-vanilla-drm-privacy-screen-set-sw-state \
ksym-vanilla-drm-privacy-screen-unregister \
ksym-vanilla-drm-privacy-screen-unregister-notifier \
ksym-vanilla-drm-probe-ddc \
ksym-vanilla-drm-property-add-enum \
ksym-vanilla-drm-property-blob-get \
ksym-vanilla-drm-property-blob-put \
ksym-vanilla-drm-property-create \
ksym-vanilla-drm-property-create-bitmask \
ksym-vanilla-drm-property-create-blob \
ksym-vanilla-drm-property-create-bool \
ksym-vanilla-drm-property-create-enum \
ksym-vanilla-drm-property-create-object \
ksym-vanilla-drm-property-create-range \
ksym-vanilla-drm-property-create-signed-range \
ksym-vanilla-drm-property-destroy \
ksym-vanilla-drm-property-lookup-blob \
ksym-vanilla-drm-property-replace-blob \
ksym-vanilla-drm-property-replace-blob-from-id \
ksym-vanilla-drm-property-replace-global-blob \
ksym-vanilla-drm-put-dev \
ksym-vanilla-drm-puts \
ksym-vanilla-drm-ras-node-register \
ksym-vanilla-drm-ras-node-unregister \
ksym-vanilla-drm-read \
ksym-vanilla-drm-rect-calc-hscale \
ksym-vanilla-drm-rect-calc-vscale \
ksym-vanilla-drm-rect-clip-scaled \
ksym-vanilla-drm-rect-debug-print \
ksym-vanilla-drm-rect-intersect \
ksym-vanilla-drm-rect-rotate \
ksym-vanilla-drm-rect-rotate-inv \
ksym-vanilla-drm-release \
ksym-vanilla-drm-release-noglobal \
ksym-vanilla-drm-rotation-simplify \
ksym-vanilla-drm-scdc-get-scrambling-status \
ksym-vanilla-drm-scdc-read \
ksym-vanilla-drm-scdc-set-high-tmds-clock-ratio \
ksym-vanilla-drm-scdc-set-scrambling \
ksym-vanilla-drm-scdc-write \
ksym-vanilla-drm-sched-entity-destroy \
ksym-vanilla-drm-sched-entity-error \
ksym-vanilla-drm-sched-entity-fini \
ksym-vanilla-drm-sched-entity-flush \
ksym-vanilla-drm-sched-entity-init \
ksym-vanilla-drm-sched-entity-kill \
ksym-vanilla-drm-sched-entity-modify-sched \
ksym-vanilla-drm-sched-entity-push-job \
ksym-vanilla-drm-sched-entity-set-priority \
ksym-vanilla-drm-sched-fault \
ksym-vanilla-drm-sched-fini \
ksym-vanilla-drm-sched-increase-karma \
ksym-vanilla-drm-sched-init \
ksym-vanilla-drm-sched-is-stopped \
ksym-vanilla-drm-sched-job-add-dependency \
ksym-vanilla-drm-sched-job-add-implicit-dependencies \
ksym-vanilla-drm-sched-job-add-resv-dependencies \
ksym-vanilla-drm-sched-job-add-syncobj-dependency \
ksym-vanilla-drm-sched-job-arm \
ksym-vanilla-drm-sched-job-cleanup \
ksym-vanilla-drm-sched-job-has-dependency \
ksym-vanilla-drm-sched-job-init \
ksym-vanilla-drm-sched-job-is-signaled \
ksym-vanilla-drm-sched-pick-best \
ksym-vanilla-drm-sched-resubmit-jobs \
ksym-vanilla-drm-sched-resume-timeout \
ksym-vanilla-drm-sched-start \
ksym-vanilla-drm-sched-stop \
ksym-vanilla-drm-sched-suspend-timeout \
ksym-vanilla-drm-sched-tdr-queue-imm \
ksym-vanilla-drm-sched-wqueue-ready \
ksym-vanilla-drm-sched-wqueue-start \
ksym-vanilla-drm-sched-wqueue-stop \
ksym-vanilla-drm-self-refresh-helper-alter-state \
ksym-vanilla-drm-self-refresh-helper-cleanup \
ksym-vanilla-drm-self-refresh-helper-init \
ksym-vanilla-drm-self-refresh-helper-update-avg-times \
ksym-vanilla-drm-send-event \
ksym-vanilla-drm-send-event-locked \
ksym-vanilla-drm-send-event-timestamp-locked \
ksym-vanilla-drm-set-preferred-mode \
ksym-vanilla-drm-show-fdinfo \
ksym-vanilla-drm-show-memory-stats \
ksym-vanilla-drm-simple-display-pipe-attach-bridge \
ksym-vanilla-drm-simple-display-pipe-init \
ksym-vanilla-drm-simple-encoder-init \
ksym-vanilla-drm-state-dump \
ksym-vanilla-drm-suballoc-alloc \
ksym-vanilla-drm-suballoc-dump-debug-info \
ksym-vanilla-drm-suballoc-free \
ksym-vanilla-drm-suballoc-insert \
ksym-vanilla-drm-suballoc-manager-fini \
ksym-vanilla-drm-suballoc-manager-init \
ksym-vanilla-drm-suballoc-new \
ksym-vanilla-drm-syncobj-add-point \
ksym-vanilla-drm-syncobj-create \
ksym-vanilla-drm-syncobj-find \
ksym-vanilla-drm-syncobj-find-fence \
ksym-vanilla-drm-syncobj-free \
ksym-vanilla-drm-syncobj-get-fd \
ksym-vanilla-drm-syncobj-get-handle \
ksym-vanilla-drm-syncobj-replace-fence \
ksym-vanilla-drm-sysfb-build-fourcc-list \
ksym-vanilla-drm-sysfb-connector-helper-get-modes \
ksym-vanilla-drm-sysfb-crtc-atomic-destroy-state \
ksym-vanilla-drm-sysfb-crtc-atomic-duplicate-state \
ksym-vanilla-drm-sysfb-crtc-helper-atomic-check \
ksym-vanilla-drm-sysfb-crtc-helper-mode-valid \
ksym-vanilla-drm-sysfb-crtc-reset \
ksym-vanilla-drm-sysfb-get-format \
ksym-vanilla-drm-sysfb-get-height-si \
ksym-vanilla-drm-sysfb-get-memory-si \
ksym-vanilla-drm-sysfb-get-stride-si \
ksym-vanilla-drm-sysfb-get-validated-int \
ksym-vanilla-drm-sysfb-get-validated-int0 \
ksym-vanilla-drm-sysfb-get-visible-size-si \
ksym-vanilla-drm-sysfb-get-width-si \
ksym-vanilla-drm-sysfb-mode \
ksym-vanilla-drm-sysfb-plane-atomic-destroy-state \
ksym-vanilla-drm-sysfb-plane-atomic-duplicate-state \
ksym-vanilla-drm-sysfb-plane-helper-atomic-check \
ksym-vanilla-drm-sysfb-plane-helper-atomic-disable \
ksym-vanilla-drm-sysfb-plane-helper-atomic-update \
ksym-vanilla-drm-sysfb-plane-helper-begin-fb-access \
ksym-vanilla-drm-sysfb-plane-helper-get-scanout-buffer \
ksym-vanilla-drm-sysfb-plane-reset \
ksym-vanilla-drm-sysfs-connector-hotplug-event \
ksym-vanilla-drm-sysfs-connector-property-event \
ksym-vanilla-drm-sysfs-hotplug-event \
ksym-vanilla-drm-timeout-abs-to-jiffies \
ksym-vanilla-drm-universal-plane-init \
ksym-vanilla-drm-vblank-init \
ksym-vanilla-drm-vblank-work-cancel-sync \
ksym-vanilla-drm-vblank-work-flush \
ksym-vanilla-drm-vblank-work-flush-all \
ksym-vanilla-drm-vblank-work-init \
ksym-vanilla-drm-vblank-work-schedule \
ksym-vanilla-drm-vma-node-allow \
ksym-vanilla-drm-vma-node-allow-once \
ksym-vanilla-drm-vma-node-is-allowed \
ksym-vanilla-drm-vma-node-revoke \
ksym-vanilla-drm-vma-offset-add \
ksym-vanilla-drm-vma-offset-lookup-locked \
ksym-vanilla-drm-vma-offset-manager-destroy \
ksym-vanilla-drm-vma-offset-manager-init \
ksym-vanilla-drm-vma-offset-remove \
ksym-vanilla-drm-vram-helper-mode-valid \
ksym-vanilla-drm-vram-mm-debugfs-init \
ksym-vanilla-drm-warn-on-modeset-not-all-locked \
ksym-vanilla-drm-writeback-cleanup-job \
ksym-vanilla-drm-writeback-connector-init \
ksym-vanilla-drm-writeback-connector-init-with-encoder \
ksym-vanilla-drm-writeback-get-out-fence \
ksym-vanilla-drm-writeback-prepare-job \
ksym-vanilla-drm-writeback-queue-job \
ksym-vanilla-drm-writeback-signal-completion \
ksym-vanilla-drmm-cgroup-register-region \
ksym-vanilla-drmm-connector-hdmi-cec-notifier-register \
ksym-vanilla-drmm-connector-hdmi-cec-register \
ksym-vanilla-drmm-connector-hdmi-init \
ksym-vanilla-drmm-connector-init \
ksym-vanilla-drmm-crtc-init-with-planes \
ksym-vanilla-drmm-encoder-init \
ksym-vanilla-drmm-kfree \
ksym-vanilla-drmm-kmalloc \
ksym-vanilla-drmm-kms-helper-poll-init \
ksym-vanilla-drmm-kstrdup \
ksym-vanilla-drmm-mode-config-init \
ksym-vanilla-drmm-of-get-bridge \
ksym-vanilla-drmm-panel-bridge-add \
ksym-vanilla-drmm-release-action \
ksym-vanilla-drmm-vram-helper-init \
ksym-vanilla-drmm-writeback-connector-init \
ksym-vanilla-drop-nlink \
ksym-vanilla-drop-reasons-by-subsys \
ksym-vanilla-drop-reasons-register-subsys \
ksym-vanilla-drop-reasons-unregister-subsys \
ksym-vanilla-drop-super \
ksym-vanilla-drx39xxj-attach \
ksym-vanilla-drxd-attach \
ksym-vanilla-drxk-attach \
ksym-vanilla-ds1685-rtc-poweroff \
ksym-vanilla-ds3000-attach \
ksym-vanilla-dsa-8021q-rcv \
ksym-vanilla-dsa-8021q-rx-source-port \
ksym-vanilla-dsa-8021q-rx-switch-id \
ksym-vanilla-dsa-8021q-xmit \
ksym-vanilla-dsa-devlink-param-get \
ksym-vanilla-dsa-devlink-param-set \
ksym-vanilla-dsa-devlink-params-register \
ksym-vanilla-dsa-devlink-params-unregister \
ksym-vanilla-dsa-devlink-port-region-create \
ksym-vanilla-dsa-devlink-region-create \
ksym-vanilla-dsa-devlink-region-destroy \
ksym-vanilla-dsa-devlink-resource-occ-get-register \
ksym-vanilla-dsa-devlink-resource-occ-get-unregister \
ksym-vanilla-dsa-devlink-resource-register \
ksym-vanilla-dsa-devlink-resources-unregister \
ksym-vanilla-dsa-enqueue-skb \
ksym-vanilla-dsa-fdb-present-in-other-db \
ksym-vanilla-dsa-flush-workqueue \
ksym-vanilla-dsa-mdb-present-in-other-db \
ksym-vanilla-dsa-port-from-netdev \
ksym-vanilla-dsa-port-phylink-mac-change \
ksym-vanilla-dsa-port-simple-hsr-join \
ksym-vanilla-dsa-port-simple-hsr-leave \
ksym-vanilla-dsa-port-simple-hsr-validate \
ksym-vanilla-dsa-register-switch \
ksym-vanilla-dsa-stubs \
ksym-vanilla-dsa-supports-eee \
ksym-vanilla-dsa-switch-find \
ksym-vanilla-dsa-switch-resume \
ksym-vanilla-dsa-switch-shutdown \
ksym-vanilla-dsa-switch-suspend \
ksym-vanilla-dsa-tag-8021q-bridge-join \
ksym-vanilla-dsa-tag-8021q-bridge-leave \
ksym-vanilla-dsa-tag-8021q-bridge-vid \
ksym-vanilla-dsa-tag-8021q-find-user \
ksym-vanilla-dsa-tag-8021q-register \
ksym-vanilla-dsa-tag-8021q-standalone-vid \
ksym-vanilla-dsa-tag-8021q-unregister \
ksym-vanilla-dsa-tag-drivers-register \
ksym-vanilla-dsa-tag-drivers-unregister \
ksym-vanilla-dsa-unregister-switch \
ksym-vanilla-dsa-user-dev-check \
ksym-vanilla-dst-alloc \
ksym-vanilla-dst-attach \
ksym-vanilla-dst-blackhole-mtu \
ksym-vanilla-dst-blackhole-redirect \
ksym-vanilla-dst-blackhole-update-pmtu \
ksym-vanilla-dst-ca-attach \
ksym-vanilla-dst-cache-destroy \
ksym-vanilla-dst-cache-get \
ksym-vanilla-dst-cache-get-ip4 \
ksym-vanilla-dst-cache-get-ip6 \
ksym-vanilla-dst-cache-init \
ksym-vanilla-dst-cache-reset-now \
ksym-vanilla-dst-cache-set-ip4 \
ksym-vanilla-dst-cache-set-ip6 \
ksym-vanilla-dst-check-sum \
ksym-vanilla-dst-comm-init \
ksym-vanilla-dst-cow-metrics-generic \
ksym-vanilla-dst-default-metrics \
ksym-vanilla-dst-dev-put \
ksym-vanilla-dst-discard-out \
ksym-vanilla-dst-error-bailout \
ksym-vanilla-dst-error-recovery \
ksym-vanilla-dst-init \
ksym-vanilla-dst-pio-disable \
ksym-vanilla-dst-release \
ksym-vanilla-dst-release-immediate \
ksym-vanilla-dst-wait-dst-ready \
ksym-vanilla-dt-init-idle-driver \
ksym-vanilla-dummy-con \
ksym-vanilla-dummy-irq-chip \
ksym-vanilla-dump-align \
ksym-vanilla-dump-emit \
ksym-vanilla-dump-page \
ksym-vanilla-dump-skip \
ksym-vanilla-dump-skip-to \
ksym-vanilla-dump-stack \
ksym-vanilla-dump-stack-lvl \
ksym-vanilla-dup-iter \
ksym-vanilla-dvb-ca-en50221-camchange-irq \
ksym-vanilla-dvb-ca-en50221-camready-irq \
ksym-vanilla-dvb-ca-en50221-frda-irq \
ksym-vanilla-dvb-ca-en50221-init \
ksym-vanilla-dvb-ca-en50221-release \
ksym-vanilla-dvb-create-media-graph \
ksym-vanilla-dvb-device-get \
ksym-vanilla-dvb-dmx-init \
ksym-vanilla-dvb-dmx-release \
ksym-vanilla-dvb-dmx-swfilter \
ksym-vanilla-dvb-dmx-swfilter-204 \
ksym-vanilla-dvb-dmx-swfilter-packets \
ksym-vanilla-dvb-dmx-swfilter-raw \
ksym-vanilla-dvb-dmxdev-init \
ksym-vanilla-dvb-dmxdev-release \
ksym-vanilla-dvb-frontend-detach \
ksym-vanilla-dvb-frontend-reinitialise \
ksym-vanilla-dvb-frontend-resume \
ksym-vanilla-dvb-frontend-sleep-until \
ksym-vanilla-dvb-frontend-suspend \
ksym-vanilla-dvb-generic-ioctl \
ksym-vanilla-dvb-generic-open \
ksym-vanilla-dvb-generic-release \
ksym-vanilla-dvb-module-probe \
ksym-vanilla-dvb-module-release \
ksym-vanilla-dvb-net-init \
ksym-vanilla-dvb-net-release \
ksym-vanilla-dvb-pll-attach \
ksym-vanilla-dvb-register-adapter \
ksym-vanilla-dvb-register-device \
ksym-vanilla-dvb-register-frontend \
ksym-vanilla-dvb-remove-device \
ksym-vanilla-dvb-ringbuffer-avail \
ksym-vanilla-dvb-ringbuffer-empty \
ksym-vanilla-dvb-ringbuffer-flush \
ksym-vanilla-dvb-ringbuffer-flush-spinlock-wakeup \
ksym-vanilla-dvb-ringbuffer-free \
ksym-vanilla-dvb-ringbuffer-init \
ksym-vanilla-dvb-ringbuffer-read \
ksym-vanilla-dvb-ringbuffer-read-user \
ksym-vanilla-dvb-ringbuffer-write \
ksym-vanilla-dvb-ringbuffer-write-user \
ksym-vanilla-dvb-unregister-adapter \
ksym-vanilla-dvb-unregister-device \
ksym-vanilla-dvb-unregister-frontend \
ksym-vanilla-dvb-usb-device-exit \
ksym-vanilla-dvb-usb-device-init \
ksym-vanilla-dvb-usb-generic-rw \
ksym-vanilla-dvb-usb-generic-write \
ksym-vanilla-dvb-usb-get-hexline \
ksym-vanilla-dvb-usb-nec-rc-key-to-event \
ksym-vanilla-dvb-usbv2-disconnect \
ksym-vanilla-dvb-usbv2-generic-rw \
ksym-vanilla-dvb-usbv2-generic-rw-locked \
ksym-vanilla-dvb-usbv2-generic-write \
ksym-vanilla-dvb-usbv2-generic-write-locked \
ksym-vanilla-dvb-usbv2-probe \
ksym-vanilla-dvb-usbv2-reset-resume \
ksym-vanilla-dvb-usbv2-resume \
ksym-vanilla-dvb-usbv2-suspend \
ksym-vanilla-dw-dma-acpi-controller-free \
ksym-vanilla-dw-dma-acpi-controller-register \
ksym-vanilla-dw-dma-filter \
ksym-vanilla-dw-dma-probe \
ksym-vanilla-dw-dma-remove \
ksym-vanilla-dw-dp-bind \
ksym-vanilla-dw-edma-probe \
ksym-vanilla-dw-edma-remove \
ksym-vanilla-dw-hdmi-audio-disable \
ksym-vanilla-dw-hdmi-audio-enable \
ksym-vanilla-dw-hdmi-bind \
ksym-vanilla-dw-hdmi-bus-fmt-is-420 \
ksym-vanilla-dw-hdmi-phy-gen1-reset \
ksym-vanilla-dw-hdmi-phy-gen2-pddq \
ksym-vanilla-dw-hdmi-phy-gen2-reset \
ksym-vanilla-dw-hdmi-phy-gen2-txpwron \
ksym-vanilla-dw-hdmi-phy-i2c-set-addr \
ksym-vanilla-dw-hdmi-phy-i2c-write \
ksym-vanilla-dw-hdmi-phy-read-hpd \
ksym-vanilla-dw-hdmi-phy-setup-hpd \
ksym-vanilla-dw-hdmi-phy-update-hpd \
ksym-vanilla-dw-hdmi-probe \
ksym-vanilla-dw-hdmi-qp-bind \
ksym-vanilla-dw-hdmi-qp-resume \
ksym-vanilla-dw-hdmi-qp-suspend \
ksym-vanilla-dw-hdmi-remove \
ksym-vanilla-dw-hdmi-resume \
ksym-vanilla-dw-hdmi-set-channel-allocation \
ksym-vanilla-dw-hdmi-set-channel-count \
ksym-vanilla-dw-hdmi-set-channel-status \
ksym-vanilla-dw-hdmi-set-high-tmds-clock-ratio \
ksym-vanilla-dw-hdmi-set-plugged-cb \
ksym-vanilla-dw-hdmi-set-sample-iec958 \
ksym-vanilla-dw-hdmi-set-sample-non-pcm \
ksym-vanilla-dw-hdmi-set-sample-rate \
ksym-vanilla-dw-hdmi-set-sample-width \
ksym-vanilla-dw-hdmi-setup-rx-sense \
ksym-vanilla-dw-hdmi-to-plat-data \
ksym-vanilla-dw-hdmi-unbind \
ksym-vanilla-dw-i3c-common-probe \
ksym-vanilla-dw-i3c-common-remove \
ksym-vanilla-dw-mci-alloc-host \
ksym-vanilla-dw-mci-pltfm-register \
ksym-vanilla-dw-mci-pltfm-remove \
ksym-vanilla-dw-mci-pmops \
ksym-vanilla-dw-mci-probe \
ksym-vanilla-dw-mci-remove \
ksym-vanilla-dw-mci-runtime-resume \
ksym-vanilla-dw-mci-runtime-suspend \
ksym-vanilla-dw-mipi-dsi-bind \
ksym-vanilla-dw-mipi-dsi-get-bridge \
ksym-vanilla-dw-mipi-dsi-probe \
ksym-vanilla-dw-mipi-dsi-remove \
ksym-vanilla-dw-mipi-dsi-set-slave \
ksym-vanilla-dw-mipi-dsi-unbind \
ksym-vanilla-dw-mipi-dsi2-bind \
ksym-vanilla-dw-mipi-dsi2-probe \
ksym-vanilla-dw-mipi-dsi2-remove \
ksym-vanilla-dw-mipi-dsi2-unbind \
ksym-vanilla-dw-pcie-allocate-domains \
ksym-vanilla-dw-pcie-ep-cleanup \
ksym-vanilla-dw-pcie-ep-deinit \
ksym-vanilla-dw-pcie-ep-init \
ksym-vanilla-dw-pcie-ep-init-registers \
ksym-vanilla-dw-pcie-ep-linkdown \
ksym-vanilla-dw-pcie-ep-linkup \
ksym-vanilla-dw-pcie-ep-raise-intx-irq \
ksym-vanilla-dw-pcie-ep-raise-msi-irq \
ksym-vanilla-dw-pcie-ep-raise-msix-irq \
ksym-vanilla-dw-pcie-ep-reset-bar \
ksym-vanilla-dw-pcie-find-capability \
ksym-vanilla-dw-pcie-find-ext-capability \
ksym-vanilla-dw-pcie-find-ptm-capability \
ksym-vanilla-dw-pcie-find-rasdes-capability \
ksym-vanilla-dw-pcie-free-msi \
ksym-vanilla-dw-pcie-host-deinit \
ksym-vanilla-dw-pcie-host-init \
ksym-vanilla-dw-pcie-link-up \
ksym-vanilla-dw-pcie-msi-host-init \
ksym-vanilla-dw-pcie-msi-init \
ksym-vanilla-dw-pcie-own-conf-map-bus \
ksym-vanilla-dw-pcie-read \
ksym-vanilla-dw-pcie-read-dbi \
ksym-vanilla-dw-pcie-remove-capability \
ksym-vanilla-dw-pcie-remove-ext-capability \
ksym-vanilla-dw-pcie-resume-noirq \
ksym-vanilla-dw-pcie-setup-rc \
ksym-vanilla-dw-pcie-suspend-noirq \
ksym-vanilla-dw-pcie-upconfig-setup \
ksym-vanilla-dw-pcie-wait-for-link \
ksym-vanilla-dw-pcie-write \
ksym-vanilla-dw-pcie-write-dbi \
ksym-vanilla-dw-pcie-write-dbi2 \
ksym-vanilla-dw-spi-add-controller \
ksym-vanilla-dw-spi-check-status \
ksym-vanilla-dw-spi-dma-setup-generic \
ksym-vanilla-dw-spi-dma-setup-mfld \
ksym-vanilla-dw-spi-remove-controller \
ksym-vanilla-dw-spi-resume-controller \
ksym-vanilla-dw-spi-set-cs \
ksym-vanilla-dw-spi-suspend-controller \
ksym-vanilla-dw-spi-update-config \
ksym-vanilla-dw8250-do-set-termios \
ksym-vanilla-dw8250-setup-port \
ksym-vanilla-dwc-pwm-alloc \
ksym-vanilla-dwc2-pci-ids \
ksym-vanilla-dwc3-core-exit \
ksym-vanilla-dwc3-core-init \
ksym-vanilla-dwc3-core-probe \
ksym-vanilla-dwc3-core-remove \
ksym-vanilla-dwc3-enable-susphy \
ksym-vanilla-dwc3-gadget-exit \
ksym-vanilla-dwc3-gadget-init \
ksym-vanilla-dwc3-host-exit \
ksym-vanilla-dwc3-host-init \
ksym-vanilla-dwc3-pm-complete \
ksym-vanilla-dwc3-pm-prepare \
ksym-vanilla-dwc3-pm-resume \
ksym-vanilla-dwc3-pm-suspend \
ksym-vanilla-dwc3-runtime-idle \
ksym-vanilla-dwc3-runtime-resume \
ksym-vanilla-dwc3-runtime-suspend \
ksym-vanilla-dwc3-set-prtcap \
ksym-vanilla-dwmac1000-dma-ops \
ksym-vanilla-dynamic-cond-resched \
ksym-vanilla-dynamic-might-resched \
ksym-vanilla-dynamic-preempt-schedule \
ksym-vanilla-dynamic-preempt-schedule-notrace \
ksym-vanilla-dynevent-create \
ksym-vanilla-ebt-do-table \
ksym-vanilla-ebt-register-table \
ksym-vanilla-ebt-register-template \
ksym-vanilla-ebt-unregister-table \
ksym-vanilla-ebt-unregister-table-pre-exit \
ksym-vanilla-ebt-unregister-template \
ksym-vanilla-ec-get-handle \
ksym-vanilla-ec-read \
ksym-vanilla-ec-transaction \
ksym-vanilla-ec-write \
ksym-vanilla-ec100-attach \
ksym-vanilla-ecc-alloc-point \
ksym-vanilla-ecc-digits-from-bytes \
ksym-vanilla-ecc-free-point \
ksym-vanilla-ecc-gen-privkey \
ksym-vanilla-ecc-get-curve \
ksym-vanilla-ecc-get-curve25519 \
ksym-vanilla-ecc-is-key-valid \
ksym-vanilla-ecc-is-pubkey-valid-full \
ksym-vanilla-ecc-is-pubkey-valid-partial \
ksym-vanilla-ecc-make-pub-key \
ksym-vanilla-ecc-point-is-zero \
ksym-vanilla-ecc-point-mult-shamir \
ksym-vanilla-ecc-sw-hamming-calculate \
ksym-vanilla-ecc-sw-hamming-correct \
ksym-vanilla-ecryptfs-fill-auth-tok \
ksym-vanilla-ecryptfs-get-auth-tok-key \
ksym-vanilla-ecryptfs-get-versions \
ksym-vanilla-edac-debug-level \
ksym-vanilla-edac-debugfs-create-dir \
ksym-vanilla-edac-debugfs-create-dir-at \
ksym-vanilla-edac-debugfs-create-file \
ksym-vanilla-edac-debugfs-create-x16 \
ksym-vanilla-edac-debugfs-create-x32 \
ksym-vanilla-edac-debugfs-create-x8 \
ksym-vanilla-edac-dev-register \
ksym-vanilla-edac-device-add-device \
ksym-vanilla-edac-device-alloc-ctl-info \
ksym-vanilla-edac-device-alloc-index \
ksym-vanilla-edac-device-del-device \
ksym-vanilla-edac-device-free-ctl-info \
ksym-vanilla-edac-device-handle-ce-count \
ksym-vanilla-edac-device-handle-ue-count \
ksym-vanilla-edac-get-owner \
ksym-vanilla-edac-get-sysfs-subsys \
ksym-vanilla-edac-has-mcs \
ksym-vanilla-edac-layer-name \
ksym-vanilla-edac-mc-add-mc-with-groups \
ksym-vanilla-edac-mc-alloc \
ksym-vanilla-edac-mc-del-mc \
ksym-vanilla-edac-mc-find \
ksym-vanilla-edac-mc-find-csrow-by-page \
ksym-vanilla-edac-mc-free \
ksym-vanilla-edac-mc-handle-error \
ksym-vanilla-edac-mem-types \
ksym-vanilla-edac-mod-work \
ksym-vanilla-edac-op-state \
ksym-vanilla-edac-pci-add-device \
ksym-vanilla-edac-pci-alloc-ctl-info \
ksym-vanilla-edac-pci-alloc-index \
ksym-vanilla-edac-pci-create-generic-ctl \
ksym-vanilla-edac-pci-del-device \
ksym-vanilla-edac-pci-free-ctl-info \
ksym-vanilla-edac-pci-handle-npe \
ksym-vanilla-edac-pci-handle-pe \
ksym-vanilla-edac-pci-release-generic-ctl \
ksym-vanilla-edac-queue-work \
ksym-vanilla-edac-raw-mc-handle-error \
ksym-vanilla-edac-repair-type \
ksym-vanilla-edac-stop-work \
ksym-vanilla-eeprom-93cx6-multiread \
ksym-vanilla-eeprom-93cx6-multireadb \
ksym-vanilla-eeprom-93cx6-read \
ksym-vanilla-eeprom-93cx6-readb \
ksym-vanilla-eeprom-93cx6-wren \
ksym-vanilla-eeprom-93cx6-write \
ksym-vanilla-efi \
ksym-vanilla-efi-capsule-supported \
ksym-vanilla-efi-capsule-update \
ksym-vanilla-efi-mem-desc-lookup \
ksym-vanilla-efi-status-to-err \
ksym-vanilla-efi-tpm-final-log-size \
ksym-vanilla-efivar-get-next-variable \
ksym-vanilla-efivar-get-variable \
ksym-vanilla-efivar-is-available \
ksym-vanilla-efivar-lock \
ksym-vanilla-efivar-ops-nh \
ksym-vanilla-efivar-query-variable-info \
ksym-vanilla-efivar-set-variable \
ksym-vanilla-efivar-set-variable-locked \
ksym-vanilla-efivar-supports-writes \
ksym-vanilla-efivar-trylock \
ksym-vanilla-efivar-unlock \
ksym-vanilla-efivars-generic-ops-register \
ksym-vanilla-efivars-generic-ops-unregister \
ksym-vanilla-efivars-register \
ksym-vanilla-efivars-unregister \
ksym-vanilla-efuse-one-byte-read \
ksym-vanilla-efuse-power-switch \
ksym-vanilla-efuse-read-1byte \
ksym-vanilla-efuse-shadow-read \
ksym-vanilla-ehci-adjust-port-wakeup-flags \
ksym-vanilla-ehci-cf-port-reset-rwsem \
ksym-vanilla-ehci-handshake \
ksym-vanilla-ehci-hub-control \
ksym-vanilla-ehci-init-driver \
ksym-vanilla-ehci-reset \
ksym-vanilla-ehci-resume \
ksym-vanilla-ehci-setup \
ksym-vanilla-ehci-suspend \
ksym-vanilla-ei-close \
ksym-vanilla-ei-get-stats \
ksym-vanilla-ei-interrupt \
ksym-vanilla-ei-netdev-ops \
ksym-vanilla-ei-open \
ksym-vanilla-ei-poll \
ksym-vanilla-ei-set-multicast-list \
ksym-vanilla-ei-start-xmit \
ksym-vanilla-ei-tx-timeout \
ksym-vanilla-elfcorehdr-addr \
ksym-vanilla-elv-bio-merge-ok \
ksym-vanilla-elv-rb-add \
ksym-vanilla-elv-rb-del \
ksym-vanilla-elv-rb-find \
ksym-vanilla-elv-rb-former-request \
ksym-vanilla-elv-rb-latter-request \
ksym-vanilla-elv-register \
ksym-vanilla-elv-rqhash-add \
ksym-vanilla-elv-rqhash-del \
ksym-vanilla-elv-unregister \
ksym-vanilla-em-cpu-get \
ksym-vanilla-em-dev-register-pd-no-update \
ksym-vanilla-em-dev-register-perf-domain \
ksym-vanilla-em-dev-unregister-perf-domain \
ksym-vanilla-em-dev-update-chip-binning \
ksym-vanilla-em-dev-update-perf-domain \
ksym-vanilla-em-pd-get \
ksym-vanilla-em-update-performance-limits \
ksym-vanilla-em2828X-decoder-vmux \
ksym-vanilla-em28xx-alloc-urbs \
ksym-vanilla-em28xx-audio-analog-set \
ksym-vanilla-em28xx-audio-setup \
ksym-vanilla-em28xx-boards \
ksym-vanilla-em28xx-find-led \
ksym-vanilla-em28xx-free-device \
ksym-vanilla-em28xx-gpio-set \
ksym-vanilla-em28xx-init-camera \
ksym-vanilla-em28xx-init-usb-xfer \
ksym-vanilla-em28xx-read-ac97 \
ksym-vanilla-em28xx-read-reg \
ksym-vanilla-em28xx-register-extension \
ksym-vanilla-em28xx-set-mode \
ksym-vanilla-em28xx-setup-xc3028 \
ksym-vanilla-em28xx-stop-urbs \
ksym-vanilla-em28xx-toggle-reg-bits \
ksym-vanilla-em28xx-tuner-callback \
ksym-vanilla-em28xx-uninit-usb-xfer \
ksym-vanilla-em28xx-unregister-extension \
ksym-vanilla-em28xx-write-ac97 \
ksym-vanilla-em28xx-write-reg \
ksym-vanilla-em28xx-write-reg-bits \
ksym-vanilla-em28xx-write-regs \
ksym-vanilla-emergency-restart \
ksym-vanilla-empty-aops \
ksym-vanilla-empty-name \
ksym-vanilla-empty-req-queue \
ksym-vanilla-empty-zero-page \
ksym-vanilla-enable-delayed-work \
ksym-vanilla-enable-irq \
ksym-vanilla-enable-kprobe \
ksym-vanilla-enable-percpu-irq \
ksym-vanilla-enable-work \
ksym-vanilla-enclosure-add-device \
ksym-vanilla-enclosure-component-alloc \
ksym-vanilla-enclosure-component-register \
ksym-vanilla-enclosure-find \
ksym-vanilla-enclosure-for-each-device \
ksym-vanilla-enclosure-register \
ksym-vanilla-enclosure-remove-device \
ksym-vanilla-enclosure-unregister \
ksym-vanilla-encode-rs8 \
ksym-vanilla-end-buffer-read-sync \
ksym-vanilla-end-creating-path \
ksym-vanilla-end-dirop \
ksym-vanilla-end-page-writeback \
ksym-vanilla-end-renaming \
ksym-vanilla-enetc-add-mac-addr-ht-filter \
ksym-vanilla-enetc-alloc-msix \
ksym-vanilla-enetc-alloc-si-resources \
ksym-vanilla-enetc-clear-mac-flt-entry \
ksym-vanilla-enetc-close \
ksym-vanilla-enetc-configure-si \
ksym-vanilla-enetc-free-msix \
ksym-vanilla-enetc-free-si-resources \
ksym-vanilla-enetc-get-driver-data \
ksym-vanilla-enetc-get-rss-table \
ksym-vanilla-enetc-get-si-caps \
ksym-vanilla-enetc-get-stats \
ksym-vanilla-enetc-has-err050089 \
ksym-vanilla-enetc-hw-alloc \
ksym-vanilla-enetc-hwtstamp-get \
ksym-vanilla-enetc-hwtstamp-set \
ksym-vanilla-enetc-ierb-register-pf \
ksym-vanilla-enetc-init-si-rings-params \
ksym-vanilla-enetc-init-sriov-resources \
ksym-vanilla-enetc-ioctl \
ksym-vanilla-enetc-mdio-lock \
ksym-vanilla-enetc-mdio-read-c22 \
ksym-vanilla-enetc-mdio-read-c45 \
ksym-vanilla-enetc-mdio-write-c22 \
ksym-vanilla-enetc-mdio-write-c45 \
ksym-vanilla-enetc-mdiobus-create \
ksym-vanilla-enetc-mdiobus-destroy \
ksym-vanilla-enetc-mm-link-state-update \
ksym-vanilla-enetc-open \
ksym-vanilla-enetc-pci-probe \
ksym-vanilla-enetc-pci-remove \
ksym-vanilla-enetc-pf-netdev-setup \
ksym-vanilla-enetc-pf-set-mac-addr \
ksym-vanilla-enetc-phylink-create \
ksym-vanilla-enetc-phylink-destroy \
ksym-vanilla-enetc-port-mac-rd \
ksym-vanilla-enetc-port-mac-wr \
ksym-vanilla-enetc-reset-mac-addr-filter \
ksym-vanilla-enetc-reset-tc-mqprio \
ksym-vanilla-enetc-send-cmd \
ksym-vanilla-enetc-set-default-rss-key \
ksym-vanilla-enetc-set-ethtool-ops \
ksym-vanilla-enetc-set-features \
ksym-vanilla-enetc-set-fs-entry \
ksym-vanilla-enetc-set-mac-flt-entry \
ksym-vanilla-enetc-set-rss-key \
ksym-vanilla-enetc-set-rss-table \
ksym-vanilla-enetc-set-si-hw-addr \
ksym-vanilla-enetc-setup-bpf \
ksym-vanilla-enetc-setup-cbdr \
ksym-vanilla-enetc-setup-mac-addresses \
ksym-vanilla-enetc-setup-tc-mqprio \
ksym-vanilla-enetc-sriov-configure \
ksym-vanilla-enetc-start \
ksym-vanilla-enetc-stop \
ksym-vanilla-enetc-teardown-cbdr \
ksym-vanilla-enetc-vlan-rx-add-vid \
ksym-vanilla-enetc-vlan-rx-del-vid \
ksym-vanilla-enetc-xdp-xmit \
ksym-vanilla-enetc-xmit \
ksym-vanilla-enetc4-get-rss-table \
ksym-vanilla-enetc4-set-rss-table \
ksym-vanilla-enetc4-setup-cbdr \
ksym-vanilla-enetc4-teardown-cbdr \
ksym-vanilla-enic-api-devcmd-proxy-by-index \
ksym-vanilla-errata \
ksym-vanilla-errname \
ksym-vanilla-errno-to-blk-status \
ksym-vanilla-errseq-check \
ksym-vanilla-errseq-check-and-advance \
ksym-vanilla-errseq-sample \
ksym-vanilla-errseq-set \
ksym-vanilla-erst-clear \
ksym-vanilla-erst-disable \
ksym-vanilla-erst-get-record-count \
ksym-vanilla-erst-get-record-id-begin \
ksym-vanilla-erst-get-record-id-end \
ksym-vanilla-erst-get-record-id-next \
ksym-vanilla-erst-read \
ksym-vanilla-erst-read-record \
ksym-vanilla-erst-write \
ksym-vanilla-es8328-probe \
ksym-vanilla-es8328-regmap-config \
ksym-vanilla-esp-input-done2 \
ksym-vanilla-esp-output-head \
ksym-vanilla-esp-output-tail \
ksym-vanilla-esp6-input-done2 \
ksym-vanilla-esp6-output-head \
ksym-vanilla-esp6-output-tail \
ksym-vanilla-espintcp-push-skb \
ksym-vanilla-espintcp-queue-out \
ksym-vanilla-eth-commit-mac-addr-change \
ksym-vanilla-eth-get-headlen \
ksym-vanilla-eth-gro-complete \
ksym-vanilla-eth-gro-receive \
ksym-vanilla-eth-header \
ksym-vanilla-eth-header-cache \
ksym-vanilla-eth-header-cache-update \
ksym-vanilla-eth-header-parse \
ksym-vanilla-eth-header-parse-protocol \
ksym-vanilla-eth-mac-addr \
ksym-vanilla-eth-platform-get-mac-address \
ksym-vanilla-eth-prepare-mac-addr-change \
ksym-vanilla-eth-type-trans \
ksym-vanilla-eth-validate-addr \
ksym-vanilla-ether-setup \
ksym-vanilla-ethnl-cable-test-alloc \
ksym-vanilla-ethnl-cable-test-amplitude \
ksym-vanilla-ethnl-cable-test-fault-length-with-src \
ksym-vanilla-ethnl-cable-test-finished \
ksym-vanilla-ethnl-cable-test-free \
ksym-vanilla-ethnl-cable-test-pulse \
ksym-vanilla-ethnl-cable-test-result-with-src \
ksym-vanilla-ethnl-cable-test-step \
ksym-vanilla-ethnl-pse-send-ntf \
ksym-vanilla-ethtool-aggregate-ctrl-stats \
ksym-vanilla-ethtool-aggregate-mac-stats \
ksym-vanilla-ethtool-aggregate-pause-stats \
ksym-vanilla-ethtool-aggregate-phy-stats \
ksym-vanilla-ethtool-aggregate-rmon-stats \
ksym-vanilla-ethtool-convert-legacy-u32-to-link-mode \
ksym-vanilla-ethtool-convert-link-mode-to-legacy-u32 \
ksym-vanilla-ethtool-dev-mm-supported \
ksym-vanilla-ethtool-forced-speed-maps-init \
ksym-vanilla-ethtool-get-phc-vclocks \
ksym-vanilla-ethtool-get-ts-info-by-layer \
ksym-vanilla-ethtool-intersect-link-masks \
ksym-vanilla-ethtool-mmsv-event-handle \
ksym-vanilla-ethtool-mmsv-get-mm \
ksym-vanilla-ethtool-mmsv-init \
ksym-vanilla-ethtool-mmsv-link-state-handle \
ksym-vanilla-ethtool-mmsv-set-mm \
ksym-vanilla-ethtool-mmsv-stop \
ksym-vanilla-ethtool-notify \
ksym-vanilla-ethtool-op-get-link \
ksym-vanilla-ethtool-op-get-ts-info \
ksym-vanilla-ethtool-params-from-link-mode \
ksym-vanilla-ethtool-puts \
ksym-vanilla-ethtool-rx-flow-rule-create \
ksym-vanilla-ethtool-rx-flow-rule-destroy \
ksym-vanilla-ethtool-rxfh-context-lost \
ksym-vanilla-ethtool-rxfh-ctxs-can-resize \
ksym-vanilla-ethtool-rxfh-ctxs-resize \
ksym-vanilla-ethtool-rxfh-indir-can-resize \
ksym-vanilla-ethtool-rxfh-indir-lost \
ksym-vanilla-ethtool-rxfh-indir-resize \
ksym-vanilla-ethtool-set-ethtool-phy-ops \
ksym-vanilla-ethtool-sprintf \
ksym-vanilla-ethtool-str-to-medium \
ksym-vanilla-ethtool-virtdev-set-link-ksettings \
ksym-vanilla-etm-perf-symlink \
ksym-vanilla-event-triggers-call \
ksym-vanilla-event-triggers-post-call \
ksym-vanilla-eventfd-ctx-do-read \
ksym-vanilla-eventfd-ctx-fdget \
ksym-vanilla-eventfd-ctx-fileget \
ksym-vanilla-eventfd-ctx-put \
ksym-vanilla-eventfd-ctx-remove-wait-queue \
ksym-vanilla-eventfd-fget \
ksym-vanilla-eventfd-signal-mask \
ksym-vanilla-evict-inodes \
ksym-vanilla-evm-inode-init-security \
ksym-vanilla-evm-set-key \
ksym-vanilla-evm-verifyxattr \
ksym-vanilla-execute-in-process-context \
ksym-vanilla-exportfs-decode-fh \
ksym-vanilla-exportfs-decode-fh-raw \
ksym-vanilla-exportfs-encode-fh \
ksym-vanilla-exportfs-encode-inode-fh \
ksym-vanilla-expresswire-enable \
ksym-vanilla-expresswire-power-off \
ksym-vanilla-expresswire-write-u8 \
ksym-vanilla-extcon-dev-free \
ksym-vanilla-extcon-dev-register \
ksym-vanilla-extcon-dev-unregister \
ksym-vanilla-extcon-find-edev-by-node \
ksym-vanilla-extcon-get-edev-by-phandle \
ksym-vanilla-extcon-get-edev-name \
ksym-vanilla-extcon-get-extcon-dev \
ksym-vanilla-extcon-get-property \
ksym-vanilla-extcon-get-property-capability \
ksym-vanilla-extcon-get-state \
ksym-vanilla-extcon-register-notifier \
ksym-vanilla-extcon-register-notifier-all \
ksym-vanilla-extcon-set-property \
ksym-vanilla-extcon-set-property-capability \
ksym-vanilla-extcon-set-property-sync \
ksym-vanilla-extcon-set-state \
ksym-vanilla-extcon-set-state-sync \
ksym-vanilla-extcon-sync \
ksym-vanilla-extcon-unregister-notifier \
ksym-vanilla-extcon-unregister-notifier-all \
ksym-vanilla-extract-iter-to-sg \
ksym-vanilla-extts-clean-up \
ksym-vanilla-exynos-get-pmu-regmap \
ksym-vanilla-exynos-get-pmu-regmap-by-phandle \
ksym-vanilla-ezusb-fx1-ihex-firmware-download \
ksym-vanilla-ezusb-fx1-set-reset \
ksym-vanilla-f-setown \
ksym-vanilla-failover-register \
ksym-vanilla-failover-slave-unregister \
ksym-vanilla-failover-unregister \
ksym-vanilla-fanout-mutex \
ksym-vanilla-fasync-helper \
ksym-vanilla-fat-add-entries \
ksym-vanilla-fat-alloc-new-dir \
ksym-vanilla-fat-attach \
ksym-vanilla-fat-build-inode \
ksym-vanilla-fat-detach \
ksym-vanilla-fat-dir-empty \
ksym-vanilla-fat-fileattr-get \
ksym-vanilla-fat-fill-super \
ksym-vanilla-fat-flush-inodes \
ksym-vanilla-fat-free-clusters \
ksym-vanilla-fat-free-fc \
ksym-vanilla-fat-get-dotdot-entry \
ksym-vanilla-fat-getattr \
ksym-vanilla-fat-init-fs-context \
ksym-vanilla-fat-param-spec \
ksym-vanilla-fat-parse-param \
ksym-vanilla-fat-reconfigure \
ksym-vanilla-fat-remove-entries \
ksym-vanilla-fat-scan \
ksym-vanilla-fat-search-long \
ksym-vanilla-fat-setattr \
ksym-vanilla-fat-sync-inode \
ksym-vanilla-fat-time-fat2unix \
ksym-vanilla-fat-time-unix2fat \
ksym-vanilla-fat-truncate-atime \
ksym-vanilla-fat-truncate-time \
ksym-vanilla-fat-update-time \
ksym-vanilla-fault-create-debugfs-attr \
ksym-vanilla-fault-in-iov-iter-readable \
ksym-vanilla-fault-in-iov-iter-writeable \
ksym-vanilla-fault-in-readable \
ksym-vanilla-fault-in-safe-writeable \
ksym-vanilla-fault-in-subpage-writeable \
ksym-vanilla-fault-in-writeable \
ksym-vanilla-faux-device-create \
ksym-vanilla-faux-device-create-with-groups \
ksym-vanilla-faux-device-destroy \
ksym-vanilla-fb-add-videomode \
ksym-vanilla-fb-alloc-cmap \
ksym-vanilla-fb-bl-default-curve \
ksym-vanilla-fb-bl-device \
ksym-vanilla-fb-blank \
ksym-vanilla-fb-copy-cmap \
ksym-vanilla-fb-dealloc-cmap \
ksym-vanilla-fb-default-cmap \
ksym-vanilla-fb-deferred-io-cleanup \
ksym-vanilla-fb-deferred-io-fsync \
ksym-vanilla-fb-deferred-io-init \
ksym-vanilla-fb-deferred-io-mmap \
ksym-vanilla-fb-deferred-io-open \
ksym-vanilla-fb-deferred-io-release \
ksym-vanilla-fb-destroy-modedb \
ksym-vanilla-fb-destroy-modelist \
ksym-vanilla-fb-edid-to-monspecs \
ksym-vanilla-fb-find-best-display \
ksym-vanilla-fb-find-best-mode \
ksym-vanilla-fb-find-mode \
ksym-vanilla-fb-find-mode-cvt \
ksym-vanilla-fb-find-nearest-mode \
ksym-vanilla-fb-firmware-edid \
ksym-vanilla-fb-get-buffer-offset \
ksym-vanilla-fb-get-color-depth \
ksym-vanilla-fb-get-mode \
ksym-vanilla-fb-get-options \
ksym-vanilla-fb-invert-cmaps \
ksym-vanilla-fb-io-mmap \
ksym-vanilla-fb-io-read \
ksym-vanilla-fb-io-write \
ksym-vanilla-fb-match-mode \
ksym-vanilla-fb-mode-is-equal \
ksym-vanilla-fb-modesetting-disabled \
ksym-vanilla-fb-notifier-call-chain \
ksym-vanilla-fb-pad-aligned-buffer \
ksym-vanilla-fb-pad-unaligned-buffer \
ksym-vanilla-fb-pan-display \
ksym-vanilla-fb-parse-edid \
ksym-vanilla-fb-register-client \
ksym-vanilla-fb-set-cmap \
ksym-vanilla-fb-set-suspend \
ksym-vanilla-fb-set-var \
ksym-vanilla-fb-set-var-from-user \
ksym-vanilla-fb-switch-outputs \
ksym-vanilla-fb-sys-read \
ksym-vanilla-fb-sys-write \
ksym-vanilla-fb-unregister-client \
ksym-vanilla-fb-validate-mode \
ksym-vanilla-fb-var-to-videomode \
ksym-vanilla-fb-videomode-from-videomode \
ksym-vanilla-fb-videomode-to-modelist \
ksym-vanilla-fb-videomode-to-var \
ksym-vanilla-fbtft-dbg-hex \
ksym-vanilla-fbtft-framebuffer-alloc \
ksym-vanilla-fbtft-framebuffer-release \
ksym-vanilla-fbtft-init-display \
ksym-vanilla-fbtft-probe-common \
ksym-vanilla-fbtft-read-spi \
ksym-vanilla-fbtft-register-backlight \
ksym-vanilla-fbtft-register-framebuffer \
ksym-vanilla-fbtft-remove-common \
ksym-vanilla-fbtft-unregister-backlight \
ksym-vanilla-fbtft-unregister-framebuffer \
ksym-vanilla-fbtft-write-buf-dc \
ksym-vanilla-fbtft-write-gpio16-wr \
ksym-vanilla-fbtft-write-gpio8-wr \
ksym-vanilla-fbtft-write-reg16-bus16 \
ksym-vanilla-fbtft-write-reg16-bus8 \
ksym-vanilla-fbtft-write-reg8-bus8 \
ksym-vanilla-fbtft-write-reg8-bus9 \
ksym-vanilla-fbtft-write-spi \
ksym-vanilla-fbtft-write-spi-emulate-9 \
ksym-vanilla-fbtft-write-vmem16-bus16 \
ksym-vanilla-fbtft-write-vmem16-bus8 \
ksym-vanilla-fbtft-write-vmem16-bus9 \
ksym-vanilla-fbtft-write-vmem8-bus8 \
ksym-vanilla-fc-attach-transport \
ksym-vanilla-fc-block-rport \
ksym-vanilla-fc-block-scsi-eh \
ksym-vanilla-fc-cpu-mask \
ksym-vanilla-fc-disc-config \
ksym-vanilla-fc-disc-init \
ksym-vanilla-fc-eh-abort \
ksym-vanilla-fc-eh-device-reset \
ksym-vanilla-fc-eh-host-reset \
ksym-vanilla-fc-eh-should-retry-cmd \
ksym-vanilla-fc-eh-timed-out \
ksym-vanilla-fc-elsct-init \
ksym-vanilla-fc-elsct-send \
ksym-vanilla-fc-exch-done \
ksym-vanilla-fc-exch-init \
ksym-vanilla-fc-exch-mgr-add \
ksym-vanilla-fc-exch-mgr-alloc \
ksym-vanilla-fc-exch-mgr-del \
ksym-vanilla-fc-exch-mgr-free \
ksym-vanilla-fc-exch-mgr-list-clone \
ksym-vanilla-fc-exch-mgr-reset \
ksym-vanilla-fc-exch-recv \
ksym-vanilla-fc-exch-seq-send \
ksym-vanilla-fc-exch-update-stats \
ksym-vanilla-fc-fabric-login \
ksym-vanilla-fc-fabric-logoff \
ksym-vanilla-fc-fc4-deregister-provider \
ksym-vanilla-fc-fc4-register-provider \
ksym-vanilla-fc-fcp-destroy \
ksym-vanilla-fc-fcp-init \
ksym-vanilla-fc-fill-hdr \
ksym-vanilla-fc-fill-reply-hdr \
ksym-vanilla-fc-find-rport-by-wwpn \
ksym-vanilla-fc-frame-alloc-fill \
ksym-vanilla-fc-frame-crc-check \
ksym-vanilla-fc-get-event-number \
ksym-vanilla-fc-get-host-port-state \
ksym-vanilla-fc-get-host-speed \
ksym-vanilla-fc-get-host-stats \
ksym-vanilla-fc-host-fpin-rcv \
ksym-vanilla-fc-host-post-event \
ksym-vanilla-fc-host-post-fc-event \
ksym-vanilla-fc-host-post-vendor-event \
ksym-vanilla-fc-linkdown \
ksym-vanilla-fc-linkup \
ksym-vanilla-fc-lport-bsg-request \
ksym-vanilla-fc-lport-config \
ksym-vanilla-fc-lport-destroy \
ksym-vanilla-fc-lport-flogi-resp \
ksym-vanilla-fc-lport-init \
ksym-vanilla-fc-lport-iterate \
ksym-vanilla-fc-lport-logo-resp \
ksym-vanilla-fc-lport-notifier-head \
ksym-vanilla-fc-lport-recv \
ksym-vanilla-fc-lport-reset \
ksym-vanilla-fc-lport-set-local-id \
ksym-vanilla-fc-mount \
ksym-vanilla-fc-mount-longterm \
ksym-vanilla-fc-queuecommand \
ksym-vanilla-fc-release-transport \
ksym-vanilla-fc-remote-port-add \
ksym-vanilla-fc-remote-port-delete \
ksym-vanilla-fc-remote-port-rolechg \
ksym-vanilla-fc-remove-host \
ksym-vanilla-fc-rport-create \
ksym-vanilla-fc-rport-destroy \
ksym-vanilla-fc-rport-flush-queue \
ksym-vanilla-fc-rport-login \
ksym-vanilla-fc-rport-logoff \
ksym-vanilla-fc-rport-lookup \
ksym-vanilla-fc-rport-recv-req \
ksym-vanilla-fc-rport-terminate-io \
ksym-vanilla-fc-sdev-init \
ksym-vanilla-fc-seq-assign \
ksym-vanilla-fc-seq-els-rsp-send \
ksym-vanilla-fc-seq-release \
ksym-vanilla-fc-seq-send \
ksym-vanilla-fc-seq-set-resp \
ksym-vanilla-fc-seq-start-next \
ksym-vanilla-fc-set-mfs \
ksym-vanilla-fc-set-rport-loss-tmo \
ksym-vanilla-fc-vport-create \
ksym-vanilla-fc-vport-id-lookup \
ksym-vanilla-fc-vport-setlink \
ksym-vanilla-fc-vport-terminate \
ksym-vanilla-fc0011-attach \
ksym-vanilla-fc0012-attach \
ksym-vanilla-fc0013-attach \
ksym-vanilla-fcoe-check-wait-queue \
ksym-vanilla-fcoe-clean-pending-queue \
ksym-vanilla-fcoe-ctlr-destroy \
ksym-vanilla-fcoe-ctlr-device-add \
ksym-vanilla-fcoe-ctlr-device-delete \
ksym-vanilla-fcoe-ctlr-els-send \
ksym-vanilla-fcoe-ctlr-get-lesb \
ksym-vanilla-fcoe-ctlr-init \
ksym-vanilla-fcoe-ctlr-link-down \
ksym-vanilla-fcoe-ctlr-link-up \
ksym-vanilla-fcoe-ctlr-recv \
ksym-vanilla-fcoe-ctlr-recv-flogi \
ksym-vanilla-fcoe-ctlr-set-fip-mode \
ksym-vanilla-fcoe-fc-crc \
ksym-vanilla-fcoe-fcf-device-add \
ksym-vanilla-fcoe-fcf-device-delete \
ksym-vanilla-fcoe-fcf-get-selected \
ksym-vanilla-fcoe-get-lesb \
ksym-vanilla-fcoe-get-paged-crc-eof \
ksym-vanilla-fcoe-get-wwn \
ksym-vanilla-fcoe-libfc-config \
ksym-vanilla-fcoe-link-speed-update \
ksym-vanilla-fcoe-queue-timer \
ksym-vanilla-fcoe-start-io \
ksym-vanilla-fcoe-transport-attach \
ksym-vanilla-fcoe-transport-detach \
ksym-vanilla-fcoe-validate-vport-create \
ksym-vanilla-fcoe-wwn-from-mac \
ksym-vanilla-fcoe-wwn-to-str \
ksym-vanilla-fcp-avc-transaction \
ksym-vanilla-fcp-bus-reset \
ksym-vanilla-fd-install \
ksym-vanilla-fddi-type-trans \
ksym-vanilla-fdget \
ksym-vanilla-fdma-alloc-coherent \
ksym-vanilla-fdma-alloc-phys \
ksym-vanilla-fdma-dcb-add \
ksym-vanilla-fdma-dcbs-init \
ksym-vanilla-fdma-free-coherent \
ksym-vanilla-fdma-free-phys \
ksym-vanilla-fdma-get-size \
ksym-vanilla-fdma-get-size-contiguous \
ksym-vanilla-fdomain-create \
ksym-vanilla-fdomain-destroy \
ksym-vanilla-felix-netdev-to-port \
ksym-vanilla-felix-port-to-netdev \
ksym-vanilla-felix-register-switch \
ksym-vanilla-ffa-bus-type \
ksym-vanilla-ffa-device-register \
ksym-vanilla-ffa-device-unregister \
ksym-vanilla-ffa-devices-unregister \
ksym-vanilla-ffa-driver-register \
ksym-vanilla-ffa-driver-unregister \
ksym-vanilla-ffs-lock \
ksym-vanilla-ffs-name-dev \
ksym-vanilla-ffs-single-dev \
ksym-vanilla-fg-console \
ksym-vanilla-fget \
ksym-vanilla-fget-raw \
ksym-vanilla-fget-task-next \
ksym-vanilla-fhctl-parse-dt \
ksym-vanilla-fib-alias-hw-flags-set \
ksym-vanilla-fib-default-rule-add \
ksym-vanilla-fib-delrule \
ksym-vanilla-fib-info-nh-uses-dev \
ksym-vanilla-fib-new-table \
ksym-vanilla-fib-newrule \
ksym-vanilla-fib-notifier-ops-register \
ksym-vanilla-fib-notifier-ops-unregister \
ksym-vanilla-fib-rule-matchall \
ksym-vanilla-fib-rules-dump \
ksym-vanilla-fib-rules-lookup \
ksym-vanilla-fib-rules-register \
ksym-vanilla-fib-rules-seq-read \
ksym-vanilla-fib-rules-unregister \
ksym-vanilla-fib-table-lookup \
ksym-vanilla-fib4-rule-default \
ksym-vanilla-fib6-check-nexthop \
ksym-vanilla-fib6-get-table \
ksym-vanilla-fib6-info-destroy-rcu \
ksym-vanilla-fib6-info-hw-flags-set \
ksym-vanilla-fib6-lookup \
ksym-vanilla-fib6-new-table \
ksym-vanilla-fib6-rule-default \
ksym-vanilla-fiemap-fill-next-extent \
ksym-vanilla-fiemap-prep \
ksym-vanilla-fifo-create-dflt \
ksym-vanilla-fifo-set-limit \
ksym-vanilla-file-bdev \
ksym-vanilla-file-check-and-advance-wb-err \
ksym-vanilla-file-f-owner-allocate \
ksym-vanilla-file-fdatawait-range \
ksym-vanilla-file-modified \
ksym-vanilla-file-ns-capable \
ksym-vanilla-file-open-root \
ksym-vanilla-file-path \
ksym-vanilla-file-ra-state-init \
ksym-vanilla-file-remove-privs \
ksym-vanilla-file-update-time \
ksym-vanilla-file-write-and-wait-range \
ksym-vanilla-fileattr-fill-flags \
ksym-vanilla-fileattr-fill-xflags \
ksym-vanilla-filemap-add-folio \
ksym-vanilla-filemap-alloc-folio-noprof \
ksym-vanilla-filemap-check-errors \
ksym-vanilla-filemap-dirty-folio \
ksym-vanilla-filemap-dontcache-kick-writeback \
ksym-vanilla-filemap-fault \
ksym-vanilla-filemap-fdatawait-keep-errors \
ksym-vanilla-filemap-fdatawait-range \
ksym-vanilla-filemap-fdatawait-range-keep-errors \
ksym-vanilla-filemap-fdatawrite \
ksym-vanilla-filemap-fdatawrite-range \
ksym-vanilla-filemap-flush \
ksym-vanilla-filemap-flush-nr \
ksym-vanilla-filemap-flush-range \
ksym-vanilla-filemap-get-folios \
ksym-vanilla-filemap-get-folios-contig \
ksym-vanilla-filemap-get-folios-tag \
ksym-vanilla-filemap-invalidate-inode \
ksym-vanilla-filemap-invalidate-lock-two \
ksym-vanilla-filemap-invalidate-unlock-two \
ksym-vanilla-filemap-map-pages \
ksym-vanilla-filemap-migrate-folio \
ksym-vanilla-filemap-page-mkwrite \
ksym-vanilla-filemap-range-has-page \
ksym-vanilla-filemap-range-has-writeback \
ksym-vanilla-filemap-read \
ksym-vanilla-filemap-release-folio \
ksym-vanilla-filemap-splice-read \
ksym-vanilla-filemap-write-and-wait-range \
ksym-vanilla-fill-inquiry-response \
ksym-vanilla-fill-mg-cmtime \
ksym-vanilla-filp-close \
ksym-vanilla-filp-open \
ksym-vanilla-filter-irq-stacks \
ksym-vanilla-filter-match-preds \
ksym-vanilla-finalize-exec \
ksym-vanilla-find-asymmetric-key \
ksym-vanilla-find-cxl-root \
ksym-vanilla-find-font \
ksym-vanilla-find-ge-pid \
ksym-vanilla-find-get-pid \
ksym-vanilla-find-inode-by-ino-rcu \
ksym-vanilla-find-inode-nowait \
ksym-vanilla-find-inode-rcu \
ksym-vanilla-find-iova \
ksym-vanilla-find-mci-by-dev \
ksym-vanilla-find-next-child \
ksym-vanilla-find-next-clump8 \
ksym-vanilla-find-pid-ns \
ksym-vanilla-find-random-bit \
ksym-vanilla-find-resource-space \
ksym-vanilla-find-vma \
ksym-vanilla-find-vma-intersection \
ksym-vanilla-find-vpid \
ksym-vanilla-finish-no-open \
ksym-vanilla-finish-open \
ksym-vanilla-finish-rcuwait \
ksym-vanilla-finish-swait \
ksym-vanilla-finish-wait \
ksym-vanilla-firmware-kobj \
ksym-vanilla-firmware-request-builtin \
ksym-vanilla-firmware-request-cache \
ksym-vanilla-firmware-request-nowait-nowarn \
ksym-vanilla-firmware-request-nowarn \
ksym-vanilla-firmware-request-platform \
ksym-vanilla-firmware-upload-register \
ksym-vanilla-firmware-upload-unregister \
ksym-vanilla-first-ec \
ksym-vanilla-fixed-phy-change-carrier \
ksym-vanilla-fixed-phy-register \
ksym-vanilla-fixed-phy-register-100fd \
ksym-vanilla-fixed-phy-set-link-update \
ksym-vanilla-fixed-phy-unregister \
ksym-vanilla-fixed-size-llseek \
ksym-vanilla-fixup-user-fault \
ksym-vanilla-fl6-merge-options \
ksym-vanilla-flexcop-device-exit \
ksym-vanilla-flexcop-device-initialize \
ksym-vanilla-flexcop-device-kfree \
ksym-vanilla-flexcop-device-kmalloc \
ksym-vanilla-flexcop-dma-allocate \
ksym-vanilla-flexcop-dma-config \
ksym-vanilla-flexcop-dma-config-timer \
ksym-vanilla-flexcop-dma-control-timer-irq \
ksym-vanilla-flexcop-dma-free \
ksym-vanilla-flexcop-dma-xfer-control \
ksym-vanilla-flexcop-eeprom-check-mac-addr \
ksym-vanilla-flexcop-i2c-request \
ksym-vanilla-flexcop-pass-dmx-data \
ksym-vanilla-flexcop-pass-dmx-packets \
ksym-vanilla-flexcop-pid-feed-control \
ksym-vanilla-flexcop-sram-ctrl \
ksym-vanilla-flexcop-sram-set-dest \
ksym-vanilla-flexcop-wan-set-speed \
ksym-vanilla-flexonenand-region \
ksym-vanilla-flow-action-cookie-create \
ksym-vanilla-flow-action-cookie-destroy \
ksym-vanilla-flow-block-cb-alloc \
ksym-vanilla-flow-block-cb-decref \
ksym-vanilla-flow-block-cb-free \
ksym-vanilla-flow-block-cb-incref \
ksym-vanilla-flow-block-cb-is-busy \
ksym-vanilla-flow-block-cb-lookup \
ksym-vanilla-flow-block-cb-priv \
ksym-vanilla-flow-block-cb-setup-simple \
ksym-vanilla-flow-get-u32-dst \
ksym-vanilla-flow-get-u32-src \
ksym-vanilla-flow-hash-from-keys \
ksym-vanilla-flow-hash-from-keys-seed \
ksym-vanilla-flow-indr-block-cb-alloc \
ksym-vanilla-flow-indr-dev-exists \
ksym-vanilla-flow-indr-dev-register \
ksym-vanilla-flow-indr-dev-setup-offload \
ksym-vanilla-flow-indr-dev-unregister \
ksym-vanilla-flow-keys-basic-dissector \
ksym-vanilla-flow-keys-dissector \
ksym-vanilla-flow-offload-add \
ksym-vanilla-flow-offload-alloc \
ksym-vanilla-flow-offload-free \
ksym-vanilla-flow-offload-lookup \
ksym-vanilla-flow-offload-refresh \
ksym-vanilla-flow-offload-route-init \
ksym-vanilla-flow-offload-teardown \
ksym-vanilla-flow-resources-add \
ksym-vanilla-flow-resources-alloc \
ksym-vanilla-flow-rule-alloc \
ksym-vanilla-flow-rule-match-arp \
ksym-vanilla-flow-rule-match-basic \
ksym-vanilla-flow-rule-match-control \
ksym-vanilla-flow-rule-match-ct \
ksym-vanilla-flow-rule-match-cvlan \
ksym-vanilla-flow-rule-match-enc-control \
ksym-vanilla-flow-rule-match-enc-ip \
ksym-vanilla-flow-rule-match-enc-ipv4-addrs \
ksym-vanilla-flow-rule-match-enc-ipv6-addrs \
ksym-vanilla-flow-rule-match-enc-keyid \
ksym-vanilla-flow-rule-match-enc-opts \
ksym-vanilla-flow-rule-match-enc-ports \
ksym-vanilla-flow-rule-match-eth-addrs \
ksym-vanilla-flow-rule-match-icmp \
ksym-vanilla-flow-rule-match-ip \
ksym-vanilla-flow-rule-match-ipsec \
ksym-vanilla-flow-rule-match-ipv4-addrs \
ksym-vanilla-flow-rule-match-ipv6-addrs \
ksym-vanilla-flow-rule-match-l2tpv3 \
ksym-vanilla-flow-rule-match-meta \
ksym-vanilla-flow-rule-match-mpls \
ksym-vanilla-flow-rule-match-ports \
ksym-vanilla-flow-rule-match-ports-range \
ksym-vanilla-flow-rule-match-pppoe \
ksym-vanilla-flow-rule-match-tcp \
ksym-vanilla-flow-rule-match-vlan \
ksym-vanilla-flush-dcache-folio \
ksym-vanilla-flush-dcache-page \
ksym-vanilla-flush-delayed-fput \
ksym-vanilla-flush-delayed-work \
ksym-vanilla-flush-rcu-work \
ksym-vanilla-flush-signals \
ksym-vanilla-flush-work \
ksym-vanilla-fman-bind \
ksym-vanilla-fman-get-bmi-max-fifo-size \
ksym-vanilla-fman-get-max-frm \
ksym-vanilla-fman-get-mem-region \
ksym-vanilla-fman-get-qman-channel-id \
ksym-vanilla-fman-get-revision \
ksym-vanilla-fman-get-rx-extra-headroom \
ksym-vanilla-fman-has-errata-a050385 \
ksym-vanilla-fman-port-bind \
ksym-vanilla-fman-port-cfg-buf-prefix-content \
ksym-vanilla-fman-port-config \
ksym-vanilla-fman-port-disable \
ksym-vanilla-fman-port-enable \
ksym-vanilla-fman-port-get-device \
ksym-vanilla-fman-port-get-hash-result-offset \
ksym-vanilla-fman-port-get-qman-channel-id \
ksym-vanilla-fman-port-get-tstamp \
ksym-vanilla-fman-port-init \
ksym-vanilla-fman-port-use-kg-hash \
ksym-vanilla-fman-register-intr \
ksym-vanilla-fman-reset-mac \
ksym-vanilla-fman-set-mac-max-frame \
ksym-vanilla-fman-set-port-params \
ksym-vanilla-fman-sp-build-buffer-struct \
ksym-vanilla-fman-sp-set-buf-pools-in-asc-order-of-buf-sizes \
ksym-vanilla-fman-unregister-intr \
ksym-vanilla-folio-add-lru \
ksym-vanilla-folio-add-pins \
ksym-vanilla-folio-alloc-buffers \
ksym-vanilla-folio-alloc-noprof \
ksym-vanilla-folio-clear-dirty-for-io \
ksym-vanilla-folio-copy \
ksym-vanilla-folio-end-dropbehind \
ksym-vanilla-folio-end-private-2 \
ksym-vanilla-folio-end-read \
ksym-vanilla-folio-end-writeback \
ksym-vanilla-folio-end-writeback-no-dropbehind \
ksym-vanilla-folio-invalidate \
ksym-vanilla-folio-mapping \
ksym-vanilla-folio-mark-accessed \
ksym-vanilla-folio-mark-dirty \
ksym-vanilla-folio-mark-dirty-lock \
ksym-vanilla-folio-mc-copy \
ksym-vanilla-folio-migrate-flags \
ksym-vanilla-folio-migrate-mapping \
ksym-vanilla-folio-mkclean \
ksym-vanilla-folio-redirty-for-writepage \
ksym-vanilla-folio-set-bh \
ksym-vanilla-folio-unlock \
ksym-vanilla-folio-wait-bit \
ksym-vanilla-folio-wait-bit-killable \
ksym-vanilla-folio-wait-private-2 \
ksym-vanilla-folio-wait-private-2-killable \
ksym-vanilla-folio-wait-stable \
ksym-vanilla-folio-wait-writeback \
ksym-vanilla-folio-wait-writeback-killable \
ksym-vanilla-folio-zero-new-buffers \
ksym-vanilla-folios-put-refs \
ksym-vanilla-follow-down \
ksym-vanilla-follow-down-one \
ksym-vanilla-follow-pfnmap-end \
ksym-vanilla-follow-pfnmap-start \
ksym-vanilla-follow-up \
ksym-vanilla-font-data-export \
ksym-vanilla-font-data-get \
ksym-vanilla-font-data-import \
ksym-vanilla-font-data-is-equal \
ksym-vanilla-font-data-put \
ksym-vanilla-font-data-rotate \
ksym-vanilla-font-data-size \
ksym-vanilla-font-glyph-rotate-180 \
ksym-vanilla-font-glyph-rotate-270 \
ksym-vanilla-font-glyph-rotate-90 \
ksym-vanilla-font-vga-8x16 \
ksym-vanilla-for-each-kernel-tracepoint \
ksym-vanilla-for-each-thermal-trip \
ksym-vanilla-force-sig \
ksym-vanilla-forget-all-cached-acls \
ksym-vanilla-forget-cached-acl \
ksym-vanilla-fou-encap-hlen \
ksym-vanilla-fpga-bridge-disable \
ksym-vanilla-fpga-bridge-enable \
ksym-vanilla-fpga-bridge-get \
ksym-vanilla-fpga-bridge-get-to-list \
ksym-vanilla-fpga-bridge-put \
ksym-vanilla-fpga-bridge-unregister \
ksym-vanilla-fpga-bridges-disable \
ksym-vanilla-fpga-bridges-enable \
ksym-vanilla-fpga-bridges-put \
ksym-vanilla-fpga-image-info-alloc \
ksym-vanilla-fpga-image-info-free \
ksym-vanilla-fpga-mgr-get \
ksym-vanilla-fpga-mgr-load \
ksym-vanilla-fpga-mgr-lock \
ksym-vanilla-fpga-mgr-put \
ksym-vanilla-fpga-mgr-unlock \
ksym-vanilla-fpga-mgr-unregister \
ksym-vanilla-fpga-region-class-find \
ksym-vanilla-fpga-region-program-fpga \
ksym-vanilla-fpga-region-unregister \
ksym-vanilla-fput \
ksym-vanilla-fqdir-exit \
ksym-vanilla-fqdir-init \
ksym-vanilla-fqdir-pre-exit \
ksym-vanilla-frame-vector-create \
ksym-vanilla-frame-vector-destroy \
ksym-vanilla-frame-vector-to-pages \
ksym-vanilla-frame-vector-to-pfns \
ksym-vanilla-framebuffer-alloc \
ksym-vanilla-framebuffer-release \
ksym-vanilla-framer-create \
ksym-vanilla-framer-destroy \
ksym-vanilla-framer-exit \
ksym-vanilla-framer-get \
ksym-vanilla-framer-get-config \
ksym-vanilla-framer-get-status \
ksym-vanilla-framer-init \
ksym-vanilla-framer-notifier-register \
ksym-vanilla-framer-notifier-unregister \
ksym-vanilla-framer-notify-status-change \
ksym-vanilla-framer-pm-runtime-get \
ksym-vanilla-framer-pm-runtime-get-sync \
ksym-vanilla-framer-pm-runtime-put \
ksym-vanilla-framer-pm-runtime-put-sync \
ksym-vanilla-framer-power-off \
ksym-vanilla-framer-power-on \
ksym-vanilla-framer-provider-of-unregister \
ksym-vanilla-framer-provider-simple-of-xlate \
ksym-vanilla-framer-put \
ksym-vanilla-framer-set-config \
ksym-vanilla-free-anon-bdev \
ksym-vanilla-free-bucket-spinlocks \
ksym-vanilla-free-buffer-head \
ksym-vanilla-free-c-can-dev \
ksym-vanilla-free-candev \
ksym-vanilla-free-cgroup-ns \
ksym-vanilla-free-contig-frozen-range \
ksym-vanilla-free-contig-range \
ksym-vanilla-free-cpumask-var \
ksym-vanilla-free-dma-pools \
ksym-vanilla-free-fib-info \
ksym-vanilla-free-inode-nonrcu \
ksym-vanilla-free-io-pgtable-ops \
ksym-vanilla-free-iova \
ksym-vanilla-free-iova-fast \
ksym-vanilla-free-irq \
ksym-vanilla-free-irq-cpu-rmap \
ksym-vanilla-free-libipw \
ksym-vanilla-free-mdio-bitbang \
ksym-vanilla-free-netdev \
ksym-vanilla-free-opal-dev \
ksym-vanilla-free-pages \
ksym-vanilla-free-pages-exact \
ksym-vanilla-free-percpu \
ksym-vanilla-free-percpu-irq \
ksym-vanilla-free-reserved-page \
ksym-vanilla-free-rs \
ksym-vanilla-free-sja1000dev \
ksym-vanilla-free-task \
ksym-vanilla-free-uid \
ksym-vanilla-free-vm-area \
ksym-vanilla-freeze-super \
ksym-vanilla-freezer-active \
ksym-vanilla-freezing-slow-path \
ksym-vanilla-freq-qos-add-notifier \
ksym-vanilla-freq-qos-add-request \
ksym-vanilla-freq-qos-remove-notifier \
ksym-vanilla-freq-qos-remove-request \
ksym-vanilla-freq-qos-update-request \
ksym-vanilla-freq-reg-info \
ksym-vanilla-from-kgid \
ksym-vanilla-from-kgid-munged \
ksym-vanilla-from-kprojid \
ksym-vanilla-from-kprojid-munged \
ksym-vanilla-from-kqid \
ksym-vanilla-from-kqid-munged \
ksym-vanilla-from-kuid \
ksym-vanilla-from-kuid-munged \
ksym-vanilla-from-vfsgid \
ksym-vanilla-from-vfsuid \
ksym-vanilla-fs-amp-load-firmware \
ksym-vanilla-fs-bio-integrity-generate \
ksym-vanilla-fs-bio-set \
ksym-vanilla-fs-context-for-mount \
ksym-vanilla-fs-context-for-submount \
ksym-vanilla-fs-dax-get \
ksym-vanilla-fs-dax-get-by-bdev \
ksym-vanilla-fs-ftype-to-dtype \
ksym-vanilla-fs-holder-ops \
ksym-vanilla-fs-kobj \
ksym-vanilla-fs-lookup-param \
ksym-vanilla-fs-overflowgid \
ksym-vanilla-fs-overflowuid \
ksym-vanilla-fs-param-is-blockdev \
ksym-vanilla-fs-param-is-bool \
ksym-vanilla-fs-param-is-enum \
ksym-vanilla-fs-param-is-fd \
ksym-vanilla-fs-param-is-file-or-string \
ksym-vanilla-fs-param-is-gid \
ksym-vanilla-fs-param-is-s32 \
ksym-vanilla-fs-param-is-string \
ksym-vanilla-fs-param-is-u32 \
ksym-vanilla-fs-param-is-u64 \
ksym-vanilla-fs-param-is-uid \
ksym-vanilla-fs-put-dax \
ksym-vanilla-fs-umode-to-dtype \
ksym-vanilla-fs-umode-to-ftype \
ksym-vanilla-fscache-acquire-cache \
ksym-vanilla-fscache-add-cache \
ksym-vanilla-fscache-addremove-sem \
ksym-vanilla-fscache-caching-failed \
ksym-vanilla-fscache-clearance-waiters \
ksym-vanilla-fscache-cookie-lookup-negative \
ksym-vanilla-fscache-end-cookie-access \
ksym-vanilla-fscache-end-volume-access \
ksym-vanilla-fscache-get-cookie \
ksym-vanilla-fscache-io-error \
ksym-vanilla-fscache-n-culled \
ksym-vanilla-fscache-n-dio-misfit \
ksym-vanilla-fscache-n-no-create-space \
ksym-vanilla-fscache-n-no-write-space \
ksym-vanilla-fscache-n-read \
ksym-vanilla-fscache-n-updates \
ksym-vanilla-fscache-n-write \
ksym-vanilla-fscache-put-cookie \
ksym-vanilla-fscache-put-volume \
ksym-vanilla-fscache-relinquish-cache \
ksym-vanilla-fscache-resume-after-invalidation \
ksym-vanilla-fscache-try-get-volume \
ksym-vanilla-fscache-wait-for-operation \
ksym-vanilla-fscache-withdraw-cache \
ksym-vanilla-fscache-withdraw-cookie \
ksym-vanilla-fscache-withdraw-volume \
ksym-vanilla-fscache-wq \
ksym-vanilla-fscrypt-context-for-new-inode \
ksym-vanilla-fscrypt-d-revalidate \
ksym-vanilla-fscrypt-decrypt-bio \
ksym-vanilla-fscrypt-decrypt-block-inplace \
ksym-vanilla-fscrypt-decrypt-pagecache-blocks \
ksym-vanilla-fscrypt-dio-supported \
ksym-vanilla-fscrypt-drop-inode \
ksym-vanilla-fscrypt-dummy-policies-equal \
ksym-vanilla-fscrypt-encrypt-block-inplace \
ksym-vanilla-fscrypt-encrypt-pagecache-blocks \
ksym-vanilla-fscrypt-enqueue-decrypt-work \
ksym-vanilla-fscrypt-file-open \
ksym-vanilla-fscrypt-fname-alloc-buffer \
ksym-vanilla-fscrypt-fname-disk-to-usr \
ksym-vanilla-fscrypt-fname-encrypt \
ksym-vanilla-fscrypt-fname-encrypted-size \
ksym-vanilla-fscrypt-fname-free-buffer \
ksym-vanilla-fscrypt-fname-siphash \
ksym-vanilla-fscrypt-free-bounce-page \
ksym-vanilla-fscrypt-free-inode \
ksym-vanilla-fscrypt-get-symlink \
ksym-vanilla-fscrypt-has-permitted-context \
ksym-vanilla-fscrypt-ioctl-add-key \
ksym-vanilla-fscrypt-ioctl-get-key-status \
ksym-vanilla-fscrypt-ioctl-get-nonce \
ksym-vanilla-fscrypt-ioctl-get-policy \
ksym-vanilla-fscrypt-ioctl-get-policy-ex \
ksym-vanilla-fscrypt-ioctl-remove-key \
ksym-vanilla-fscrypt-ioctl-remove-key-all-users \
ksym-vanilla-fscrypt-ioctl-set-policy \
ksym-vanilla-fscrypt-limit-io-blocks \
ksym-vanilla-fscrypt-match-name \
ksym-vanilla-fscrypt-mergeable-bio \
ksym-vanilla-fscrypt-parse-test-dummy-encryption \
ksym-vanilla-fscrypt-prepare-lookup-partial \
ksym-vanilla-fscrypt-prepare-new-inode \
ksym-vanilla-fscrypt-prepare-symlink \
ksym-vanilla-fscrypt-put-encryption-info \
ksym-vanilla-fscrypt-set-bio-crypt-ctx \
ksym-vanilla-fscrypt-set-context \
ksym-vanilla-fscrypt-setup-filename \
ksym-vanilla-fscrypt-show-test-dummy-encryption \
ksym-vanilla-fscrypt-symlink-getattr \
ksym-vanilla-fscrypt-zeroout-range \
ksym-vanilla-fserror-report \
ksym-vanilla-fsg-common-create-lun \
ksym-vanilla-fsg-common-create-luns \
ksym-vanilla-fsg-common-free-buffers \
ksym-vanilla-fsg-common-remove-lun \
ksym-vanilla-fsg-common-remove-luns \
ksym-vanilla-fsg-common-set-cdev \
ksym-vanilla-fsg-common-set-inquiry-string \
ksym-vanilla-fsg-common-set-num-buffers \
ksym-vanilla-fsg-common-set-sysfs \
ksym-vanilla-fsg-config-from-params \
ksym-vanilla-fsg-fs-bulk-in-desc \
ksym-vanilla-fsg-fs-bulk-out-desc \
ksym-vanilla-fsg-fs-function \
ksym-vanilla-fsg-hs-bulk-in-desc \
ksym-vanilla-fsg-hs-bulk-out-desc \
ksym-vanilla-fsg-hs-function \
ksym-vanilla-fsg-intf-desc \
ksym-vanilla-fsg-lun-close \
ksym-vanilla-fsg-lun-fsync-sub \
ksym-vanilla-fsg-lun-open \
ksym-vanilla-fsg-show-cdrom \
ksym-vanilla-fsg-show-file \
ksym-vanilla-fsg-show-inquiry-string \
ksym-vanilla-fsg-show-nofua \
ksym-vanilla-fsg-show-removable \
ksym-vanilla-fsg-show-ro \
ksym-vanilla-fsg-ss-bulk-in-comp-desc \
ksym-vanilla-fsg-ss-bulk-in-desc \
ksym-vanilla-fsg-ss-bulk-out-comp-desc \
ksym-vanilla-fsg-ss-bulk-out-desc \
ksym-vanilla-fsg-ss-function \
ksym-vanilla-fsg-store-cdrom \
ksym-vanilla-fsg-store-file \
ksym-vanilla-fsg-store-forced-eject \
ksym-vanilla-fsg-store-inquiry-string \
ksym-vanilla-fsg-store-nofua \
ksym-vanilla-fsg-store-removable \
ksym-vanilla-fsg-store-ro \
ksym-vanilla-fsl-asoc-constrain-rates \
ksym-vanilla-fsl-asoc-get-dma-channel \
ksym-vanilla-fsl-asoc-get-enum-double \
ksym-vanilla-fsl-asoc-get-pll-clocks \
ksym-vanilla-fsl-asoc-get-volsw \
ksym-vanilla-fsl-asoc-get-xr-sx \
ksym-vanilla-fsl-asoc-put-enum-double \
ksym-vanilla-fsl-asoc-put-volsw \
ksym-vanilla-fsl-asoc-put-xr-sx \
ksym-vanilla-fsl-asoc-reparent-pll-clocks \
ksym-vanilla-fsl-asrc-component \
ksym-vanilla-fsl-asrc-m2m-exit \
ksym-vanilla-fsl-asrc-m2m-init \
ksym-vanilla-fsl-asrc-m2m-resume \
ksym-vanilla-fsl-asrc-m2m-suspend \
ksym-vanilla-fsl-ifc-ctrl-dev \
ksym-vanilla-fsl-ifc-find \
ksym-vanilla-fsl-mc-allocate-irqs \
ksym-vanilla-fsl-mc-bus-dpaiop-type \
ksym-vanilla-fsl-mc-bus-dpbp-type \
ksym-vanilla-fsl-mc-bus-dpci-type \
ksym-vanilla-fsl-mc-bus-dpcon-type \
ksym-vanilla-fsl-mc-bus-dpdcei-type \
ksym-vanilla-fsl-mc-bus-dpdmai-type \
ksym-vanilla-fsl-mc-bus-dpdmux-type \
ksym-vanilla-fsl-mc-bus-dpio-type \
ksym-vanilla-fsl-mc-bus-dpmac-type \
ksym-vanilla-fsl-mc-bus-dpmcp-type \
ksym-vanilla-fsl-mc-bus-dpni-type \
ksym-vanilla-fsl-mc-bus-dprc-type \
ksym-vanilla-fsl-mc-bus-dprtc-type \
ksym-vanilla-fsl-mc-bus-dpseci-type \
ksym-vanilla-fsl-mc-bus-dpsw-type \
ksym-vanilla-fsl-mc-bus-type \
ksym-vanilla-fsl-mc-cleanup-irq-pool \
ksym-vanilla-fsl-mc-device-add \
ksym-vanilla-fsl-mc-device-group \
ksym-vanilla-fsl-mc-device-remove \
ksym-vanilla-fsl-mc-driver-unregister \
ksym-vanilla-fsl-mc-free-irqs \
ksym-vanilla-fsl-mc-get-endpoint \
ksym-vanilla-fsl-mc-get-version \
ksym-vanilla-fsl-mc-obj-close \
ksym-vanilla-fsl-mc-obj-open \
ksym-vanilla-fsl-mc-obj-reset \
ksym-vanilla-fsl-mc-object-allocate \
ksym-vanilla-fsl-mc-object-free \
ksym-vanilla-fsl-mc-populate-irq-pool \
ksym-vanilla-fsl-mc-portal-allocate \
ksym-vanilla-fsl-mc-portal-free \
ksym-vanilla-fsl-mc-resource-allocate \
ksym-vanilla-fsl-mc-resource-free \
ksym-vanilla-fsl8250-handle-irq \
ksym-vanilla-fsnotify \
ksym-vanilla-fsnotify-add-mark \
ksym-vanilla-fsnotify-alloc-group \
ksym-vanilla-fsnotify-destroy-mark \
ksym-vanilla-fsnotify-find-mark \
ksym-vanilla-fsnotify-get-cookie \
ksym-vanilla-fsnotify-init-mark \
ksym-vanilla-fsnotify-modify-mark-mask \
ksym-vanilla-fsnotify-put-group \
ksym-vanilla-fsnotify-put-mark \
ksym-vanilla-fsnotify-wait-marks-destroyed \
ksym-vanilla-fsstack-copy-attr-all \
ksym-vanilla-fsstack-copy-inode-size \
ksym-vanilla-fsverity-enqueue-verify-work \
ksym-vanilla-fsverity-fill-zerohash \
ksym-vanilla-fsverity-get-digest \
ksym-vanilla-fsverity-ioctl-enable \
ksym-vanilla-fsverity-ioctl-measure \
ksym-vanilla-fsverity-ioctl-read-metadata \
ksym-vanilla-fsverity-readahead \
ksym-vanilla-fsverity-verify-bio \
ksym-vanilla-fsverity-verify-blocks \
ksym-vanilla-ftrace-dump \
ksym-vanilla-ftrace-free-filter \
ksym-vanilla-ftrace-ops-set-global-filter \
ksym-vanilla-ftrace-set-filter \
ksym-vanilla-ftrace-set-filter-ip \
ksym-vanilla-ftrace-set-filter-ips \
ksym-vanilla-ftrace-set-global-filter \
ksym-vanilla-ftrace-set-global-notrace \
ksym-vanilla-ftrace-set-notrace \
ksym-vanilla-full-name-hash \
ksym-vanilla-fun-alloc-ring-mem \
ksym-vanilla-fun-bind \
ksym-vanilla-fun-cq-create \
ksym-vanilla-fun-dev-disable \
ksym-vanilla-fun-dev-enable \
ksym-vanilla-fun-free-ring-mem \
ksym-vanilla-fun-get-res-count \
ksym-vanilla-fun-release-irqs \
ksym-vanilla-fun-res-destroy \
ksym-vanilla-fun-reserve-irqs \
ksym-vanilla-fun-serv-restart \
ksym-vanilla-fun-serv-sched \
ksym-vanilla-fun-serv-stop \
ksym-vanilla-fun-sq-create \
ksym-vanilla-fun-submit-admin-sync-cmd \
ksym-vanilla-fuse-chan-abort \
ksym-vanilla-fuse-chan-free \
ksym-vanilla-fuse-chan-new \
ksym-vanilla-fuse-conn-destroy \
ksym-vanilla-fuse-conn-get \
ksym-vanilla-fuse-conn-init \
ksym-vanilla-fuse-conn-put \
ksym-vanilla-fuse-dax-cancel-work \
ksym-vanilla-fuse-dev-alloc \
ksym-vanilla-fuse-dev-alloc-install \
ksym-vanilla-fuse-dev-chan-new \
ksym-vanilla-fuse-dev-install \
ksym-vanilla-fuse-dev-operations \
ksym-vanilla-fuse-dev-put \
ksym-vanilla-fuse-dev-release \
ksym-vanilla-fuse-direct-io \
ksym-vanilla-fuse-do-ioctl \
ksym-vanilla-fuse-do-open \
ksym-vanilla-fuse-file-poll \
ksym-vanilla-fuse-fill-super-common \
ksym-vanilla-fuse-free-conn \
ksym-vanilla-fuse-get-unique \
ksym-vanilla-fuse-init-fs-context-submount \
ksym-vanilla-fuse-iqueue-init \
ksym-vanilla-fuse-len-args \
ksym-vanilla-fuse-mount-destroy \
ksym-vanilla-fuse-mount-remove \
ksym-vanilla-fuse-req-hash \
ksym-vanilla-fuse-request-assign-unique \
ksym-vanilla-fuse-request-end \
ksym-vanilla-fuse-send-init \
ksym-vanilla-fuse-simple-background \
ksym-vanilla-fuse-sync-release \
ksym-vanilla-fw-bus-type \
ksym-vanilla-fw-cancel-transaction \
ksym-vanilla-fw-card-add \
ksym-vanilla-fw-card-initialize \
ksym-vanilla-fw-card-read-cycle-time \
ksym-vanilla-fw-card-release \
ksym-vanilla-fw-core-add-address-handler \
ksym-vanilla-fw-core-add-descriptor \
ksym-vanilla-fw-core-handle-bus-reset \
ksym-vanilla-fw-core-handle-request \
ksym-vanilla-fw-core-handle-response \
ksym-vanilla-fw-core-remove-address-handler \
ksym-vanilla-fw-core-remove-card \
ksym-vanilla-fw-core-remove-descriptor \
ksym-vanilla-fw-csr-iterator-init \
ksym-vanilla-fw-csr-iterator-next \
ksym-vanilla-fw-csr-string \
ksym-vanilla-fw-device-enable-phys-dma \
ksym-vanilla-fw-devlink-purge-absent-suppliers \
ksym-vanilla-fw-fallback-config \
ksym-vanilla-fw-fill-response \
ksym-vanilla-fw-get-request-speed \
ksym-vanilla-fw-high-memory-region \
ksym-vanilla-fw-iso-buffer-destroy \
ksym-vanilla-fw-iso-buffer-init \
ksym-vanilla-fw-iso-context-destroy \
ksym-vanilla-fw-iso-context-flush-completions \
ksym-vanilla-fw-iso-context-queue \
ksym-vanilla-fw-iso-context-queue-flush \
ksym-vanilla-fw-iso-context-start \
ksym-vanilla-fw-iso-context-stop \
ksym-vanilla-fw-iso-resource-manage \
ksym-vanilla-fw-iso-resources-allocate \
ksym-vanilla-fw-iso-resources-destroy \
ksym-vanilla-fw-iso-resources-free \
ksym-vanilla-fw-iso-resources-init \
ksym-vanilla-fw-iso-resources-update \
ksym-vanilla-fw-rcode-string \
ksym-vanilla-fw-request-get-timestamp \
ksym-vanilla-fw-run-transaction \
ksym-vanilla-fw-schedule-bus-reset \
ksym-vanilla-fw-send-response \
ksym-vanilla-fw-workqueue \
ksym-vanilla-fwctl-register \
ksym-vanilla-fwctl-unregister \
ksym-vanilla-fwnode-connection-find-match \
ksym-vanilla-fwnode-connection-find-matches \
ksym-vanilla-fwnode-count-parents \
ksym-vanilla-fwnode-create-software-node \
ksym-vanilla-fwnode-device-is-available \
ksym-vanilla-fwnode-dpll-pin-find \
ksym-vanilla-fwnode-find-reference \
ksym-vanilla-fwnode-get-child-node-count \
ksym-vanilla-fwnode-get-mac-address \
ksym-vanilla-fwnode-get-name \
ksym-vanilla-fwnode-get-named-child-node \
ksym-vanilla-fwnode-get-named-child-node-count \
ksym-vanilla-fwnode-get-next-available-child-node \
ksym-vanilla-fwnode-get-next-child-node \
ksym-vanilla-fwnode-get-next-parent \
ksym-vanilla-fwnode-get-nth-parent \
ksym-vanilla-fwnode-get-parent \
ksym-vanilla-fwnode-get-phy-id \
ksym-vanilla-fwnode-get-phy-mode \
ksym-vanilla-fwnode-get-phy-node \
ksym-vanilla-fwnode-gpiod-get-index \
ksym-vanilla-fwnode-graph-get-endpoint-by-id \
ksym-vanilla-fwnode-graph-get-endpoint-count \
ksym-vanilla-fwnode-graph-get-next-endpoint \
ksym-vanilla-fwnode-graph-get-port-parent \
ksym-vanilla-fwnode-graph-get-remote-endpoint \
ksym-vanilla-fwnode-graph-get-remote-port \
ksym-vanilla-fwnode-graph-get-remote-port-parent \
ksym-vanilla-fwnode-graph-parse-endpoint \
ksym-vanilla-fwnode-handle-get \
ksym-vanilla-fwnode-iio-channel-get-by-name \
ksym-vanilla-fwnode-iomap \
ksym-vanilla-fwnode-irq-get \
ksym-vanilla-fwnode-irq-get-byname \
ksym-vanilla-fwnode-mdio-find-device \
ksym-vanilla-fwnode-mdiobus-phy-device-register \
ksym-vanilla-fwnode-mdiobus-register-phy \
ksym-vanilla-fwnode-name-eq \
ksym-vanilla-fwnode-phy-find-device \
ksym-vanilla-fwnode-property-get-reference-args \
ksym-vanilla-fwnode-property-match-property-string \
ksym-vanilla-fwnode-property-match-string \
ksym-vanilla-fwnode-property-present \
ksym-vanilla-fwnode-property-read-bool \
ksym-vanilla-fwnode-property-read-string \
ksym-vanilla-fwnode-property-read-string-array \
ksym-vanilla-fwnode-property-read-u16-array \
ksym-vanilla-fwnode-property-read-u32-array \
ksym-vanilla-fwnode-property-read-u64-array \
ksym-vanilla-fwnode-property-read-u8-array \
ksym-vanilla-fwnode-remove-software-node \
ksym-vanilla-fwnode-reset-control-array-get \
ksym-vanilla-fwnode-typec-mux-get \
ksym-vanilla-fwnode-typec-retimer-get \
ksym-vanilla-fwnode-typec-switch-get \
ksym-vanilla-fwnode-usb-role-switch-get \
ksym-vanilla-fxas21002c-core-probe \
ksym-vanilla-fxas21002c-core-remove \
ksym-vanilla-fxas21002c-pm-ops \
ksym-vanilla-fxls8962af-core-probe \
ksym-vanilla-fxls8962af-i2c-regmap-conf \
ksym-vanilla-fxls8962af-pm-ops \
ksym-vanilla-fxls8962af-spi-regmap-conf \
ksym-vanilla-fxos8700-core-probe \
ksym-vanilla-fxos8700-regmap-config \
ksym-vanilla-g-audio-cleanup \
ksym-vanilla-g-audio-setup \
ksym-vanilla-g12a-fifo-pcm-hw-params \
ksym-vanilla-gadget-find-ep-by-name \
ksym-vanilla-gadget-release \
ksym-vanilla-gaokun-ec-psy-get-smart-charge \
ksym-vanilla-gaokun-ec-psy-get-smart-charge-enable \
ksym-vanilla-gaokun-ec-psy-multi-read \
ksym-vanilla-gaokun-ec-psy-set-smart-charge \
ksym-vanilla-gaokun-ec-psy-set-smart-charge-enable \
ksym-vanilla-gaokun-ec-read \
ksym-vanilla-gaokun-ec-read-byte \
ksym-vanilla-gaokun-ec-register-notify \
ksym-vanilla-gaokun-ec-ucsi-get-reg \
ksym-vanilla-gaokun-ec-ucsi-pan-ack \
ksym-vanilla-gaokun-ec-ucsi-read \
ksym-vanilla-gaokun-ec-ucsi-write \
ksym-vanilla-gaokun-ec-unregister-notify \
ksym-vanilla-gaokun-ec-write \
ksym-vanilla-garp-init-applicant \
ksym-vanilla-garp-register-application \
ksym-vanilla-garp-request-join \
ksym-vanilla-garp-request-leave \
ksym-vanilla-garp-uninit-applicant \
ksym-vanilla-garp-unregister-application \
ksym-vanilla-gcd \
ksym-vanilla-gdsc-gx-do-nothing-enable \
ksym-vanilla-gen-estimator-active \
ksym-vanilla-gen-estimator-read \
ksym-vanilla-gen-kill-estimator \
ksym-vanilla-gen-new-estimator \
ksym-vanilla-gen-pool-add-owner \
ksym-vanilla-gen-pool-alloc-algo-owner \
ksym-vanilla-gen-pool-avail \
ksym-vanilla-gen-pool-best-fit \
ksym-vanilla-gen-pool-create \
ksym-vanilla-gen-pool-destroy \
ksym-vanilla-gen-pool-dma-alloc \
ksym-vanilla-gen-pool-dma-alloc-algo \
ksym-vanilla-gen-pool-dma-alloc-align \
ksym-vanilla-gen-pool-dma-zalloc \
ksym-vanilla-gen-pool-dma-zalloc-algo \
ksym-vanilla-gen-pool-dma-zalloc-align \
ksym-vanilla-gen-pool-first-fit \
ksym-vanilla-gen-pool-first-fit-align \
ksym-vanilla-gen-pool-first-fit-order-align \
ksym-vanilla-gen-pool-fixed-alloc \
ksym-vanilla-gen-pool-for-each-chunk \
ksym-vanilla-gen-pool-free-owner \
ksym-vanilla-gen-pool-get \
ksym-vanilla-gen-pool-has-addr \
ksym-vanilla-gen-pool-set-algo \
ksym-vanilla-gen-pool-size \
ksym-vanilla-gen-pool-virt-to-phys \
ksym-vanilla-gen-replace-estimator \
ksym-vanilla-gen-split-key \
ksym-vanilla-gen10g-config-aneg \
ksym-vanilla-generate-random-guid \
ksym-vanilla-generate-random-uuid \
ksym-vanilla-generic-access-phys \
ksym-vanilla-generic-atomic-write-valid \
ksym-vanilla-generic-block-bmap \
ksym-vanilla-generic-check-addressable \
ksym-vanilla-generic-ci-d-compare \
ksym-vanilla-generic-ci-d-hash \
ksym-vanilla-generic-ci-match \
ksym-vanilla-generic-cont-expand-simple \
ksym-vanilla-generic-device-group \
ksym-vanilla-generic-encode-ino32-fh \
ksym-vanilla-generic-error-remove-folio \
ksym-vanilla-generic-fadvise \
ksym-vanilla-generic-fh-to-dentry \
ksym-vanilla-generic-fh-to-parent \
ksym-vanilla-generic-file-direct-write \
ksym-vanilla-generic-file-llseek \
ksym-vanilla-generic-file-llseek-size \
ksym-vanilla-generic-file-mmap \
ksym-vanilla-generic-file-mmap-prepare \
ksym-vanilla-generic-file-open \
ksym-vanilla-generic-file-read-iter \
ksym-vanilla-generic-file-readonly-mmap \
ksym-vanilla-generic-file-readonly-mmap-prepare \
ksym-vanilla-generic-file-write-iter \
ksym-vanilla-generic-fill-statx-atomic-writes \
ksym-vanilla-generic-fill-statx-attr \
ksym-vanilla-generic-fillattr \
ksym-vanilla-generic-handle-demux-domain-irq \
ksym-vanilla-generic-handle-domain-irq \
ksym-vanilla-generic-handle-domain-irq-safe \
ksym-vanilla-generic-handle-irq \
ksym-vanilla-generic-handle-irq-safe \
ksym-vanilla-generic-hwtstamp-get-lower \
ksym-vanilla-generic-hwtstamp-set-lower \
ksym-vanilla-generic-key-instantiate \
ksym-vanilla-generic-listxattr \
ksym-vanilla-generic-llseek-cookie \
ksym-vanilla-generic-mii-ioctl \
ksym-vanilla-generic-online-page \
ksym-vanilla-generic-parse-monolithic \
ksym-vanilla-generic-perform-write \
ksym-vanilla-generic-permission \
ksym-vanilla-generic-pipe-buf-get \
ksym-vanilla-generic-pipe-buf-release \
ksym-vanilla-generic-pipe-buf-try-steal \
ksym-vanilla-generic-read-dir \
ksym-vanilla-generic-read-merkle-tree-page \
ksym-vanilla-generic-readahead-merkle-tree \
ksym-vanilla-generic-remap-file-range-prep \
ksym-vanilla-generic-rndis-bind \
ksym-vanilla-generic-ro-fops \
ksym-vanilla-generic-set-sb-d-ops \
ksym-vanilla-generic-setlease \
ksym-vanilla-generic-shutdown-super \
ksym-vanilla-generic-single-device-group \
ksym-vanilla-generic-update-time \
ksym-vanilla-generic-write-check-limits \
ksym-vanilla-generic-write-checks \
ksym-vanilla-generic-write-checks-count \
ksym-vanilla-generic-write-end \
ksym-vanilla-geneve-dev-create-fb \
ksym-vanilla-geni-icc-disable \
ksym-vanilla-geni-icc-enable \
ksym-vanilla-geni-icc-get \
ksym-vanilla-geni-icc-set-bw \
ksym-vanilla-geni-icc-set-bw-ab \
ksym-vanilla-geni-icc-set-tag \
ksym-vanilla-geni-load-se-firmware \
ksym-vanilla-geni-se-clk-freq-match \
ksym-vanilla-geni-se-clk-tbl-get \
ksym-vanilla-geni-se-config-packing \
ksym-vanilla-geni-se-domain-attach \
ksym-vanilla-geni-se-get-qup-hw-version \
ksym-vanilla-geni-se-init \
ksym-vanilla-geni-se-resources-activate \
ksym-vanilla-geni-se-resources-deactivate \
ksym-vanilla-geni-se-resources-init \
ksym-vanilla-geni-se-resources-off \
ksym-vanilla-geni-se-resources-on \
ksym-vanilla-geni-se-rx-dma-prep \
ksym-vanilla-geni-se-rx-dma-unprep \
ksym-vanilla-geni-se-rx-init-dma \
ksym-vanilla-geni-se-select-mode \
ksym-vanilla-geni-se-set-perf-level \
ksym-vanilla-geni-se-set-perf-opp \
ksym-vanilla-geni-se-tx-dma-prep \
ksym-vanilla-geni-se-tx-dma-unprep \
ksym-vanilla-geni-se-tx-init-dma \
ksym-vanilla-genl-lock \
ksym-vanilla-genl-notify \
ksym-vanilla-genl-register-family \
ksym-vanilla-genl-unlock \
ksym-vanilla-genl-unregister-family \
ksym-vanilla-genlmsg-multicast-allns \
ksym-vanilla-genlmsg-put \
ksym-vanilla-genpd-dev-pm-attach \
ksym-vanilla-genpd-dev-pm-attach-by-id \
ksym-vanilla-genphy-aneg-done \
ksym-vanilla-genphy-c37-config-aneg \
ksym-vanilla-genphy-c37-read-status \
ksym-vanilla-genphy-c45-an-config-aneg \
ksym-vanilla-genphy-c45-an-config-eee-aneg \
ksym-vanilla-genphy-c45-an-disable-aneg \
ksym-vanilla-genphy-c45-aneg-done \
ksym-vanilla-genphy-c45-baset1-read-status \
ksym-vanilla-genphy-c45-check-and-restart-aneg \
ksym-vanilla-genphy-c45-config-aneg \
ksym-vanilla-genphy-c45-eee-is-active \
ksym-vanilla-genphy-c45-ethtool-get-eee \
ksym-vanilla-genphy-c45-ethtool-set-eee \
ksym-vanilla-genphy-c45-fast-retrain \
ksym-vanilla-genphy-c45-loopback \
ksym-vanilla-genphy-c45-oatc14-cable-test-get-status \
ksym-vanilla-genphy-c45-oatc14-cable-test-start \
ksym-vanilla-genphy-c45-oatc14-get-sqi \
ksym-vanilla-genphy-c45-oatc14-get-sqi-max \
ksym-vanilla-genphy-c45-plca-get-cfg \
ksym-vanilla-genphy-c45-plca-get-status \
ksym-vanilla-genphy-c45-plca-set-cfg \
ksym-vanilla-genphy-c45-pma-baset1-read-abilities \
ksym-vanilla-genphy-c45-pma-baset1-read-master-slave \
ksym-vanilla-genphy-c45-pma-baset1-setup-master-slave \
ksym-vanilla-genphy-c45-pma-read-abilities \
ksym-vanilla-genphy-c45-pma-read-ext-abilities \
ksym-vanilla-genphy-c45-pma-resume \
ksym-vanilla-genphy-c45-pma-setup-forced \
ksym-vanilla-genphy-c45-pma-suspend \
ksym-vanilla-genphy-c45-read-eee-abilities \
ksym-vanilla-genphy-c45-read-link \
ksym-vanilla-genphy-c45-read-lpa \
ksym-vanilla-genphy-c45-read-mdix \
ksym-vanilla-genphy-c45-read-pma \
ksym-vanilla-genphy-c45-read-status \
ksym-vanilla-genphy-c45-restart-aneg \
ksym-vanilla-genphy-check-and-restart-aneg \
ksym-vanilla-genphy-handle-interrupt-no-ack \
ksym-vanilla-genphy-loopback \
ksym-vanilla-genphy-match-phy-device \
ksym-vanilla-genphy-read-abilities \
ksym-vanilla-genphy-read-lpa \
ksym-vanilla-genphy-read-master-slave \
ksym-vanilla-genphy-read-mmd-unsupported \
ksym-vanilla-genphy-read-status \
ksym-vanilla-genphy-read-status-fixed \
ksym-vanilla-genphy-restart-aneg \
ksym-vanilla-genphy-resume \
ksym-vanilla-genphy-setup-forced \
ksym-vanilla-genphy-soft-reset \
ksym-vanilla-genphy-suspend \
ksym-vanilla-genphy-update-link \
ksym-vanilla-genphy-write-mmd-unsupported \
ksym-vanilla-get-anon-bdev \
ksym-vanilla-get-cached-acl \
ksym-vanilla-get-cached-acl-rcu \
ksym-vanilla-get-cached-msi-msg \
ksym-vanilla-get-compat-sigset \
ksym-vanilla-get-completed-synchronize-rcu \
ksym-vanilla-get-completed-synchronize-rcu-full \
ksym-vanilla-get-conversion-matrix-to-argb-u16 \
ksym-vanilla-get-cpu-device \
ksym-vanilla-get-cpu-idle-time \
ksym-vanilla-get-cpu-idle-time-us \
ksym-vanilla-get-cpu-iowait-time-us \
ksym-vanilla-get-current-tty \
ksym-vanilla-get-default-font \
ksym-vanilla-get-dev-from-fwnode \
ksym-vanilla-get-dev-pagemap \
ksym-vanilla-get-device \
ksym-vanilla-get-device-system-crosststamp \
ksym-vanilla-get-file-active \
ksym-vanilla-get-file-rcu \
ksym-vanilla-get-free-pages-noprof \
ksym-vanilla-get-fs-type \
ksym-vanilla-get-governor-parent-kobj \
ksym-vanilla-get-h225-addr \
ksym-vanilla-get-inode-acl \
ksym-vanilla-get-itimerspec64 \
ksym-vanilla-get-max-files \
ksym-vanilla-get-mem-cgroup-from-mm \
ksym-vanilla-get-mtd-device \
ksym-vanilla-get-mtd-device-nm \
ksym-vanilla-get-net-ns \
ksym-vanilla-get-net-ns-by-fd \
ksym-vanilla-get-net-ns-by-id \
ksym-vanilla-get-net-ns-by-pid \
ksym-vanilla-get-next-ino \
ksym-vanilla-get-nfs-open-context \
ksym-vanilla-get-nfs-version \
ksym-vanilla-get-old-itimerspec32 \
ksym-vanilla-get-old-timespec32 \
ksym-vanilla-get-option \
ksym-vanilla-get-options \
ksym-vanilla-get-pbs-client-device \
ksym-vanilla-get-phv-bit \
ksym-vanilla-get-phy-device \
ksym-vanilla-get-pid-task \
ksym-vanilla-get-random-bytes \
ksym-vanilla-get-random-u16 \
ksym-vanilla-get-random-u32 \
ksym-vanilla-get-random-u64 \
ksym-vanilla-get-random-u8 \
ksym-vanilla-get-rcu-tasks-gp-kthread \
ksym-vanilla-get-rcu-tasks-rude-gp-kthread \
ksym-vanilla-get-scpi-ops \
ksym-vanilla-get-sg-io-hdr \
ksym-vanilla-get-state-synchronize-rcu \
ksym-vanilla-get-state-synchronize-rcu-full \
ksym-vanilla-get-state-synchronize-srcu \
ksym-vanilla-get-task-cred \
ksym-vanilla-get-task-mm \
ksym-vanilla-get-task-pid \
ksym-vanilla-get-task-policy \
ksym-vanilla-get-timespec64 \
ksym-vanilla-get-torture-init-jiffies \
ksym-vanilla-get-tree-bdev \
ksym-vanilla-get-tree-bdev-flags \
ksym-vanilla-get-tree-keyed \
ksym-vanilla-get-tree-mtd \
ksym-vanilla-get-tree-nodev \
ksym-vanilla-get-tree-single \
ksym-vanilla-get-unused-fd-flags \
ksym-vanilla-get-user-ifreq \
ksym-vanilla-get-user-pages \
ksym-vanilla-get-user-pages-fast \
ksym-vanilla-get-user-pages-fast-only \
ksym-vanilla-get-user-pages-remote \
ksym-vanilla-get-user-pages-unlocked \
ksym-vanilla-get-vaddr-frames \
ksym-vanilla-get-watch-queue \
ksym-vanilla-get-wiphy-regdom \
ksym-vanilla-get-zeroed-page-noprof \
ksym-vanilla-getboottime64 \
ksym-vanilla-gether-attach-gadget \
ksym-vanilla-gether-cleanup \
ksym-vanilla-gether-connect \
ksym-vanilla-gether-detach-gadget \
ksym-vanilla-gether-disconnect \
ksym-vanilla-gether-get-dev-addr \
ksym-vanilla-gether-get-host-addr \
ksym-vanilla-gether-get-host-addr-cdc \
ksym-vanilla-gether-get-host-addr-u8 \
ksym-vanilla-gether-get-ifname \
ksym-vanilla-gether-get-qmult \
ksym-vanilla-gether-register-netdev \
ksym-vanilla-gether-resume \
ksym-vanilla-gether-set-dev-addr \
ksym-vanilla-gether-set-gadget \
ksym-vanilla-gether-set-host-addr \
ksym-vanilla-gether-set-ifname \
ksym-vanilla-gether-set-qmult \
ksym-vanilla-gether-setup-name \
ksym-vanilla-gether-setup-name-default \
ksym-vanilla-gether-suspend \
ksym-vanilla-getname-kernel \
ksym-vanilla-gf128mul-64k-bbe \
ksym-vanilla-gf128mul-free-64k \
ksym-vanilla-gf128mul-init-64k-bbe \
ksym-vanilla-gf128mul-lle \
ksym-vanilla-gf128mul-x8-ble \
ksym-vanilla-ghash-final \
ksym-vanilla-ghash-preparekey \
ksym-vanilla-ghash-update \
ksym-vanilla-ghes-estatus-pool-region-free \
ksym-vanilla-ghes-get-devices \
ksym-vanilla-ghes-register-report-chain \
ksym-vanilla-ghes-register-vendor-record-notifier \
ksym-vanilla-ghes-unregister-report-chain \
ksym-vanilla-ghes-unregister-vendor-record-notifier \
ksym-vanilla-give-up-console \
ksym-vanilla-glob-match \
ksym-vanilla-glob-match-len \
ksym-vanilla-global-cursor-default \
ksym-vanilla-gnet-stats-add-basic \
ksym-vanilla-gnet-stats-add-queue \
ksym-vanilla-gnet-stats-basic-sync-init \
ksym-vanilla-gnet-stats-copy-app \
ksym-vanilla-gnet-stats-copy-basic \
ksym-vanilla-gnet-stats-copy-basic-hw \
ksym-vanilla-gnet-stats-copy-queue \
ksym-vanilla-gnet-stats-copy-rate-est \
ksym-vanilla-gnet-stats-finish-copy \
ksym-vanilla-gnet-stats-start-copy \
ksym-vanilla-gnet-stats-start-copy-compat \
ksym-vanilla-gnss-allocate-device \
ksym-vanilla-gnss-deregister-device \
ksym-vanilla-gnss-insert-raw \
ksym-vanilla-gnss-put-device \
ksym-vanilla-gnss-register-device \
ksym-vanilla-gnss-serial-allocate \
ksym-vanilla-gnss-serial-deregister \
ksym-vanilla-gnss-serial-free \
ksym-vanilla-gnss-serial-pm-ops \
ksym-vanilla-gnss-serial-register \
ksym-vanilla-go7007-alloc \
ksym-vanilla-go7007-boot-encoder \
ksym-vanilla-go7007-parse-video-stream \
ksym-vanilla-go7007-read-addr \
ksym-vanilla-go7007-read-interrupt \
ksym-vanilla-go7007-register-encoder \
ksym-vanilla-go7007-snd-init \
ksym-vanilla-go7007-snd-remove \
ksym-vanilla-go7007-update-board \
ksym-vanilla-goodix-berlin-groups \
ksym-vanilla-goodix-berlin-pm-ops \
ksym-vanilla-goodix-berlin-probe \
ksym-vanilla-gov-attr-set-get \
ksym-vanilla-gov-attr-set-init \
ksym-vanilla-gov-attr-set-put \
ksym-vanilla-gov-update-cpu-data \
ksym-vanilla-governor-sysfs-ops \
ksym-vanilla-gp8psk-fe-attach \
ksym-vanilla-gpio-device-find \
ksym-vanilla-gpio-device-find-by-fwnode \
ksym-vanilla-gpio-device-find-by-label \
ksym-vanilla-gpio-device-get \
ksym-vanilla-gpio-device-get-base \
ksym-vanilla-gpio-device-get-chip \
ksym-vanilla-gpio-device-get-desc \
ksym-vanilla-gpio-device-get-label \
ksym-vanilla-gpio-device-put \
ksym-vanilla-gpio-device-to-device \
ksym-vanilla-gpio-free \
ksym-vanilla-gpio-generic-chip-init \
ksym-vanilla-gpio-regmap-get-drvdata \
ksym-vanilla-gpio-regmap-register \
ksym-vanilla-gpio-regmap-unregister \
ksym-vanilla-gpio-request \
ksym-vanilla-gpio-request-one \
ksym-vanilla-gpio-to-desc \
ksym-vanilla-gpiochip-add-data-with-key \
ksym-vanilla-gpiochip-add-pin-range-with-pins \
ksym-vanilla-gpiochip-add-pingroup-range \
ksym-vanilla-gpiochip-disable-irq \
ksym-vanilla-gpiochip-dup-line-label \
ksym-vanilla-gpiochip-enable-irq \
ksym-vanilla-gpiochip-free-own-desc \
ksym-vanilla-gpiochip-fwd-desc-add \
ksym-vanilla-gpiochip-fwd-desc-free \
ksym-vanilla-gpiochip-fwd-get-data \
ksym-vanilla-gpiochip-fwd-get-gpiochip \
ksym-vanilla-gpiochip-fwd-gpio-direction-input \
ksym-vanilla-gpiochip-fwd-gpio-direction-output \
ksym-vanilla-gpiochip-fwd-gpio-get \
ksym-vanilla-gpiochip-fwd-gpio-get-direction \
ksym-vanilla-gpiochip-fwd-gpio-get-multiple \
ksym-vanilla-gpiochip-fwd-gpio-request \
ksym-vanilla-gpiochip-fwd-gpio-set \
ksym-vanilla-gpiochip-fwd-gpio-set-config \
ksym-vanilla-gpiochip-fwd-gpio-set-multiple \
ksym-vanilla-gpiochip-fwd-gpio-to-irq \
ksym-vanilla-gpiochip-fwd-register \
ksym-vanilla-gpiochip-generic-config \
ksym-vanilla-gpiochip-generic-free \
ksym-vanilla-gpiochip-generic-request \
ksym-vanilla-gpiochip-get-data \
ksym-vanilla-gpiochip-get-ngpios \
ksym-vanilla-gpiochip-irq-relres \
ksym-vanilla-gpiochip-irq-reqres \
ksym-vanilla-gpiochip-irqchip-add-domain \
ksym-vanilla-gpiochip-line-is-irq \
ksym-vanilla-gpiochip-line-is-open-drain \
ksym-vanilla-gpiochip-line-is-open-source \
ksym-vanilla-gpiochip-line-is-persistent \
ksym-vanilla-gpiochip-line-is-valid \
ksym-vanilla-gpiochip-lock-as-irq \
ksym-vanilla-gpiochip-populate-parent-fwspec-fourcell \
ksym-vanilla-gpiochip-populate-parent-fwspec-twocell \
ksym-vanilla-gpiochip-query-valid-mask \
ksym-vanilla-gpiochip-relres-irq \
ksym-vanilla-gpiochip-remove \
ksym-vanilla-gpiochip-remove-pin-ranges \
ksym-vanilla-gpiochip-reqres-irq \
ksym-vanilla-gpiochip-request-own-desc \
ksym-vanilla-gpiochip-unlock-as-irq \
ksym-vanilla-gpiod-add-lookup-table \
ksym-vanilla-gpiod-cansleep \
ksym-vanilla-gpiod-count \
ksym-vanilla-gpiod-direction-input \
ksym-vanilla-gpiod-direction-output \
ksym-vanilla-gpiod-direction-output-raw \
ksym-vanilla-gpiod-disable-hw-timestamp-ns \
ksym-vanilla-gpiod-enable-hw-timestamp-ns \
ksym-vanilla-gpiod-export \
ksym-vanilla-gpiod-export-link \
ksym-vanilla-gpiod-get \
ksym-vanilla-gpiod-get-array \
ksym-vanilla-gpiod-get-array-optional \
ksym-vanilla-gpiod-get-array-value \
ksym-vanilla-gpiod-get-array-value-cansleep \
ksym-vanilla-gpiod-get-direction \
ksym-vanilla-gpiod-get-index \
ksym-vanilla-gpiod-get-index-optional \
ksym-vanilla-gpiod-get-optional \
ksym-vanilla-gpiod-get-raw-array-value \
ksym-vanilla-gpiod-get-raw-array-value-cansleep \
ksym-vanilla-gpiod-get-raw-value \
ksym-vanilla-gpiod-get-raw-value-cansleep \
ksym-vanilla-gpiod-get-value \
ksym-vanilla-gpiod-get-value-cansleep \
ksym-vanilla-gpiod-hwgpio \
ksym-vanilla-gpiod-is-active-low \
ksym-vanilla-gpiod-is-equal \
ksym-vanilla-gpiod-is-shared \
ksym-vanilla-gpiod-is-single-ended \
ksym-vanilla-gpiod-put \
ksym-vanilla-gpiod-put-array \
ksym-vanilla-gpiod-remove-lookup-table \
ksym-vanilla-gpiod-set-array-value \
ksym-vanilla-gpiod-set-array-value-cansleep \
ksym-vanilla-gpiod-set-config \
ksym-vanilla-gpiod-set-consumer-name \
ksym-vanilla-gpiod-set-debounce \
ksym-vanilla-gpiod-set-raw-array-value \
ksym-vanilla-gpiod-set-raw-array-value-cansleep \
ksym-vanilla-gpiod-set-raw-value \
ksym-vanilla-gpiod-set-raw-value-cansleep \
ksym-vanilla-gpiod-set-value \
ksym-vanilla-gpiod-set-value-cansleep \
ksym-vanilla-gpiod-to-chip \
ksym-vanilla-gpiod-to-gpio-device \
ksym-vanilla-gpiod-to-irq \
ksym-vanilla-gpiod-toggle-active-low \
ksym-vanilla-gpiod-unexport \
ksym-vanilla-gpr-alloc-port \
ksym-vanilla-gpr-free-port \
ksym-vanilla-gpr-send-pkt \
ksym-vanilla-gpr-send-port-pkt \
ksym-vanilla-gpu-buddy-alloc-blocks \
ksym-vanilla-gpu-buddy-block-print \
ksym-vanilla-gpu-buddy-block-trim \
ksym-vanilla-gpu-buddy-fini \
ksym-vanilla-gpu-buddy-free-block \
ksym-vanilla-gpu-buddy-free-list \
ksym-vanilla-gpu-buddy-init \
ksym-vanilla-gpu-buddy-print \
ksym-vanilla-gpu-buddy-reset-clear \
ksym-vanilla-gpu-mem-2-clk \
ksym-vanilla-graph-util-card-probe \
ksym-vanilla-graph-util-is-ports0 \
ksym-vanilla-graph-util-parse-dai \
ksym-vanilla-graph-util-parse-link-direction \
ksym-vanilla-graph-util-parse-trigger-order \
ksym-vanilla-gre-add-protocol \
ksym-vanilla-gre-del-protocol \
ksym-vanilla-gre-parse-header \
ksym-vanilla-gre-pptp-destroy-siblings \
ksym-vanilla-gretap-fb-dev-create \
ksym-vanilla-gro-cells-destroy \
ksym-vanilla-gro-cells-init \
ksym-vanilla-gro-cells-receive \
ksym-vanilla-gro-find-complete-by-type \
ksym-vanilla-gro-find-receive-by-type \
ksym-vanilla-gro-receive-skb \
ksym-vanilla-group-cpus-evenly \
ksym-vanilla-groups-alloc \
ksym-vanilla-groups-free \
ksym-vanilla-groups-sort \
ksym-vanilla-gs-alloc-req \
ksym-vanilla-gs-free-req \
ksym-vanilla-gsc-read \
ksym-vanilla-gsc-write \
ksym-vanilla-gserial-alloc-line \
ksym-vanilla-gserial-alloc-line-no-console \
ksym-vanilla-gserial-connect \
ksym-vanilla-gserial-disconnect \
ksym-vanilla-gserial-free-line \
ksym-vanilla-gserial-get-console \
ksym-vanilla-gserial-resume \
ksym-vanilla-gserial-set-console \
ksym-vanilla-gserial-suspend \
ksym-vanilla-gspca-coarse-grained-expo-autogain \
ksym-vanilla-gspca-debug \
ksym-vanilla-gspca-dev-probe \
ksym-vanilla-gspca-dev-probe2 \
ksym-vanilla-gspca-disconnect \
ksym-vanilla-gspca-expo-autogain \
ksym-vanilla-gspca-frame-add \
ksym-vanilla-gspca-resume \
ksym-vanilla-gspca-suspend \
ksym-vanilla-gss-mech-get \
ksym-vanilla-gss-mech-put \
ksym-vanilla-gss-mech-register \
ksym-vanilla-gss-mech-unregister \
ksym-vanilla-gss-pseudoflavor-to-service \
ksym-vanilla-gssd-running \
ksym-vanilla-gswip-probe-common \
ksym-vanilla-gue-encap-hlen \
ksym-vanilla-guid-gen \
ksym-vanilla-guid-null \
ksym-vanilla-guid-parse \
ksym-vanilla-h4-recv-buf \
ksym-vanilla-handle-bad-irq \
ksym-vanilla-handle-edge-irq \
ksym-vanilla-handle-fasteoi-ack-irq \
ksym-vanilla-handle-fasteoi-irq \
ksym-vanilla-handle-fasteoi-mask-irq \
ksym-vanilla-handle-fasteoi-nmi \
ksym-vanilla-handle-level-irq \
ksym-vanilla-handle-mm-fault \
ksym-vanilla-handle-nested-irq \
ksym-vanilla-handle-simple-irq \
ksym-vanilla-handle-sysrq \
ksym-vanilla-handle-untracked-irq \
ksym-vanilla-handshake-genl-put \
ksym-vanilla-handshake-req-alloc \
ksym-vanilla-handshake-req-cancel \
ksym-vanilla-handshake-req-private \
ksym-vanilla-handshake-req-submit \
ksym-vanilla-has-capability-noaudit \
ksym-vanilla-hash-algo-name \
ksym-vanilla-hash-digest-size \
ksym-vanilla-hashlen-string \
ksym-vanilla-have-governor-per-policy \
ksym-vanilla-hchacha-block \
ksym-vanilla-hchacha-block-generic \
ksym-vanilla-hci-alloc-dev-priv \
ksym-vanilla-hci-cmd-sync \
ksym-vanilla-hci-cmd-sync-cancel \
ksym-vanilla-hci-cmd-sync-cancel-entry \
ksym-vanilla-hci-cmd-sync-cancel-sync \
ksym-vanilla-hci-cmd-sync-dequeue \
ksym-vanilla-hci-cmd-sync-dequeue-once \
ksym-vanilla-hci-cmd-sync-lookup-entry \
ksym-vanilla-hci-cmd-sync-queue \
ksym-vanilla-hci-cmd-sync-queue-once \
ksym-vanilla-hci-cmd-sync-run \
ksym-vanilla-hci-cmd-sync-run-once \
ksym-vanilla-hci-cmd-sync-status \
ksym-vanilla-hci-cmd-sync-submit \
ksym-vanilla-hci-conn-check-secure \
ksym-vanilla-hci-conn-security \
ksym-vanilla-hci-conn-switch-role \
ksym-vanilla-hci-devcd-abort \
ksym-vanilla-hci-devcd-append \
ksym-vanilla-hci-devcd-append-pattern \
ksym-vanilla-hci-devcd-complete \
ksym-vanilla-hci-devcd-init \
ksym-vanilla-hci-devcd-register \
ksym-vanilla-hci-devcd-rx \
ksym-vanilla-hci-devcd-timeout \
ksym-vanilla-hci-discovery-active \
ksym-vanilla-hci-drv-cmd-complete \
ksym-vanilla-hci-drv-cmd-status \
ksym-vanilla-hci-drv-process-cmd \
ksym-vanilla-hci-free-dev \
ksym-vanilla-hci-get-route \
ksym-vanilla-hci-mgmt-chan-register \
ksym-vanilla-hci-mgmt-chan-unregister \
ksym-vanilla-hci-recv-diag \
ksym-vanilla-hci-recv-frame \
ksym-vanilla-hci-register-cb \
ksym-vanilla-hci-register-dev \
ksym-vanilla-hci-release-dev \
ksym-vanilla-hci-reset-dev \
ksym-vanilla-hci-resume-dev \
ksym-vanilla-hci-set-fw-info \
ksym-vanilla-hci-set-hw-info \
ksym-vanilla-hci-suspend-dev \
ksym-vanilla-hci-uart-register-device-priv \
ksym-vanilla-hci-uart-tx-wakeup \
ksym-vanilla-hci-uart-unregister-device \
ksym-vanilla-hci-unregister-cb \
ksym-vanilla-hci-unregister-dev \
ksym-vanilla-hclge-comm-cmd-init \
ksym-vanilla-hclge-comm-cmd-init-ops \
ksym-vanilla-hclge-comm-cmd-queue-init \
ksym-vanilla-hclge-comm-cmd-reuse-desc \
ksym-vanilla-hclge-comm-cmd-send \
ksym-vanilla-hclge-comm-cmd-setup-basic-desc \
ksym-vanilla-hclge-comm-cmd-uninit \
ksym-vanilla-hclge-comm-convert-rss-tuple \
ksym-vanilla-hclge-comm-get-rss-hash-info \
ksym-vanilla-hclge-comm-get-rss-indir-tbl \
ksym-vanilla-hclge-comm-get-rss-key-size \
ksym-vanilla-hclge-comm-get-rss-tc-info \
ksym-vanilla-hclge-comm-get-rss-tuple \
ksym-vanilla-hclge-comm-reset-tqp-stats \
ksym-vanilla-hclge-comm-rss-indir-init-cfg \
ksym-vanilla-hclge-comm-rss-init-cfg \
ksym-vanilla-hclge-comm-set-rss-algo-key \
ksym-vanilla-hclge-comm-set-rss-hash-key \
ksym-vanilla-hclge-comm-set-rss-indir-table \
ksym-vanilla-hclge-comm-set-rss-input-tuple \
ksym-vanilla-hclge-comm-set-rss-tc-mode \
ksym-vanilla-hclge-comm-set-rss-tuple \
ksym-vanilla-hclge-comm-tqps-get-sset-count \
ksym-vanilla-hclge-comm-tqps-get-stats \
ksym-vanilla-hclge-comm-tqps-get-strings \
ksym-vanilla-hclge-comm-tqps-update-stats \
ksym-vanilla-hd44780-common-alloc \
ksym-vanilla-hd44780-common-blink \
ksym-vanilla-hd44780-common-clear-display \
ksym-vanilla-hd44780-common-cursor \
ksym-vanilla-hd44780-common-display \
ksym-vanilla-hd44780-common-fontsize \
ksym-vanilla-hd44780-common-free \
ksym-vanilla-hd44780-common-gotoxy \
ksym-vanilla-hd44780-common-home \
ksym-vanilla-hd44780-common-init-display \
ksym-vanilla-hd44780-common-lines \
ksym-vanilla-hd44780-common-print \
ksym-vanilla-hd44780-common-redefine-char \
ksym-vanilla-hd44780-common-shift-cursor \
ksym-vanilla-hd44780-common-shift-display \
ksym-vanilla-hda-codec-driver-unregister \
ksym-vanilla-hda-codec-probe-complete \
ksym-vanilla-hda-component-acpi-device-notify \
ksym-vanilla-hda-component-manager-bind \
ksym-vanilla-hda-component-manager-bind-acpi-notifications \
ksym-vanilla-hda-component-manager-free \
ksym-vanilla-hda-component-manager-init \
ksym-vanilla-hda-component-manager-playback-hook \
ksym-vanilla-hda-component-manager-unbind-acpi-notifications \
ksym-vanilla-hda-extra-out-badness \
ksym-vanilla-hda-get-autocfg-input-label \
ksym-vanilla-hda-main-out-badness \
ksym-vanilla-hdac-get-device-id \
ksym-vanilla-hdlc-close \
ksym-vanilla-hdlc-ioctl \
ksym-vanilla-hdlc-open \
ksym-vanilla-hdlc-start-xmit \
ksym-vanilla-hdmi-audio-infoframe-check \
ksym-vanilla-hdmi-audio-infoframe-init \
ksym-vanilla-hdmi-audio-infoframe-pack \
ksym-vanilla-hdmi-audio-infoframe-pack-for-dp \
ksym-vanilla-hdmi-audio-infoframe-pack-only \
ksym-vanilla-hdmi-avi-infoframe-check \
ksym-vanilla-hdmi-avi-infoframe-init \
ksym-vanilla-hdmi-avi-infoframe-pack \
ksym-vanilla-hdmi-avi-infoframe-pack-only \
ksym-vanilla-hdmi-drm-infoframe-check \
ksym-vanilla-hdmi-drm-infoframe-init \
ksym-vanilla-hdmi-drm-infoframe-pack \
ksym-vanilla-hdmi-drm-infoframe-pack-only \
ksym-vanilla-hdmi-drm-infoframe-unpack-only \
ksym-vanilla-hdmi-infoframe-log \
ksym-vanilla-hdmi-infoframe-pack \
ksym-vanilla-hdmi-infoframe-pack-only \
ksym-vanilla-hdmi-infoframe-unpack \
ksym-vanilla-hdmi-spd-infoframe-check \
ksym-vanilla-hdmi-spd-infoframe-init \
ksym-vanilla-hdmi-spd-infoframe-pack \
ksym-vanilla-hdmi-spd-infoframe-pack-only \
ksym-vanilla-hdmi-vendor-infoframe-check \
ksym-vanilla-hdmi-vendor-infoframe-init \
ksym-vanilla-hdmi-vendor-infoframe-pack \
ksym-vanilla-hdmi-vendor-infoframe-pack-only \
ksym-vanilla-helene-attach \
ksym-vanilla-helene-attach-s \
ksym-vanilla-hest-disable \
ksym-vanilla-hex-asc \
ksym-vanilla-hex-asc-upper \
ksym-vanilla-hex-dump-to-buffer \
ksym-vanilla-hex-to-bin \
ksym-vanilla-hex2bin \
ksym-vanilla-hfi-session-abort \
ksym-vanilla-hfi-session-continue \
ksym-vanilla-hfi-session-create \
ksym-vanilla-hfi-session-deinit \
ksym-vanilla-hfi-session-destroy \
ksym-vanilla-hfi-session-flush \
ksym-vanilla-hfi-session-get-property \
ksym-vanilla-hfi-session-init \
ksym-vanilla-hfi-session-process-buf \
ksym-vanilla-hfi-session-set-property \
ksym-vanilla-hfi-session-start \
ksym-vanilla-hfi-session-stop \
ksym-vanilla-hfi-session-unload-res \
ksym-vanilla-hibernate-quiet-exec \
ksym-vanilla-hibernation-set-ops \
ksym-vanilla-hid-add-device \
ksym-vanilla-hid-alloc-report-buf \
ksym-vanilla-hid-allocate-device \
ksym-vanilla-hid-bpf-connect-device \
ksym-vanilla-hid-bpf-destroy-device \
ksym-vanilla-hid-bpf-device-init \
ksym-vanilla-hid-bpf-disconnect-device \
ksym-vanilla-hid-bus-type \
ksym-vanilla-hid-check-keys-pressed \
ksym-vanilla-hid-compare-device-paths \
ksym-vanilla-hid-connect \
ksym-vanilla-hid-debug-event \
ksym-vanilla-hid-destroy-device \
ksym-vanilla-hid-disconnect \
ksym-vanilla-hid-driver-reset-resume \
ksym-vanilla-hid-driver-resume \
ksym-vanilla-hid-driver-suspend \
ksym-vanilla-hid-dump-device \
ksym-vanilla-hid-dump-field \
ksym-vanilla-hid-dump-input \
ksym-vanilla-hid-dump-report \
ksym-vanilla-hid-field-extract \
ksym-vanilla-hid-find-field \
ksym-vanilla-hid-haptic-check-pressure-unit \
ksym-vanilla-hid-haptic-feature-mapping \
ksym-vanilla-hid-haptic-init \
ksym-vanilla-hid-haptic-input-configured \
ksym-vanilla-hid-haptic-input-mapping \
ksym-vanilla-hid-haptic-pressure-increase \
ksym-vanilla-hid-haptic-pressure-reset \
ksym-vanilla-hid-hw-close \
ksym-vanilla-hid-hw-open \
ksym-vanilla-hid-hw-output-report \
ksym-vanilla-hid-hw-raw-request \
ksym-vanilla-hid-hw-request \
ksym-vanilla-hid-hw-start \
ksym-vanilla-hid-hw-stop \
ksym-vanilla-hid-ignore \
ksym-vanilla-hid-input-report \
ksym-vanilla-hid-is-usb \
ksym-vanilla-hid-lookup-quirk \
ksym-vanilla-hid-match-device \
ksym-vanilla-hid-match-id \
ksym-vanilla-hid-open-report \
ksym-vanilla-hid-ops \
ksym-vanilla-hid-output-report \
ksym-vanilla-hid-parse-report \
ksym-vanilla-hid-pidff-init-with-quirks \
ksym-vanilla-hid-quirks-exit \
ksym-vanilla-hid-quirks-init \
ksym-vanilla-hid-register-report \
ksym-vanilla-hid-report-raw-event \
ksym-vanilla-hid-resolv-usage \
ksym-vanilla-hid-safe-input-report \
ksym-vanilla-hid-sensor-batch-mode-supported \
ksym-vanilla-hid-sensor-convert-timestamp \
ksym-vanilla-hid-sensor-format-scale \
ksym-vanilla-hid-sensor-get-report-latency \
ksym-vanilla-hid-sensor-get-usage-index \
ksym-vanilla-hid-sensor-parse-common-attributes \
ksym-vanilla-hid-sensor-pm-ops \
ksym-vanilla-hid-sensor-power-state \
ksym-vanilla-hid-sensor-read-poll-value \
ksym-vanilla-hid-sensor-read-raw-hyst-rel-value \
ksym-vanilla-hid-sensor-read-raw-hyst-value \
ksym-vanilla-hid-sensor-read-samp-freq-value \
ksym-vanilla-hid-sensor-remove-trigger \
ksym-vanilla-hid-sensor-set-report-latency \
ksym-vanilla-hid-sensor-setup-trigger \
ksym-vanilla-hid-sensor-write-raw-hyst-rel-value \
ksym-vanilla-hid-sensor-write-raw-hyst-value \
ksym-vanilla-hid-sensor-write-samp-freq-value \
ksym-vanilla-hid-set-field \
ksym-vanilla-hid-setup-resolution-multiplier \
ksym-vanilla-hid-unregister-driver \
ksym-vanilla-hid-validate-values \
ksym-vanilla-hiddev-hid-event \
ksym-vanilla-hidinput-calc-abs-res \
ksym-vanilla-hidinput-connect \
ksym-vanilla-hidinput-count-leds \
ksym-vanilla-hidinput-disconnect \
ksym-vanilla-hidinput-get-led-field \
ksym-vanilla-hidinput-report-event \
ksym-vanilla-hidinput-reset-resume \
ksym-vanilla-hidma-mgmt-init-sys \
ksym-vanilla-hidma-mgmt-setup \
ksym-vanilla-hidraw-connect \
ksym-vanilla-hidraw-disconnect \
ksym-vanilla-hidraw-report-event \
ksym-vanilla-high-memory \
ksym-vanilla-hisi-acc-create-sgl-pool \
ksym-vanilla-hisi-acc-free-sgl-pool \
ksym-vanilla-hisi-acc-sg-buf-map-to-hw-sgl \
ksym-vanilla-hisi-acc-sg-buf-unmap \
ksym-vanilla-hisi-clk-alloc \
ksym-vanilla-hisi-clk-init \
ksym-vanilla-hisi-clk-register-divider \
ksym-vanilla-hisi-clk-register-fixed-factor \
ksym-vanilla-hisi-clk-register-fixed-rate \
ksym-vanilla-hisi-clk-register-gate \
ksym-vanilla-hisi-clk-register-gate-sep \
ksym-vanilla-hisi-clk-register-mux \
ksym-vanilla-hisi-clk-register-phase \
ksym-vanilla-hisi-cpumask-sysfs-show \
ksym-vanilla-hisi-event-sysfs-show \
ksym-vanilla-hisi-hpre-get-pf-driver \
ksym-vanilla-hisi-pmu-cpumask-attr-group \
ksym-vanilla-hisi-pmu-identifier-group \
ksym-vanilla-hisi-pmu-init \
ksym-vanilla-hisi-qm-acc-diff-regs-dump \
ksym-vanilla-hisi-qm-alg-register \
ksym-vanilla-hisi-qm-alg-unregister \
ksym-vanilla-hisi-qm-alloc-qps-node \
ksym-vanilla-hisi-qm-debug-init \
ksym-vanilla-hisi-qm-debug-regs-clear \
ksym-vanilla-hisi-qm-dev-err-detected \
ksym-vanilla-hisi-qm-dev-err-init \
ksym-vanilla-hisi-qm-dev-err-uninit \
ksym-vanilla-hisi-qm-dev-shutdown \
ksym-vanilla-hisi-qm-dev-slot-reset \
ksym-vanilla-hisi-qm-free-qps \
ksym-vanilla-hisi-qm-get-cap-value \
ksym-vanilla-hisi-qm-get-dfx-access \
ksym-vanilla-hisi-qm-get-hw-info \
ksym-vanilla-hisi-qm-init \
ksym-vanilla-hisi-qm-mb \
ksym-vanilla-hisi-qm-mb-read \
ksym-vanilla-hisi-qm-pm-init \
ksym-vanilla-hisi-qm-pm-uninit \
ksym-vanilla-hisi-qm-put-dfx-access \
ksym-vanilla-hisi-qm-q-num-set \
ksym-vanilla-hisi-qm-register-uacce \
ksym-vanilla-hisi-qm-regs-debugfs-init \
ksym-vanilla-hisi-qm-regs-debugfs-uninit \
ksym-vanilla-hisi-qm-regs-dump \
ksym-vanilla-hisi-qm-reset-done \
ksym-vanilla-hisi-qm-reset-prepare \
ksym-vanilla-hisi-qm-resume \
ksym-vanilla-hisi-qm-set-algs \
ksym-vanilla-hisi-qm-sriov-configure \
ksym-vanilla-hisi-qm-sriov-disable \
ksym-vanilla-hisi-qm-sriov-enable \
ksym-vanilla-hisi-qm-start \
ksym-vanilla-hisi-qm-stop \
ksym-vanilla-hisi-qm-suspend \
ksym-vanilla-hisi-qm-uninit \
ksym-vanilla-hisi-qm-wait-mb-ready \
ksym-vanilla-hisi-qm-wait-task-finish \
ksym-vanilla-hisi-qp-send \
ksym-vanilla-hisi-reset-exit \
ksym-vanilla-hisi-reset-init \
ksym-vanilla-hisi-sas-alloc \
ksym-vanilla-hisi-sas-controller-reset-done \
ksym-vanilla-hisi-sas-controller-reset-prepare \
ksym-vanilla-hisi-sas-debugfs-dir \
ksym-vanilla-hisi-sas-debugfs-dump-count \
ksym-vanilla-hisi-sas-debugfs-enable \
ksym-vanilla-hisi-sas-free \
ksym-vanilla-hisi-sas-get-ata-protocol \
ksym-vanilla-hisi-sas-get-fw-info \
ksym-vanilla-hisi-sas-get-prog-phy-linkrate-mask \
ksym-vanilla-hisi-sas-host-reset \
ksym-vanilla-hisi-sas-init-mem \
ksym-vanilla-hisi-sas-notify-phy-event \
ksym-vanilla-hisi-sas-phy-bcast \
ksym-vanilla-hisi-sas-phy-down \
ksym-vanilla-hisi-sas-phy-enable \
ksym-vanilla-hisi-sas-phy-oob-ready \
ksym-vanilla-hisi-sas-probe \
ksym-vanilla-hisi-sas-release-tasks \
ksym-vanilla-hisi-sas-remove \
ksym-vanilla-hisi-sas-rst-work-handler \
ksym-vanilla-hisi-sas-sata-done \
ksym-vanilla-hisi-sas-scan-finished \
ksym-vanilla-hisi-sas-scan-start \
ksym-vanilla-hisi-sas-sdev-configure \
ksym-vanilla-hisi-sas-sdev-init \
ksym-vanilla-hisi-sas-slot-task-free \
ksym-vanilla-hisi-sas-stop-phys \
ksym-vanilla-hisi-sas-stt \
ksym-vanilla-hisi-sas-sync-cqs \
ksym-vanilla-hisi-sas-sync-poll-cqs \
ksym-vanilla-hisi-sas-sync-rst-work-handler \
ksym-vanilla-hisi-sec-get-pf-driver \
ksym-vanilla-hisi-uncore-pmu-add \
ksym-vanilla-hisi-uncore-pmu-del \
ksym-vanilla-hisi-uncore-pmu-disable \
ksym-vanilla-hisi-uncore-pmu-enable \
ksym-vanilla-hisi-uncore-pmu-event-init \
ksym-vanilla-hisi-uncore-pmu-event-update \
ksym-vanilla-hisi-uncore-pmu-get-event-idx \
ksym-vanilla-hisi-uncore-pmu-identifier-attr-show \
ksym-vanilla-hisi-uncore-pmu-init-irq \
ksym-vanilla-hisi-uncore-pmu-init-topology \
ksym-vanilla-hisi-uncore-pmu-isr \
ksym-vanilla-hisi-uncore-pmu-offline-cpu \
ksym-vanilla-hisi-uncore-pmu-online-cpu \
ksym-vanilla-hisi-uncore-pmu-read \
ksym-vanilla-hisi-uncore-pmu-set-event-period \
ksym-vanilla-hisi-uncore-pmu-start \
ksym-vanilla-hisi-uncore-pmu-stop \
ksym-vanilla-hisi-zip-get-pf-driver \
ksym-vanilla-hmac-md5 \
ksym-vanilla-hmac-md5-final \
ksym-vanilla-hmac-md5-init \
ksym-vanilla-hmac-md5-init-usingrawkey \
ksym-vanilla-hmac-md5-preparekey \
ksym-vanilla-hmac-md5-usingrawkey \
ksym-vanilla-hmac-sha1 \
ksym-vanilla-hmac-sha1-final \
ksym-vanilla-hmac-sha1-init \
ksym-vanilla-hmac-sha1-init-usingrawkey \
ksym-vanilla-hmac-sha1-preparekey \
ksym-vanilla-hmac-sha1-usingrawkey \
ksym-vanilla-hmac-sha224 \
ksym-vanilla-hmac-sha224-final \
ksym-vanilla-hmac-sha224-init-usingrawkey \
ksym-vanilla-hmac-sha224-preparekey \
ksym-vanilla-hmac-sha224-usingrawkey \
ksym-vanilla-hmac-sha256 \
ksym-vanilla-hmac-sha256-final \
ksym-vanilla-hmac-sha256-init-usingrawkey \
ksym-vanilla-hmac-sha256-preparekey \
ksym-vanilla-hmac-sha256-usingrawkey \
ksym-vanilla-hmac-sha384 \
ksym-vanilla-hmac-sha384-final \
ksym-vanilla-hmac-sha384-init-usingrawkey \
ksym-vanilla-hmac-sha384-preparekey \
ksym-vanilla-hmac-sha384-usingrawkey \
ksym-vanilla-hmac-sha512 \
ksym-vanilla-hmac-sha512-final \
ksym-vanilla-hmac-sha512-init-usingrawkey \
ksym-vanilla-hmac-sha512-preparekey \
ksym-vanilla-hmac-sha512-usingrawkey \
ksym-vanilla-hmat-get-extended-linear-cache-size \
ksym-vanilla-hmm-dma-map-alloc \
ksym-vanilla-hmm-dma-map-free \
ksym-vanilla-hmm-dma-map-pfn \
ksym-vanilla-hmm-dma-unmap-pfn \
ksym-vanilla-hmm-range-fault \
ksym-vanilla-hnae-ae-register \
ksym-vanilla-hnae-ae-unregister \
ksym-vanilla-hnae-get-handle \
ksym-vanilla-hnae-put-handle \
ksym-vanilla-hnae-register-notifier \
ksym-vanilla-hnae-reinit-handle \
ksym-vanilla-hnae-unregister-notifier \
ksym-vanilla-hnae3-acquire-unload-lock \
ksym-vanilla-hnae3-register-ae-algo \
ksym-vanilla-hnae3-register-ae-dev \
ksym-vanilla-hnae3-register-client \
ksym-vanilla-hnae3-release-unload-lock \
ksym-vanilla-hnae3-set-client-init-flag \
ksym-vanilla-hnae3-unregister-ae-algo \
ksym-vanilla-hnae3-unregister-ae-algo-prepare \
ksym-vanilla-hnae3-unregister-ae-dev \
ksym-vanilla-hnae3-unregister-client \
ksym-vanilla-horus3a-attach \
ksym-vanilla-host1x-bo-clear-cached-mappings \
ksym-vanilla-host1x-bo-pin \
ksym-vanilla-host1x-bo-unpin \
ksym-vanilla-host1x-channel-get \
ksym-vanilla-host1x-channel-put \
ksym-vanilla-host1x-channel-request \
ksym-vanilla-host1x-channel-stop \
ksym-vanilla-host1x-client-exit \
ksym-vanilla-host1x-client-resume \
ksym-vanilla-host1x-client-suspend \
ksym-vanilla-host1x-client-unregister \
ksym-vanilla-host1x-context-device-bus-type \
ksym-vanilla-host1x-device-exit \
ksym-vanilla-host1x-device-init \
ksym-vanilla-host1x-driver-register-full \
ksym-vanilla-host1x-driver-unregister \
ksym-vanilla-host1x-fence-cancel \
ksym-vanilla-host1x-fence-create \
ksym-vanilla-host1x-get-dma-mask \
ksym-vanilla-host1x-job-add-gather \
ksym-vanilla-host1x-job-add-wait \
ksym-vanilla-host1x-job-alloc \
ksym-vanilla-host1x-job-get \
ksym-vanilla-host1x-job-pin \
ksym-vanilla-host1x-job-put \
ksym-vanilla-host1x-job-submit \
ksym-vanilla-host1x-job-unpin \
ksym-vanilla-host1x-memory-context-alloc \
ksym-vanilla-host1x-memory-context-get \
ksym-vanilla-host1x-memory-context-put \
ksym-vanilla-host1x-syncpt-alloc \
ksym-vanilla-host1x-syncpt-base-id \
ksym-vanilla-host1x-syncpt-get \
ksym-vanilla-host1x-syncpt-get-base \
ksym-vanilla-host1x-syncpt-get-by-id \
ksym-vanilla-host1x-syncpt-get-by-id-noref \
ksym-vanilla-host1x-syncpt-id \
ksym-vanilla-host1x-syncpt-incr \
ksym-vanilla-host1x-syncpt-incr-max \
ksym-vanilla-host1x-syncpt-put \
ksym-vanilla-host1x-syncpt-read \
ksym-vanilla-host1x-syncpt-read-max \
ksym-vanilla-host1x-syncpt-read-min \
ksym-vanilla-host1x-syncpt-release-vblank-reservation \
ksym-vanilla-host1x-syncpt-request \
ksym-vanilla-host1x-syncpt-wait \
ksym-vanilla-housekeeping-affine \
ksym-vanilla-housekeeping-any-cpu \
ksym-vanilla-housekeeping-cpumask \
ksym-vanilla-housekeeping-enabled \
ksym-vanilla-housekeeping-overridden \
ksym-vanilla-housekeeping-test-cpu \
ksym-vanilla-hrtimer-active \
ksym-vanilla-hrtimer-cancel \
ksym-vanilla-hrtimer-cb-get-time \
ksym-vanilla-hrtimer-forward \
ksym-vanilla-hrtimer-resolution \
ksym-vanilla-hrtimer-setup \
ksym-vanilla-hrtimer-setup-on-stack \
ksym-vanilla-hrtimer-setup-sleeper-on-stack \
ksym-vanilla-hrtimer-sleeper-start-expires \
ksym-vanilla-hrtimer-start-range-ns \
ksym-vanilla-hrtimer-start-range-ns-user \
ksym-vanilla-hrtimer-try-to-cancel \
ksym-vanilla-hsi-add-clients-from-dt \
ksym-vanilla-hsi-alloc-controller \
ksym-vanilla-hsi-alloc-msg \
ksym-vanilla-hsi-async \
ksym-vanilla-hsi-board-list \
ksym-vanilla-hsi-claim-port \
ksym-vanilla-hsi-event \
ksym-vanilla-hsi-free-msg \
ksym-vanilla-hsi-get-channel-id-by-name \
ksym-vanilla-hsi-new-client \
ksym-vanilla-hsi-port-unregister-clients \
ksym-vanilla-hsi-put-controller \
ksym-vanilla-hsi-register-client-driver \
ksym-vanilla-hsi-register-controller \
ksym-vanilla-hsi-register-port-event \
ksym-vanilla-hsi-release-port \
ksym-vanilla-hsi-remove-client \
ksym-vanilla-hsi-unregister-controller \
ksym-vanilla-hsi-unregister-port-event \
ksym-vanilla-hsiphash-1u32 \
ksym-vanilla-hsiphash-2u32 \
ksym-vanilla-hsiphash-3u32 \
ksym-vanilla-hsiphash-4u32 \
ksym-vanilla-hsr-get-port-ndev \
ksym-vanilla-hsr-get-port-type \
ksym-vanilla-hsr-get-version \
ksym-vanilla-hte-disable-ts \
ksym-vanilla-hte-enable-ts \
ksym-vanilla-hte-get-clk-src-info \
ksym-vanilla-hte-init-line-attr \
ksym-vanilla-hte-push-ts-ns \
ksym-vanilla-hte-request-ts-ns \
ksym-vanilla-hte-ts-get \
ksym-vanilla-hte-ts-put \
ksym-vanilla-hts221-pm-ops \
ksym-vanilla-hts221-probe \
ksym-vanilla-hugetlb-cgrp-subsys-enabled-key \
ksym-vanilla-hugetlb-cgrp-subsys-on-dfl-key \
ksym-vanilla-hv-call-create-vp \
ksym-vanilla-hv-call-delete-vp \
ksym-vanilla-hv-call-deposit-pages \
ksym-vanilla-hv-call-get-partition-property \
ksym-vanilla-hv-call-get-vp-registers \
ksym-vanilla-hv-call-set-vp-registers \
ksym-vanilla-hv-context \
ksym-vanilla-hv-create-ring-sysfs \
ksym-vanilla-hv-curr-partition-type \
ksym-vanilla-hv-current-partition-id \
ksym-vanilla-hv-deposit-memory-node \
ksym-vanilla-hv-do-fast-hypercall16 \
ksym-vanilla-hv-do-fast-hypercall8 \
ksym-vanilla-hv-do-hypercall \
ksym-vanilla-hv-enable-coco-interrupt \
ksym-vanilla-hv-get-hypervisor-version \
ksym-vanilla-hv-get-vmbus-root-device \
ksym-vanilla-hv-get-vpreg \
ksym-vanilla-hv-get-vpreg-128 \
ksym-vanilla-hv-ghcb-hypercall \
ksym-vanilla-hv-is-hibernation-supported \
ksym-vanilla-hv-is-hyperv-initialized \
ksym-vanilla-hv-is-isolation-supported \
ksym-vanilla-hv-isolation-type-snp \
ksym-vanilla-hv-isolation-type-tdx \
ksym-vanilla-hv-max-vp-index \
ksym-vanilla-hv-nested \
ksym-vanilla-hv-para-get-synic-register \
ksym-vanilla-hv-para-set-sint-proxy \
ksym-vanilla-hv-para-set-synic-register \
ksym-vanilla-hv-pkt-iter-close \
ksym-vanilla-hv-pkt-iter-first \
ksym-vanilla-hv-post-message \
ksym-vanilla-hv-query-ext-cap \
ksym-vanilla-hv-read-reference-counter \
ksym-vanilla-hv-remove-crash-handler \
ksym-vanilla-hv-remove-kexec-handler \
ksym-vanilla-hv-remove-ring-sysfs \
ksym-vanilla-hv-remove-vmbus-handler \
ksym-vanilla-hv-result-needs-memory \
ksym-vanilla-hv-result-to-errno \
ksym-vanilla-hv-result-to-string \
ksym-vanilla-hv-ringbuffer-get-debuginfo \
ksym-vanilla-hv-ringbuffer-spinlock-busy \
ksym-vanilla-hv-set-vpreg \
ksym-vanilla-hv-setup-crash-handler \
ksym-vanilla-hv-setup-dma-ops \
ksym-vanilla-hv-setup-kexec-handler \
ksym-vanilla-hv-setup-mshv-handler \
ksym-vanilla-hv-setup-vmbus-handler \
ksym-vanilla-hv-synic-eventring-tail \
ksym-vanilla-hv-tdx-hypercall \
ksym-vanilla-hv-vmbus-exists \
ksym-vanilla-hv-vp-index \
ksym-vanilla-hvc-alloc \
ksym-vanilla-hvc-instantiate \
ksym-vanilla-hvc-kick \
ksym-vanilla-hvc-poll \
ksym-vanilla-hvc-remove \
ksym-vanilla-hvpci-block-ops \
ksym-vanilla-hw-phymode-configure \
ksym-vanilla-hwerr-log-error-type \
ksym-vanilla-hwmon-device-register \
ksym-vanilla-hwmon-device-register-for-thermal \
ksym-vanilla-hwmon-device-register-with-groups \
ksym-vanilla-hwmon-device-register-with-info \
ksym-vanilla-hwmon-device-unregister \
ksym-vanilla-hwmon-lock \
ksym-vanilla-hwmon-notify-event \
ksym-vanilla-hwmon-sanitize-name \
ksym-vanilla-hwmon-unlock \
ksym-vanilla-hwpoison-filter-register \
ksym-vanilla-hwpoison-filter-unregister \
ksym-vanilla-hwrng-msleep \
ksym-vanilla-hwrng-register \
ksym-vanilla-hwrng-unregister \
ksym-vanilla-hwrng-yield \
ksym-vanilla-hwspin-lock-bust \
ksym-vanilla-hwspin-lock-free \
ksym-vanilla-hwspin-lock-register \
ksym-vanilla-hwspin-lock-request-specific \
ksym-vanilla-hwspin-lock-unregister \
ksym-vanilla-hyperbus-register-device \
ksym-vanilla-hyperbus-unregister-device \
ksym-vanilla-hyperv-cleanup \
ksym-vanilla-hyperv-pcpu-input-arg \
ksym-vanilla-hyperv-pcpu-output-arg \
ksym-vanilla-hyperv-read-cfg-blk \
ksym-vanilla-hyperv-reg-block-invalidate \
ksym-vanilla-hyperv-report-panic \
ksym-vanilla-hyperv-write-cfg-blk \
ksym-vanilla-i2c-acpi-client-count \
ksym-vanilla-i2c-acpi-find-adapter-by-handle \
ksym-vanilla-i2c-acpi-find-bus-speed \
ksym-vanilla-i2c-acpi-get-i2c-resource \
ksym-vanilla-i2c-acpi-new-device-by-fwnode \
ksym-vanilla-i2c-acpi-waive-d0-probe \
ksym-vanilla-i2c-adapter-depth \
ksym-vanilla-i2c-adapter-type \
ksym-vanilla-i2c-add-adapter \
ksym-vanilla-i2c-add-numbered-adapter \
ksym-vanilla-i2c-atr-add-adapter \
ksym-vanilla-i2c-atr-del-adapter \
ksym-vanilla-i2c-atr-delete \
ksym-vanilla-i2c-atr-get-driver-data \
ksym-vanilla-i2c-atr-new \
ksym-vanilla-i2c-atr-set-driver-data \
ksym-vanilla-i2c-bit-add-bus \
ksym-vanilla-i2c-bit-add-numbered-bus \
ksym-vanilla-i2c-bit-algo \
ksym-vanilla-i2c-bus-type \
ksym-vanilla-i2c-client-get-device-id \
ksym-vanilla-i2c-client-type \
ksym-vanilla-i2c-clients-command \
ksym-vanilla-i2c-del-adapter \
ksym-vanilla-i2c-del-driver \
ksym-vanilla-i2c-detect-slave-mode \
ksym-vanilla-i2c-dw-configure-master \
ksym-vanilla-i2c-dw-configure-slave \
ksym-vanilla-i2c-dw-dev-pm-ops \
ksym-vanilla-i2c-dw-disable \
ksym-vanilla-i2c-dw-fw-parse-and-configure \
ksym-vanilla-i2c-dw-init \
ksym-vanilla-i2c-dw-prepare-clk \
ksym-vanilla-i2c-dw-probe \
ksym-vanilla-i2c-dw-shutdown \
ksym-vanilla-i2c-find-adapter-by-fwnode \
ksym-vanilla-i2c-find-device-by-fwnode \
ksym-vanilla-i2c-for-each-dev \
ksym-vanilla-i2c-free-slave-host-notify-device \
ksym-vanilla-i2c-freq-mode-string \
ksym-vanilla-i2c-generic-scl-recovery \
ksym-vanilla-i2c-get-adapter \
ksym-vanilla-i2c-get-adapter-by-fwnode \
ksym-vanilla-i2c-get-device-id \
ksym-vanilla-i2c-get-dma-safe-msg-buf \
ksym-vanilla-i2c-get-match-data \
ksym-vanilla-i2c-handle-smbus-alert \
ksym-vanilla-i2c-handle-smbus-host-notify \
ksym-vanilla-i2c-hid-core-pm \
ksym-vanilla-i2c-hid-core-probe \
ksym-vanilla-i2c-hid-core-remove \
ksym-vanilla-i2c-hid-core-shutdown \
ksym-vanilla-i2c-match-id \
ksym-vanilla-i2c-mux-add-adapter \
ksym-vanilla-i2c-mux-alloc \
ksym-vanilla-i2c-mux-del-adapters \
ksym-vanilla-i2c-new-ancillary-device \
ksym-vanilla-i2c-new-ccgx-ucsi \
ksym-vanilla-i2c-new-client-device \
ksym-vanilla-i2c-new-dummy-device \
ksym-vanilla-i2c-new-scanned-device \
ksym-vanilla-i2c-new-slave-host-notify-device \
ksym-vanilla-i2c-new-smbus-alert-device \
ksym-vanilla-i2c-of-probe-component \
ksym-vanilla-i2c-of-probe-simple-cleanup \
ksym-vanilla-i2c-of-probe-simple-cleanup-early \
ksym-vanilla-i2c-of-probe-simple-enable \
ksym-vanilla-i2c-of-probe-simple-ops \
ksym-vanilla-i2c-parse-fw-timings \
ksym-vanilla-i2c-pca-add-bus \
ksym-vanilla-i2c-pca-add-numbered-bus \
ksym-vanilla-i2c-probe-func-quick-read \
ksym-vanilla-i2c-put-adapter \
ksym-vanilla-i2c-put-dma-safe-msg-buf \
ksym-vanilla-i2c-recover-bus \
ksym-vanilla-i2c-register-driver \
ksym-vanilla-i2c-register-spd-write-disable \
ksym-vanilla-i2c-register-spd-write-enable \
ksym-vanilla-i2c-root-adapter \
ksym-vanilla-i2c-slave-event \
ksym-vanilla-i2c-slave-register \
ksym-vanilla-i2c-slave-unregister \
ksym-vanilla-i2c-smbus-pec \
ksym-vanilla-i2c-smbus-read-block-data \
ksym-vanilla-i2c-smbus-read-byte \
ksym-vanilla-i2c-smbus-read-byte-data \
ksym-vanilla-i2c-smbus-read-i2c-block-data \
ksym-vanilla-i2c-smbus-read-i2c-block-data-or-emulated \
ksym-vanilla-i2c-smbus-read-word-data \
ksym-vanilla-i2c-smbus-write-block-data \
ksym-vanilla-i2c-smbus-write-byte \
ksym-vanilla-i2c-smbus-write-byte-data \
ksym-vanilla-i2c-smbus-write-i2c-block-data \
ksym-vanilla-i2c-smbus-write-word-data \
ksym-vanilla-i2c-smbus-xfer \
ksym-vanilla-i2c-transfer \
ksym-vanilla-i2c-transfer-buffer-flags \
ksym-vanilla-i2c-unregister-device \
ksym-vanilla-i2c-verify-adapter \
ksym-vanilla-i2c-verify-client \
ksym-vanilla-i3c-bus-type \
ksym-vanilla-i3c-dev-disable-ibi-locked \
ksym-vanilla-i3c-dev-enable-ibi-locked \
ksym-vanilla-i3c-dev-free-ibi-locked \
ksym-vanilla-i3c-dev-request-ibi-locked \
ksym-vanilla-i3c-device-disable-ibi \
ksym-vanilla-i3c-device-do-setdasa \
ksym-vanilla-i3c-device-do-xfers \
ksym-vanilla-i3c-device-enable-ibi \
ksym-vanilla-i3c-device-free-ibi \
ksym-vanilla-i3c-device-get-info \
ksym-vanilla-i3c-device-get-supported-xfer-mode \
ksym-vanilla-i3c-device-match-id \
ksym-vanilla-i3c-device-request-ibi \
ksym-vanilla-i3c-driver-register-with-owner \
ksym-vanilla-i3c-driver-unregister \
ksym-vanilla-i3c-for-each-bus-locked \
ksym-vanilla-i3c-generic-ibi-alloc-pool \
ksym-vanilla-i3c-generic-ibi-free-pool \
ksym-vanilla-i3c-generic-ibi-get-free-slot \
ksym-vanilla-i3c-generic-ibi-recycle-slot \
ksym-vanilla-i3c-hci-rpm-resume \
ksym-vanilla-i3c-hci-rpm-suspend \
ksym-vanilla-i3c-master-add-i3c-dev-locked \
ksym-vanilla-i3c-master-defslvs-locked \
ksym-vanilla-i3c-master-disable-hotjoin \
ksym-vanilla-i3c-master-disec-locked \
ksym-vanilla-i3c-master-dma-map-single \
ksym-vanilla-i3c-master-dma-unmap-single \
ksym-vanilla-i3c-master-do-daa \
ksym-vanilla-i3c-master-do-daa-ext \
ksym-vanilla-i3c-master-enable-hotjoin \
ksym-vanilla-i3c-master-enec-disec-locked \
ksym-vanilla-i3c-master-enec-locked \
ksym-vanilla-i3c-master-entdaa-locked \
ksym-vanilla-i3c-master-get-free-addr \
ksym-vanilla-i3c-master-queue-hotjoin \
ksym-vanilla-i3c-master-queue-ibi \
ksym-vanilla-i3c-master-reattach-i3c-dev-locked \
ksym-vanilla-i3c-master-register \
ksym-vanilla-i3c-master-set-info \
ksym-vanilla-i3c-master-unregister \
ksym-vanilla-i3c-register-notifier \
ksym-vanilla-i3c-unregister-notifier \
ksym-vanilla-i3cdev-to-dev \
ksym-vanilla-i40e-client-device-register \
ksym-vanilla-i40e-client-device-unregister \
ksym-vanilla-ib-advise-mr \
ksym-vanilla-ib-alloc-mr \
ksym-vanilla-ib-alloc-mr-integrity \
ksym-vanilla-ib-alloc-xrcd-user \
ksym-vanilla-ib-attach-mcast \
ksym-vanilla-ib-cache-gid-parse-type-str \
ksym-vanilla-ib-cache-gid-type-str \
ksym-vanilla-ib-check-mr-status \
ksym-vanilla-ib-close-qp \
ksym-vanilla-ib-cm-init-qp-attr \
ksym-vanilla-ib-cm-insert-listen \
ksym-vanilla-ib-cm-listen \
ksym-vanilla-ib-cm-notify \
ksym-vanilla-ib-copy-ah-attr-to-user \
ksym-vanilla-ib-copy-path-rec-to-user \
ksym-vanilla-ib-copy-qp-attr-to-user \
ksym-vanilla-ib-cq-pool-get \
ksym-vanilla-ib-cq-pool-put \
ksym-vanilla-ib-create-ah-from-wc \
ksym-vanilla-ib-create-cm-id \
ksym-vanilla-ib-create-qp-kernel \
ksym-vanilla-ib-create-qp-security \
ksym-vanilla-ib-create-qp-user \
ksym-vanilla-ib-create-send-mad \
ksym-vanilla-ib-create-srq-user \
ksym-vanilla-ib-create-ucap \
ksym-vanilla-ib-create-wq \
ksym-vanilla-ib-dealloc-device \
ksym-vanilla-ib-dealloc-pd-user \
ksym-vanilla-ib-dealloc-xrcd-user \
ksym-vanilla-ib-dereg-mr-user \
ksym-vanilla-ib-destroy-cm-id \
ksym-vanilla-ib-destroy-cq-user \
ksym-vanilla-ib-destroy-qp-user \
ksym-vanilla-ib-destroy-srq-user \
ksym-vanilla-ib-destroy-wq-user \
ksym-vanilla-ib-detach-mcast \
ksym-vanilla-ib-device-get-by-netdev \
ksym-vanilla-ib-device-get-netdev \
ksym-vanilla-ib-device-put \
ksym-vanilla-ib-device-set-netdev \
ksym-vanilla-ib-dispatch-event \
ksym-vanilla-ib-dispatch-port-state-event \
ksym-vanilla-ib-dma-virt-map-sg \
ksym-vanilla-ib-drain-qp \
ksym-vanilla-ib-drain-rq \
ksym-vanilla-ib-drain-sq \
ksym-vanilla-ib-event-msg \
ksym-vanilla-ib-find-cached-pkey \
ksym-vanilla-ib-find-gid \
ksym-vanilla-ib-find-pkey \
ksym-vanilla-ib-free-cq \
ksym-vanilla-ib-free-recv-mad \
ksym-vanilla-ib-free-send-mad \
ksym-vanilla-ib-frmr-pool-drop \
ksym-vanilla-ib-frmr-pool-pop \
ksym-vanilla-ib-frmr-pool-push \
ksym-vanilla-ib-frmr-pools-cleanup \
ksym-vanilla-ib-frmr-pools-init \
ksym-vanilla-ib-get-cached-lmc \
ksym-vanilla-ib-get-cached-pkey \
ksym-vanilla-ib-get-cached-port-state \
ksym-vanilla-ib-get-cached-subnet-prefix \
ksym-vanilla-ib-get-device-fw-str \
ksym-vanilla-ib-get-eth-speed \
ksym-vanilla-ib-get-gids-from-rdma-hdr \
ksym-vanilla-ib-get-mad-data-offset \
ksym-vanilla-ib-get-net-dev-by-params \
ksym-vanilla-ib-get-rdma-header-version \
ksym-vanilla-ib-get-rmpp-segment \
ksym-vanilla-ib-get-ucaps \
ksym-vanilla-ib-get-vf-config \
ksym-vanilla-ib-get-vf-guid \
ksym-vanilla-ib-get-vf-stats \
ksym-vanilla-ib-init-ah-attr-from-path \
ksym-vanilla-ib-init-ah-attr-from-wc \
ksym-vanilla-ib-init-ah-from-mcmember \
ksym-vanilla-ib-is-mad-class-rmpp \
ksym-vanilla-ib-mad-kernel-rmpp-agent \
ksym-vanilla-ib-map-mr-sg \
ksym-vanilla-ib-map-mr-sg-pi \
ksym-vanilla-ib-modify-device \
ksym-vanilla-ib-modify-mad \
ksym-vanilla-ib-modify-port \
ksym-vanilla-ib-modify-qp \
ksym-vanilla-ib-modify-qp-is-ok \
ksym-vanilla-ib-modify-qp-with-udata \
ksym-vanilla-ib-modify-srq \
ksym-vanilla-ib-mr-pool-destroy \
ksym-vanilla-ib-mr-pool-get \
ksym-vanilla-ib-mr-pool-init \
ksym-vanilla-ib-mr-pool-put \
ksym-vanilla-ib-open-qp \
ksym-vanilla-ib-pack \
ksym-vanilla-ib-port-attr-to-speed-info \
ksym-vanilla-ib-port-immutable-read \
ksym-vanilla-ib-port-register-client-groups \
ksym-vanilla-ib-port-sysfs-get-ibdev-kobj \
ksym-vanilla-ib-port-unregister-client-groups \
ksym-vanilla-ib-post-send-mad \
ksym-vanilla-ib-prepare-cm-mra \
ksym-vanilla-ib-process-cq-direct \
ksym-vanilla-ib-qp-usecnt-dec \
ksym-vanilla-ib-qp-usecnt-inc \
ksym-vanilla-ib-query-netdev-port \
ksym-vanilla-ib-query-pkey \
ksym-vanilla-ib-query-port \
ksym-vanilla-ib-query-qp \
ksym-vanilla-ib-query-srq \
ksym-vanilla-ib-rate-to-mbps \
ksym-vanilla-ib-rate-to-mult \
ksym-vanilla-ib-rdmacg-try-charge \
ksym-vanilla-ib-rdmacg-uncharge \
ksym-vanilla-ib-reg-user-mr \
ksym-vanilla-ib-register-client \
ksym-vanilla-ib-register-device \
ksym-vanilla-ib-register-event-handler \
ksym-vanilla-ib-register-mad-agent \
ksym-vanilla-ib-remove-ucap \
ksym-vanilla-ib-response-mad \
ksym-vanilla-ib-sa-cancel-query \
ksym-vanilla-ib-sa-free-multicast \
ksym-vanilla-ib-sa-get-mcmember-rec \
ksym-vanilla-ib-sa-guid-info-rec-query \
ksym-vanilla-ib-sa-join-multicast \
ksym-vanilla-ib-sa-pack-path \
ksym-vanilla-ib-sa-pack-service \
ksym-vanilla-ib-sa-path-rec-get \
ksym-vanilla-ib-sa-register-client \
ksym-vanilla-ib-sa-service-rec-get \
ksym-vanilla-ib-sa-unpack-path \
ksym-vanilla-ib-sa-unpack-service \
ksym-vanilla-ib-sa-unregister-client \
ksym-vanilla-ib-send-cm-drep \
ksym-vanilla-ib-send-cm-dreq \
ksym-vanilla-ib-send-cm-rej \
ksym-vanilla-ib-send-cm-rep \
ksym-vanilla-ib-send-cm-req \
ksym-vanilla-ib-send-cm-rtu \
ksym-vanilla-ib-send-cm-sidr-rep \
ksym-vanilla-ib-send-cm-sidr-req \
ksym-vanilla-ib-set-client-data \
ksym-vanilla-ib-set-device-ops \
ksym-vanilla-ib-set-vf-guid \
ksym-vanilla-ib-set-vf-link-state \
ksym-vanilla-ib-sg-to-pages \
ksym-vanilla-ib-ud-header-init \
ksym-vanilla-ib-ud-header-pack \
ksym-vanilla-ib-ud-ip4-csum \
ksym-vanilla-ib-umem-check-rereg \
ksym-vanilla-ib-umem-copy-from \
ksym-vanilla-ib-umem-dmabuf-get \
ksym-vanilla-ib-umem-dmabuf-get-pinned \
ksym-vanilla-ib-umem-dmabuf-get-pinned-revocable-and-lock \
ksym-vanilla-ib-umem-dmabuf-get-pinned-with-dma-device \
ksym-vanilla-ib-umem-dmabuf-map-pages \
ksym-vanilla-ib-umem-dmabuf-revoke \
ksym-vanilla-ib-umem-dmabuf-revoke-lock \
ksym-vanilla-ib-umem-dmabuf-revoke-unlock \
ksym-vanilla-ib-umem-dmabuf-set-revoke-locked \
ksym-vanilla-ib-umem-dmabuf-unmap-pages \
ksym-vanilla-ib-umem-find-best-pgsz \
ksym-vanilla-ib-umem-get-attr \
ksym-vanilla-ib-umem-get-attr-or-va \
ksym-vanilla-ib-umem-get-cq-buf \
ksym-vanilla-ib-umem-get-cq-buf-or-va \
ksym-vanilla-ib-umem-get-desc \
ksym-vanilla-ib-umem-odp-alloc-child \
ksym-vanilla-ib-umem-odp-alloc-implicit \
ksym-vanilla-ib-umem-odp-get \
ksym-vanilla-ib-umem-odp-map-dma-and-lock \
ksym-vanilla-ib-umem-odp-release \
ksym-vanilla-ib-umem-odp-unmap-dma-pages \
ksym-vanilla-ib-umem-release \
ksym-vanilla-ib-unpack \
ksym-vanilla-ib-unregister-client \
ksym-vanilla-ib-unregister-device \
ksym-vanilla-ib-unregister-device-and-put \
ksym-vanilla-ib-unregister-device-queued \
ksym-vanilla-ib-unregister-driver \
ksym-vanilla-ib-unregister-event-handler \
ksym-vanilla-ib-unregister-mad-agent \
ksym-vanilla-ib-uverbs-flow-resources-free \
ksym-vanilla-ib-uverbs-get-ucontext-file \
ksym-vanilla-ib-uverbs-release-file \
ksym-vanilla-ib-wc-status-msg \
ksym-vanilla-ib-wq \
ksym-vanilla-ibcm-reject-msg \
ksym-vanilla-ibdev-alert \
ksym-vanilla-ibdev-crit \
ksym-vanilla-ibdev-emerg \
ksym-vanilla-ibdev-err \
ksym-vanilla-ibdev-info \
ksym-vanilla-ibdev-notice \
ksym-vanilla-ibdev-warn \
ksym-vanilla-ibnl-put-attr \
ksym-vanilla-ibnl-put-msg \
ksym-vanilla-icc-bulk-disable \
ksym-vanilla-icc-bulk-enable \
ksym-vanilla-icc-bulk-put \
ksym-vanilla-icc-bulk-set-bw \
ksym-vanilla-icc-clk-register \
ksym-vanilla-icc-clk-unregister \
ksym-vanilla-icc-disable \
ksym-vanilla-icc-enable \
ksym-vanilla-icc-get-name \
ksym-vanilla-icc-link-create \
ksym-vanilla-icc-link-nodes \
ksym-vanilla-icc-node-add \
ksym-vanilla-icc-node-create \
ksym-vanilla-icc-node-create-dyn \
ksym-vanilla-icc-node-del \
ksym-vanilla-icc-node-destroy \
ksym-vanilla-icc-node-set-name \
ksym-vanilla-icc-nodes-remove \
ksym-vanilla-icc-provider-deregister \
ksym-vanilla-icc-provider-init \
ksym-vanilla-icc-provider-register \
ksym-vanilla-icc-put \
ksym-vanilla-icc-set-bw \
ksym-vanilla-icc-set-tag \
ksym-vanilla-icc-std-aggregate \
ksym-vanilla-icc-sync-state \
ksym-vanilla-ice-add-rdma-qset \
ksym-vanilla-ice-alloc-rdma-qvector \
ksym-vanilla-ice-del-rdma-qset \
ksym-vanilla-ice-free-rdma-qvector \
ksym-vanilla-ice-rdma-request-reset \
ksym-vanilla-ice-rdma-update-vsi-filter \
ksym-vanilla-ice-xdp-locking-key \
ksym-vanilla-icmp-err-convert \
ksym-vanilla-icmp-ndo-send \
ksym-vanilla-icmp6-send \
ksym-vanilla-icmpv6-err-convert \
ksym-vanilla-icmpv6-ndo-send \
ksym-vanilla-icst-clk-register \
ksym-vanilla-icst-clk-setup \
ksym-vanilla-icst-hz \
ksym-vanilla-icst-hz-to-vco \
ksym-vanilla-icst307-idx2s \
ksym-vanilla-icst307-s2div \
ksym-vanilla-icst525-idx2s \
ksym-vanilla-icst525-s2div \
ksym-vanilla-ida-alloc-range \
ksym-vanilla-ida-destroy \
ksym-vanilla-ida-find-first-range \
ksym-vanilla-ida-free \
ksym-vanilla-idma-reg-addr-init \
ksym-vanilla-idma32-dma-probe \
ksym-vanilla-idma32-dma-remove \
ksym-vanilla-idpf-idc-rdma-vc-send-sync \
ksym-vanilla-idpf-idc-request-reset \
ksym-vanilla-idpf-idc-vport-dev-ctrl \
ksym-vanilla-idr-alloc \
ksym-vanilla-idr-alloc-cyclic \
ksym-vanilla-idr-alloc-u32 \
ksym-vanilla-idr-destroy \
ksym-vanilla-idr-find \
ksym-vanilla-idr-for-each \
ksym-vanilla-idr-get-next \
ksym-vanilla-idr-get-next-ul \
ksym-vanilla-idr-preload \
ksym-vanilla-idr-remove \
ksym-vanilla-idr-replace \
ksym-vanilla-ieee80211-alloc-hw-nm \
ksym-vanilla-ieee80211-amsdu-to-8023s \
ksym-vanilla-ieee80211-ap-probereq-get \
ksym-vanilla-ieee80211-ave-rssi \
ksym-vanilla-ieee80211-beacon-cntdwn-is-complete \
ksym-vanilla-ieee80211-beacon-free-ema-list \
ksym-vanilla-ieee80211-beacon-get-template \
ksym-vanilla-ieee80211-beacon-get-template-ema-index \
ksym-vanilla-ieee80211-beacon-get-template-ema-list \
ksym-vanilla-ieee80211-beacon-get-tim \
ksym-vanilla-ieee80211-beacon-loss \
ksym-vanilla-ieee80211-beacon-set-cntdwn \
ksym-vanilla-ieee80211-beacon-update-cntdwn \
ksym-vanilla-ieee80211-bss-get-elem \
ksym-vanilla-ieee80211-calc-rx-airtime \
ksym-vanilla-ieee80211-calc-tx-airtime \
ksym-vanilla-ieee80211-calculate-rx-timestamp \
ksym-vanilla-ieee80211-chandef-to-operating-class \
ksym-vanilla-ieee80211-channel-switch-disconnect \
ksym-vanilla-ieee80211-channel-to-freq-khz \
ksym-vanilla-ieee80211-chswitch-done \
ksym-vanilla-ieee80211-color-change-finish \
ksym-vanilla-ieee80211-connection-loss \
ksym-vanilla-ieee80211-cqm-beacon-loss-notify \
ksym-vanilla-ieee80211-cqm-rssi-notify \
ksym-vanilla-ieee80211-csa-finish \
ksym-vanilla-ieee80211-ctstoself-duration \
ksym-vanilla-ieee80211-ctstoself-get \
ksym-vanilla-ieee80211-data-to-8023-exthdr \
ksym-vanilla-ieee80211-disable-rssi-reports \
ksym-vanilla-ieee80211-disconnect \
ksym-vanilla-ieee80211-emulate-add-chanctx \
ksym-vanilla-ieee80211-emulate-change-chanctx \
ksym-vanilla-ieee80211-emulate-remove-chanctx \
ksym-vanilla-ieee80211-emulate-switch-vif-chanctx \
ksym-vanilla-ieee80211-enable-rssi-reports \
ksym-vanilla-ieee80211-encrypt-tx-skb \
ksym-vanilla-ieee80211-finalize-rx-omi-bw \
ksym-vanilla-ieee80211-find-sta \
ksym-vanilla-ieee80211-find-sta-by-ifaddr \
ksym-vanilla-ieee80211-find-sta-by-link-addrs \
ksym-vanilla-ieee80211-fragment-element \
ksym-vanilla-ieee80211-free-hw \
ksym-vanilla-ieee80211-free-txskb \
ksym-vanilla-ieee80211-freq-khz-to-channel \
ksym-vanilla-ieee80211-generic-frame-duration \
ksym-vanilla-ieee80211-get-8023-tunnel-proto \
ksym-vanilla-ieee80211-get-buffered-bc \
ksym-vanilla-ieee80211-get-channel-khz \
ksym-vanilla-ieee80211-get-fils-discovery-tmpl \
ksym-vanilla-ieee80211-get-hdrlen-from-skb \
ksym-vanilla-ieee80211-get-key-rx-seq \
ksym-vanilla-ieee80211-get-mesh-hdrlen \
ksym-vanilla-ieee80211-get-num-supported-channels \
ksym-vanilla-ieee80211-get-response-rate \
ksym-vanilla-ieee80211-get-tkip-p1k-iv \
ksym-vanilla-ieee80211-get-tkip-p2k \
ksym-vanilla-ieee80211-get-tkip-rx-p1k \
ksym-vanilla-ieee80211-get-tx-rates \
ksym-vanilla-ieee80211-get-unsol-bcast-probe-resp-tmpl \
ksym-vanilla-ieee80211-get-vht-max-nss \
ksym-vanilla-ieee80211-gtk-rekey-add \
ksym-vanilla-ieee80211-gtk-rekey-notify \
ksym-vanilla-ieee80211-handle-wake-tx-queue \
ksym-vanilla-ieee80211-hdrlen \
ksym-vanilla-ieee80211-hw-restart-disconnect \
ksym-vanilla-ieee80211-ie-split-ric \
ksym-vanilla-ieee80211-is-valid-amsdu \
ksym-vanilla-ieee80211-iter-chan-contexts-atomic \
ksym-vanilla-ieee80211-iter-chan-contexts-mtx \
ksym-vanilla-ieee80211-iter-keys \
ksym-vanilla-ieee80211-iter-keys-rcu \
ksym-vanilla-ieee80211-iterate-active-interfaces-atomic \
ksym-vanilla-ieee80211-iterate-interfaces \
ksym-vanilla-ieee80211-iterate-stations-atomic \
ksym-vanilla-ieee80211-key-mic-failure \
ksym-vanilla-ieee80211-key-replay \
ksym-vanilla-ieee80211-manage-rx-ba-offl \
ksym-vanilla-ieee80211-mandatory-rates \
ksym-vanilla-ieee80211-mark-rx-ba-filtered-frames \
ksym-vanilla-ieee80211-nan-cluster-joined \
ksym-vanilla-ieee80211-nan-func-match \
ksym-vanilla-ieee80211-nan-func-terminated \
ksym-vanilla-ieee80211-nan-sched-update-done \
ksym-vanilla-ieee80211-nan-try-evacuate \
ksym-vanilla-ieee80211-next-txq \
ksym-vanilla-ieee80211-nullfunc-get \
ksym-vanilla-ieee80211-obss-color-collision-notify \
ksym-vanilla-ieee80211-operating-class-to-band \
ksym-vanilla-ieee80211-operating-class-to-chandef \
ksym-vanilla-ieee80211-parse-p2p-noa \
ksym-vanilla-ieee80211-prepare-rx-omi-bw \
ksym-vanilla-ieee80211-probereq-get \
ksym-vanilla-ieee80211-proberesp-get \
ksym-vanilla-ieee80211-pspoll-get \
ksym-vanilla-ieee80211-purge-tx-queue \
ksym-vanilla-ieee80211-queue-delayed-work \
ksym-vanilla-ieee80211-queue-stopped \
ksym-vanilla-ieee80211-queue-work \
ksym-vanilla-ieee80211-radar-detected \
ksym-vanilla-ieee80211-radio-freq-range-valid \
ksym-vanilla-ieee80211-radiotap-iterator-init \
ksym-vanilla-ieee80211-radiotap-iterator-next \
ksym-vanilla-ieee80211-rate-control-register \
ksym-vanilla-ieee80211-rate-control-unregister \
ksym-vanilla-ieee80211-ready-on-channel \
ksym-vanilla-ieee80211-refresh-tx-agg-session-timer \
ksym-vanilla-ieee80211-register-hw \
ksym-vanilla-ieee80211-remain-on-channel-expired \
ksym-vanilla-ieee80211-report-low-ack \
ksym-vanilla-ieee80211-report-wowlan-wakeup \
ksym-vanilla-ieee80211-request-smps \
ksym-vanilla-ieee80211-reserve-tid \
ksym-vanilla-ieee80211-restart-hw \
ksym-vanilla-ieee80211-resume-disconnect \
ksym-vanilla-ieee80211-rts-duration \
ksym-vanilla-ieee80211-rts-get \
ksym-vanilla-ieee80211-rx-ba-timer-expired \
ksym-vanilla-ieee80211-rx-irqsafe \
ksym-vanilla-ieee80211-rx-list \
ksym-vanilla-ieee80211-rx-napi \
ksym-vanilla-ieee80211-scan-completed \
ksym-vanilla-ieee80211-sched-scan-results \
ksym-vanilla-ieee80211-sched-scan-stopped \
ksym-vanilla-ieee80211-send-bar \
ksym-vanilla-ieee80211-send-eosp-nullfunc \
ksym-vanilla-ieee80211-send-teardown-neg-ttlm \
ksym-vanilla-ieee80211-set-active-links \
ksym-vanilla-ieee80211-set-active-links-async \
ksym-vanilla-ieee80211-set-key-rx-seq \
ksym-vanilla-ieee80211-sta-block-awake \
ksym-vanilla-ieee80211-sta-eosp \
ksym-vanilla-ieee80211-sta-ps-transition \
ksym-vanilla-ieee80211-sta-pspoll \
ksym-vanilla-ieee80211-sta-recalc-aggregates \
ksym-vanilla-ieee80211-sta-register-airtime \
ksym-vanilla-ieee80211-sta-set-buffered \
ksym-vanilla-ieee80211-sta-uapsd-trigger \
ksym-vanilla-ieee80211-start-tx-ba-cb-irqsafe \
ksym-vanilla-ieee80211-start-tx-ba-session \
ksym-vanilla-ieee80211-stop-queue \
ksym-vanilla-ieee80211-stop-queues \
ksym-vanilla-ieee80211-stop-rx-ba-session \
ksym-vanilla-ieee80211-stop-tx-ba-cb-irqsafe \
ksym-vanilla-ieee80211-stop-tx-ba-session \
ksym-vanilla-ieee80211-strip-8023-mesh-hdr \
ksym-vanilla-ieee80211-tdls-oper-request \
ksym-vanilla-ieee80211-tkip-add-iv \
ksym-vanilla-ieee80211-tx-dequeue \
ksym-vanilla-ieee80211-tx-prepare-skb \
ksym-vanilla-ieee80211-tx-rate-update \
ksym-vanilla-ieee80211-tx-status-ext \
ksym-vanilla-ieee80211-tx-status-irqsafe \
ksym-vanilla-ieee80211-tx-status-skb \
ksym-vanilla-ieee80211-txq-airtime-check \
ksym-vanilla-ieee80211-txq-get-depth \
ksym-vanilla-ieee80211-txq-may-transmit \
ksym-vanilla-ieee80211-txq-schedule-start \
ksym-vanilla-ieee80211-unregister-hw \
ksym-vanilla-ieee80211-unreserve-tid \
ksym-vanilla-ieee80211-update-mu-groups \
ksym-vanilla-ieee80211-update-p2p-noa \
ksym-vanilla-ieee80211-vif-nan-started \
ksym-vanilla-ieee80211-vif-to-wdev \
ksym-vanilla-ieee80211-wake-queue \
ksym-vanilla-ieee80211-wake-queues \
ksym-vanilla-ieee802154-alloc-hw \
ksym-vanilla-ieee802154-beacon-push \
ksym-vanilla-ieee802154-configure-durations \
ksym-vanilla-ieee802154-free-hw \
ksym-vanilla-ieee802154-hdr-peek \
ksym-vanilla-ieee802154-hdr-peek-addrs \
ksym-vanilla-ieee802154-hdr-pull \
ksym-vanilla-ieee802154-hdr-push \
ksym-vanilla-ieee802154-mac-cmd-pl-pull \
ksym-vanilla-ieee802154-mac-cmd-push \
ksym-vanilla-ieee802154-max-payload \
ksym-vanilla-ieee802154-register-hw \
ksym-vanilla-ieee802154-rx-irqsafe \
ksym-vanilla-ieee802154-unregister-hw \
ksym-vanilla-ieee802154-xmit-complete \
ksym-vanilla-ieee802154-xmit-error \
ksym-vanilla-ieee802154-xmit-hw-error \
ksym-vanilla-ieee8021q-tt-to-tc \
ksym-vanilla-ietf-dscp-to-ieee8021q-tt \
ksym-vanilla-ife-alloc-meta-u16 \
ksym-vanilla-ife-alloc-meta-u32 \
ksym-vanilla-ife-check-meta-u16 \
ksym-vanilla-ife-check-meta-u32 \
ksym-vanilla-ife-decode \
ksym-vanilla-ife-encode \
ksym-vanilla-ife-encode-meta-u16 \
ksym-vanilla-ife-encode-meta-u32 \
ksym-vanilla-ife-get-meta-u16 \
ksym-vanilla-ife-get-meta-u32 \
ksym-vanilla-ife-release-meta-gen \
ksym-vanilla-ife-tlv-meta-decode \
ksym-vanilla-ife-tlv-meta-encode \
ksym-vanilla-ife-tlv-meta-next \
ksym-vanilla-ife-validate-meta-u16 \
ksym-vanilla-ife-validate-meta-u32 \
ksym-vanilla-iforce-init-device \
ksym-vanilla-iforce-process-packet \
ksym-vanilla-iforce-send-packet \
ksym-vanilla-iget-failed \
ksym-vanilla-iget-locked \
ksym-vanilla-iget5-locked \
ksym-vanilla-iget5-locked-rcu \
ksym-vanilla-ignore-console-lock-warning \
ksym-vanilla-igrab \
ksym-vanilla-ihold \
ksym-vanilla-iio-active-scan-mask-index \
ksym-vanilla-iio-alloc-pollfunc \
ksym-vanilla-iio-backend-chan-disable \
ksym-vanilla-iio-backend-chan-enable \
ksym-vanilla-iio-backend-chan-status \
ksym-vanilla-iio-backend-data-format-set \
ksym-vanilla-iio-backend-data-sample-trigger \
ksym-vanilla-iio-backend-data-size-set \
ksym-vanilla-iio-backend-data-source-get \
ksym-vanilla-iio-backend-data-source-set \
ksym-vanilla-iio-backend-data-stream-disable \
ksym-vanilla-iio-backend-data-stream-enable \
ksym-vanilla-iio-backend-data-transfer-addr \
ksym-vanilla-iio-backend-ddr-disable \
ksym-vanilla-iio-backend-ddr-enable \
ksym-vanilla-iio-backend-debugfs-add \
ksym-vanilla-iio-backend-debugfs-print-chan-status \
ksym-vanilla-iio-backend-disable \
ksym-vanilla-iio-backend-enable \
ksym-vanilla-iio-backend-ext-info-get \
ksym-vanilla-iio-backend-ext-info-set \
ksym-vanilla-iio-backend-extend-chan-spec \
ksym-vanilla-iio-backend-filter-type-set \
ksym-vanilla-iio-backend-get-priv \
ksym-vanilla-iio-backend-has-caps \
ksym-vanilla-iio-backend-interface-data-align \
ksym-vanilla-iio-backend-interface-type-get \
ksym-vanilla-iio-backend-iodelay-set \
ksym-vanilla-iio-backend-num-lanes-set \
ksym-vanilla-iio-backend-oversampling-ratio-set \
ksym-vanilla-iio-backend-read-raw \
ksym-vanilla-iio-backend-set-sampling-freq \
ksym-vanilla-iio-backend-test-pattern-set \
ksym-vanilla-iio-buffer-enabled \
ksym-vanilla-iio-buffer-get \
ksym-vanilla-iio-buffer-init \
ksym-vanilla-iio-buffer-put \
ksym-vanilla-iio-buffer-signal-dmabuf-done \
ksym-vanilla-iio-bus-type \
ksym-vanilla-iio-channel-cb-get-channels \
ksym-vanilla-iio-channel-cb-get-iio-dev \
ksym-vanilla-iio-channel-cb-set-buffer-watermark \
ksym-vanilla-iio-channel-get \
ksym-vanilla-iio-channel-get-all \
ksym-vanilla-iio-channel-get-all-cb \
ksym-vanilla-iio-channel-release \
ksym-vanilla-iio-channel-release-all \
ksym-vanilla-iio-channel-release-all-cb \
ksym-vanilla-iio-channel-start-all-cb \
ksym-vanilla-iio-channel-stop-all-cb \
ksym-vanilla-iio-configfs-subsys \
ksym-vanilla-iio-convert-raw-to-processed \
ksym-vanilla-iio-dealloc-pollfunc \
ksym-vanilla-iio-device-alloc \
ksym-vanilla-iio-device-attach-buffer \
ksym-vanilla-iio-device-free \
ksym-vanilla-iio-device-get-clock \
ksym-vanilla-iio-device-get-current-mode \
ksym-vanilla-iio-device-id \
ksym-vanilla-iio-device-resume-triggering \
ksym-vanilla-iio-device-set-clock \
ksym-vanilla-iio-device-suspend-triggering \
ksym-vanilla-iio-device-unregister \
ksym-vanilla-iio-dma-buffer-attach-dmabuf \
ksym-vanilla-iio-dma-buffer-block-done \
ksym-vanilla-iio-dma-buffer-block-list-abort \
ksym-vanilla-iio-dma-buffer-detach-dmabuf \
ksym-vanilla-iio-dma-buffer-disable \
ksym-vanilla-iio-dma-buffer-enable \
ksym-vanilla-iio-dma-buffer-enqueue-dmabuf \
ksym-vanilla-iio-dma-buffer-exit \
ksym-vanilla-iio-dma-buffer-get-dma-dev \
ksym-vanilla-iio-dma-buffer-init \
ksym-vanilla-iio-dma-buffer-lock-queue \
ksym-vanilla-iio-dma-buffer-read \
ksym-vanilla-iio-dma-buffer-release \
ksym-vanilla-iio-dma-buffer-request-update \
ksym-vanilla-iio-dma-buffer-set-bytes-per-datum \
ksym-vanilla-iio-dma-buffer-set-length \
ksym-vanilla-iio-dma-buffer-unlock-queue \
ksym-vanilla-iio-dma-buffer-usage \
ksym-vanilla-iio-dma-buffer-write \
ksym-vanilla-iio-dmaengine-buffer-setup-ext \
ksym-vanilla-iio-dmaengine-buffer-teardown \
ksym-vanilla-iio-enum-available-read \
ksym-vanilla-iio-enum-read \
ksym-vanilla-iio-enum-write \
ksym-vanilla-iio-find-closest-gain-low \
ksym-vanilla-iio-format-value \
ksym-vanilla-iio-get-acpi-device-name-and-data \
ksym-vanilla-iio-get-channel-ext-info-count \
ksym-vanilla-iio-get-channel-type \
ksym-vanilla-iio-get-debugfs-dentry \
ksym-vanilla-iio-get-time-ns \
ksym-vanilla-iio-gts-all-avail-scales \
ksym-vanilla-iio-gts-avail-scales-for-time \
ksym-vanilla-iio-gts-avail-times \
ksym-vanilla-iio-gts-find-gain-by-sel \
ksym-vanilla-iio-gts-find-gain-sel-for-scale-using-time \
ksym-vanilla-iio-gts-find-gain-time-sel-for-scale \
ksym-vanilla-iio-gts-find-new-gain-by-gain-time-min \
ksym-vanilla-iio-gts-find-new-gain-by-old-gain-time \
ksym-vanilla-iio-gts-find-new-gain-sel-by-old-gain-time \
ksym-vanilla-iio-gts-find-sel-by-gain \
ksym-vanilla-iio-gts-get-min-gain \
ksym-vanilla-iio-gts-get-scale \
ksym-vanilla-iio-gts-get-total-gain \
ksym-vanilla-iio-gts-total-gain-to-scale \
ksym-vanilla-iio-hw-consumer-alloc \
ksym-vanilla-iio-hw-consumer-disable \
ksym-vanilla-iio-hw-consumer-enable \
ksym-vanilla-iio-hw-consumer-free \
ksym-vanilla-iio-kfifo-allocate \
ksym-vanilla-iio-kfifo-free \
ksym-vanilla-iio-map-array-register \
ksym-vanilla-iio-map-array-unregister \
ksym-vanilla-iio-multiply-value \
ksym-vanilla-iio-pollfunc-store-time \
ksym-vanilla-iio-pop-from-buffer \
ksym-vanilla-iio-push-event \
ksym-vanilla-iio-push-to-buffers \
ksym-vanilla-iio-push-to-buffers-with-ts-unaligned \
ksym-vanilla-iio-read-acpi-mount-matrix \
ksym-vanilla-iio-read-avail-channel-attribute \
ksym-vanilla-iio-read-avail-channel-raw \
ksym-vanilla-iio-read-channel-attribute \
ksym-vanilla-iio-read-channel-average-raw \
ksym-vanilla-iio-read-channel-ext-info \
ksym-vanilla-iio-read-channel-label \
ksym-vanilla-iio-read-channel-offset \
ksym-vanilla-iio-read-channel-processed \
ksym-vanilla-iio-read-channel-processed-scale \
ksym-vanilla-iio-read-channel-raw \
ksym-vanilla-iio-read-channel-scale \
ksym-vanilla-iio-read-const-attr \
ksym-vanilla-iio-read-max-channel-raw \
ksym-vanilla-iio-read-min-channel-raw \
ksym-vanilla-iio-read-mount-matrix \
ksym-vanilla-iio-register-sw-device-type \
ksym-vanilla-iio-register-sw-trigger-type \
ksym-vanilla-iio-show-mount-matrix \
ksym-vanilla-iio-str-to-fixpoint \
ksym-vanilla-iio-sw-device-create \
ksym-vanilla-iio-sw-device-destroy \
ksym-vanilla-iio-sw-trigger-create \
ksym-vanilla-iio-sw-trigger-destroy \
ksym-vanilla-iio-trigger-free \
ksym-vanilla-iio-trigger-generic-data-rdy-poll \
ksym-vanilla-iio-trigger-notify-done \
ksym-vanilla-iio-trigger-poll \
ksym-vanilla-iio-trigger-poll-nested \
ksym-vanilla-iio-trigger-register \
ksym-vanilla-iio-trigger-set-immutable \
ksym-vanilla-iio-trigger-unregister \
ksym-vanilla-iio-trigger-using-own \
ksym-vanilla-iio-trigger-validate-own-device \
ksym-vanilla-iio-triggered-buffer-cleanup \
ksym-vanilla-iio-triggered-buffer-setup-ext \
ksym-vanilla-iio-triggered-event-cleanup \
ksym-vanilla-iio-triggered-event-setup \
ksym-vanilla-iio-unregister-sw-device-type \
ksym-vanilla-iio-unregister-sw-trigger-type \
ksym-vanilla-iio-update-buffers \
ksym-vanilla-iio-validate-own-trigger \
ksym-vanilla-iio-validate-scan-mask-onehot \
ksym-vanilla-iio-write-channel-attribute \
ksym-vanilla-iio-write-channel-ext-info \
ksym-vanilla-iio-write-channel-raw \
ksym-vanilla-il-add-beacon-time \
ksym-vanilla-il-add-station-common \
ksym-vanilla-il-alloc-txq-mem \
ksym-vanilla-il-apm-init \
ksym-vanilla-il-apm-stop \
ksym-vanilla-il-bcast-addr \
ksym-vanilla-il-bg-watchdog \
ksym-vanilla-il-cancel-scan-deferred-work \
ksym-vanilla-il-check-rxon-cmd \
ksym-vanilla-il-chswitch-done \
ksym-vanilla-il-clear-bit \
ksym-vanilla-il-clear-ucode-stations \
ksym-vanilla-il-cmd-queue-free \
ksym-vanilla-il-cmd-queue-unmap \
ksym-vanilla-il-connection-init-rx-config \
ksym-vanilla-il-dealloc-bcast-stations \
ksym-vanilla-il-debug-level \
ksym-vanilla-il-eeprom-free \
ksym-vanilla-il-eeprom-init \
ksym-vanilla-il-eeprom-query-addr \
ksym-vanilla-il-eeprom-query16 \
ksym-vanilla-il-fill-probe-req \
ksym-vanilla-il-force-reset \
ksym-vanilla-il-free-channel-map \
ksym-vanilla-il-free-geos \
ksym-vanilla-il-free-txq-mem \
ksym-vanilla-il-full-rxon-required \
ksym-vanilla-il-get-active-dwell-time \
ksym-vanilla-il-get-channel-info \
ksym-vanilla-il-get-cmd-string \
ksym-vanilla-il-get-free-ucode-key-idx \
ksym-vanilla-il-get-lowest-plcp \
ksym-vanilla-il-get-passive-dwell-time \
ksym-vanilla-il-hdl-csa \
ksym-vanilla-il-hdl-error \
ksym-vanilla-il-hdl-pm-debug-stats \
ksym-vanilla-il-hdl-pm-sleep \
ksym-vanilla-il-hdl-spectrum-measurement \
ksym-vanilla-il-init-channel-map \
ksym-vanilla-il-init-geos \
ksym-vanilla-il-init-scan-params \
ksym-vanilla-il-irq-handle-error \
ksym-vanilla-il-is-ht40-tx-allowed \
ksym-vanilla-il-isr \
ksym-vanilla-il-leds-exit \
ksym-vanilla-il-leds-init \
ksym-vanilla-il-mac-add-interface \
ksym-vanilla-il-mac-bss-info-changed \
ksym-vanilla-il-mac-change-interface \
ksym-vanilla-il-mac-conf-tx \
ksym-vanilla-il-mac-config \
ksym-vanilla-il-mac-flush \
ksym-vanilla-il-mac-hw-scan \
ksym-vanilla-il-mac-remove-interface \
ksym-vanilla-il-mac-reset-tsf \
ksym-vanilla-il-mac-sta-remove \
ksym-vanilla-il-mac-tx-last-beacon \
ksym-vanilla-il-pm-ops \
ksym-vanilla-il-poll-bit \
ksym-vanilla-il-power-initialize \
ksym-vanilla-il-power-update-mode \
ksym-vanilla-il-prep-station \
ksym-vanilla-il-queue-space \
ksym-vanilla-il-rd-prph \
ksym-vanilla-il-read-targ-mem \
ksym-vanilla-il-remove-station \
ksym-vanilla-il-restore-stations \
ksym-vanilla-il-rx-queue-alloc \
ksym-vanilla-il-rx-queue-space \
ksym-vanilla-il-rx-queue-update-write-ptr \
ksym-vanilla-il-scan-cancel \
ksym-vanilla-il-scan-cancel-timeout \
ksym-vanilla-il-send-add-sta \
ksym-vanilla-il-send-bt-config \
ksym-vanilla-il-send-cmd \
ksym-vanilla-il-send-cmd-pdu \
ksym-vanilla-il-send-cmd-pdu-async \
ksym-vanilla-il-send-cmd-sync \
ksym-vanilla-il-send-lq-cmd \
ksym-vanilla-il-send-rxon-timing \
ksym-vanilla-il-send-stats-request \
ksym-vanilla-il-set-bit \
ksym-vanilla-il-set-decrypted-flag \
ksym-vanilla-il-set-flags-for-band \
ksym-vanilla-il-set-rate \
ksym-vanilla-il-set-rxon-channel \
ksym-vanilla-il-set-rxon-ht \
ksym-vanilla-il-set-rxon-hwcrypto \
ksym-vanilla-il-set-tx-power \
ksym-vanilla-il-setup-rx-scan-handlers \
ksym-vanilla-il-setup-scan-deferred-work \
ksym-vanilla-il-setup-watchdog \
ksym-vanilla-il-tx-cmd-complete \
ksym-vanilla-il-tx-cmd-protection \
ksym-vanilla-il-tx-queue-free \
ksym-vanilla-il-tx-queue-init \
ksym-vanilla-il-tx-queue-reset \
ksym-vanilla-il-tx-queue-unmap \
ksym-vanilla-il-txq-update-write-ptr \
ksym-vanilla-il-usecs-to-beacons \
ksym-vanilla-il-wr-prph \
ksym-vanilla-il-write-targ-mem \
ksym-vanilla-ilookup \
ksym-vanilla-ilookup5 \
ksym-vanilla-ilookup5-nowait \
ksym-vanilla-ima-file-hash \
ksym-vanilla-ima-inode-hash \
ksym-vanilla-ima-measure-critical-data \
ksym-vanilla-import-iovec \
ksym-vanilla-import-ubuf \
ksym-vanilla-imx-1416x-pll \
ksym-vanilla-imx-1443x-dram-pll \
ksym-vanilla-imx-1443x-pll \
ksym-vanilla-imx-audmux-v1-configure-port \
ksym-vanilla-imx-audmux-v2-configure-port \
ksym-vanilla-imx-ccm-lock \
ksym-vanilla-imx-check-clk-hws \
ksym-vanilla-imx-clk-fracn-gppll \
ksym-vanilla-imx-clk-fracn-gppll-integer \
ksym-vanilla-imx-clk-hw-cpu \
ksym-vanilla-imx-clk-hw-frac-pll \
ksym-vanilla-imx-clk-hw-pfd \
ksym-vanilla-imx-clk-hw-pfdv2 \
ksym-vanilla-imx-clk-hw-pllv3 \
ksym-vanilla-imx-clk-hw-pllv4 \
ksym-vanilla-imx-clk-hw-sscg-pll \
ksym-vanilla-imx-dev-clk-hw-pll14xx \
ksym-vanilla-imx-dsp-free-channel \
ksym-vanilla-imx-dsp-request-channel \
ksym-vanilla-imx-dsp-ring-doorbell \
ksym-vanilla-imx-fracn-gppll \
ksym-vanilla-imx-fracn-gppll-integer \
ksym-vanilla-imx-get-clk-hw-by-name \
ksym-vanilla-imx-icc-register \
ksym-vanilla-imx-icc-unregister \
ksym-vanilla-imx-pcm-dma-init \
ksym-vanilla-imx-pinconf-get-scu \
ksym-vanilla-imx-pinconf-set-scu \
ksym-vanilla-imx-pinctrl-parse-pin-scu \
ksym-vanilla-imx-pinctrl-pm-ops \
ksym-vanilla-imx-pinctrl-probe \
ksym-vanilla-imx-pinctrl-sc-ipc-init \
ksym-vanilla-imx-sc-misc-get-control \
ksym-vanilla-imx-sc-misc-set-control \
ksym-vanilla-imx-sc-pm-cpu-start \
ksym-vanilla-imx-sc-rm-get-resource-owner \
ksym-vanilla-imx-sc-rm-is-resource-owned \
ksym-vanilla-imx-scu-call-rpc \
ksym-vanilla-imx-scu-get-handle \
ksym-vanilla-imx-scu-irq-get-status \
ksym-vanilla-imx-scu-irq-group-enable \
ksym-vanilla-imx-scu-irq-register-notifier \
ksym-vanilla-imx-scu-irq-unregister-notifier \
ksym-vanilla-imx-unregister-hw-clocks \
ksym-vanilla-imx-usbmisc-charger-detection \
ksym-vanilla-imx-usbmisc-hsic-set-connect \
ksym-vanilla-imx-usbmisc-init \
ksym-vanilla-imx-usbmisc-init-post \
ksym-vanilla-imx-usbmisc-pullup \
ksym-vanilla-imx-usbmisc-resume \
ksym-vanilla-imx-usbmisc-suspend \
ksym-vanilla-imx8-dump \
ksym-vanilla-imx8ulp-clk-hw-composite \
ksym-vanilla-imx93-clk-composite-flags \
ksym-vanilla-imx93-clk-gate \
ksym-vanilla-in-aton \
ksym-vanilla-in-dev-finish-destroy \
ksym-vanilla-in-egroup-p \
ksym-vanilla-in-group-or-capable \
ksym-vanilla-in-group-p \
ksym-vanilla-in-lock-functions \
ksym-vanilla-in4-pton \
ksym-vanilla-in6-dev-finish-destroy \
ksym-vanilla-in6-pton \
ksym-vanilla-in6addr-any \
ksym-vanilla-in6addr-linklocal-allnodes \
ksym-vanilla-in6addr-loopback \
ksym-vanilla-inc-nlink \
ksym-vanilla-inc-node-page-state \
ksym-vanilla-inc-zone-page-state \
ksym-vanilla-inet-accept \
ksym-vanilla-inet-add-offload \
ksym-vanilla-inet-add-protocol \
ksym-vanilla-inet-addr-is-any \
ksym-vanilla-inet-addr-type \
ksym-vanilla-inet-addr-type-dev-table \
ksym-vanilla-inet-addr-type-table \
ksym-vanilla-inet-bind \
ksym-vanilla-inet-confirm-addr \
ksym-vanilla-inet-csk-get-port \
ksym-vanilla-inet-ctl-sock-create \
ksym-vanilla-inet-del-offload \
ksym-vanilla-inet-del-protocol \
ksym-vanilla-inet-dev-addr-type \
ksym-vanilla-inet-dgram-connect \
ksym-vanilla-inet-dgram-ops \
ksym-vanilla-inet-diag-bc-sk \
ksym-vanilla-inet-diag-msg-attrs-fill \
ksym-vanilla-inet-diag-msg-common-fill \
ksym-vanilla-inet-diag-register \
ksym-vanilla-inet-diag-unregister \
ksym-vanilla-inet-ehashfn \
ksym-vanilla-inet-frag-destroy \
ksym-vanilla-inet-frag-find \
ksym-vanilla-inet-frag-kill \
ksym-vanilla-inet-frag-pull-head \
ksym-vanilla-inet-frag-queue-flush \
ksym-vanilla-inet-frag-queue-insert \
ksym-vanilla-inet-frag-reasm-finish \
ksym-vanilla-inet-frag-reasm-prepare \
ksym-vanilla-inet-frags-fini \
ksym-vanilla-inet-frags-init \
ksym-vanilla-inet-getname \
ksym-vanilla-inet-ioctl \
ksym-vanilla-inet-listen \
ksym-vanilla-inet-lookup-reuseport \
ksym-vanilla-inet-offloads \
ksym-vanilla-inet-proto-csum-replace-by-diff \
ksym-vanilla-inet-proto-csum-replace16 \
ksym-vanilla-inet-proto-csum-replace4 \
ksym-vanilla-inet-protos \
ksym-vanilla-inet-pton-with-scope \
ksym-vanilla-inet-recv-error \
ksym-vanilla-inet-recvmsg \
ksym-vanilla-inet-register-protosw \
ksym-vanilla-inet-release \
ksym-vanilla-inet-select-addr \
ksym-vanilla-inet-sendmsg \
ksym-vanilla-inet-shutdown \
ksym-vanilla-inet-sk-diag-fill \
ksym-vanilla-inet-sk-get-local-port-range \
ksym-vanilla-inet-sk-set-state \
ksym-vanilla-inet-sock-destruct \
ksym-vanilla-inet-stream-connect \
ksym-vanilla-inet-stream-ops \
ksym-vanilla-inet-twsk-deschedule-put \
ksym-vanilla-inet-twsk-put \
ksym-vanilla-inet-unregister-protosw \
ksym-vanilla-inet6-add-offload \
ksym-vanilla-inet6-add-protocol \
ksym-vanilla-inet6-bind \
ksym-vanilla-inet6-compat-ioctl \
ksym-vanilla-inet6-csk-xmit \
ksym-vanilla-inet6-del-offload \
ksym-vanilla-inet6-del-protocol \
ksym-vanilla-inet6-ehashfn \
ksym-vanilla-inet6-getname \
ksym-vanilla-inet6-hash-connect \
ksym-vanilla-inet6-ioctl \
ksym-vanilla-inet6-lookup \
ksym-vanilla-inet6-lookup-listener \
ksym-vanilla-inet6-lookup-reuseport \
ksym-vanilla-inet6-lookup-run-sk-lookup \
ksym-vanilla-inet6-offloads \
ksym-vanilla-inet6-protos \
ksym-vanilla-inet6-register-protosw \
ksym-vanilla-inet6-release \
ksym-vanilla-inet6-sock-destruct \
ksym-vanilla-inet6-stream-ops \
ksym-vanilla-inet6-unregister-protosw \
ksym-vanilla-inetdev-by-index \
ksym-vanilla-init-binfmt-misc \
ksym-vanilla-init-cdrom-command \
ksym-vanilla-init-dma-pools \
ksym-vanilla-init-iova-domain \
ksym-vanilla-init-net \
ksym-vanilla-init-node-memory-type \
ksym-vanilla-init-on-alloc \
ksym-vanilla-init-on-free \
ksym-vanilla-init-opal-dev \
ksym-vanilla-init-pid-ns \
ksym-vanilla-init-pseudo \
ksym-vanilla-init-rs-gfp \
ksym-vanilla-init-rs-non-canonical \
ksym-vanilla-init-special-inode \
ksym-vanilla-init-srcu-struct \
ksym-vanilla-init-srcu-struct-fast \
ksym-vanilla-init-srcu-struct-fast-updown \
ksym-vanilla-init-task \
ksym-vanilla-init-time-ns \
ksym-vanilla-init-user-ns \
ksym-vanilla-init-uts-ns \
ksym-vanilla-init-wait-entry \
ksym-vanilla-init-wait-var-entry \
ksym-vanilla-inno-hdmi-bind \
ksym-vanilla-inode-add-bytes \
ksym-vanilla-inode-bit-waitqueue \
ksym-vanilla-inode-dax \
ksym-vanilla-inode-dio-finished \
ksym-vanilla-inode-dio-wait \
ksym-vanilla-inode-dio-wait-interruptible \
ksym-vanilla-inode-get-bytes \
ksym-vanilla-inode-init-always-gfp \
ksym-vanilla-inode-init-once \
ksym-vanilla-inode-init-owner \
ksym-vanilla-inode-insert5 \
ksym-vanilla-inode-io-list-del \
ksym-vanilla-inode-just-drop \
ksym-vanilla-inode-lease-ignore-mask \
ksym-vanilla-inode-maybe-inc-iversion \
ksym-vanilla-inode-needs-sync \
ksym-vanilla-inode-newsize-ok \
ksym-vanilla-inode-nohighmem \
ksym-vanilla-inode-owner-or-capable \
ksym-vanilla-inode-permission \
ksym-vanilla-inode-query-iversion \
ksym-vanilla-inode-sb-list-add \
ksym-vanilla-inode-set-bytes \
ksym-vanilla-inode-set-ctime-current \
ksym-vanilla-inode-set-ctime-deleg \
ksym-vanilla-inode-set-ctime-to-ts \
ksym-vanilla-inode-set-flags \
ksym-vanilla-inode-sub-bytes \
ksym-vanilla-inode-to-bdi \
ksym-vanilla-inode-update-time \
ksym-vanilla-input-alloc-absinfo \
ksym-vanilla-input-allocate-device \
ksym-vanilla-input-class \
ksym-vanilla-input-close-device \
ksym-vanilla-input-copy-abs \
ksym-vanilla-input-default-setkeycode \
ksym-vanilla-input-device-enabled \
ksym-vanilla-input-enable-softrepeat \
ksym-vanilla-input-event \
ksym-vanilla-input-event-from-user \
ksym-vanilla-input-event-to-user \
ksym-vanilla-input-ff-create \
ksym-vanilla-input-ff-create-memless \
ksym-vanilla-input-ff-destroy \
ksym-vanilla-input-ff-effect-from-user \
ksym-vanilla-input-ff-erase \
ksym-vanilla-input-ff-event \
ksym-vanilla-input-ff-flush \
ksym-vanilla-input-ff-upload \
ksym-vanilla-input-flush-device \
ksym-vanilla-input-free-device \
ksym-vanilla-input-free-minor \
ksym-vanilla-input-get-keycode \
ksym-vanilla-input-get-new-minor \
ksym-vanilla-input-get-poll-interval \
ksym-vanilla-input-get-timestamp \
ksym-vanilla-input-grab-device \
ksym-vanilla-input-handler-for-each-handle \
ksym-vanilla-input-inject-event \
ksym-vanilla-input-match-device-id \
ksym-vanilla-input-mt-assign-slots \
ksym-vanilla-input-mt-destroy-slots \
ksym-vanilla-input-mt-drop-unused \
ksym-vanilla-input-mt-get-slot-by-key \
ksym-vanilla-input-mt-init-slots \
ksym-vanilla-input-mt-report-finger-count \
ksym-vanilla-input-mt-report-pointer-emulation \
ksym-vanilla-input-mt-report-slot-state \
ksym-vanilla-input-mt-sync-frame \
ksym-vanilla-input-open-device \
ksym-vanilla-input-register-device \
ksym-vanilla-input-register-handle \
ksym-vanilla-input-register-handler \
ksym-vanilla-input-release-device \
ksym-vanilla-input-reset-device \
ksym-vanilla-input-scancode-to-scalar \
ksym-vanilla-input-set-abs-params \
ksym-vanilla-input-set-capability \
ksym-vanilla-input-set-keycode \
ksym-vanilla-input-set-max-poll-interval \
ksym-vanilla-input-set-min-poll-interval \
ksym-vanilla-input-set-poll-interval \
ksym-vanilla-input-set-timestamp \
ksym-vanilla-input-setup-polling \
ksym-vanilla-input-unregister-device \
ksym-vanilla-input-unregister-handle \
ksym-vanilla-input-unregister-handler \
ksym-vanilla-insert-inode-locked \
ksym-vanilla-insert-inode-locked4 \
ksym-vanilla-insert-resource \
ksym-vanilla-insert-resource-expand-to-fit \
ksym-vanilla-int-active-memcg \
ksym-vanilla-int-pow \
ksym-vanilla-int-sqrt \
ksym-vanilla-int-to-scsilun \
ksym-vanilla-intel-nhlt-free \
ksym-vanilla-intel-nhlt-get-dmic-geo \
ksym-vanilla-intel-nhlt-get-endpoint-blob \
ksym-vanilla-intel-nhlt-has-endpoint-type \
ksym-vanilla-intel-nhlt-init \
ksym-vanilla-intel-nhlt-ssp-device-type \
ksym-vanilla-intel-nhlt-ssp-endpoint-mask \
ksym-vanilla-intel-nhlt-ssp-mclk-mask \
ksym-vanilla-intel-pmic-install-opregion-handler \
ksym-vanilla-intel-soc-pmic-exec-mipi-pmic-seq-element \
ksym-vanilla-interval-tree-insert \
ksym-vanilla-interval-tree-iter-first \
ksym-vanilla-interval-tree-iter-next \
ksym-vanilla-interval-tree-remove \
ksym-vanilla-interval-tree-subtree-search \
ksym-vanilla-intlog10 \
ksym-vanilla-intlog2 \
ksym-vanilla-inv-icm42600-core-probe \
ksym-vanilla-inv-icm42600-pm-ops \
ksym-vanilla-inv-icm42600-regmap-config \
ksym-vanilla-inv-icm42600-spi-regmap-config \
ksym-vanilla-inv-mpu-core-probe \
ksym-vanilla-inv-mpu-pmops \
ksym-vanilla-inv-sensors-timestamp-apply-odr \
ksym-vanilla-inv-sensors-timestamp-init \
ksym-vanilla-inv-sensors-timestamp-interrupt \
ksym-vanilla-inv-sensors-timestamp-update-odr \
ksym-vanilla-invalid-mnt-idmap \
ksym-vanilla-invalidate-bdev \
ksym-vanilla-invalidate-bh-lrus \
ksym-vanilla-invalidate-disk \
ksym-vanilla-invalidate-inode-pages2 \
ksym-vanilla-invalidate-inode-pages2-range \
ksym-vanilla-invalidate-mapping-pages \
ksym-vanilla-inverse-translate \
ksym-vanilla-io-buffer-register-bvec \
ksym-vanilla-io-buffer-unregister-bvec \
ksym-vanilla-io-cgrp-subsys \
ksym-vanilla-io-cgrp-subsys-enabled-key \
ksym-vanilla-io-cgrp-subsys-on-dfl-key \
ksym-vanilla-io-schedule \
ksym-vanilla-io-schedule-timeout \
ksym-vanilla-io-uring-cmd-buffer-select \
ksym-vanilla-io-uring-cmd-import-fixed \
ksym-vanilla-io-uring-cmd-import-fixed-vec \
ksym-vanilla-io-uring-cmd-mark-cancelable \
ksym-vanilla-io-uring-cmd-sock \
ksym-vanilla-io-uring-mshot-cmd-post-cqe \
ksym-vanilla-ioc-find-get-icq \
ksym-vanilla-ioc-list \
ksym-vanilla-ioc-lookup-icq \
ksym-vanilla-iocb-bio-iopoll \
ksym-vanilla-iomap-add-to-ioend \
ksym-vanilla-iomap-bio-read-folio-range \
ksym-vanilla-iomap-bio-read-ops \
ksym-vanilla-iomap-bio-submit-read-endio \
ksym-vanilla-iomap-bmap \
ksym-vanilla-iomap-dio-bio-end-io \
ksym-vanilla-iomap-dio-complete \
ksym-vanilla-iomap-dio-rw \
ksym-vanilla-iomap-dirty-folio \
ksym-vanilla-iomap-fiemap \
ksym-vanilla-iomap-file-buffered-write \
ksym-vanilla-iomap-file-unshare \
ksym-vanilla-iomap-fill-dirty-folios \
ksym-vanilla-iomap-finish-folio-read \
ksym-vanilla-iomap-finish-folio-write \
ksym-vanilla-iomap-finish-ioends \
ksym-vanilla-iomap-fsverity-write \
ksym-vanilla-iomap-get-folio \
ksym-vanilla-iomap-init-ioend \
ksym-vanilla-iomap-invalidate-folio \
ksym-vanilla-iomap-ioend-bioset \
ksym-vanilla-iomap-ioend-try-merge \
ksym-vanilla-iomap-ioend-writeback-submit \
ksym-vanilla-iomap-is-partially-uptodate \
ksym-vanilla-iomap-page-mkwrite \
ksym-vanilla-iomap-read-folio \
ksym-vanilla-iomap-readahead \
ksym-vanilla-iomap-release-folio \
ksym-vanilla-iomap-seek-data \
ksym-vanilla-iomap-seek-hole \
ksym-vanilla-iomap-sort-ioends \
ksym-vanilla-iomap-split-ioend \
ksym-vanilla-iomap-swapfile-activate \
ksym-vanilla-iomap-truncate-page \
ksym-vanilla-iomap-write-delalloc-release \
ksym-vanilla-iomap-writeback-folio \
ksym-vanilla-iomap-writepages \
ksym-vanilla-iomap-zero-range \
ksym-vanilla-iomem-resource \
ksym-vanilla-iommu-alloc-global-pasid \
ksym-vanilla-iommu-alloc-pages-node-sz \
ksym-vanilla-iommu-alloc-resv-region \
ksym-vanilla-iommu-attach-device \
ksym-vanilla-iommu-attach-device-pasid \
ksym-vanilla-iommu-attach-group \
ksym-vanilla-iommu-attach-group-handle \
ksym-vanilla-iommu-attach-handle-get \
ksym-vanilla-iommu-default-passthrough \
ksym-vanilla-iommu-detach-device \
ksym-vanilla-iommu-detach-device-pasid \
ksym-vanilla-iommu-detach-group \
ksym-vanilla-iommu-detach-group-handle \
ksym-vanilla-iommu-device-claim-dma-owner \
ksym-vanilla-iommu-device-register \
ksym-vanilla-iommu-device-release-dma-owner \
ksym-vanilla-iommu-device-sysfs-add \
ksym-vanilla-iommu-device-sysfs-remove \
ksym-vanilla-iommu-device-unregister \
ksym-vanilla-iommu-dma-get-resv-regions \
ksym-vanilla-iommu-domain-free \
ksym-vanilla-iommu-driver-get-domain-for-dev \
ksym-vanilla-iommu-free-global-pasid \
ksym-vanilla-iommu-free-pages \
ksym-vanilla-iommu-fwspec-add-ids \
ksym-vanilla-iommu-fwspec-init \
ksym-vanilla-iommu-get-domain-for-dev \
ksym-vanilla-iommu-get-group-resv-regions \
ksym-vanilla-iommu-get-msi-cookie \
ksym-vanilla-iommu-get-resv-regions \
ksym-vanilla-iommu-group-add-device \
ksym-vanilla-iommu-group-alloc \
ksym-vanilla-iommu-group-claim-dma-owner \
ksym-vanilla-iommu-group-dma-owner-claimed \
ksym-vanilla-iommu-group-for-each-dev \
ksym-vanilla-iommu-group-get \
ksym-vanilla-iommu-group-get-iommudata \
ksym-vanilla-iommu-group-has-isolated-msi \
ksym-vanilla-iommu-group-id \
ksym-vanilla-iommu-group-put \
ksym-vanilla-iommu-group-ref-get \
ksym-vanilla-iommu-group-release-dma-owner \
ksym-vanilla-iommu-group-remove-device \
ksym-vanilla-iommu-group-set-iommudata \
ksym-vanilla-iommu-group-set-name \
ksym-vanilla-iommu-iova-to-phys \
ksym-vanilla-iommu-map \
ksym-vanilla-iommu-map-sg \
ksym-vanilla-iommu-pages-free-incoherent \
ksym-vanilla-iommu-pages-start-incoherent \
ksym-vanilla-iommu-pages-start-incoherent-list \
ksym-vanilla-iommu-pages-stop-incoherent-list \
ksym-vanilla-iommu-paging-domain-alloc-flags \
ksym-vanilla-iommu-put-pages-list \
ksym-vanilla-iommu-put-resv-regions \
ksym-vanilla-iommu-replace-device-pasid \
ksym-vanilla-iommu-replace-group-handle \
ksym-vanilla-iommu-report-device-fault \
ksym-vanilla-iommu-set-fault-handler \
ksym-vanilla-iommu-set-pgtable-quirks \
ksym-vanilla-iommu-sva-bind-device \
ksym-vanilla-iommu-sva-get-pasid \
ksym-vanilla-iommu-sva-unbind-device \
ksym-vanilla-iommu-unmap \
ksym-vanilla-iommu-unmap-fast \
ksym-vanilla-ionic-adminq-post-wait \
ksym-vanilla-ionic-error-to-errno \
ksym-vanilla-ionic-get-cmb \
ksym-vanilla-ionic-intr-alloc \
ksym-vanilla-ionic-intr-free \
ksym-vanilla-ionic-put-cmb \
ksym-vanilla-ionic-request-rdma-reset \
ksym-vanilla-iopf-free-group \
ksym-vanilla-iopf-group-dequeue \
ksym-vanilla-iopf-group-response \
ksym-vanilla-iopf-queue-add-device \
ksym-vanilla-iopf-queue-alloc \
ksym-vanilla-iopf-queue-discard-partial \
ksym-vanilla-iopf-queue-flush-dev \
ksym-vanilla-iopf-queue-free \
ksym-vanilla-iopf-queue-remove-device \
ksym-vanilla-ioport-resource \
ksym-vanilla-iort-get-rmr-sids \
ksym-vanilla-iort-put-rmr-sids \
ksym-vanilla-iounmap \
ksym-vanilla-iov-iter-advance \
ksym-vanilla-iov-iter-alignment \
ksym-vanilla-iov-iter-bvec \
ksym-vanilla-iov-iter-discard \
ksym-vanilla-iov-iter-extract-bvecs \
ksym-vanilla-iov-iter-extract-pages \
ksym-vanilla-iov-iter-folio-queue \
ksym-vanilla-iov-iter-gap-alignment \
ksym-vanilla-iov-iter-get-pages-alloc2 \
ksym-vanilla-iov-iter-get-pages2 \
ksym-vanilla-iov-iter-init \
ksym-vanilla-iov-iter-kvec \
ksym-vanilla-iov-iter-npages \
ksym-vanilla-iov-iter-revert \
ksym-vanilla-iov-iter-single-seg-count \
ksym-vanilla-iov-iter-xarray \
ksym-vanilla-iov-iter-zero \
ksym-vanilla-iova-bitmap-alloc \
ksym-vanilla-iova-bitmap-for-each \
ksym-vanilla-iova-bitmap-free \
ksym-vanilla-iova-bitmap-set \
ksym-vanilla-iova-cache-get \
ksym-vanilla-iova-cache-put \
ksym-vanilla-iova-domain-init-rcaches \
ksym-vanilla-ip-check-defrag \
ksym-vanilla-ip-cmsg-recv-offset \
ksym-vanilla-ip-compute-csum \
ksym-vanilla-ip-defrag \
ksym-vanilla-ip-do-fragment \
ksym-vanilla-ip-frag-ecn-table \
ksym-vanilla-ip-frag-init \
ksym-vanilla-ip-frag-next \
ksym-vanilla-ip-fraglist-init \
ksym-vanilla-ip-fraglist-prepare \
ksym-vanilla-ip-generic-getfrag \
ksym-vanilla-ip-getsockopt \
ksym-vanilla-ip-icmp-error \
ksym-vanilla-ip-local-deliver \
ksym-vanilla-ip-local-out \
ksym-vanilla-ip-mc-check-igmp \
ksym-vanilla-ip-mc-inc-group \
ksym-vanilla-ip-mc-join-group \
ksym-vanilla-ip-mc-leave-group \
ksym-vanilla-ip-md-tunnel-xmit \
ksym-vanilla-ip-options-compile \
ksym-vanilla-ip-options-rcv-srr \
ksym-vanilla-ip-output \
ksym-vanilla-ip-queue-xmit \
ksym-vanilla-ip-route-input-noref \
ksym-vanilla-ip-route-me-harder \
ksym-vanilla-ip-route-output-flow \
ksym-vanilla-ip-route-output-key-hash \
ksym-vanilla-ip-send-check \
ksym-vanilla-ip-set-add \
ksym-vanilla-ip-set-alloc \
ksym-vanilla-ip-set-del \
ksym-vanilla-ip-set-elem-len \
ksym-vanilla-ip-set-extensions \
ksym-vanilla-ip-set-free \
ksym-vanilla-ip-set-get-byname \
ksym-vanilla-ip-set-get-extensions \
ksym-vanilla-ip-set-get-ip4-port \
ksym-vanilla-ip-set-get-ip6-port \
ksym-vanilla-ip-set-get-ipaddr4 \
ksym-vanilla-ip-set-get-ipaddr6 \
ksym-vanilla-ip-set-hostmask-map \
ksym-vanilla-ip-set-init-comment \
ksym-vanilla-ip-set-match-extensions \
ksym-vanilla-ip-set-name-byindex \
ksym-vanilla-ip-set-netmask-map \
ksym-vanilla-ip-set-nfnl-get-byindex \
ksym-vanilla-ip-set-nfnl-put \
ksym-vanilla-ip-set-put-byindex \
ksym-vanilla-ip-set-put-extensions \
ksym-vanilla-ip-set-put-flags \
ksym-vanilla-ip-set-range-to-cidr \
ksym-vanilla-ip-set-test \
ksym-vanilla-ip-set-type-register \
ksym-vanilla-ip-set-type-unregister \
ksym-vanilla-ip-setsockopt \
ksym-vanilla-ip-sock-set-freebind \
ksym-vanilla-ip-sock-set-mtu-discover \
ksym-vanilla-ip-sock-set-pktinfo \
ksym-vanilla-ip-sock-set-recverr \
ksym-vanilla-ip-sock-set-tos \
ksym-vanilla-ip-tos2prio \
ksym-vanilla-ip-tunnel-change-mtu \
ksym-vanilla-ip-tunnel-changelink \
ksym-vanilla-ip-tunnel-ctl \
ksym-vanilla-ip-tunnel-delete-net \
ksym-vanilla-ip-tunnel-dellink \
ksym-vanilla-ip-tunnel-encap-add-ops \
ksym-vanilla-ip-tunnel-encap-del-ops \
ksym-vanilla-ip-tunnel-encap-setup \
ksym-vanilla-ip-tunnel-get-iflink \
ksym-vanilla-ip-tunnel-get-link-net \
ksym-vanilla-ip-tunnel-header-ops \
ksym-vanilla-ip-tunnel-init-net \
ksym-vanilla-ip-tunnel-lookup \
ksym-vanilla-ip-tunnel-md-udp-encap \
ksym-vanilla-ip-tunnel-metadata-cnt \
ksym-vanilla-ip-tunnel-need-metadata \
ksym-vanilla-ip-tunnel-netlink-encap-parms \
ksym-vanilla-ip-tunnel-netlink-parms \
ksym-vanilla-ip-tunnel-newlink \
ksym-vanilla-ip-tunnel-parm-from-user \
ksym-vanilla-ip-tunnel-parm-to-user \
ksym-vanilla-ip-tunnel-parse-protocol \
ksym-vanilla-ip-tunnel-rcv \
ksym-vanilla-ip-tunnel-setup \
ksym-vanilla-ip-tunnel-siocdevprivate \
ksym-vanilla-ip-tunnel-uninit \
ksym-vanilla-ip-tunnel-unneed-metadata \
ksym-vanilla-ip-tunnel-xmit \
ksym-vanilla-ip-valid-fib-dump-req \
ksym-vanilla-ip-vs-conn-in-get \
ksym-vanilla-ip-vs-conn-in-get-proto \
ksym-vanilla-ip-vs-conn-new \
ksym-vanilla-ip-vs-conn-out-get \
ksym-vanilla-ip-vs-conn-out-get-proto \
ksym-vanilla-ip-vs-conn-put \
ksym-vanilla-ip-vs-new-conn-out \
ksym-vanilla-ip-vs-nfct-expect-related \
ksym-vanilla-ip-vs-proto-data-get \
ksym-vanilla-ip-vs-proto-get \
ksym-vanilla-ip-vs-proto-name \
ksym-vanilla-ip-vs-scheduler-err \
ksym-vanilla-ip-vs-tcp-conn-listen \
ksym-vanilla-ip4-datagram-connect \
ksym-vanilla-ip4-datagram-release-cb \
ksym-vanilla-ip6-append-data \
ksym-vanilla-ip6-datagram-connect \
ksym-vanilla-ip6-datagram-connect-v6-only \
ksym-vanilla-ip6-datagram-recv-ctl \
ksym-vanilla-ip6-datagram-release-cb \
ksym-vanilla-ip6-datagram-send-ctl \
ksym-vanilla-ip6-dst-alloc \
ksym-vanilla-ip6-dst-hoplimit \
ksym-vanilla-ip6-dst-lookup \
ksym-vanilla-ip6-dst-lookup-flow \
ksym-vanilla-ip6-err-gen-icmpv6-unreach \
ksym-vanilla-ip6-find-1stfragopt \
ksym-vanilla-ip6-flush-pending-frames \
ksym-vanilla-ip6-frag-init \
ksym-vanilla-ip6-frag-next \
ksym-vanilla-ip6-fraglist-init \
ksym-vanilla-ip6-fraglist-prepare \
ksym-vanilla-ip6-fragment \
ksym-vanilla-ip6-input \
ksym-vanilla-ip6-local-out \
ksym-vanilla-ip6-output \
ksym-vanilla-ip6-pol-route \
ksym-vanilla-ip6-push-pending-frames \
ksym-vanilla-ip6-redirect \
ksym-vanilla-ip6-route-input \
ksym-vanilla-ip6-route-input-lookup \
ksym-vanilla-ip6-route-lookup \
ksym-vanilla-ip6-route-me-harder \
ksym-vanilla-ip6-route-output-flags \
ksym-vanilla-ip6-tnl-change-mtu \
ksym-vanilla-ip6-tnl-encap-add-ops \
ksym-vanilla-ip6-tnl-encap-del-ops \
ksym-vanilla-ip6-tnl-encap-setup \
ksym-vanilla-ip6-tnl-get-cap \
ksym-vanilla-ip6-tnl-get-iflink \
ksym-vanilla-ip6-tnl-get-link-net \
ksym-vanilla-ip6-tnl-parse-tlv-enc-lim \
ksym-vanilla-ip6-tnl-rcv \
ksym-vanilla-ip6-tnl-rcv-ctl \
ksym-vanilla-ip6-tnl-xmit \
ksym-vanilla-ip6-tnl-xmit-ctl \
ksym-vanilla-ip6-update-pmtu \
ksym-vanilla-ip6-xmit \
ksym-vanilla-ip6mr-rule-default \
ksym-vanilla-ip6t-alloc-initial-table \
ksym-vanilla-ip6t-do-table \
ksym-vanilla-ip6t-register-table \
ksym-vanilla-ip6t-unregister-table-exit \
ksym-vanilla-ip6tun-encaps \
ksym-vanilla-ipack-bus-register \
ksym-vanilla-ipack-bus-unregister \
ksym-vanilla-ipack-device-add \
ksym-vanilla-ipack-device-del \
ksym-vanilla-ipack-device-init \
ksym-vanilla-ipack-driver-register \
ksym-vanilla-ipack-driver-unregister \
ksym-vanilla-ipack-get-device \
ksym-vanilla-ipack-put-device \
ksym-vanilla-ipcomp-destroy \
ksym-vanilla-ipcomp-init-state \
ksym-vanilla-ipcomp-input \
ksym-vanilla-ipcomp-output \
ksym-vanilla-ipi-get-hwirq \
ksym-vanilla-ipi-send-mask \
ksym-vanilla-ipi-send-single \
ksym-vanilla-ipmb-checksum \
ksym-vanilla-ipmi-add-smi \
ksym-vanilla-ipmi-addr-length \
ksym-vanilla-ipmi-addr-src-to-str \
ksym-vanilla-ipmi-alloc-smi-msg \
ksym-vanilla-ipmi-create-user \
ksym-vanilla-ipmi-destroy-user \
ksym-vanilla-ipmi-dmi-get-slave-addr \
ksym-vanilla-ipmi-free-recv-msg \
ksym-vanilla-ipmi-get-maintenance-mode \
ksym-vanilla-ipmi-get-my-LUN \
ksym-vanilla-ipmi-get-my-address \
ksym-vanilla-ipmi-get-smi-info \
ksym-vanilla-ipmi-get-version \
ksym-vanilla-ipmi-panic-request-and-wait \
ksym-vanilla-ipmi-platform-add \
ksym-vanilla-ipmi-poll-interface \
ksym-vanilla-ipmi-register-for-cmd \
ksym-vanilla-ipmi-request-settime \
ksym-vanilla-ipmi-request-supply-msgs \
ksym-vanilla-ipmi-set-gets-events \
ksym-vanilla-ipmi-set-maintenance-mode \
ksym-vanilla-ipmi-set-my-LUN \
ksym-vanilla-ipmi-set-my-address \
ksym-vanilla-ipmi-smi-msg-received \
ksym-vanilla-ipmi-smi-watchdog-pretimeout \
ksym-vanilla-ipmi-smi-watcher-register \
ksym-vanilla-ipmi-smi-watcher-unregister \
ksym-vanilla-ipmi-unregister-for-cmd \
ksym-vanilla-ipmi-unregister-smi \
ksym-vanilla-ipmi-validate-addr \
ksym-vanilla-ipmr-rule-default \
ksym-vanilla-iproc-msi-exit \
ksym-vanilla-iproc-msi-init \
ksym-vanilla-iproc-pcie-remove \
ksym-vanilla-iproc-pcie-setup \
ksym-vanilla-iproc-pcie-shutdown \
ksym-vanilla-ipt-alloc-initial-table \
ksym-vanilla-ipt-do-table \
ksym-vanilla-ipt-register-table \
ksym-vanilla-ipt-unregister-table-exit \
ksym-vanilla-iptun-encaps \
ksym-vanilla-iptunnel-handle-offloads \
ksym-vanilla-iptunnel-metadata-reply \
ksym-vanilla-iptunnel-xmit \
ksym-vanilla-ipu-bridge-init \
ksym-vanilla-ipu-bridge-instantiate-vcm \
ksym-vanilla-ipu-bridge-parse-ssdb \
ksym-vanilla-iput \
ksym-vanilla-iput-not-last \
ksym-vanilla-ipv4-redirect \
ksym-vanilla-ipv4-synproxy-hook \
ksym-vanilla-ipv4-update-pmtu \
ksym-vanilla-ipv6-chk-addr \
ksym-vanilla-ipv6-chk-addr-and-flags \
ksym-vanilla-ipv6-chk-custom-prefix \
ksym-vanilla-ipv6-chk-prefix \
ksym-vanilla-ipv6-dev-find \
ksym-vanilla-ipv6-dev-get-saddr \
ksym-vanilla-ipv6-dev-mc-dec \
ksym-vanilla-ipv6-dev-mc-inc \
ksym-vanilla-ipv6-dup-options \
ksym-vanilla-ipv6-ext-hdr \
ksym-vanilla-ipv6-find-hdr \
ksym-vanilla-ipv6-find-tlv \
ksym-vanilla-ipv6-flowlabel-exclusive \
ksym-vanilla-ipv6-getsockopt \
ksym-vanilla-ipv6-icmp-error \
ksym-vanilla-ipv6-mc-check-mld \
ksym-vanilla-ipv6-push-frag-opts \
ksym-vanilla-ipv6-recv-error \
ksym-vanilla-ipv6-select-ident \
ksym-vanilla-ipv6-setsockopt \
ksym-vanilla-ipv6-skip-exthdr \
ksym-vanilla-ipv6-sock-mc-drop \
ksym-vanilla-ipv6-sock-mc-join \
ksym-vanilla-ipv6-synproxy-hook \
ksym-vanilla-ipvlan-count-rx \
ksym-vanilla-ipvlan-link-delete \
ksym-vanilla-ipvlan-link-new \
ksym-vanilla-ipvlan-link-register \
ksym-vanilla-ipvlan-link-setup \
ksym-vanilla-ipw-wx-get-spy \
ksym-vanilla-ipw-wx-get-thrspy \
ksym-vanilla-ipw-wx-set-spy \
ksym-vanilla-ipw-wx-set-thrspy \
ksym-vanilla-iqs62x-events \
ksym-vanilla-ir-raw-encode-carrier \
ksym-vanilla-ir-raw-encode-scancode \
ksym-vanilla-ir-raw-event-handle \
ksym-vanilla-ir-raw-event-set-idle \
ksym-vanilla-ir-raw-event-store \
ksym-vanilla-ir-raw-event-store-edge \
ksym-vanilla-ir-raw-event-store-with-filter \
ksym-vanilla-ir-raw-event-store-with-timeout \
ksym-vanilla-ir-raw-gen-manchester \
ksym-vanilla-ir-raw-gen-pd \
ksym-vanilla-ir-raw-gen-pl \
ksym-vanilla-ir-raw-handler-register \
ksym-vanilla-ir-raw-handler-unregister \
ksym-vanilla-irq-alloc-generic-chip \
ksym-vanilla-irq-bypass-register-consumer \
ksym-vanilla-irq-bypass-register-producer \
ksym-vanilla-irq-bypass-unregister-consumer \
ksym-vanilla-irq-bypass-unregister-producer \
ksym-vanilla-irq-check-status-bit \
ksym-vanilla-irq-chip-ack-parent \
ksym-vanilla-irq-chip-disable-parent \
ksym-vanilla-irq-chip-enable-parent \
ksym-vanilla-irq-chip-eoi-parent \
ksym-vanilla-irq-chip-get-parent-state \
ksym-vanilla-irq-chip-mask-ack-parent \
ksym-vanilla-irq-chip-mask-parent \
ksym-vanilla-irq-chip-pre-redirect-parent \
ksym-vanilla-irq-chip-redirect-set-affinity \
ksym-vanilla-irq-chip-release-resources-parent \
ksym-vanilla-irq-chip-request-resources-parent \
ksym-vanilla-irq-chip-retrigger-hierarchy \
ksym-vanilla-irq-chip-set-affinity-parent \
ksym-vanilla-irq-chip-set-parent-state \
ksym-vanilla-irq-chip-set-type-parent \
ksym-vanilla-irq-chip-set-vcpu-affinity-parent \
ksym-vanilla-irq-chip-set-wake-parent \
ksym-vanilla-irq-chip-shutdown-parent \
ksym-vanilla-irq-chip-startup-parent \
ksym-vanilla-irq-chip-unmask-parent \
ksym-vanilla-irq-cpu-rmap-add \
ksym-vanilla-irq-cpu-rmap-remove \
ksym-vanilla-irq-create-fwspec-mapping \
ksym-vanilla-irq-create-mapping-affinity \
ksym-vanilla-irq-create-of-mapping \
ksym-vanilla-irq-dispose-mapping \
ksym-vanilla-irq-domain-alloc-generic-chips \
ksym-vanilla-irq-domain-alloc-irqs-parent \
ksym-vanilla-irq-domain-associate \
ksym-vanilla-irq-domain-associate-many \
ksym-vanilla-irq-domain-create-legacy \
ksym-vanilla-irq-domain-create-sim \
ksym-vanilla-irq-domain-create-sim-full \
ksym-vanilla-irq-domain-create-simple \
ksym-vanilla-irq-domain-disconnect-hierarchy \
ksym-vanilla-irq-domain-free-fwnode \
ksym-vanilla-irq-domain-free-irqs \
ksym-vanilla-irq-domain-free-irqs-common \
ksym-vanilla-irq-domain-free-irqs-parent \
ksym-vanilla-irq-domain-free-irqs-top \
ksym-vanilla-irq-domain-get-irq-data \
ksym-vanilla-irq-domain-instantiate \
ksym-vanilla-irq-domain-pop-irq \
ksym-vanilla-irq-domain-push-irq \
ksym-vanilla-irq-domain-remove \
ksym-vanilla-irq-domain-remove-generic-chips \
ksym-vanilla-irq-domain-remove-sim \
ksym-vanilla-irq-domain-reset-irq-data \
ksym-vanilla-irq-domain-set-hwirq-and-chip \
ksym-vanilla-irq-domain-set-info \
ksym-vanilla-irq-domain-simple-ops \
ksym-vanilla-irq-domain-translate-onecell \
ksym-vanilla-irq-domain-translate-twocell \
ksym-vanilla-irq-domain-translate-twothreecell \
ksym-vanilla-irq-domain-update-bus-token \
ksym-vanilla-irq-domain-xlate-onecell \
ksym-vanilla-irq-domain-xlate-onetwocell \
ksym-vanilla-irq-domain-xlate-twocell \
ksym-vanilla-irq-domain-xlate-twothreecell \
ksym-vanilla-irq-find-matching-fwspec \
ksym-vanilla-irq-force-affinity \
ksym-vanilla-irq-free-descs \
ksym-vanilla-irq-gc-ack-set-bit \
ksym-vanilla-irq-gc-mask-clr-bit \
ksym-vanilla-irq-gc-mask-disable-and-ack-set \
ksym-vanilla-irq-gc-mask-disable-reg \
ksym-vanilla-irq-gc-mask-set-bit \
ksym-vanilla-irq-gc-noop \
ksym-vanilla-irq-gc-set-wake \
ksym-vanilla-irq-gc-unmask-enable-reg \
ksym-vanilla-irq-generic-chip-ops \
ksym-vanilla-irq-get-default-domain \
ksym-vanilla-irq-get-domain-generic-chip \
ksym-vanilla-irq-get-irq-data \
ksym-vanilla-irq-get-irqchip-state \
ksym-vanilla-irq-get-nr-irqs \
ksym-vanilla-irq-has-action \
ksym-vanilla-irq-inject-interrupt \
ksym-vanilla-irq-modify-status \
ksym-vanilla-irq-of-parse-and-map \
ksym-vanilla-irq-percpu-is-enabled \
ksym-vanilla-irq-poll-complete \
ksym-vanilla-irq-poll-disable \
ksym-vanilla-irq-poll-enable \
ksym-vanilla-irq-poll-init \
ksym-vanilla-irq-poll-sched \
ksym-vanilla-irq-remove-generic-chip \
ksym-vanilla-irq-set-affinity \
ksym-vanilla-irq-set-affinity-notifier \
ksym-vanilla-irq-set-chained-handler-and-data \
ksym-vanilla-irq-set-chip \
ksym-vanilla-irq-set-chip-and-handler-name \
ksym-vanilla-irq-set-chip-data \
ksym-vanilla-irq-set-default-domain \
ksym-vanilla-irq-set-handler-data \
ksym-vanilla-irq-set-irq-type \
ksym-vanilla-irq-set-irq-wake \
ksym-vanilla-irq-set-irqchip-state \
ksym-vanilla-irq-set-parent \
ksym-vanilla-irq-set-vcpu-affinity \
ksym-vanilla-irq-setup-alt-chip \
ksym-vanilla-irq-setup-generic-chip \
ksym-vanilla-irq-stat \
ksym-vanilla-irq-wake-thread \
ksym-vanilla-irq-work-queue \
ksym-vanilla-irq-work-run \
ksym-vanilla-irq-work-sync \
ksym-vanilla-irqchip-fwnode-ops \
ksym-vanilla-is-acpi-data-node \
ksym-vanilla-is-acpi-device-node \
ksym-vanilla-is-bad-inode \
ksym-vanilla-is-binary-blacklisted \
ksym-vanilla-is-clock-scaling-supported-by-slave \
ksym-vanilla-is-console-locked \
ksym-vanilla-is-cxl-memdev \
ksym-vanilla-is-cxl-nvdimm \
ksym-vanilla-is-cxl-pmem-region \
ksym-vanilla-is-cxl-port \
ksym-vanilla-is-cxl-region \
ksym-vanilla-is-dock-device \
ksym-vanilla-is-endpoint-decoder \
ksym-vanilla-is-free-buddy-page \
ksym-vanilla-is-fw-load \
ksym-vanilla-is-hash-blacklisted \
ksym-vanilla-is-hsr-master \
ksym-vanilla-is-jack-detectable \
ksym-vanilla-is-kho-boot \
ksym-vanilla-is-midr-in-range-list \
ksym-vanilla-is-module-sig-enforced \
ksym-vanilla-is-nd-btt \
ksym-vanilla-is-nd-dax \
ksym-vanilla-is-nd-pfn \
ksym-vanilla-is-nvdimm-bus-locked \
ksym-vanilla-is-nvdimm-sync \
ksym-vanilla-is-root-decoder \
ksym-vanilla-is-skb-forwardable \
ksym-vanilla-is-software-node \
ksym-vanilla-is-stm32-lptim-trigger \
ksym-vanilla-is-stm32-timer-trigger \
ksym-vanilla-is-subdir \
ksym-vanilla-is-switch-decoder \
ksym-vanilla-is-virtio-device \
ksym-vanilla-is-virtio-dma-buf \
ksym-vanilla-is-vmalloc-addr \
ksym-vanilla-is-vmalloc-or-module-addr \
ksym-vanilla-iscsi-add-conn \
ksym-vanilla-iscsi-add-session \
ksym-vanilla-iscsi-alloc-conn \
ksym-vanilla-iscsi-alloc-session \
ksym-vanilla-iscsi-block-scsi-eh \
ksym-vanilla-iscsi-block-session \
ksym-vanilla-iscsi-boot-create-acpitbl \
ksym-vanilla-iscsi-boot-create-ethernet \
ksym-vanilla-iscsi-boot-create-host-kset \
ksym-vanilla-iscsi-boot-create-initiator \
ksym-vanilla-iscsi-boot-create-kset \
ksym-vanilla-iscsi-boot-create-target \
ksym-vanilla-iscsi-boot-destroy-kset \
ksym-vanilla-iscsi-change-param-sprintf \
ksym-vanilla-iscsi-complete-pdu \
ksym-vanilla-iscsi-complete-scsi-task \
ksym-vanilla-iscsi-conn-bind \
ksym-vanilla-iscsi-conn-error-event \
ksym-vanilla-iscsi-conn-failure \
ksym-vanilla-iscsi-conn-get-addr-param \
ksym-vanilla-iscsi-conn-get-param \
ksym-vanilla-iscsi-conn-login-event \
ksym-vanilla-iscsi-conn-queue-recv \
ksym-vanilla-iscsi-conn-queue-xmit \
ksym-vanilla-iscsi-conn-send-pdu \
ksym-vanilla-iscsi-conn-setup \
ksym-vanilla-iscsi-conn-start \
ksym-vanilla-iscsi-conn-stop \
ksym-vanilla-iscsi-conn-teardown \
ksym-vanilla-iscsi-conn-unbind \
ksym-vanilla-iscsi-create-endpoint \
ksym-vanilla-iscsi-create-flashnode-conn \
ksym-vanilla-iscsi-create-flashnode-sess \
ksym-vanilla-iscsi-create-iface \
ksym-vanilla-iscsi-dbg-trace \
ksym-vanilla-iscsi-destroy-all-flashnode \
ksym-vanilla-iscsi-destroy-endpoint \
ksym-vanilla-iscsi-destroy-flashnode-sess \
ksym-vanilla-iscsi-destroy-iface \
ksym-vanilla-iscsi-eh-abort \
ksym-vanilla-iscsi-eh-cmd-timed-out \
ksym-vanilla-iscsi-eh-device-reset \
ksym-vanilla-iscsi-eh-recover-target \
ksym-vanilla-iscsi-eh-session-reset \
ksym-vanilla-iscsi-find-flashnode-conn \
ksym-vanilla-iscsi-find-flashnode-sess \
ksym-vanilla-iscsi-find-param-from-key \
ksym-vanilla-iscsi-flashnode-bus-match \
ksym-vanilla-iscsi-force-destroy-session \
ksym-vanilla-iscsi-free-session \
ksym-vanilla-iscsi-get-conn \
ksym-vanilla-iscsi-get-discovery-parent-name \
ksym-vanilla-iscsi-get-ipaddress-state-name \
ksym-vanilla-iscsi-get-port-speed-name \
ksym-vanilla-iscsi-get-port-state-name \
ksym-vanilla-iscsi-get-router-state-name \
ksym-vanilla-iscsi-get-task \
ksym-vanilla-iscsi-host-add \
ksym-vanilla-iscsi-host-alloc \
ksym-vanilla-iscsi-host-for-each-session \
ksym-vanilla-iscsi-host-free \
ksym-vanilla-iscsi-host-get-max-scsi-cmds \
ksym-vanilla-iscsi-host-get-param \
ksym-vanilla-iscsi-host-remove \
ksym-vanilla-iscsi-host-set-param \
ksym-vanilla-iscsi-is-session-dev \
ksym-vanilla-iscsi-is-session-online \
ksym-vanilla-iscsi-itt-to-ctask \
ksym-vanilla-iscsi-itt-to-task \
ksym-vanilla-iscsi-lookup-endpoint \
ksym-vanilla-iscsi-offload-mesg \
ksym-vanilla-iscsi-ping-comp-event \
ksym-vanilla-iscsi-pool-free \
ksym-vanilla-iscsi-pool-init \
ksym-vanilla-iscsi-post-host-event \
ksym-vanilla-iscsi-prep-data-out-pdu \
ksym-vanilla-iscsi-put-conn \
ksym-vanilla-iscsi-put-endpoint \
ksym-vanilla-iscsi-put-task \
ksym-vanilla-iscsi-queuecommand \
ksym-vanilla-iscsi-recv-pdu \
ksym-vanilla-iscsi-register-transport \
ksym-vanilla-iscsi-remove-conn \
ksym-vanilla-iscsi-remove-session \
ksym-vanilla-iscsi-requeue-task \
ksym-vanilla-iscsi-segment-init-linear \
ksym-vanilla-iscsi-segment-seek-sg \
ksym-vanilla-iscsi-session-chkready \
ksym-vanilla-iscsi-session-event \
ksym-vanilla-iscsi-session-failure \
ksym-vanilla-iscsi-session-free \
ksym-vanilla-iscsi-session-get-param \
ksym-vanilla-iscsi-session-recovery-timedout \
ksym-vanilla-iscsi-session-remove \
ksym-vanilla-iscsi-session-setup \
ksym-vanilla-iscsi-session-teardown \
ksym-vanilla-iscsi-set-param \
ksym-vanilla-iscsi-suspend-queue \
ksym-vanilla-iscsi-suspend-rx \
ksym-vanilla-iscsi-suspend-tx \
ksym-vanilla-iscsi-switch-str-param \
ksym-vanilla-iscsi-target-alloc \
ksym-vanilla-iscsi-target-check-login-request \
ksym-vanilla-iscsi-tcp-cleanup-task \
ksym-vanilla-iscsi-tcp-conn-get-stats \
ksym-vanilla-iscsi-tcp-conn-setup \
ksym-vanilla-iscsi-tcp-conn-teardown \
ksym-vanilla-iscsi-tcp-dgst-header \
ksym-vanilla-iscsi-tcp-hdr-recv-prep \
ksym-vanilla-iscsi-tcp-r2tpool-alloc \
ksym-vanilla-iscsi-tcp-r2tpool-free \
ksym-vanilla-iscsi-tcp-recv-segment-is-hdr \
ksym-vanilla-iscsi-tcp-recv-skb \
ksym-vanilla-iscsi-tcp-segment-done \
ksym-vanilla-iscsi-tcp-segment-unmap \
ksym-vanilla-iscsi-tcp-set-max-r2t \
ksym-vanilla-iscsi-tcp-task-init \
ksym-vanilla-iscsi-tcp-task-xmit \
ksym-vanilla-iscsi-unblock-session \
ksym-vanilla-iscsi-unregister-transport \
ksym-vanilla-iscsi-update-cmdsn \
ksym-vanilla-iscsi-verify-itt \
ksym-vanilla-iscsit-aborted-task \
ksym-vanilla-iscsit-add-cmd-to-immediate-queue \
ksym-vanilla-iscsit-add-reject \
ksym-vanilla-iscsit-allocate-cmd \
ksym-vanilla-iscsit-build-datain-pdu \
ksym-vanilla-iscsit-build-logout-rsp \
ksym-vanilla-iscsit-build-nopin-rsp \
ksym-vanilla-iscsit-build-r2ts-for-cmd \
ksym-vanilla-iscsit-build-reject \
ksym-vanilla-iscsit-build-rsp-pdu \
ksym-vanilla-iscsit-build-task-mgt-rsp \
ksym-vanilla-iscsit-build-text-rsp \
ksym-vanilla-iscsit-cause-connection-reinstatement \
ksym-vanilla-iscsit-check-dataout-hdr \
ksym-vanilla-iscsit-check-dataout-payload \
ksym-vanilla-iscsit-find-cmd-from-itt \
ksym-vanilla-iscsit-find-cmd-from-itt-or-dump \
ksym-vanilla-iscsit-free-cmd \
ksym-vanilla-iscsit-get-datain-values \
ksym-vanilla-iscsit-handle-logout-cmd \
ksym-vanilla-iscsit-handle-snack \
ksym-vanilla-iscsit-handle-task-mgt-cmd \
ksym-vanilla-iscsit-immediate-queue \
ksym-vanilla-iscsit-increment-maxcmdsn \
ksym-vanilla-iscsit-logout-post-handler \
ksym-vanilla-iscsit-process-nop-out \
ksym-vanilla-iscsit-process-scsi-cmd \
ksym-vanilla-iscsit-process-text-cmd \
ksym-vanilla-iscsit-queue-rsp \
ksym-vanilla-iscsit-register-transport \
ksym-vanilla-iscsit-reject-cmd \
ksym-vanilla-iscsit-release-cmd \
ksym-vanilla-iscsit-response-queue \
ksym-vanilla-iscsit-sequence-cmd \
ksym-vanilla-iscsit-set-unsolicited-dataout \
ksym-vanilla-iscsit-setup-nop-out \
ksym-vanilla-iscsit-setup-scsi-cmd \
ksym-vanilla-iscsit-setup-text-cmd \
ksym-vanilla-iscsit-stop-dataout-timer \
ksym-vanilla-iscsit-thread-check-cpumask \
ksym-vanilla-iscsit-tmr-post-handler \
ksym-vanilla-iscsit-unregister-transport \
ksym-vanilla-isl6405-attach \
ksym-vanilla-isl6421-attach \
ksym-vanilla-isl6423-attach \
ksym-vanilla-iso-packets-buffer-destroy \
ksym-vanilla-iso-packets-buffer-init \
ksym-vanilla-isp-kernel-buffer-alloc \
ksym-vanilla-isp-kernel-buffer-free \
ksym-vanilla-isp-user-buffer-alloc \
ksym-vanilla-isp-user-buffer-free \
ksym-vanilla-isp1301-get-client \
ksym-vanilla-itd1000-attach \
ksym-vanilla-iter-div-u64-rem \
ksym-vanilla-iter-file-splice-write \
ksym-vanilla-iterate-dir \
ksym-vanilla-iterate-fd \
ksym-vanilla-iterate-supers-type \
ksym-vanilla-iunique \
ksym-vanilla-ivtv-api \
ksym-vanilla-ivtv-claim-stream \
ksym-vanilla-ivtv-clear-irq-mask \
ksym-vanilla-ivtv-debug \
ksym-vanilla-ivtv-ext-init \
ksym-vanilla-ivtv-firmware-check \
ksym-vanilla-ivtv-init-on-first-open \
ksym-vanilla-ivtv-release-stream \
ksym-vanilla-ivtv-reset-ir-gpio \
ksym-vanilla-ivtv-set-irq-mask \
ksym-vanilla-ivtv-start-v4l2-encode-stream \
ksym-vanilla-ivtv-stop-v4l2-encode-stream \
ksym-vanilla-ivtv-udma-alloc \
ksym-vanilla-ivtv-udma-prepare \
ksym-vanilla-ivtv-udma-setup \
ksym-vanilla-ivtv-udma-unmap \
ksym-vanilla-ivtv-vapi \
ksym-vanilla-ivtv-vapi-result \
ksym-vanilla-iw-cm-accept \
ksym-vanilla-iw-cm-connect \
ksym-vanilla-iw-cm-disconnect \
ksym-vanilla-iw-cm-init-qp-attr \
ksym-vanilla-iw-cm-listen \
ksym-vanilla-iw-cm-reject \
ksym-vanilla-iw-create-cm-id \
ksym-vanilla-iw-destroy-cm-id \
ksym-vanilla-iwcm-reject-msg \
ksym-vanilla-iwe-stream-add-event \
ksym-vanilla-iwe-stream-add-point \
ksym-vanilla-iwe-stream-add-value \
ksym-vanilla-iwl-abort-notification-waits \
ksym-vanilla-iwl-acpi-get-guid-lock-status \
ksym-vanilla-iwl-acpi-get-phy-filters \
ksym-vanilla-iwl-add-mcc-to-tas-block-list \
ksym-vanilla-iwl-average-neg-dbm \
ksym-vanilla-iwl-bios-get-dsbr \
ksym-vanilla-iwl-bios-get-dsm \
ksym-vanilla-iwl-bios-get-eckv \
ksym-vanilla-iwl-bios-get-ewrd-table \
ksym-vanilla-iwl-bios-get-mcc \
ksym-vanilla-iwl-bios-get-phy-filters \
ksym-vanilla-iwl-bios-get-ppag-table \
ksym-vanilla-iwl-bios-get-pwr-limit \
ksym-vanilla-iwl-bios-get-tas-table \
ksym-vanilla-iwl-bios-get-wbem \
ksym-vanilla-iwl-bios-get-wgds-table \
ksym-vanilla-iwl-bios-get-wrds-table \
ksym-vanilla-iwl-clear-bits-prph \
ksym-vanilla-iwl-configure-rxq \
ksym-vanilla-iwl-dbg-tlv-del-timers \
ksym-vanilla-iwl-drv-get-fwname-pre \
ksym-vanilla-iwl-dump-desc-assert \
ksym-vanilla-iwl-force-nmi \
ksym-vanilla-iwl-free-fw-paging \
ksym-vanilla-iwl-fw-dbg-clear-monitor-buf \
ksym-vanilla-iwl-fw-dbg-collect \
ksym-vanilla-iwl-fw-dbg-collect-desc \
ksym-vanilla-iwl-fw-dbg-collect-trig \
ksym-vanilla-iwl-fw-dbg-error-collect \
ksym-vanilla-iwl-fw-dbg-read-d3-debug-data \
ksym-vanilla-iwl-fw-dbg-stop-restart-recording \
ksym-vanilla-iwl-fw-dbg-stop-sync \
ksym-vanilla-iwl-fw-disable-dbg-asserts \
ksym-vanilla-iwl-fw-lookup-assert-desc \
ksym-vanilla-iwl-fw-lookup-cmd-bios-supported-revision \
ksym-vanilla-iwl-fw-lookup-cmd-ver \
ksym-vanilla-iwl-fw-lookup-notif-ver \
ksym-vanilla-iwl-fw-runtime-init \
ksym-vanilla-iwl-fw-runtime-resume \
ksym-vanilla-iwl-fw-runtime-suspend \
ksym-vanilla-iwl-fw-start-dbg-conf \
ksym-vanilla-iwl-fwrt-dump-error-logs \
ksym-vanilla-iwl-fwrt-read-err-table \
ksym-vanilla-iwl-get-cmd-string \
ksym-vanilla-iwl-get-nvm \
ksym-vanilla-iwl-get-shared-mem-conf \
ksym-vanilla-iwl-he-is-sgi \
ksym-vanilla-iwl-init-ht-hw-capab \
ksym-vanilla-iwl-init-notification-wait \
ksym-vanilla-iwl-init-paging \
ksym-vanilla-iwl-init-sband-channels \
ksym-vanilla-iwl-is-ppag-approved \
ksym-vanilla-iwl-is-tas-approved \
ksym-vanilla-iwl-notification-wait \
ksym-vanilla-iwl-notification-wait-init \
ksym-vanilla-iwl-nvm-fixups \
ksym-vanilla-iwl-opmode-deregister \
ksym-vanilla-iwl-opmode-register \
ksym-vanilla-iwl-parse-mei-nvm-data \
ksym-vanilla-iwl-parse-nvm-data \
ksym-vanilla-iwl-parse-nvm-mcc-info \
ksym-vanilla-iwl-parse-tas-selection \
ksym-vanilla-iwl-phy-db-free \
ksym-vanilla-iwl-phy-db-init \
ksym-vanilla-iwl-phy-db-set-section \
ksym-vanilla-iwl-pnvm-load \
ksym-vanilla-iwl-poll-bits-mask \
ksym-vanilla-iwl-puncturing-is-allowed-in-bios \
ksym-vanilla-iwl-rate-mcs \
ksym-vanilla-iwl-read-external-nvm \
ksym-vanilla-iwl-read-prph \
ksym-vanilla-iwl-read32 \
ksym-vanilla-iwl-reinit-cab \
ksym-vanilla-iwl-remove-notification \
ksym-vanilla-iwl-rfi-is-enabled-in-bios \
ksym-vanilla-iwl-rs-pretty-ant \
ksym-vanilla-iwl-rs-pretty-bw \
ksym-vanilla-iwl-sar-fill-profile \
ksym-vanilla-iwl-sar-geo-fill-table \
ksym-vanilla-iwl-sar-geo-support \
ksym-vanilla-iwl-send-phy-db-data \
ksym-vanilla-iwl-set-bits-mask-prph \
ksym-vanilla-iwl-set-bits-prph \
ksym-vanilla-iwl-set-soc-latency \
ksym-vanilla-iwl-trans-activate-nic \
ksym-vanilla-iwl-trans-alloc-tx-cmd \
ksym-vanilla-iwl-trans-d3-resume \
ksym-vanilla-iwl-trans-d3-suspend \
ksym-vanilla-iwl-trans-free-tx-cmd \
ksym-vanilla-iwl-trans-freeze-txq-timer \
ksym-vanilla-iwl-trans-fw-alive \
ksym-vanilla-iwl-trans-grab-nic-access \
ksym-vanilla-iwl-trans-is-ltr-enabled \
ksym-vanilla-iwl-trans-is-pm-supported \
ksym-vanilla-iwl-trans-load-pnvm \
ksym-vanilla-iwl-trans-op-mode-enter \
ksym-vanilla-iwl-trans-op-mode-leave \
ksym-vanilla-iwl-trans-pcie-reset \
ksym-vanilla-iwl-trans-read-mem \
ksym-vanilla-iwl-trans-reclaim \
ksym-vanilla-iwl-trans-release-nic-access \
ksym-vanilla-iwl-trans-send-cmd \
ksym-vanilla-iwl-trans-set-bits-mask \
ksym-vanilla-iwl-trans-set-pmi \
ksym-vanilla-iwl-trans-set-q-ptrs \
ksym-vanilla-iwl-trans-start-fw \
ksym-vanilla-iwl-trans-start-hw \
ksym-vanilla-iwl-trans-stop-device \
ksym-vanilla-iwl-trans-tx \
ksym-vanilla-iwl-trans-txq-alloc \
ksym-vanilla-iwl-trans-txq-disable \
ksym-vanilla-iwl-trans-txq-enable-cfg \
ksym-vanilla-iwl-trans-txq-free \
ksym-vanilla-iwl-trans-txq-set-shared-mode \
ksym-vanilla-iwl-trans-wait-tx-queues-empty \
ksym-vanilla-iwl-trans-wait-txq-empty \
ksym-vanilla-iwl-trans-write-mem \
ksym-vanilla-iwl-tx-tso-segment \
ksym-vanilla-iwl-uefi-get-puncturing \
ksym-vanilla-iwl-uefi-get-sgom-table \
ksym-vanilla-iwl-uefi-get-step-table \
ksym-vanilla-iwl-uefi-get-uats-table \
ksym-vanilla-iwl-uefi-get-uneb-table \
ksym-vanilla-iwl-wait-notification \
ksym-vanilla-iwl-write-direct32 \
ksym-vanilla-iwl-write-prph-delay \
ksym-vanilla-iwl-write32 \
ksym-vanilla-iwl-write64 \
ksym-vanilla-iwl-write8 \
ksym-vanilla-iwlwifi-mod-params \
ksym-vanilla-ix2505v-attach \
ksym-vanilla-ixgbe-xdp-locking-key \
ksym-vanilla-jbd2--journal-restart \
ksym-vanilla-jbd2--journal-start \
ksym-vanilla-jbd2-complete-transaction \
ksym-vanilla-jbd2-fc-begin-commit \
ksym-vanilla-jbd2-fc-end-commit \
ksym-vanilla-jbd2-fc-end-commit-fallback \
ksym-vanilla-jbd2-fc-get-buf \
ksym-vanilla-jbd2-fc-release-bufs \
ksym-vanilla-jbd2-fc-wait-bufs \
ksym-vanilla-jbd2-inode-cache \
ksym-vanilla-jbd2-journal-abort \
ksym-vanilla-jbd2-journal-ack-err \
ksym-vanilla-jbd2-journal-begin-ordered-truncate \
ksym-vanilla-jbd2-journal-blocks-per-folio \
ksym-vanilla-jbd2-journal-check-available-features \
ksym-vanilla-jbd2-journal-check-used-features \
ksym-vanilla-jbd2-journal-clear-err \
ksym-vanilla-jbd2-journal-clear-features \
ksym-vanilla-jbd2-journal-destroy \
ksym-vanilla-jbd2-journal-dirty-metadata \
ksym-vanilla-jbd2-journal-errno \
ksym-vanilla-jbd2-journal-extend \
ksym-vanilla-jbd2-journal-finish-inode-data-buffers \
ksym-vanilla-jbd2-journal-flush \
ksym-vanilla-jbd2-journal-force-commit \
ksym-vanilla-jbd2-journal-force-commit-nested \
ksym-vanilla-jbd2-journal-forget \
ksym-vanilla-jbd2-journal-free-reserved \
ksym-vanilla-jbd2-journal-get-create-access \
ksym-vanilla-jbd2-journal-get-undo-access \
ksym-vanilla-jbd2-journal-get-write-access \
ksym-vanilla-jbd2-journal-grab-journal-head \
ksym-vanilla-jbd2-journal-init-dev \
ksym-vanilla-jbd2-journal-init-inode \
ksym-vanilla-jbd2-journal-init-jbd-inode \
ksym-vanilla-jbd2-journal-inode-ranged-wait \
ksym-vanilla-jbd2-journal-inode-ranged-write \
ksym-vanilla-jbd2-journal-invalidate-folio \
ksym-vanilla-jbd2-journal-load \
ksym-vanilla-jbd2-journal-lock-updates \
ksym-vanilla-jbd2-journal-put-journal-head \
ksym-vanilla-jbd2-journal-release-jbd-inode \
ksym-vanilla-jbd2-journal-restart \
ksym-vanilla-jbd2-journal-revoke \
ksym-vanilla-jbd2-journal-set-features \
ksym-vanilla-jbd2-journal-set-triggers \
ksym-vanilla-jbd2-journal-start \
ksym-vanilla-jbd2-journal-start-commit \
ksym-vanilla-jbd2-journal-start-reserved \
ksym-vanilla-jbd2-journal-stop \
ksym-vanilla-jbd2-journal-try-to-free-buffers \
ksym-vanilla-jbd2-journal-unlock-updates \
ksym-vanilla-jbd2-journal-update-sb-errno \
ksym-vanilla-jbd2-journal-wipe \
ksym-vanilla-jbd2-log-wait-commit \
ksym-vanilla-jbd2-submit-inode-data \
ksym-vanilla-jbd2-trans-will-send-data-barrier \
ksym-vanilla-jbd2-transaction-committed \
ksym-vanilla-jbd2-wait-inode-data \
ksym-vanilla-jiffies \
ksym-vanilla-jiffies-64 \
ksym-vanilla-jiffies-64-to-clock-t \
ksym-vanilla-jiffies-to-clock-t \
ksym-vanilla-jiffies-to-timespec64 \
ksym-vanilla-jiffies64-to-msecs \
ksym-vanilla-jiffies64-to-nsecs \
ksym-vanilla-jump-label-rate-limit \
ksym-vanilla-jump-label-update-timeout \
ksym-vanilla-kasprintf \
ksym-vanilla-kasprintf-strarray \
ksym-vanilla-kblockd-mod-delayed-work-on \
ksym-vanilla-kblockd-schedule-work \
ksym-vanilla-kcpustat-cpu-fetch \
ksym-vanilla-kcpustat-field \
ksym-vanilla-kcpustat-field-idle \
ksym-vanilla-kcpustat-field-iowait \
ksym-vanilla-kcs-bmc-add-device \
ksym-vanilla-kcs-bmc-disable-device \
ksym-vanilla-kcs-bmc-enable-device \
ksym-vanilla-kcs-bmc-handle-event \
ksym-vanilla-kcs-bmc-read-data \
ksym-vanilla-kcs-bmc-read-status \
ksym-vanilla-kcs-bmc-register-driver \
ksym-vanilla-kcs-bmc-remove-device \
ksym-vanilla-kcs-bmc-unregister-driver \
ksym-vanilla-kcs-bmc-update-event-mask \
ksym-vanilla-kcs-bmc-update-status \
ksym-vanilla-kcs-bmc-write-data \
ksym-vanilla-kcs-bmc-write-status \
ksym-vanilla-kd-mksound \
ksym-vanilla-kdb-get-kbd-char \
ksym-vanilla-kdb-grepping-flag \
ksym-vanilla-kdb-poll-funcs \
ksym-vanilla-kdb-poll-idx \
ksym-vanilla-kdb-printf \
ksym-vanilla-kdb-register \
ksym-vanilla-kdb-unregister \
ksym-vanilla-kdbgetsymval \
ksym-vanilla-kempld-get-mutex \
ksym-vanilla-kempld-read16 \
ksym-vanilla-kempld-read32 \
ksym-vanilla-kempld-read8 \
ksym-vanilla-kempld-release-mutex \
ksym-vanilla-kempld-write16 \
ksym-vanilla-kempld-write32 \
ksym-vanilla-kempld-write8 \
ksym-vanilla-kern-mount \
ksym-vanilla-kern-path \
ksym-vanilla-kern-sys-bpf \
ksym-vanilla-kern-unmount \
ksym-vanilla-kern-unmount-array \
ksym-vanilla-kernel-accept \
ksym-vanilla-kernel-bind \
ksym-vanilla-kernel-can-power-off \
ksym-vanilla-kernel-connect \
ksym-vanilla-kernel-cpustat \
ksym-vanilla-kernel-file-open \
ksym-vanilla-kernel-getpeername \
ksym-vanilla-kernel-getsockname \
ksym-vanilla-kernel-halt \
ksym-vanilla-kernel-kobj \
ksym-vanilla-kernel-listen \
ksym-vanilla-kernel-neon-begin \
ksym-vanilla-kernel-neon-end \
ksym-vanilla-kernel-param-lock \
ksym-vanilla-kernel-param-unlock \
ksym-vanilla-kernel-power-off \
ksym-vanilla-kernel-read \
ksym-vanilla-kernel-read-file \
ksym-vanilla-kernel-read-file-from-fd \
ksym-vanilla-kernel-read-file-from-path \
ksym-vanilla-kernel-read-file-from-path-initns \
ksym-vanilla-kernel-recvmsg \
ksym-vanilla-kernel-restart \
ksym-vanilla-kernel-sendmsg \
ksym-vanilla-kernel-setlease \
ksym-vanilla-kernel-sigaction \
ksym-vanilla-kernel-sock-ip-overhead \
ksym-vanilla-kernel-sock-shutdown \
ksym-vanilla-kernel-tmpfile-open \
ksym-vanilla-kernel-write \
ksym-vanilla-kernfs-find-and-get-ns \
ksym-vanilla-kernfs-get \
ksym-vanilla-kernfs-notify \
ksym-vanilla-kernfs-path-from-node \
ksym-vanilla-kernfs-put \
ksym-vanilla-kexec-crash-loaded \
ksym-vanilla-key-alloc \
ksym-vanilla-key-create \
ksym-vanilla-key-create-or-update \
ksym-vanilla-key-instantiate-and-link \
ksym-vanilla-key-invalidate \
ksym-vanilla-key-link \
ksym-vanilla-key-lookup \
ksym-vanilla-key-move \
ksym-vanilla-key-payload-reserve \
ksym-vanilla-key-put \
ksym-vanilla-key-reject-and-link \
ksym-vanilla-key-revoke \
ksym-vanilla-key-set-timeout \
ksym-vanilla-key-task-permission \
ksym-vanilla-key-type-asymmetric \
ksym-vanilla-key-type-encrypted \
ksym-vanilla-key-type-keyring \
ksym-vanilla-key-type-logon \
ksym-vanilla-key-type-rxrpc \
ksym-vanilla-key-type-trusted \
ksym-vanilla-key-type-user \
ksym-vanilla-key-unlink \
ksym-vanilla-key-update \
ksym-vanilla-key-validate \
ksym-vanilla-keygen-init \
ksym-vanilla-keygen-port-hashing-init \
ksym-vanilla-keyring-alloc \
ksym-vanilla-keyring-clear \
ksym-vanilla-keyring-restrict \
ksym-vanilla-keyring-search \
ksym-vanilla-kfence-sample-interval \
ksym-vanilla-kfree \
ksym-vanilla-kfree-const \
ksym-vanilla-kfree-link \
ksym-vanilla-kfree-nolock \
ksym-vanilla-kfree-sensitive \
ksym-vanilla-kfree-skb-list-reason \
ksym-vanilla-kfree-skb-partial \
ksym-vanilla-kfree-strarray \
ksym-vanilla-kgdb-active \
ksym-vanilla-kgdb-breakpoint \
ksym-vanilla-kgdb-connected \
ksym-vanilla-kgdb-register-io-module \
ksym-vanilla-kgdb-unregister-io-module \
ksym-vanilla-kho-add-subtree \
ksym-vanilla-kho-alloc-preserve \
ksym-vanilla-kho-is-enabled \
ksym-vanilla-kho-preserve-folio \
ksym-vanilla-kho-preserve-pages \
ksym-vanilla-kho-preserve-vmalloc \
ksym-vanilla-kho-radix-add-page \
ksym-vanilla-kho-radix-del-page \
ksym-vanilla-kho-radix-walk-tree \
ksym-vanilla-kho-remove-subtree \
ksym-vanilla-kho-restore-folio \
ksym-vanilla-kho-restore-free \
ksym-vanilla-kho-restore-pages \
ksym-vanilla-kho-restore-vmalloc \
ksym-vanilla-kho-retrieve-subtree \
ksym-vanilla-kho-unpreserve-folio \
ksym-vanilla-kho-unpreserve-free \
ksym-vanilla-kho-unpreserve-pages \
ksym-vanilla-kho-unpreserve-vmalloc \
ksym-vanilla-kick-all-cpus-sync \
ksym-vanilla-kick-process \
ksym-vanilla-kill-anon-super \
ksym-vanilla-kill-block-super \
ksym-vanilla-kill-dax \
ksym-vanilla-kill-dev-dax \
ksym-vanilla-kill-device \
ksym-vanilla-kill-fasync \
ksym-vanilla-kill-mtd-super \
ksym-vanilla-kill-pgrp \
ksym-vanilla-kill-pid \
ksym-vanilla-kill-pid-usb-asyncio \
ksym-vanilla-kimage-voffset \
ksym-vanilla-kiocb-invalidate-pages \
ksym-vanilla-kiocb-modified \
ksym-vanilla-kiocb-set-cancel-fn \
ksym-vanilla-kiocb-write-and-wait \
ksym-vanilla-klist-add-before \
ksym-vanilla-klist-add-behind \
ksym-vanilla-klist-add-head \
ksym-vanilla-klist-add-tail \
ksym-vanilla-klist-del \
ksym-vanilla-klist-init \
ksym-vanilla-klist-iter-exit \
ksym-vanilla-klist-iter-init \
ksym-vanilla-klist-iter-init-node \
ksym-vanilla-klist-next \
ksym-vanilla-klist-node-attached \
ksym-vanilla-klist-prev \
ksym-vanilla-klist-remove \
ksym-vanilla-klp-enable-patch \
ksym-vanilla-klp-find-section-by-name \
ksym-vanilla-klp-get-prev-state \
ksym-vanilla-klp-get-state \
ksym-vanilla-klp-shadow-alloc \
ksym-vanilla-klp-shadow-free \
ksym-vanilla-klp-shadow-free-all \
ksym-vanilla-klp-shadow-get \
ksym-vanilla-klp-shadow-get-or-alloc \
ksym-vanilla-km-migrate \
ksym-vanilla-km-new-mapping \
ksym-vanilla-km-policy-expired \
ksym-vanilla-km-policy-notify \
ksym-vanilla-km-query \
ksym-vanilla-km-report \
ksym-vanilla-km-state-expired \
ksym-vanilla-km-state-notify \
ksym-vanilla-kmalloc-caches \
ksym-vanilla-kmalloc-size-roundup \
ksym-vanilla-kmem-buckets-create \
ksym-vanilla-kmem-cache-alloc-bulk-noprof \
ksym-vanilla-kmem-cache-alloc-lru-noprof \
ksym-vanilla-kmem-cache-alloc-node-noprof \
ksym-vanilla-kmem-cache-alloc-noprof \
ksym-vanilla-kmem-cache-charge \
ksym-vanilla-kmem-cache-destroy \
ksym-vanilla-kmem-cache-free \
ksym-vanilla-kmem-cache-free-bulk \
ksym-vanilla-kmem-cache-shrink \
ksym-vanilla-kmem-cache-size \
ksym-vanilla-kmem-dump-obj \
ksym-vanilla-kmemdup-array \
ksym-vanilla-kmemdup-noprof \
ksym-vanilla-kmemdup-nul \
ksym-vanilla-kmsg-dump-get-buffer \
ksym-vanilla-kmsg-dump-get-line \
ksym-vanilla-kmsg-dump-reason-str \
ksym-vanilla-kmsg-dump-register \
ksym-vanilla-kmsg-dump-rewind \
ksym-vanilla-kmsg-dump-unregister \
ksym-vanilla-kobj-ns-drop \
ksym-vanilla-kobj-ns-grab-current \
ksym-vanilla-kobj-sysfs-ops \
ksym-vanilla-kobject-add \
ksym-vanilla-kobject-create-and-add \
ksym-vanilla-kobject-del \
ksym-vanilla-kobject-get \
ksym-vanilla-kobject-get-path \
ksym-vanilla-kobject-get-unless-zero \
ksym-vanilla-kobject-init \
ksym-vanilla-kobject-init-and-add \
ksym-vanilla-kobject-move \
ksym-vanilla-kobject-put \
ksym-vanilla-kobject-rename \
ksym-vanilla-kobject-set-name \
ksym-vanilla-kobject-uevent \
ksym-vanilla-kobject-uevent-env \
ksym-vanilla-kpp-register-instance \
ksym-vanilla-kprobe-event-cmd-init \
ksym-vanilla-kprobe-event-delete \
ksym-vanilla-kptr-restrict \
ksym-vanilla-krealloc-node-align-noprof \
ksym-vanilla-kryo-l2-get-indirect-reg \
ksym-vanilla-kryo-l2-set-indirect-reg \
ksym-vanilla-ks0108-address \
ksym-vanilla-ks0108-displaystate \
ksym-vanilla-ks0108-isinited \
ksym-vanilla-ks0108-page \
ksym-vanilla-ks0108-startline \
ksym-vanilla-ks0108-writecontrol \
ksym-vanilla-ks0108-writedata \
ksym-vanilla-ks8851-probe-common \
ksym-vanilla-ks8851-remove-common \
ksym-vanilla-ks8851-resume \
ksym-vanilla-ks8851-suspend \
ksym-vanilla-kset-create-and-add \
ksym-vanilla-kset-find-obj \
ksym-vanilla-kset-register \
ksym-vanilla-kset-unregister \
ksym-vanilla-ksize \
ksym-vanilla-ksm-madvise \
ksym-vanilla-kstat \
ksym-vanilla-kstrdup \
ksym-vanilla-kstrdup-and-replace \
ksym-vanilla-kstrdup-const \
ksym-vanilla-kstrdup-quotable \
ksym-vanilla-kstrdup-quotable-cmdline \
ksym-vanilla-kstrdup-quotable-file \
ksym-vanilla-kstrndup \
ksym-vanilla-kstrtobool \
ksym-vanilla-kstrtobool-from-user \
ksym-vanilla-kstrtoint \
ksym-vanilla-kstrtoint-from-user \
ksym-vanilla-kstrtol-from-user \
ksym-vanilla-kstrtoll \
ksym-vanilla-kstrtoll-from-user \
ksym-vanilla-kstrtos16 \
ksym-vanilla-kstrtos16-from-user \
ksym-vanilla-kstrtos8 \
ksym-vanilla-kstrtos8-from-user \
ksym-vanilla-kstrtou16 \
ksym-vanilla-kstrtou16-from-user \
ksym-vanilla-kstrtou8 \
ksym-vanilla-kstrtou8-from-user \
ksym-vanilla-kstrtouint \
ksym-vanilla-kstrtouint-from-user \
ksym-vanilla-kstrtoul-from-user \
ksym-vanilla-kstrtoull \
ksym-vanilla-kstrtoull-from-user \
ksym-vanilla-ksys-sync-helper \
ksym-vanilla-ksz-switch-alloc \
ksym-vanilla-ksz-switch-chips \
ksym-vanilla-ksz-switch-register \
ksym-vanilla-ksz-switch-remove \
ksym-vanilla-ksz-switch-resume \
ksym-vanilla-ksz-switch-shutdown \
ksym-vanilla-ksz-switch-suspend \
ksym-vanilla-kthread-affine-preferred \
ksym-vanilla-kthread-associate-blkcg \
ksym-vanilla-kthread-bind \
ksym-vanilla-kthread-cancel-delayed-work-sync \
ksym-vanilla-kthread-cancel-work-sync \
ksym-vanilla-kthread-complete-and-exit \
ksym-vanilla-kthread-create-on-cpu \
ksym-vanilla-kthread-create-on-node \
ksym-vanilla-kthread-create-worker-on-cpu \
ksym-vanilla-kthread-create-worker-on-node \
ksym-vanilla-kthread-data \
ksym-vanilla-kthread-delayed-work-timer-fn \
ksym-vanilla-kthread-destroy-worker \
ksym-vanilla-kthread-flush-work \
ksym-vanilla-kthread-flush-worker \
ksym-vanilla-kthread-freezable-should-stop \
ksym-vanilla-kthread-func \
ksym-vanilla-kthread-mod-delayed-work \
ksym-vanilla-kthread-park \
ksym-vanilla-kthread-parkme \
ksym-vanilla-kthread-queue-delayed-work \
ksym-vanilla-kthread-queue-work \
ksym-vanilla-kthread-should-park \
ksym-vanilla-kthread-should-stop \
ksym-vanilla-kthread-stop \
ksym-vanilla-kthread-stop-put \
ksym-vanilla-kthread-unpark \
ksym-vanilla-kthread-unuse-mm \
ksym-vanilla-kthread-use-mm \
ksym-vanilla-kthread-worker-fn \
ksym-vanilla-ktime-add-safe \
ksym-vanilla-ktime-get \
ksym-vanilla-ktime-get-aux \
ksym-vanilla-ktime-get-aux-ts64 \
ksym-vanilla-ktime-get-boot-fast-ns \
ksym-vanilla-ktime-get-clock-ts64 \
ksym-vanilla-ktime-get-coarse-real-ts64 \
ksym-vanilla-ktime-get-coarse-ts64 \
ksym-vanilla-ktime-get-coarse-with-offset \
ksym-vanilla-ktime-get-mono-fast-ns \
ksym-vanilla-ktime-get-raw \
ksym-vanilla-ktime-get-raw-fast-ns \
ksym-vanilla-ktime-get-raw-ts64 \
ksym-vanilla-ktime-get-real-fast-ns \
ksym-vanilla-ktime-get-real-seconds \
ksym-vanilla-ktime-get-real-ts64 \
ksym-vanilla-ktime-get-resolution-ns \
ksym-vanilla-ktime-get-seconds \
ksym-vanilla-ktime-get-snapshot-id \
ksym-vanilla-ktime-get-tai-fast-ns \
ksym-vanilla-ktime-get-ts64 \
ksym-vanilla-ktime-get-with-offset \
ksym-vanilla-ktime-mono-to-any \
ksym-vanilla-ktime-real-to-base-clock \
ksym-vanilla-kvasprintf \
ksym-vanilla-kvasprintf-const \
ksym-vanilla-kvfree \
ksym-vanilla-kvfree-atomic \
ksym-vanilla-kvfree-call-rcu \
ksym-vanilla-kvfree-rcu-barrier \
ksym-vanilla-kvfree-rcu-barrier-on-cache \
ksym-vanilla-kvfree-sensitive \
ksym-vanilla-kvm-arch-ptp-get-crosststamp \
ksym-vanilla-kvm-arm-hyp-service-available \
ksym-vanilla-kvm-disable-trbe \
ksym-vanilla-kvm-enable-trbe \
ksym-vanilla-kvm-get-kvm \
ksym-vanilla-kvm-get-kvm-safe \
ksym-vanilla-kvm-put-kvm \
ksym-vanilla-kvm-tracing-set-el1-configuration \
ksym-vanilla-kvmemdup \
ksym-vanilla-kvrealloc-node-align-noprof \
ksym-vanilla-l2cap-add-psm \
ksym-vanilla-l2cap-chan-close \
ksym-vanilla-l2cap-chan-connect \
ksym-vanilla-l2cap-chan-create \
ksym-vanilla-l2cap-chan-del \
ksym-vanilla-l2cap-chan-hold \
ksym-vanilla-l2cap-chan-list \
ksym-vanilla-l2cap-chan-put \
ksym-vanilla-l2cap-chan-send \
ksym-vanilla-l2cap-chan-set-defaults \
ksym-vanilla-l2cap-conn-get \
ksym-vanilla-l2cap-conn-hold-unless-zero \
ksym-vanilla-l2cap-conn-put \
ksym-vanilla-l2cap-is-socket \
ksym-vanilla-l2cap-register-user \
ksym-vanilla-l2cap-unregister-user \
ksym-vanilla-l2tp-ioctl \
ksym-vanilla-l2tp-nl-register-ops \
ksym-vanilla-l2tp-nl-unregister-ops \
ksym-vanilla-l2tp-recv-common \
ksym-vanilla-l2tp-session-create \
ksym-vanilla-l2tp-session-delete \
ksym-vanilla-l2tp-session-get \
ksym-vanilla-l2tp-session-get-by-ifname \
ksym-vanilla-l2tp-session-get-next \
ksym-vanilla-l2tp-session-put \
ksym-vanilla-l2tp-session-register \
ksym-vanilla-l2tp-session-set-header-len \
ksym-vanilla-l2tp-sk-to-tunnel \
ksym-vanilla-l2tp-tunnel-create \
ksym-vanilla-l2tp-tunnel-delete \
ksym-vanilla-l2tp-tunnel-get \
ksym-vanilla-l2tp-tunnel-get-next \
ksym-vanilla-l2tp-tunnel-put \
ksym-vanilla-l2tp-tunnel-register \
ksym-vanilla-l2tp-udp-encap-recv \
ksym-vanilla-l2tp-v2-session-get \
ksym-vanilla-l2tp-v3-session-get \
ksym-vanilla-l2tp-xmit-skb \
ksym-vanilla-l3mdev-fib-table-by-index \
ksym-vanilla-l3mdev-fib-table-rcu \
ksym-vanilla-l3mdev-ifindex-lookup-by-table-id \
ksym-vanilla-l3mdev-link-scope-lookup \
ksym-vanilla-l3mdev-master-ifindex-rcu \
ksym-vanilla-l3mdev-master-upper-ifindex-by-index-rcu \
ksym-vanilla-l3mdev-table-lookup-register \
ksym-vanilla-l3mdev-table-lookup-unregister \
ksym-vanilla-l3mdev-update-flow \
ksym-vanilla-l64781-attach \
ksym-vanilla-lan87xx-read-status \
ksym-vanilla-lan9303-indirect-phy-ops \
ksym-vanilla-lan9303-probe \
ksym-vanilla-lan9303-register-set \
ksym-vanilla-lan9303-remove \
ksym-vanilla-lan9303-shutdown \
ksym-vanilla-lapb-connect-request \
ksym-vanilla-lapb-data-received \
ksym-vanilla-lapb-data-request \
ksym-vanilla-lapb-disconnect-request \
ksym-vanilla-lapb-getparms \
ksym-vanilla-lapb-register \
ksym-vanilla-lapb-setparms \
ksym-vanilla-lapb-unregister \
ksym-vanilla-layoutstats-timer \
ksym-vanilla-lbs-add-card \
ksym-vanilla-lbs-cmd-copyback \
ksym-vanilla-lbs-debug \
ksym-vanilla-lbs-get-firmware \
ksym-vanilla-lbs-get-firmware-async \
ksym-vanilla-lbs-host-sleep-cfg \
ksym-vanilla-lbs-host-to-card-done \
ksym-vanilla-lbs-notify-command-response \
ksym-vanilla-lbs-process-rxed-packet \
ksym-vanilla-lbs-queue-event \
ksym-vanilla-lbs-remove-card \
ksym-vanilla-lbs-resume \
ksym-vanilla-lbs-send-tx-feedback \
ksym-vanilla-lbs-start-card \
ksym-vanilla-lbs-stop-card \
ksym-vanilla-lbs-suspend \
ksym-vanilla-lbtf-add-card \
ksym-vanilla-lbtf-bcn-sent \
ksym-vanilla-lbtf-cmd-copyback \
ksym-vanilla-lbtf-cmd-response-rx \
ksym-vanilla-lbtf-debug \
ksym-vanilla-lbtf-remove-card \
ksym-vanilla-lbtf-rx \
ksym-vanilla-lbtf-send-tx-feedback \
ksym-vanilla-lc-committed \
ksym-vanilla-lc-create \
ksym-vanilla-lc-del \
ksym-vanilla-lc-destroy \
ksym-vanilla-lc-element-by-index \
ksym-vanilla-lc-find \
ksym-vanilla-lc-get \
ksym-vanilla-lc-get-cumulative \
ksym-vanilla-lc-is-used \
ksym-vanilla-lc-put \
ksym-vanilla-lc-reset \
ksym-vanilla-lc-seq-dump-details \
ksym-vanilla-lc-seq-printf-stats \
ksym-vanilla-lc-try-get \
ksym-vanilla-lc-try-lock \
ksym-vanilla-lcd-device-register \
ksym-vanilla-lcd-device-unregister \
ksym-vanilla-lcd-notify-blank-all \
ksym-vanilla-lcd-notify-mode-change-all \
ksym-vanilla-lcm \
ksym-vanilla-lcm-not-zero \
ksym-vanilla-ldb-add-bridge-helper \
ksym-vanilla-ldb-bridge-atomic-check-helper \
ksym-vanilla-ldb-bridge-attach-helper \
ksym-vanilla-ldb-bridge-disable-helper \
ksym-vanilla-ldb-bridge-enable-helper \
ksym-vanilla-ldb-bridge-mode-set-helper \
ksym-vanilla-ldb-channel-is-single-link \
ksym-vanilla-ldb-channel-is-split-link \
ksym-vanilla-ldb-find-next-bridge-helper \
ksym-vanilla-ldb-init-helper \
ksym-vanilla-ldb-remove-bridge-helper \
ksym-vanilla-lease-get-mtime \
ksym-vanilla-lease-modify \
ksym-vanilla-lease-register-notifier \
ksym-vanilla-lease-unregister-notifier \
ksym-vanilla-led-add-lookup \
ksym-vanilla-led-blink-set \
ksym-vanilla-led-blink-set-nosleep \
ksym-vanilla-led-blink-set-oneshot \
ksym-vanilla-led-classdev-flash-register-ext \
ksym-vanilla-led-classdev-flash-unregister \
ksym-vanilla-led-classdev-multicolor-register-ext \
ksym-vanilla-led-classdev-multicolor-unregister \
ksym-vanilla-led-classdev-notify-brightness-hw-changed \
ksym-vanilla-led-classdev-register-ext \
ksym-vanilla-led-classdev-resume \
ksym-vanilla-led-classdev-suspend \
ksym-vanilla-led-classdev-unregister \
ksym-vanilla-led-compose-name \
ksym-vanilla-led-get \
ksym-vanilla-led-get-color-name \
ksym-vanilla-led-get-default-pattern \
ksym-vanilla-led-get-flash-fault \
ksym-vanilla-led-init-core \
ksym-vanilla-led-init-default-state-get \
ksym-vanilla-led-mc-calc-color-components \
ksym-vanilla-led-mc-set-brightness \
ksym-vanilla-led-mc-trigger-event \
ksym-vanilla-led-put \
ksym-vanilla-led-remove-lookup \
ksym-vanilla-led-set-brightness \
ksym-vanilla-led-set-brightness-nopm \
ksym-vanilla-led-set-brightness-nosleep \
ksym-vanilla-led-set-brightness-sync \
ksym-vanilla-led-set-flash-brightness \
ksym-vanilla-led-set-flash-duration \
ksym-vanilla-led-set-flash-timeout \
ksym-vanilla-led-stop-software-blink \
ksym-vanilla-led-sysfs-disable \
ksym-vanilla-led-sysfs-enable \
ksym-vanilla-led-trigger-blink \
ksym-vanilla-led-trigger-blink-oneshot \
ksym-vanilla-led-trigger-event \
ksym-vanilla-led-trigger-read \
ksym-vanilla-led-trigger-register \
ksym-vanilla-led-trigger-register-simple \
ksym-vanilla-led-trigger-remove \
ksym-vanilla-led-trigger-set \
ksym-vanilla-led-trigger-set-default \
ksym-vanilla-led-trigger-unregister \
ksym-vanilla-led-trigger-unregister-simple \
ksym-vanilla-led-trigger-write \
ksym-vanilla-led-update-brightness \
ksym-vanilla-led-update-flash-brightness \
ksym-vanilla-leds-list \
ksym-vanilla-leds-list-lock \
ksym-vanilla-ledtrig-backlight-blank \
ksym-vanilla-ledtrig-cpu \
ksym-vanilla-ledtrig-disk-activity \
ksym-vanilla-ledtrig-flash-ctrl \
ksym-vanilla-ledtrig-mtd-activity \
ksym-vanilla-ledtrig-torch-ctrl \
ksym-vanilla-lg2160-attach \
ksym-vanilla-lgdt3305-attach \
ksym-vanilla-lgdt3306a-attach \
ksym-vanilla-lgdt330x-attach \
ksym-vanilla-lgs8gl5-attach \
ksym-vanilla-lgs8gxx-attach \
ksym-vanilla-libceph-compatible \
ksym-vanilla-libeth-attach-xdp \
ksym-vanilla-libeth-rx-fq-create \
ksym-vanilla-libeth-rx-fq-destroy \
ksym-vanilla-libeth-rx-pt-gen-hash-type \
ksym-vanilla-libeth-rx-recycle-slow \
ksym-vanilla-libeth-tx-complete-any \
ksym-vanilla-libeth-xdp-buff-add-frag \
ksym-vanilla-libeth-xdp-load-stash \
ksym-vanilla-libeth-xdp-prog-exception \
ksym-vanilla-libeth-xdp-queue-threshold \
ksym-vanilla-libeth-xdp-return-buff-bulk \
ksym-vanilla-libeth-xdp-return-buff-slow \
ksym-vanilla-libeth-xdp-save-stash \
ksym-vanilla-libeth-xdp-set-redirect \
ksym-vanilla-libeth-xdp-tx-exception \
ksym-vanilla-libeth-xdp-xmit-return-bulk \
ksym-vanilla-libeth-xdpsq-init-timer \
ksym-vanilla-libeth-xdpsq-share \
ksym-vanilla-libeth-xsk-buff-add-frag \
ksym-vanilla-libeth-xsk-buff-free-slow \
ksym-vanilla-libeth-xsk-buff-stats-frags \
ksym-vanilla-libeth-xsk-init-wakeup \
ksym-vanilla-libeth-xsk-setup-pool \
ksym-vanilla-libeth-xsk-wakeup \
ksym-vanilla-libeth-xskfq-create \
ksym-vanilla-libeth-xskfq-destroy \
ksym-vanilla-libfc-vport-create \
ksym-vanilla-libie-aq-str \
ksym-vanilla-libie-fwlog-deinit \
ksym-vanilla-libie-fwlog-init \
ksym-vanilla-libie-fwlog-reregister \
ksym-vanilla-libie-get-fwlog-data \
ksym-vanilla-libie-rx-pt-lut \
ksym-vanilla-libipw-channel-to-freq \
ksym-vanilla-libipw-channel-to-index \
ksym-vanilla-libipw-crypt-delayed-deinit \
ksym-vanilla-libipw-crypt-info-free \
ksym-vanilla-libipw-crypt-info-init \
ksym-vanilla-libipw-debug-level \
ksym-vanilla-libipw-freq-to-channel \
ksym-vanilla-libipw-get-channel \
ksym-vanilla-libipw-get-channel-flags \
ksym-vanilla-libipw-get-crypto-ops \
ksym-vanilla-libipw-get-geo \
ksym-vanilla-libipw-is-valid-channel \
ksym-vanilla-libipw-networks-age \
ksym-vanilla-libipw-register-crypto-ops \
ksym-vanilla-libipw-rx \
ksym-vanilla-libipw-rx-mgt \
ksym-vanilla-libipw-set-geo \
ksym-vanilla-libipw-txb-free \
ksym-vanilla-libipw-unregister-crypto-ops \
ksym-vanilla-libipw-wx-get-encode \
ksym-vanilla-libipw-wx-get-encodeext \
ksym-vanilla-libipw-wx-get-scan \
ksym-vanilla-libipw-wx-set-encode \
ksym-vanilla-libipw-wx-set-encodeext \
ksym-vanilla-libipw-xmit \
ksym-vanilla-line6-alloc-sysex-buffer \
ksym-vanilla-line6-disconnect \
ksym-vanilla-line6-init-midi \
ksym-vanilla-line6-init-pcm \
ksym-vanilla-line6-midi-id \
ksym-vanilla-line6-pcm-acquire \
ksym-vanilla-line6-pcm-release \
ksym-vanilla-line6-probe \
ksym-vanilla-line6-read-data \
ksym-vanilla-line6-read-serial-number \
ksym-vanilla-line6-resume \
ksym-vanilla-line6-send-raw-message \
ksym-vanilla-line6-send-raw-message-async \
ksym-vanilla-line6-send-sysex-message \
ksym-vanilla-line6-suspend \
ksym-vanilla-line6-version-request-async \
ksym-vanilla-line6-write-data \
ksym-vanilla-linear-eotf \
ksym-vanilla-linear-range-get-max-value \
ksym-vanilla-linear-range-get-selector-high \
ksym-vanilla-linear-range-get-selector-high-array \
ksym-vanilla-linear-range-get-selector-low \
ksym-vanilla-linear-range-get-selector-low-array \
ksym-vanilla-linear-range-get-selector-within \
ksym-vanilla-linear-range-get-value \
ksym-vanilla-linear-range-get-value-array \
ksym-vanilla-linear-range-values-in-range \
ksym-vanilla-linear-range-values-in-range-array \
ksym-vanilla-linedisp-attach \
ksym-vanilla-linedisp-detach \
ksym-vanilla-linedisp-register \
ksym-vanilla-linedisp-unregister \
ksym-vanilla-link-mode-params \
ksym-vanilla-linkmode-resolve-pause \
ksym-vanilla-linkmode-set-pause \
ksym-vanilla-linkwatch-fire-event \
ksym-vanilla-lio-delete-glists \
ksym-vanilla-lio-enable-irq \
ksym-vanilla-lio-fetch-stats \
ksym-vanilla-lio-get-device \
ksym-vanilla-lio-get-state-string \
ksym-vanilla-lio-pci-readq \
ksym-vanilla-lio-pci-writeq \
ksym-vanilla-lio-process-iq-request-list \
ksym-vanilla-lio-process-ordered-list \
ksym-vanilla-lio-setup-cn66xx-octeon-device \
ksym-vanilla-lio-setup-cn68xx-octeon-device \
ksym-vanilla-lio-setup-glists \
ksym-vanilla-lio-wait-for-clean-oq \
ksym-vanilla-lio-wait-for-instr-fetch \
ksym-vanilla-liquidio-change-mtu \
ksym-vanilla-liquidio-get-fec \
ksym-vanilla-liquidio-get-speed \
ksym-vanilla-liquidio-link-ctrl-cmd-completion \
ksym-vanilla-liquidio-set-ethtool-ops \
ksym-vanilla-liquidio-set-feature \
ksym-vanilla-liquidio-setup-io-queues \
ksym-vanilla-lirc-scancode-event \
ksym-vanilla-lis3-dev \
ksym-vanilla-lis3lv02d-init-device \
ksym-vanilla-lis3lv02d-init-dt \
ksym-vanilla-lis3lv02d-joystick-disable \
ksym-vanilla-lis3lv02d-joystick-enable \
ksym-vanilla-lis3lv02d-poweroff \
ksym-vanilla-lis3lv02d-poweron \
ksym-vanilla-lis3lv02d-remove-fs \
ksym-vanilla-list-lru-add \
ksym-vanilla-list-lru-add-obj \
ksym-vanilla-list-lru-count-node \
ksym-vanilla-list-lru-count-one \
ksym-vanilla-list-lru-del-obj \
ksym-vanilla-list-lru-destroy \
ksym-vanilla-list-lru-isolate \
ksym-vanilla-list-lru-isolate-move \
ksym-vanilla-list-lru-walk-node \
ksym-vanilla-list-lru-walk-one \
ksym-vanilla-list-sort \
ksym-vanilla-ljca-register-event-cb \
ksym-vanilla-ljca-transfer \
ksym-vanilla-ljca-transfer-noack \
ksym-vanilla-ljca-unregister-event-cb \
ksym-vanilla-llc-add-pack \
ksym-vanilla-llc-build-and-send-ui-pkt \
ksym-vanilla-llc-mac-hdr-init \
ksym-vanilla-llc-remove-pack \
ksym-vanilla-llc-sap-close \
ksym-vanilla-llc-sap-find \
ksym-vanilla-llc-sap-list \
ksym-vanilla-llc-sap-open \
ksym-vanilla-llc-set-station-handler \
ksym-vanilla-llcc-get-slice-id \
ksym-vanilla-llcc-get-slice-size \
ksym-vanilla-llcc-slice-activate \
ksym-vanilla-llcc-slice-deactivate \
ksym-vanilla-llcc-slice-getd \
ksym-vanilla-llcc-slice-putd \
ksym-vanilla-llist-del-first \
ksym-vanilla-llist-del-first-this \
ksym-vanilla-llist-reverse-order \
ksym-vanilla-lm3533-ctrlbank-disable \
ksym-vanilla-lm3533-ctrlbank-enable \
ksym-vanilla-lm3533-ctrlbank-get-brightness \
ksym-vanilla-lm3533-ctrlbank-get-pwm \
ksym-vanilla-lm3533-ctrlbank-set-brightness \
ksym-vanilla-lm3533-ctrlbank-set-max-current \
ksym-vanilla-lm3533-ctrlbank-set-pwm \
ksym-vanilla-lm3533-read \
ksym-vanilla-lm3533-update \
ksym-vanilla-lm3533-write \
ksym-vanilla-lnbh24-attach \
ksym-vanilla-lnbh25-attach \
ksym-vanilla-lnbh29-attach \
ksym-vanilla-lnbp21-attach \
ksym-vanilla-lnbp22-attach \
ksym-vanilla-load-nls \
ksym-vanilla-load-nls-default \
ksym-vanilla-lochnagar-update-config \
ksym-vanilla-lock-sock-nested \
ksym-vanilla-lock-system-sleep \
ksym-vanilla-lock-two-nondirectories \
ksym-vanilla-lockd-down \
ksym-vanilla-lockd-up \
ksym-vanilla-lockdep-assert-cpus-held \
ksym-vanilla-locked-recursive-removal \
ksym-vanilla-lockref-get \
ksym-vanilla-lockref-get-not-dead \
ksym-vanilla-lockref-get-not-zero \
ksym-vanilla-lockref-mark-dead \
ksym-vanilla-lockref-put-or-lock \
ksym-vanilla-lockref-put-return \
ksym-vanilla-locks-alloc-lease \
ksym-vanilla-locks-alloc-lock \
ksym-vanilla-locks-copy-conflock \
ksym-vanilla-locks-copy-lock \
ksym-vanilla-locks-delete-block \
ksym-vanilla-locks-end-grace \
ksym-vanilla-locks-free-lease \
ksym-vanilla-locks-free-lock \
ksym-vanilla-locks-in-grace \
ksym-vanilla-locks-init-lease \
ksym-vanilla-locks-init-lock \
ksym-vanilla-locks-lock-inode-wait \
ksym-vanilla-locks-owner-has-blockers \
ksym-vanilla-locks-release-private \
ksym-vanilla-locks-remove-posix \
ksym-vanilla-locks-start-grace \
ksym-vanilla-log-non-standard-event \
ksym-vanilla-logfc \
ksym-vanilla-logic-inb \
ksym-vanilla-logic-inl \
ksym-vanilla-logic-insb \
ksym-vanilla-logic-insl \
ksym-vanilla-logic-insw \
ksym-vanilla-logic-inw \
ksym-vanilla-logic-outb \
ksym-vanilla-logic-outl \
ksym-vanilla-logic-outsb \
ksym-vanilla-logic-outsl \
ksym-vanilla-logic-outsw \
ksym-vanilla-logic-outw \
ksym-vanilla-look-up-OID \
ksym-vanilla-lookup-bdev \
ksym-vanilla-lookup-constant \
ksym-vanilla-lookup-noperm \
ksym-vanilla-lookup-noperm-positive-unlocked \
ksym-vanilla-lookup-noperm-unlocked \
ksym-vanilla-lookup-one \
ksym-vanilla-lookup-one-positive-killable \
ksym-vanilla-lookup-one-positive-unlocked \
ksym-vanilla-lookup-one-unlocked \
ksym-vanilla-lookup-user-key \
ksym-vanilla-loops-per-jiffy \
ksym-vanilla-lowpan-header-compress \
ksym-vanilla-lowpan-header-decompress \
ksym-vanilla-lowpan-nhc-add \
ksym-vanilla-lowpan-nhc-del \
ksym-vanilla-lowpan-register-netdev \
ksym-vanilla-lowpan-register-netdevice \
ksym-vanilla-lowpan-unregister-netdev \
ksym-vanilla-lowpan-unregister-netdevice \
ksym-vanilla-lp3943-read-byte \
ksym-vanilla-lp3943-update-bits \
ksym-vanilla-lp3943-write-byte \
ksym-vanilla-lp55xx-firmware-loaded-cb \
ksym-vanilla-lp55xx-is-extclk-used \
ksym-vanilla-lp55xx-led-brightness \
ksym-vanilla-lp55xx-load-engine \
ksym-vanilla-lp55xx-multicolor-brightness \
ksym-vanilla-lp55xx-probe \
ksym-vanilla-lp55xx-read \
ksym-vanilla-lp55xx-remove \
ksym-vanilla-lp55xx-run-engine-common \
ksym-vanilla-lp55xx-set-led-current \
ksym-vanilla-lp55xx-show-engine-leds \
ksym-vanilla-lp55xx-show-engine-mode \
ksym-vanilla-lp55xx-show-master-fader \
ksym-vanilla-lp55xx-show-master-fader-leds \
ksym-vanilla-lp55xx-stop-all-engine \
ksym-vanilla-lp55xx-stop-engine \
ksym-vanilla-lp55xx-store-engine-leds \
ksym-vanilla-lp55xx-store-engine-load \
ksym-vanilla-lp55xx-store-engine-mode \
ksym-vanilla-lp55xx-store-master-fader \
ksym-vanilla-lp55xx-store-master-fader-leds \
ksym-vanilla-lp55xx-turn-off-channels \
ksym-vanilla-lp55xx-update-bits \
ksym-vanilla-lp55xx-update-program-memory \
ksym-vanilla-lp55xx-write \
ksym-vanilla-lp5860-device-init \
ksym-vanilla-lp5860-device-remove \
ksym-vanilla-lpass-macro-get-codec-version \
ksym-vanilla-lpass-macro-pds-exit \
ksym-vanilla-lpass-macro-pds-init \
ksym-vanilla-lpass-macro-set-codec-version \
ksym-vanilla-lpc-ich-gpio-swnode \
ksym-vanilla-lpddr-cmdset \
ksym-vanilla-lpi-pinctrl-probe \
ksym-vanilla-lpi-pinctrl-remove \
ksym-vanilla-lruvec-stat-mod-folio \
ksym-vanilla-lskcipher-alloc-instance-simple \
ksym-vanilla-lskcipher-register-instance \
ksym-vanilla-ltc2497core-probe \
ksym-vanilla-ltc2497core-remove \
ksym-vanilla-ltc2947-core-probe \
ksym-vanilla-ltc2947-of-match \
ksym-vanilla-ltc2947-pm-ops \
ksym-vanilla-lwq-dequeue-all \
ksym-vanilla-lwtstate-free \
ksym-vanilla-lwtunnel-build-state \
ksym-vanilla-lwtunnel-cmp-encap \
ksym-vanilla-lwtunnel-encap-add-ops \
ksym-vanilla-lwtunnel-encap-del-ops \
ksym-vanilla-lwtunnel-fill-encap \
ksym-vanilla-lwtunnel-get-encap-size \
ksym-vanilla-lwtunnel-input \
ksym-vanilla-lwtunnel-output \
ksym-vanilla-lwtunnel-state-alloc \
ksym-vanilla-lwtunnel-valid-encap-type \
ksym-vanilla-lwtunnel-valid-encap-type-attr \
ksym-vanilla-lwtunnel-xmit \
ksym-vanilla-lynx-lane-mode-str \
ksym-vanilla-lynx-lane-supports-mode \
ksym-vanilla-lynx-pccr-read \
ksym-vanilla-lynx-pccr-write \
ksym-vanilla-lynx-pcs-create-fwnode \
ksym-vanilla-lynx-pcs-create-mdiodev \
ksym-vanilla-lynx-pcs-destroy \
ksym-vanilla-lynx-pcvt-read \
ksym-vanilla-lynx-pcvt-rmw \
ksym-vanilla-lynx-pcvt-write \
ksym-vanilla-lynx-phy-mode-to-lane-mode \
ksym-vanilla-lynx-pll-get \
ksym-vanilla-lynx-probe \
ksym-vanilla-lynx-remove \
ksym-vanilla-lzo1x-1-compress \
ksym-vanilla-lzo1x-1-compress-safe \
ksym-vanilla-lzo1x-decompress-safe \
ksym-vanilla-lzorle1x-1-compress \
ksym-vanilla-lzorle1x-1-compress-safe \
ksym-vanilla-m-can-check-mram-cfg \
ksym-vanilla-m-can-class-allocate-dev \
ksym-vanilla-m-can-class-free-dev \
ksym-vanilla-m-can-class-get-clocks \
ksym-vanilla-m-can-class-register \
ksym-vanilla-m-can-class-resume \
ksym-vanilla-m-can-class-suspend \
ksym-vanilla-m-can-class-unregister \
ksym-vanilla-m88ds3103-attach \
ksym-vanilla-m88ds3103-get-agc-pwm \
ksym-vanilla-m88rs2000-attach \
ksym-vanilla-ma35d1-reg-adc-clkdiv \
ksym-vanilla-ma35d1-reg-clk-pll \
ksym-vanilla-mac-pton \
ksym-vanilla-macsec-get-real-dev \
ksym-vanilla-macsec-netdev-is-offloaded \
ksym-vanilla-macsec-pn-wrapped \
ksym-vanilla-macvlan-common-newlink \
ksym-vanilla-macvlan-common-setup \
ksym-vanilla-macvlan-dellink \
ksym-vanilla-macvlan-link-register \
ksym-vanilla-madera-dev-exit \
ksym-vanilla-madera-dev-init \
ksym-vanilla-madera-name-from-type \
ksym-vanilla-madera-of-match \
ksym-vanilla-madera-pm-ops \
ksym-vanilla-make-bad-inode \
ksym-vanilla-make-device-exclusive \
ksym-vanilla-make-flow-keys-digest \
ksym-vanilla-make-kgid \
ksym-vanilla-make-kprojid \
ksym-vanilla-make-kuid \
ksym-vanilla-make-vfsgid \
ksym-vanilla-make-vfsuid \
ksym-vanilla-mana-cfg-vport \
ksym-vanilla-mana-create-eq \
ksym-vanilla-mana-create-wq-obj \
ksym-vanilla-mana-destroy-eq \
ksym-vanilla-mana-destroy-wq-obj \
ksym-vanilla-mana-disable-vport-rx \
ksym-vanilla-mana-gd-create-mana-eq \
ksym-vanilla-mana-gd-create-mana-wq-cq \
ksym-vanilla-mana-gd-destroy-dma-region \
ksym-vanilla-mana-gd-destroy-queue \
ksym-vanilla-mana-gd-get-gic \
ksym-vanilla-mana-gd-poll-cq \
ksym-vanilla-mana-gd-post-work-request \
ksym-vanilla-mana-gd-put-gic \
ksym-vanilla-mana-gd-ring-cq \
ksym-vanilla-mana-gd-send-request \
ksym-vanilla-mana-gd-wq-ring-doorbell \
ksym-vanilla-mana-get-primary-netdev \
ksym-vanilla-mana-uncfg-vport \
ksym-vanilla-mangle-path \
ksym-vanilla-mantis-ca-exit \
ksym-vanilla-mantis-ca-init \
ksym-vanilla-mantis-dma-exit \
ksym-vanilla-mantis-dma-init \
ksym-vanilla-mantis-dvb-exit \
ksym-vanilla-mantis-dvb-init \
ksym-vanilla-mantis-frontend-power \
ksym-vanilla-mantis-frontend-soft-reset \
ksym-vanilla-mantis-get-mac \
ksym-vanilla-mantis-gpio-set-bits \
ksym-vanilla-mantis-i2c-exit \
ksym-vanilla-mantis-i2c-init \
ksym-vanilla-mantis-input-exit \
ksym-vanilla-mantis-input-init \
ksym-vanilla-mantis-pci-exit \
ksym-vanilla-mantis-pci-init \
ksym-vanilla-mantis-stream-control \
ksym-vanilla-mantis-uart-exit \
ksym-vanilla-mantis-uart-init \
ksym-vanilla-map-destroy \
ksym-vanilla-map-kernel-pages-complete \
ksym-vanilla-map-kernel-pages-prepare \
ksym-vanilla-mapping-read-folio-gfp \
ksym-vanilla-mapping-wrprotect-range \
ksym-vanilla-mark-buffer-dirty \
ksym-vanilla-mark-buffer-write-io-error \
ksym-vanilla-mark-info-dirty \
ksym-vanilla-mark-mounts-for-expiry \
ksym-vanilla-mark-page-accessed \
ksym-vanilla-mas-alloc-cyclic \
ksym-vanilla-mas-destroy \
ksym-vanilla-mas-empty-area \
ksym-vanilla-mas-empty-area-rev \
ksym-vanilla-mas-erase \
ksym-vanilla-mas-find \
ksym-vanilla-mas-find-range \
ksym-vanilla-mas-find-range-rev \
ksym-vanilla-mas-find-rev \
ksym-vanilla-mas-next \
ksym-vanilla-mas-next-range \
ksym-vanilla-mas-pause \
ksym-vanilla-mas-preallocate \
ksym-vanilla-mas-prev \
ksym-vanilla-mas-prev-range \
ksym-vanilla-mas-store \
ksym-vanilla-mas-store-gfp \
ksym-vanilla-mas-store-prealloc \
ksym-vanilla-mas-walk \
ksym-vanilla-match-devname-and-update-preferred-console \
ksym-vanilla-match-hex \
ksym-vanilla-match-int \
ksym-vanilla-match-octal \
ksym-vanilla-match-strdup \
ksym-vanilla-match-string \
ksym-vanilla-match-strlcpy \
ksym-vanilla-match-token \
ksym-vanilla-match-u64 \
ksym-vanilla-match-uint \
ksym-vanilla-match-wildcard \
ksym-vanilla-matrix-keypad-build-keymap \
ksym-vanilla-matrix-keypad-parse-properties \
ksym-vanilla-max-session-cb-slots \
ksym-vanilla-max-session-slots \
ksym-vanilla-max2165-attach \
ksym-vanilla-max77759-maxq-command \
ksym-vanilla-max9271-clear-gpios \
ksym-vanilla-max9271-configure-gmsl-link \
ksym-vanilla-max9271-configure-i2c \
ksym-vanilla-max9271-disable-gpios \
ksym-vanilla-max9271-enable-gpios \
ksym-vanilla-max9271-set-address \
ksym-vanilla-max9271-set-deserializer-address \
ksym-vanilla-max9271-set-gpios \
ksym-vanilla-max9271-set-high-threshold \
ksym-vanilla-max9271-set-serial-link \
ksym-vanilla-max9271-set-translation \
ksym-vanilla-max9271-verify-id \
ksym-vanilla-max9271-wake-up \
ksym-vanilla-max98095-jack-detect \
ksym-vanilla-max98373-reset \
ksym-vanilla-max98373-slot-config \
ksym-vanilla-may-create-dentry \
ksym-vanilla-may-delete-dentry \
ksym-vanilla-may-setattr \
ksym-vanilla-may-umount \
ksym-vanilla-may-umount-tree \
ksym-vanilla-mb-cache-create \
ksym-vanilla-mb-cache-destroy \
ksym-vanilla-mb-cache-entry-create \
ksym-vanilla-mb-cache-entry-delete-or-get \
ksym-vanilla-mb-cache-entry-find-first \
ksym-vanilla-mb-cache-entry-find-next \
ksym-vanilla-mb-cache-entry-get \
ksym-vanilla-mb-cache-entry-touch \
ksym-vanilla-mb-cache-entry-wait-unused \
ksym-vanilla-mb86a16-attach \
ksym-vanilla-mb86a20s-attach \
ksym-vanilla-mbox-bind-client \
ksym-vanilla-mbox-chan-received-data \
ksym-vanilla-mbox-chan-tx-slots-available \
ksym-vanilla-mbox-chan-txdone \
ksym-vanilla-mbox-client-peek-data \
ksym-vanilla-mbox-client-txdone \
ksym-vanilla-mbox-controller-register \
ksym-vanilla-mbox-controller-unregister \
ksym-vanilla-mbox-flush \
ksym-vanilla-mbox-free-channel \
ksym-vanilla-mbox-handler-msix-offset \
ksym-vanilla-mbox-handler-nix-bp-enable \
ksym-vanilla-mbox-handler-nix-lf-alloc \
ksym-vanilla-mbox-handler-npa-lf-alloc \
ksym-vanilla-mbox-request-channel \
ksym-vanilla-mbox-request-channel-byname \
ksym-vanilla-mbox-send-message \
ksym-vanilla-mc-send-command \
ksym-vanilla-mc33xs2410-modify-reg \
ksym-vanilla-mc33xs2410-read-reg-ctrl \
ksym-vanilla-mc33xs2410-read-reg-diag \
ksym-vanilla-mc44s803-attach \
ksym-vanilla-mccic-irq \
ksym-vanilla-mccic-register \
ksym-vanilla-mccic-resume \
ksym-vanilla-mccic-shutdown \
ksym-vanilla-mccic-suspend \
ksym-vanilla-mcore-booted \
ksym-vanilla-mcp23s08-probe-one \
ksym-vanilla-mcp23x08-regmap \
ksym-vanilla-mcp23x17-regmap \
ksym-vanilla-mctp-register-netdev \
ksym-vanilla-mctp-unregister-netdev \
ksym-vanilla-mctrl-gpio-disable-irq-wake \
ksym-vanilla-mctrl-gpio-disable-ms-no-sync \
ksym-vanilla-mctrl-gpio-disable-ms-sync \
ksym-vanilla-mctrl-gpio-enable-irq-wake \
ksym-vanilla-mctrl-gpio-enable-ms \
ksym-vanilla-mctrl-gpio-get \
ksym-vanilla-mctrl-gpio-get-outputs \
ksym-vanilla-mctrl-gpio-init \
ksym-vanilla-mctrl-gpio-init-noauto \
ksym-vanilla-mctrl-gpio-set \
ksym-vanilla-mctrl-gpio-to-gpiod \
ksym-vanilla-md-account-bio \
ksym-vanilla-md-allow-write \
ksym-vanilla-md-check-no-bitmap \
ksym-vanilla-md-check-recovery \
ksym-vanilla-md-do-sync \
ksym-vanilla-md-done-sync \
ksym-vanilla-md-error \
ksym-vanilla-md-find-rdev-nr-rcu \
ksym-vanilla-md-find-rdev-rcu \
ksym-vanilla-md-finish-reshape \
ksym-vanilla-md-flush-request \
ksym-vanilla-md-frozen-sync-thread \
ksym-vanilla-md-handle-request \
ksym-vanilla-md-idle-sync-thread \
ksym-vanilla-md-init-stacking-limits \
ksym-vanilla-md-integrity-register \
ksym-vanilla-md-new-event \
ksym-vanilla-md-rdev-clear \
ksym-vanilla-md-rdev-init \
ksym-vanilla-md-reap-sync-thread \
ksym-vanilla-md-register-thread \
ksym-vanilla-md-reload-sb \
ksym-vanilla-md-run \
ksym-vanilla-md-set-array-sectors \
ksym-vanilla-md-start \
ksym-vanilla-md-stop \
ksym-vanilla-md-stop-writes \
ksym-vanilla-md-submit-discard-bio \
ksym-vanilla-md-sync-error \
ksym-vanilla-md-unfrozen-sync-thread \
ksym-vanilla-md-unregister-thread \
ksym-vanilla-md-update-sb \
ksym-vanilla-md-wait-for-blocked-rdev \
ksym-vanilla-md-write-end \
ksym-vanilla-md-write-inc \
ksym-vanilla-md-write-start \
ksym-vanilla-md5 \
ksym-vanilla-md5-final \
ksym-vanilla-md5-init \
ksym-vanilla-md5-update \
ksym-vanilla-md5-zero-message-hash \
ksym-vanilla-mddev-destroy \
ksym-vanilla-mddev-init \
ksym-vanilla-mddev-resume \
ksym-vanilla-mddev-stack-new-rdev \
ksym-vanilla-mddev-stack-rdev-limits \
ksym-vanilla-mddev-suspend \
ksym-vanilla-mddev-unlock \
ksym-vanilla-mddev-update-io-opt \
ksym-vanilla-mdio-device-create \
ksym-vanilla-mdio-device-free \
ksym-vanilla-mdio-device-register \
ksym-vanilla-mdio-device-remove \
ksym-vanilla-mdio-device-reset \
ksym-vanilla-mdio-driver-register \
ksym-vanilla-mdio-driver-unregister \
ksym-vanilla-mdio-find-bus \
ksym-vanilla-mdio-i2c-alloc \
ksym-vanilla-mdio-mii-ioctl \
ksym-vanilla-mdio-mux-init \
ksym-vanilla-mdio-mux-uninit \
ksym-vanilla-mdio-set-flag \
ksym-vanilla-mdio45-ethtool-ksettings-get-npage \
ksym-vanilla-mdio45-links-ok \
ksym-vanilla-mdio45-nway-restart \
ksym-vanilla-mdio45-probe \
ksym-vanilla-mdiobb-read-c22 \
ksym-vanilla-mdiobb-read-c45 \
ksym-vanilla-mdiobb-write-c22 \
ksym-vanilla-mdiobb-write-c45 \
ksym-vanilla-mdiobus-alloc-size \
ksym-vanilla-mdiobus-c45-modify \
ksym-vanilla-mdiobus-c45-modify-changed \
ksym-vanilla-mdiobus-c45-read \
ksym-vanilla-mdiobus-c45-read-nested \
ksym-vanilla-mdiobus-c45-write \
ksym-vanilla-mdiobus-c45-write-nested \
ksym-vanilla-mdiobus-free \
ksym-vanilla-mdiobus-get-phy \
ksym-vanilla-mdiobus-is-registered-device \
ksym-vanilla-mdiobus-modify \
ksym-vanilla-mdiobus-modify-changed \
ksym-vanilla-mdiobus-read \
ksym-vanilla-mdiobus-read-nested \
ksym-vanilla-mdiobus-scan-c22 \
ksym-vanilla-mdiobus-unregister \
ksym-vanilla-mdiobus-write \
ksym-vanilla-mdiobus-write-nested \
ksym-vanilla-mdp-cmdq-send \
ksym-vanilla-media-create-ancillary-link \
ksym-vanilla-media-create-intf-link \
ksym-vanilla-media-create-pad-link \
ksym-vanilla-media-create-pad-links \
ksym-vanilla-media-device-cleanup \
ksym-vanilla-media-device-delete \
ksym-vanilla-media-device-init \
ksym-vanilla-media-device-pci-init \
ksym-vanilla-media-device-register-entity \
ksym-vanilla-media-device-register-entity-notify \
ksym-vanilla-media-device-unregister \
ksym-vanilla-media-device-unregister-entity \
ksym-vanilla-media-device-unregister-entity-notify \
ksym-vanilla-media-device-usb-allocate \
ksym-vanilla-media-devnode-create \
ksym-vanilla-media-devnode-remove \
ksym-vanilla-media-entity-enum-cleanup \
ksym-vanilla-media-entity-enum-init \
ksym-vanilla-media-entity-find-link \
ksym-vanilla-media-entity-get-fwnode-pad \
ksym-vanilla-media-entity-pads-init \
ksym-vanilla-media-entity-pipeline \
ksym-vanilla-media-entity-remote-pad-unique \
ksym-vanilla-media-entity-remove-links \
ksym-vanilla-media-entity-setup-link \
ksym-vanilla-media-get-pad-index \
ksym-vanilla-media-graph-walk-cleanup \
ksym-vanilla-media-graph-walk-init \
ksym-vanilla-media-graph-walk-next \
ksym-vanilla-media-graph-walk-start \
ksym-vanilla-media-pad-pipeline \
ksym-vanilla-media-pad-remote-pad-first \
ksym-vanilla-media-pad-remote-pad-unique \
ksym-vanilla-media-pipeline-alloc-start \
ksym-vanilla-media-pipeline-entity-iter-cleanup \
ksym-vanilla-media-pipeline-entity-iter-init \
ksym-vanilla-media-pipeline-start \
ksym-vanilla-media-pipeline-stop \
ksym-vanilla-media-remove-intf-link \
ksym-vanilla-media-remove-intf-links \
ksym-vanilla-media-request-get-by-fd \
ksym-vanilla-media-request-manual-complete \
ksym-vanilla-media-request-object-bind \
ksym-vanilla-media-request-object-complete \
ksym-vanilla-media-request-object-find \
ksym-vanilla-media-request-object-init \
ksym-vanilla-media-request-object-put \
ksym-vanilla-media-request-object-unbind \
ksym-vanilla-media-request-put \
ksym-vanilla-mem-1-clk \
ksym-vanilla-mem-accounting \
ksym-vanilla-mem-cgroup-from-task \
ksym-vanilla-mem-dump-obj \
ksym-vanilla-mem-section \
ksym-vanilla-memalloc-socks-key \
ksym-vanilla-memcg-bpf-enabled-key \
ksym-vanilla-memcg-kmem-online-key \
ksym-vanilla-memcg-sockets-enabled-key \
ksym-vanilla-memchr \
ksym-vanilla-memchr-inv \
ksym-vanilla-memcmp \
ksym-vanilla-memconsole-exit \
ksym-vanilla-memconsole-setup \
ksym-vanilla-memconsole-sysfs-init \
ksym-vanilla-memcpy \
ksym-vanilla-memcpy-and-pad \
ksym-vanilla-memcpy-flushcache \
ksym-vanilla-memcpy-from-scatterwalk \
ksym-vanilla-memcpy-from-sglist \
ksym-vanilla-memcpy-fromio \
ksym-vanilla-memcpy-sglist \
ksym-vanilla-memcpy-to-scatterwalk \
ksym-vanilla-memcpy-to-sglist \
ksym-vanilla-memcpy-toio \
ksym-vanilla-memdup-user \
ksym-vanilla-memdup-user-nul \
ksym-vanilla-memfd-pin-folios \
ksym-vanilla-memmove \
ksym-vanilla-memory-add-physaddr-to-nid \
ksym-vanilla-memory-block-size-bytes \
ksym-vanilla-memory-cgrp-subsys \
ksym-vanilla-memory-cgrp-subsys-enabled-key \
ksym-vanilla-memory-cgrp-subsys-on-dfl-key \
ksym-vanilla-memory-failure \
ksym-vanilla-memory-failure-queue \
ksym-vanilla-memory-group-register-dynamic \
ksym-vanilla-memory-group-register-static \
ksym-vanilla-memory-group-unregister \
ksym-vanilla-memory-read-from-buffer \
ksym-vanilla-memparse \
ksym-vanilla-mempool-alloc-bulk-noprof \
ksym-vanilla-mempool-alloc-noprof \
ksym-vanilla-mempool-alloc-pages \
ksym-vanilla-mempool-alloc-preallocated \
ksym-vanilla-mempool-alloc-slab \
ksym-vanilla-mempool-create-node-noprof \
ksym-vanilla-mempool-destroy \
ksym-vanilla-mempool-exit \
ksym-vanilla-mempool-free \
ksym-vanilla-mempool-free-bulk \
ksym-vanilla-mempool-free-pages \
ksym-vanilla-mempool-free-slab \
ksym-vanilla-mempool-init-node \
ksym-vanilla-mempool-init-noprof \
ksym-vanilla-mempool-kfree \
ksym-vanilla-mempool-kmalloc \
ksym-vanilla-mempool-resize \
ksym-vanilla-memregion-alloc \
ksym-vanilla-memregion-free \
ksym-vanilla-memremap \
ksym-vanilla-memremap-compat-align \
ksym-vanilla-memremap-pages \
ksym-vanilla-memscan \
ksym-vanilla-memset \
ksym-vanilla-memset-io \
ksym-vanilla-memset16 \
ksym-vanilla-memset32 \
ksym-vanilla-memset64 \
ksym-vanilla-memstart-addr \
ksym-vanilla-memstick-add-host \
ksym-vanilla-memstick-alloc-host \
ksym-vanilla-memstick-detect-change \
ksym-vanilla-memstick-free-host \
ksym-vanilla-memstick-init-req \
ksym-vanilla-memstick-init-req-sg \
ksym-vanilla-memstick-new-req \
ksym-vanilla-memstick-next-req \
ksym-vanilla-memstick-register-driver \
ksym-vanilla-memstick-remove-host \
ksym-vanilla-memstick-resume-host \
ksym-vanilla-memstick-set-rw-addr \
ksym-vanilla-memstick-suspend-host \
ksym-vanilla-memstick-unregister-driver \
ksym-vanilla-memunmap \
ksym-vanilla-memunmap-pages \
ksym-vanilla-memweight \
ksym-vanilla-meson-a1-parse-dt-extra \
ksym-vanilla-meson-aoclkc-probe \
ksym-vanilla-meson-axg-pmx-ops \
ksym-vanilla-meson-canvas-alloc \
ksym-vanilla-meson-canvas-config \
ksym-vanilla-meson-canvas-free \
ksym-vanilla-meson-canvas-get \
ksym-vanilla-meson-card-i2s-set-sysclk \
ksym-vanilla-meson-card-parse-dai \
ksym-vanilla-meson-card-parse-daifmt \
ksym-vanilla-meson-card-probe \
ksym-vanilla-meson-card-reallocate-links \
ksym-vanilla-meson-card-remove \
ksym-vanilla-meson-card-set-be-link \
ksym-vanilla-meson-card-set-fe-link \
ksym-vanilla-meson-clk-cpu-dyndiv-ops \
ksym-vanilla-meson-clk-dualdiv-ops \
ksym-vanilla-meson-clk-dualdiv-ro-ops \
ksym-vanilla-meson-clk-hw-get \
ksym-vanilla-meson-clk-mpll-ops \
ksym-vanilla-meson-clk-mpll-ro-ops \
ksym-vanilla-meson-clk-pcie-pll-ops \
ksym-vanilla-meson-clk-phase-ops \
ksym-vanilla-meson-clk-pll-ops \
ksym-vanilla-meson-clk-pll-ro-ops \
ksym-vanilla-meson-clk-triphase-ops \
ksym-vanilla-meson-clkc-mmio-probe \
ksym-vanilla-meson-clkc-syscon-probe \
ksym-vanilla-meson-codec-glue-input-dai-probe \
ksym-vanilla-meson-codec-glue-input-dai-remove \
ksym-vanilla-meson-codec-glue-input-get-data \
ksym-vanilla-meson-codec-glue-input-hw-params \
ksym-vanilla-meson-codec-glue-input-set-fmt \
ksym-vanilla-meson-codec-glue-output-startup \
ksym-vanilla-meson-pinctrl-probe \
ksym-vanilla-meson-pmx-get-func-name \
ksym-vanilla-meson-pmx-get-funcs-count \
ksym-vanilla-meson-pmx-get-groups \
ksym-vanilla-meson-reset-controller-register \
ksym-vanilla-meson-reset-ops \
ksym-vanilla-meson-reset-toggle-ops \
ksym-vanilla-meson-sclk-div-ops \
ksym-vanilla-meson-sclk-ws-inv-ops \
ksym-vanilla-meson-sm-call \
ksym-vanilla-meson-sm-call-read \
ksym-vanilla-meson-sm-call-write \
ksym-vanilla-meson-sm-get \
ksym-vanilla-meson-sm-get-thermal-calib \
ksym-vanilla-meson-vclk-div-ops \
ksym-vanilla-meson-vclk-dmt-supported-freq \
ksym-vanilla-meson-vclk-gate-ops \
ksym-vanilla-meson-vclk-setup \
ksym-vanilla-meson-vclk-vic-supported-freq \
ksym-vanilla-meson-venc-hdmi-mode-set \
ksym-vanilla-meson-venc-hdmi-supported-mode \
ksym-vanilla-meson-venc-hdmi-supported-vic \
ksym-vanilla-meson-venc-hdmi-venc-repeat \
ksym-vanilla-meson-venc-mipi-dsi-mode-set \
ksym-vanilla-meson-vid-pll-div-ro-ops \
ksym-vanilla-meson8-aobus-parse-dt-extra \
ksym-vanilla-meson8-pmx-ops \
ksym-vanilla-metadata-dst-alloc \
ksym-vanilla-metadata-dst-alloc-percpu \
ksym-vanilla-metadata-dst-free \
ksym-vanilla-metadata-dst-free-percpu \
ksym-vanilla-mf-dax-kill-procs \
ksym-vanilla-mfd-add-devices \
ksym-vanilla-mfd-remove-devices \
ksym-vanilla-mfd-remove-devices-late \
ksym-vanilla-mhi-alloc-controller \
ksym-vanilla-mhi-async-power-up \
ksym-vanilla-mhi-device-get-sync \
ksym-vanilla-mhi-device-put \
ksym-vanilla-mhi-download-rddm-image \
ksym-vanilla-mhi-driver-unregister \
ksym-vanilla-mhi-ep-driver-unregister \
ksym-vanilla-mhi-ep-power-down \
ksym-vanilla-mhi-ep-power-up \
ksym-vanilla-mhi-ep-queue-is-empty \
ksym-vanilla-mhi-ep-queue-skb \
ksym-vanilla-mhi-ep-register-controller \
ksym-vanilla-mhi-ep-unregister-controller \
ksym-vanilla-mhi-force-rddm-mode \
ksym-vanilla-mhi-free-controller \
ksym-vanilla-mhi-get-channel-doorbell-offset \
ksym-vanilla-mhi-get-exec-env \
ksym-vanilla-mhi-get-free-desc-count \
ksym-vanilla-mhi-get-mhi-state \
ksym-vanilla-mhi-notify \
ksym-vanilla-mhi-pm-resume \
ksym-vanilla-mhi-pm-resume-force \
ksym-vanilla-mhi-pm-suspend \
ksym-vanilla-mhi-power-down \
ksym-vanilla-mhi-power-down-keep-dev \
ksym-vanilla-mhi-prepare-for-power-up \
ksym-vanilla-mhi-prepare-for-transfer \
ksym-vanilla-mhi-queue-buf \
ksym-vanilla-mhi-queue-is-full \
ksym-vanilla-mhi-queue-skb \
ksym-vanilla-mhi-register-controller \
ksym-vanilla-mhi-soc-reset \
ksym-vanilla-mhi-sync-power-up \
ksym-vanilla-mhi-unprepare-after-power-down \
ksym-vanilla-mhi-unprepare-from-transfer \
ksym-vanilla-mhi-unregister-controller \
ksym-vanilla-mhp-get-pluggable-range \
ksym-vanilla-mhp-supports-memmap-on-memory \
ksym-vanilla-michael-mic \
ksym-vanilla-microread-probe \
ksym-vanilla-microread-remove \
ksym-vanilla-microtune-attach \
ksym-vanilla-migrate-device-finalize \
ksym-vanilla-migrate-device-pages \
ksym-vanilla-migrate-device-pfns \
ksym-vanilla-migrate-device-range \
ksym-vanilla-migrate-disable \
ksym-vanilla-migrate-enable \
ksym-vanilla-migrate-folio \
ksym-vanilla-migrate-vma-finalize \
ksym-vanilla-migrate-vma-pages \
ksym-vanilla-migrate-vma-setup \
ksym-vanilla-mii-check-gmii-support \
ksym-vanilla-mii-check-link \
ksym-vanilla-mii-check-media \
ksym-vanilla-mii-ethtool-get-link-ksettings \
ksym-vanilla-mii-ethtool-gset \
ksym-vanilla-mii-ethtool-set-link-ksettings \
ksym-vanilla-mii-ethtool-sset \
ksym-vanilla-mii-link-ok \
ksym-vanilla-mii-nway-restart \
ksym-vanilla-miic-create \
ksym-vanilla-miic-destroy \
ksym-vanilla-mini-qdisc-pair-block-init \
ksym-vanilla-mini-qdisc-pair-init \
ksym-vanilla-mini-qdisc-pair-swap \
ksym-vanilla-minmax-running-max \
ksym-vanilla-minmax-running-min \
ksym-vanilla-mipi-dbi-buf-copy \
ksym-vanilla-mipi-dbi-command-buf \
ksym-vanilla-mipi-dbi-command-read \
ksym-vanilla-mipi-dbi-command-stackbuf \
ksym-vanilla-mipi-dbi-debugfs-init \
ksym-vanilla-mipi-dbi-display-is-on \
ksym-vanilla-mipi-dbi-hw-reset \
ksym-vanilla-mipi-dbi-poweron-conditional-reset \
ksym-vanilla-mipi-dbi-poweron-reset \
ksym-vanilla-mipi-dbi-spi-cmd-max-speed \
ksym-vanilla-mipi-dbi-spi-init \
ksym-vanilla-mipi-dbi-spi-transfer \
ksym-vanilla-mipi-dsi-attach \
ksym-vanilla-mipi-dsi-bus-type \
ksym-vanilla-mipi-dsi-compression-mode \
ksym-vanilla-mipi-dsi-compression-mode-ext \
ksym-vanilla-mipi-dsi-compression-mode-ext-multi \
ksym-vanilla-mipi-dsi-compression-mode-multi \
ksym-vanilla-mipi-dsi-create-packet \
ksym-vanilla-mipi-dsi-dcs-enter-sleep-mode \
ksym-vanilla-mipi-dsi-dcs-enter-sleep-mode-multi \
ksym-vanilla-mipi-dsi-dcs-exit-sleep-mode \
ksym-vanilla-mipi-dsi-dcs-exit-sleep-mode-multi \
ksym-vanilla-mipi-dsi-dcs-get-display-brightness \
ksym-vanilla-mipi-dsi-dcs-get-display-brightness-large \
ksym-vanilla-mipi-dsi-dcs-get-pixel-format \
ksym-vanilla-mipi-dsi-dcs-get-power-mode \
ksym-vanilla-mipi-dsi-dcs-nop \
ksym-vanilla-mipi-dsi-dcs-nop-multi \
ksym-vanilla-mipi-dsi-dcs-read \
ksym-vanilla-mipi-dsi-dcs-read-multi \
ksym-vanilla-mipi-dsi-dcs-set-column-address \
ksym-vanilla-mipi-dsi-dcs-set-column-address-multi \
ksym-vanilla-mipi-dsi-dcs-set-display-brightness \
ksym-vanilla-mipi-dsi-dcs-set-display-brightness-large \
ksym-vanilla-mipi-dsi-dcs-set-display-brightness-multi \
ksym-vanilla-mipi-dsi-dcs-set-display-off \
ksym-vanilla-mipi-dsi-dcs-set-display-off-multi \
ksym-vanilla-mipi-dsi-dcs-set-display-on \
ksym-vanilla-mipi-dsi-dcs-set-display-on-multi \
ksym-vanilla-mipi-dsi-dcs-set-page-address \
ksym-vanilla-mipi-dsi-dcs-set-page-address-multi \
ksym-vanilla-mipi-dsi-dcs-set-pixel-format \
ksym-vanilla-mipi-dsi-dcs-set-pixel-format-multi \
ksym-vanilla-mipi-dsi-dcs-set-tear-off-multi \
ksym-vanilla-mipi-dsi-dcs-set-tear-on \
ksym-vanilla-mipi-dsi-dcs-set-tear-on-multi \
ksym-vanilla-mipi-dsi-dcs-set-tear-scanline \
ksym-vanilla-mipi-dsi-dcs-set-tear-scanline-multi \
ksym-vanilla-mipi-dsi-dcs-soft-reset \
ksym-vanilla-mipi-dsi-dcs-soft-reset-multi \
ksym-vanilla-mipi-dsi-dcs-write \
ksym-vanilla-mipi-dsi-dcs-write-buffer \
ksym-vanilla-mipi-dsi-dcs-write-buffer-chatty \
ksym-vanilla-mipi-dsi-dcs-write-buffer-multi \
ksym-vanilla-mipi-dsi-detach \
ksym-vanilla-mipi-dsi-device-register-full \
ksym-vanilla-mipi-dsi-device-unregister \
ksym-vanilla-mipi-dsi-driver-register-full \
ksym-vanilla-mipi-dsi-driver-unregister \
ksym-vanilla-mipi-dsi-dual-dcs-write-buffer-multi \
ksym-vanilla-mipi-dsi-dual-generic-write-multi \
ksym-vanilla-mipi-dsi-generic-read \
ksym-vanilla-mipi-dsi-generic-write \
ksym-vanilla-mipi-dsi-generic-write-multi \
ksym-vanilla-mipi-dsi-host-register \
ksym-vanilla-mipi-dsi-host-unregister \
ksym-vanilla-mipi-dsi-packet-format-is-long \
ksym-vanilla-mipi-dsi-packet-format-is-short \
ksym-vanilla-mipi-dsi-picture-parameter-set \
ksym-vanilla-mipi-dsi-picture-parameter-set-multi \
ksym-vanilla-mipi-dsi-set-maximum-return-packet-size \
ksym-vanilla-mipi-dsi-shutdown-peripheral \
ksym-vanilla-mipi-dsi-shutdown-peripheral-multi \
ksym-vanilla-mipi-dsi-turn-on-peripheral \
ksym-vanilla-mipi-dsi-turn-on-peripheral-multi \
ksym-vanilla-misc-cg-set-capacity \
ksym-vanilla-misc-cg-try-charge \
ksym-vanilla-misc-cg-uncharge \
ksym-vanilla-misc-cgrp-subsys-enabled-key \
ksym-vanilla-misc-cgrp-subsys-on-dfl-key \
ksym-vanilla-misc-deregister \
ksym-vanilla-misc-register \
ksym-vanilla-mktime64 \
ksym-vanilla-mldsa-verify \
ksym-vanilla-mlog-and-bits \
ksym-vanilla-mlog-not-bits \
ksym-vanilla-mlx4-ACCESS-PTYS-REG \
ksym-vanilla-mlx4-ALLOCATE-VPP-get \
ksym-vanilla-mlx4-ALLOCATE-VPP-set \
ksym-vanilla-mlx4-CLOSE-PORT \
ksym-vanilla-mlx4-FLOW-STEERING-IB-UC-QP-RANGE \
ksym-vanilla-mlx4-INIT-PORT \
ksym-vanilla-mlx4-SET-MCAST-FLTR \
ksym-vanilla-mlx4-SET-PORT-BEACON \
ksym-vanilla-mlx4-SET-PORT-PRIO2TC \
ksym-vanilla-mlx4-SET-PORT-SCHEDULER \
ksym-vanilla-mlx4-SET-PORT-VXLAN \
ksym-vanilla-mlx4-SET-PORT-fcs-check \
ksym-vanilla-mlx4-SET-PORT-general \
ksym-vanilla-mlx4-SET-PORT-qpn-calc \
ksym-vanilla-mlx4-SET-PORT-user-mac \
ksym-vanilla-mlx4-SET-PORT-user-mtu \
ksym-vanilla-mlx4-SET-VPORT-QOS-get \
ksym-vanilla-mlx4-SET-VPORT-QOS-set \
ksym-vanilla-mlx4-SYNC-TPT \
ksym-vanilla-mlx4-alloc-cmd-mailbox \
ksym-vanilla-mlx4-alloc-hwq-res \
ksym-vanilla-mlx4-assign-eq \
ksym-vanilla-mlx4-bf-alloc \
ksym-vanilla-mlx4-bf-free \
ksym-vanilla-mlx4-buf-alloc \
ksym-vanilla-mlx4-buf-free \
ksym-vanilla-mlx4-buf-write-mtt \
ksym-vanilla-mlx4-config-dev-retrieval \
ksym-vanilla-mlx4-config-roce-v2-port \
ksym-vanilla-mlx4-config-vxlan-port \
ksym-vanilla-mlx4-counter-alloc \
ksym-vanilla-mlx4-counter-free \
ksym-vanilla-mlx4-cq-alloc \
ksym-vanilla-mlx4-cq-free \
ksym-vanilla-mlx4-cq-modify \
ksym-vanilla-mlx4-cq-resize \
ksym-vanilla-mlx4-db-alloc \
ksym-vanilla-mlx4-db-free \
ksym-vanilla-mlx4-eq-get-irq \
ksym-vanilla-mlx4-find-cached-vlan \
ksym-vanilla-mlx4-flow-attach \
ksym-vanilla-mlx4-flow-detach \
ksym-vanilla-mlx4-flow-steer-promisc-add \
ksym-vanilla-mlx4-flow-steer-promisc-remove \
ksym-vanilla-mlx4-free-cmd-mailbox \
ksym-vanilla-mlx4-free-hwq-res \
ksym-vanilla-mlx4-gen-guid-change-eqe \
ksym-vanilla-mlx4-gen-pkey-eqe \
ksym-vanilla-mlx4-gen-port-state-change-eqe \
ksym-vanilla-mlx4-gen-slaves-port-mgt-ev \
ksym-vanilla-mlx4-get-active-ports \
ksym-vanilla-mlx4-get-admin-guid \
ksym-vanilla-mlx4-get-base-gid-ix \
ksym-vanilla-mlx4-get-base-qpn \
ksym-vanilla-mlx4-get-counter-stats \
ksym-vanilla-mlx4-get-cpu-rmap \
ksym-vanilla-mlx4-get-default-counter-index \
ksym-vanilla-mlx4-get-devlink-port \
ksym-vanilla-mlx4-get-eqs-per-port \
ksym-vanilla-mlx4-get-internal-clock-params \
ksym-vanilla-mlx4-get-is-vlan-offload-disabled \
ksym-vanilla-mlx4-get-module-info \
ksym-vanilla-mlx4-get-parav-qkey \
ksym-vanilla-mlx4-get-roce-gid-from-slave \
ksym-vanilla-mlx4-get-slave-default-vlan \
ksym-vanilla-mlx4-get-slave-from-roce-gid \
ksym-vanilla-mlx4-get-slave-node-guid \
ksym-vanilla-mlx4-get-slave-pkey-gid-tbl-len \
ksym-vanilla-mlx4-get-slave-port-state \
ksym-vanilla-mlx4-get-vf-config \
ksym-vanilla-mlx4-get-vf-stats \
ksym-vanilla-mlx4-handle-eth-header-mcast-prio \
ksym-vanilla-mlx4-hw-rule-sz \
ksym-vanilla-mlx4-is-eq-shared \
ksym-vanilla-mlx4-is-eq-vector-valid \
ksym-vanilla-mlx4-is-slave-active \
ksym-vanilla-mlx4-map-sw-to-hw-steering-id \
ksym-vanilla-mlx4-map-sw-to-hw-steering-mode \
ksym-vanilla-mlx4-max-tc \
ksym-vanilla-mlx4-mr-alloc \
ksym-vanilla-mlx4-mr-enable \
ksym-vanilla-mlx4-mr-free \
ksym-vanilla-mlx4-mr-hw-change-access \
ksym-vanilla-mlx4-mr-hw-change-pd \
ksym-vanilla-mlx4-mr-hw-get-mpt \
ksym-vanilla-mlx4-mr-hw-put-mpt \
ksym-vanilla-mlx4-mr-hw-write-mpt \
ksym-vanilla-mlx4-mr-rereg-mem-cleanup \
ksym-vanilla-mlx4-mr-rereg-mem-write \
ksym-vanilla-mlx4-mtt-addr \
ksym-vanilla-mlx4-mtt-cleanup \
ksym-vanilla-mlx4-mtt-init \
ksym-vanilla-mlx4-multicast-attach \
ksym-vanilla-mlx4-multicast-detach \
ksym-vanilla-mlx4-multicast-promisc-add \
ksym-vanilla-mlx4-multicast-promisc-remove \
ksym-vanilla-mlx4-mw-alloc \
ksym-vanilla-mlx4-mw-enable \
ksym-vanilla-mlx4-mw-free \
ksym-vanilla-mlx4-pd-alloc \
ksym-vanilla-mlx4-pd-free \
ksym-vanilla-mlx4-phys-to-slave-port \
ksym-vanilla-mlx4-phys-to-slaves-pport \
ksym-vanilla-mlx4-phys-to-slaves-pport-actv \
ksym-vanilla-mlx4-put-qp \
ksym-vanilla-mlx4-put-slave-node-guid \
ksym-vanilla-mlx4-qp-alloc \
ksym-vanilla-mlx4-qp-free \
ksym-vanilla-mlx4-qp-modify \
ksym-vanilla-mlx4-qp-query \
ksym-vanilla-mlx4-qp-release-range \
ksym-vanilla-mlx4-qp-remove \
ksym-vanilla-mlx4-qp-reserve-range \
ksym-vanilla-mlx4-qp-to-ready \
ksym-vanilla-mlx4-query-diag-counters \
ksym-vanilla-mlx4-queue-bond-work \
ksym-vanilla-mlx4-read-clock \
ksym-vanilla-mlx4-register-auxiliary-driver \
ksym-vanilla-mlx4-register-event-notifier \
ksym-vanilla-mlx4-register-mac \
ksym-vanilla-mlx4-register-vlan \
ksym-vanilla-mlx4-release-eq \
ksym-vanilla-mlx4-replace-zero-macs \
ksym-vanilla-mlx4-set-admin-guid \
ksym-vanilla-mlx4-set-vf-link-state \
ksym-vanilla-mlx4-set-vf-mac \
ksym-vanilla-mlx4-set-vf-rate \
ksym-vanilla-mlx4-set-vf-spoofchk \
ksym-vanilla-mlx4-set-vf-vlan \
ksym-vanilla-mlx4-slave-convert-port \
ksym-vanilla-mlx4-srq-alloc \
ksym-vanilla-mlx4-srq-arm \
ksym-vanilla-mlx4-srq-free \
ksym-vanilla-mlx4-srq-lookup \
ksym-vanilla-mlx4-srq-query \
ksym-vanilla-mlx4-sync-pkey-table \
ksym-vanilla-mlx4-test-async \
ksym-vanilla-mlx4-test-interrupt \
ksym-vanilla-mlx4-tunnel-steer-add \
ksym-vanilla-mlx4-uar-alloc \
ksym-vanilla-mlx4-uar-free \
ksym-vanilla-mlx4-unicast-attach \
ksym-vanilla-mlx4-unicast-detach \
ksym-vanilla-mlx4-unicast-promisc-add \
ksym-vanilla-mlx4-unicast-promisc-remove \
ksym-vanilla-mlx4-unregister-auxiliary-driver \
ksym-vanilla-mlx4-unregister-event-notifier \
ksym-vanilla-mlx4-unregister-mac \
ksym-vanilla-mlx4-unregister-vlan \
ksym-vanilla-mlx4-update-qp \
ksym-vanilla-mlx4-vf-get-enable-smi-admin \
ksym-vanilla-mlx4-vf-set-enable-smi-admin \
ksym-vanilla-mlx4-vf-smi-enabled \
ksym-vanilla-mlx4-wol-read \
ksym-vanilla-mlx4-wol-write \
ksym-vanilla-mlx4-write-mtt \
ksym-vanilla-mlx4-xrcd-alloc \
ksym-vanilla-mlx4-xrcd-free \
ksym-vanilla-mlx5-access-reg \
ksym-vanilla-mlx5-add-cq-to-tasklet \
ksym-vanilla-mlx5-add-flow-rules \
ksym-vanilla-mlx5-alloc-bfreg \
ksym-vanilla-mlx5-blocking-notifier-register \
ksym-vanilla-mlx5-blocking-notifier-unregister \
ksym-vanilla-mlx5-cmd-add-privileged-uid \
ksym-vanilla-mlx5-cmd-check \
ksym-vanilla-mlx5-cmd-cleanup-async-ctx \
ksym-vanilla-mlx5-cmd-create-vport-lag \
ksym-vanilla-mlx5-cmd-destroy-vport-lag \
ksym-vanilla-mlx5-cmd-do \
ksym-vanilla-mlx5-cmd-exec \
ksym-vanilla-mlx5-cmd-exec-cb \
ksym-vanilla-mlx5-cmd-exec-polling \
ksym-vanilla-mlx5-cmd-init-async-ctx \
ksym-vanilla-mlx5-cmd-out-err \
ksym-vanilla-mlx5-cmd-remove-privileged-uid \
ksym-vanilla-mlx5-comp-eqn-get \
ksym-vanilla-mlx5-comp-vector-get-cpu \
ksym-vanilla-mlx5-comp-vectors-max \
ksym-vanilla-mlx5-core-access-reg \
ksym-vanilla-mlx5-core-alloc-pd \
ksym-vanilla-mlx5-core-alloc-transport-domain \
ksym-vanilla-mlx5-core-attach-mcg \
ksym-vanilla-mlx5-core-create-cq \
ksym-vanilla-mlx5-core-create-mkey \
ksym-vanilla-mlx5-core-create-psv \
ksym-vanilla-mlx5-core-create-rq \
ksym-vanilla-mlx5-core-create-rqt \
ksym-vanilla-mlx5-core-create-tir \
ksym-vanilla-mlx5-core-create-tis \
ksym-vanilla-mlx5-core-dealloc-pd \
ksym-vanilla-mlx5-core-dealloc-transport-domain \
ksym-vanilla-mlx5-core-destroy-cq \
ksym-vanilla-mlx5-core-destroy-mkey \
ksym-vanilla-mlx5-core-destroy-psv \
ksym-vanilla-mlx5-core-destroy-rq \
ksym-vanilla-mlx5-core-destroy-rqt \
ksym-vanilla-mlx5-core-destroy-tir \
ksym-vanilla-mlx5-core-destroy-tis \
ksym-vanilla-mlx5-core-detach-mcg \
ksym-vanilla-mlx5-core-get-terminate-scatter-list-mkey \
ksym-vanilla-mlx5-core-modify-cq \
ksym-vanilla-mlx5-core-modify-cq-moderation \
ksym-vanilla-mlx5-core-modify-hca-vport-context \
ksym-vanilla-mlx5-core-modify-rq \
ksym-vanilla-mlx5-core-modify-sq \
ksym-vanilla-mlx5-core-modify-tis \
ksym-vanilla-mlx5-core-mp-event-replay \
ksym-vanilla-mlx5-core-query-cq \
ksym-vanilla-mlx5-core-query-mkey \
ksym-vanilla-mlx5-core-query-rq \
ksym-vanilla-mlx5-core-query-sq \
ksym-vanilla-mlx5-core-query-sq-state \
ksym-vanilla-mlx5-core-query-vendor-id \
ksym-vanilla-mlx5-core-query-vport-counter \
ksym-vanilla-mlx5-core-reserved-gids-count \
ksym-vanilla-mlx5-core-roce-gid-set \
ksym-vanilla-mlx5-core-uplink-netdev-event-replay \
ksym-vanilla-mlx5-create-auto-grouped-flow-table \
ksym-vanilla-mlx5-create-cq \
ksym-vanilla-mlx5-create-flow-group \
ksym-vanilla-mlx5-create-flow-table \
ksym-vanilla-mlx5-create-lag-demux-flow-table \
ksym-vanilla-mlx5-db-alloc-node \
ksym-vanilla-mlx5-db-free \
ksym-vanilla-mlx5-debug-qp-add \
ksym-vanilla-mlx5-debug-qp-remove \
ksym-vanilla-mlx5-debugfs-get-dev-root \
ksym-vanilla-mlx5-debugfs-root \
ksym-vanilla-mlx5-del-flow-rules \
ksym-vanilla-mlx5-destroy-flow-group \
ksym-vanilla-mlx5-destroy-flow-table \
ksym-vanilla-mlx5-dm-sw-icm-alloc \
ksym-vanilla-mlx5-dm-sw-icm-dealloc \
ksym-vanilla-mlx5-eq-create-generic \
ksym-vanilla-mlx5-eq-destroy-generic \
ksym-vanilla-mlx5-eq-disable \
ksym-vanilla-mlx5-eq-enable \
ksym-vanilla-mlx5-eq-get-eqe \
ksym-vanilla-mlx5-eq-notifier-register \
ksym-vanilla-mlx5-eq-notifier-unregister \
ksym-vanilla-mlx5-eq-update-ci \
ksym-vanilla-mlx5-eswitch-add-send-to-vport-rule \
ksym-vanilla-mlx5-eswitch-get-core-dev \
ksym-vanilla-mlx5-eswitch-get-encap-mode \
ksym-vanilla-mlx5-eswitch-get-proto-dev \
ksym-vanilla-mlx5-eswitch-get-total-vports \
ksym-vanilla-mlx5-eswitch-get-vport-metadata-for-match \
ksym-vanilla-mlx5-eswitch-get-vport-metadata-for-set \
ksym-vanilla-mlx5-eswitch-mode \
ksym-vanilla-mlx5-eswitch-reg-c1-loopback-enabled \
ksym-vanilla-mlx5-eswitch-register-vport-reps \
ksym-vanilla-mlx5-eswitch-register-vport-reps-nested \
ksym-vanilla-mlx5-eswitch-unregister-vport-reps \
ksym-vanilla-mlx5-eswitch-unregister-vport-reps-nested \
ksym-vanilla-mlx5-eswitch-uplink-get-proto-dev \
ksym-vanilla-mlx5-eswitch-vport-match-metadata-enabled \
ksym-vanilla-mlx5-eswitch-vport-rep \
ksym-vanilla-mlx5-fc-create \
ksym-vanilla-mlx5-fc-destroy \
ksym-vanilla-mlx5-fc-id \
ksym-vanilla-mlx5-fc-local-create \
ksym-vanilla-mlx5-fc-local-destroy \
ksym-vanilla-mlx5-fc-query \
ksym-vanilla-mlx5-fill-page-frag-array \
ksym-vanilla-mlx5-fill-page-frag-array-perm \
ksym-vanilla-mlx5-flow-table-id \
ksym-vanilla-mlx5-fpga-get-sbu-caps \
ksym-vanilla-mlx5-fpga-mem-read \
ksym-vanilla-mlx5-fpga-mem-write \
ksym-vanilla-mlx5-fpga-sbu-conn-create \
ksym-vanilla-mlx5-fpga-sbu-conn-destroy \
ksym-vanilla-mlx5-fpga-sbu-conn-sendmsg \
ksym-vanilla-mlx5-frag-buf-alloc-node \
ksym-vanilla-mlx5-frag-buf-free \
ksym-vanilla-mlx5-free-bfreg \
ksym-vanilla-mlx5-fs-add-rx-underlay-qpn \
ksym-vanilla-mlx5-fs-remove-rx-underlay-qpn \
ksym-vanilla-mlx5-fs-set-root-dev \
ksym-vanilla-mlx5-get-fdb-sub-ns \
ksym-vanilla-mlx5-get-flow-namespace \
ksym-vanilla-mlx5-get-flow-vport-namespace \
ksym-vanilla-mlx5-get-uars-page \
ksym-vanilla-mlx5-ipsec-device-caps \
ksym-vanilla-mlx5-is-roce-on \
ksym-vanilla-mlx5-lag-demux-cleanup \
ksym-vanilla-mlx5-lag-demux-init \
ksym-vanilla-mlx5-lag-demux-rule-add \
ksym-vanilla-mlx5-lag-demux-rule-del \
ksym-vanilla-mlx5-lag-get-dev-seq \
ksym-vanilla-mlx5-lag-get-next-peer-mdev \
ksym-vanilla-mlx5-lag-get-num-ports \
ksym-vanilla-mlx5-lag-get-slave-port \
ksym-vanilla-mlx5-lag-is-active \
ksym-vanilla-mlx5-lag-is-master \
ksym-vanilla-mlx5-lag-is-mpesw \
ksym-vanilla-mlx5-lag-is-roce \
ksym-vanilla-mlx5-lag-is-shared-fdb \
ksym-vanilla-mlx5-lag-is-sriov \
ksym-vanilla-mlx5-lag-mode-is-hash \
ksym-vanilla-mlx5-lag-query-bond-speed \
ksym-vanilla-mlx5-lag-query-cong-counters \
ksym-vanilla-mlx5-macsec-add-roce-rule \
ksym-vanilla-mlx5-macsec-add-roce-sa-rules \
ksym-vanilla-mlx5-macsec-del-roce-rule \
ksym-vanilla-mlx5-macsec-del-roce-sa-rules \
ksym-vanilla-mlx5-modify-header-alloc \
ksym-vanilla-mlx5-modify-header-dealloc \
ksym-vanilla-mlx5-modify-nic-vport-mac-address \
ksym-vanilla-mlx5-modify-nic-vport-mac-list \
ksym-vanilla-mlx5-modify-nic-vport-mtu \
ksym-vanilla-mlx5-modify-nic-vport-promisc \
ksym-vanilla-mlx5-modify-nic-vport-vlans \
ksym-vanilla-mlx5-mpfs-add-mac \
ksym-vanilla-mlx5-mpfs-del-mac \
ksym-vanilla-mlx5-nic-vport-affiliate-multiport \
ksym-vanilla-mlx5-nic-vport-disable-roce \
ksym-vanilla-mlx5-nic-vport-enable-roce \
ksym-vanilla-mlx5-nic-vport-query-local-lb \
ksym-vanilla-mlx5-nic-vport-unaffiliate-multiport \
ksym-vanilla-mlx5-nic-vport-update-local-lb \
ksym-vanilla-mlx5-notifier-register \
ksym-vanilla-mlx5-notifier-unregister \
ksym-vanilla-mlx5-packet-reformat-alloc \
ksym-vanilla-mlx5-packet-reformat-dealloc \
ksym-vanilla-mlx5-put-uars-page \
ksym-vanilla-mlx5-qp-debugfs-cleanup \
ksym-vanilla-mlx5-qp-debugfs-init \
ksym-vanilla-mlx5-query-hca-vport-context \
ksym-vanilla-mlx5-query-hca-vport-gid \
ksym-vanilla-mlx5-query-hca-vport-node-guid \
ksym-vanilla-mlx5-query-hca-vport-pkey \
ksym-vanilla-mlx5-query-hca-vport-system-image-guid \
ksym-vanilla-mlx5-query-ib-port-oper \
ksym-vanilla-mlx5-query-mac-address \
ksym-vanilla-mlx5-query-min-inline \
ksym-vanilla-mlx5-query-nic-system-image-guid \
ksym-vanilla-mlx5-query-nic-vport-mac-address \
ksym-vanilla-mlx5-query-nic-vport-mac-list \
ksym-vanilla-mlx5-query-nic-vport-min-inline \
ksym-vanilla-mlx5-query-nic-vport-mtu \
ksym-vanilla-mlx5-query-nic-vport-node-guid \
ksym-vanilla-mlx5-query-nic-vport-promisc \
ksym-vanilla-mlx5-query-nic-vport-qkey-viol-cntr \
ksym-vanilla-mlx5-query-nic-vport-system-image-guid \
ksym-vanilla-mlx5-query-port-max-mtu \
ksym-vanilla-mlx5-query-port-oper-mtu \
ksym-vanilla-mlx5-query-port-ptys \
ksym-vanilla-mlx5-query-port-vl-hw-cap \
ksym-vanilla-mlx5-query-vport-max-tx-speed \
ksym-vanilla-mlx5-rdma-rn-get-params \
ksym-vanilla-mlx5-rl-add-rate \
ksym-vanilla-mlx5-rl-add-rate-raw \
ksym-vanilla-mlx5-rl-are-equal \
ksym-vanilla-mlx5-rl-is-in-range \
ksym-vanilla-mlx5-rl-remove-rate \
ksym-vanilla-mlx5-rl-remove-rate-raw \
ksym-vanilla-mlx5-rsc-dump-cmd-create \
ksym-vanilla-mlx5-rsc-dump-cmd-destroy \
ksym-vanilla-mlx5-rsc-dump-next \
ksym-vanilla-mlx5-set-port-caps \
ksym-vanilla-mlx5-sriov-blocking-notifier-register \
ksym-vanilla-mlx5-sriov-blocking-notifier-unregister \
ksym-vanilla-mlx5-st-alloc-index \
ksym-vanilla-mlx5-st-dealloc-index \
ksym-vanilla-mlx5-vf-get-core-dev \
ksym-vanilla-mlx5-vf-put-core-dev \
ksym-vanilla-mlx5-vport-get-other-func-cap \
ksym-vanilla-mlx5-vport-get-vhca-id \
ksym-vanilla-mlx5-wc-support-get \
ksym-vanilla-mlxfw-firmware-flash \
ksym-vanilla-mlxsw-afa-block-activity-get \
ksym-vanilla-mlxsw-afa-block-append-allocated-counter \
ksym-vanilla-mlxsw-afa-block-append-counter \
ksym-vanilla-mlxsw-afa-block-append-drop \
ksym-vanilla-mlxsw-afa-block-append-fid-set \
ksym-vanilla-mlxsw-afa-block-append-fwd \
ksym-vanilla-mlxsw-afa-block-append-ignore \
ksym-vanilla-mlxsw-afa-block-append-ip \
ksym-vanilla-mlxsw-afa-block-append-l4port \
ksym-vanilla-mlxsw-afa-block-append-mcrouter \
ksym-vanilla-mlxsw-afa-block-append-mirror \
ksym-vanilla-mlxsw-afa-block-append-police \
ksym-vanilla-mlxsw-afa-block-append-qos-dscp \
ksym-vanilla-mlxsw-afa-block-append-qos-dsfield \
ksym-vanilla-mlxsw-afa-block-append-qos-ecn \
ksym-vanilla-mlxsw-afa-block-append-qos-switch-prio \
ksym-vanilla-mlxsw-afa-block-append-sampler \
ksym-vanilla-mlxsw-afa-block-append-trap \
ksym-vanilla-mlxsw-afa-block-append-trap-and-forward \
ksym-vanilla-mlxsw-afa-block-append-vlan-modify \
ksym-vanilla-mlxsw-afa-block-commit \
ksym-vanilla-mlxsw-afa-block-continue \
ksym-vanilla-mlxsw-afa-block-create \
ksym-vanilla-mlxsw-afa-block-cur-set \
ksym-vanilla-mlxsw-afa-block-destroy \
ksym-vanilla-mlxsw-afa-block-first-kvdl-index \
ksym-vanilla-mlxsw-afa-block-first-set \
ksym-vanilla-mlxsw-afa-block-jump \
ksym-vanilla-mlxsw-afa-block-terminate \
ksym-vanilla-mlxsw-afa-cookie-lookup \
ksym-vanilla-mlxsw-afa-create \
ksym-vanilla-mlxsw-afa-destroy \
ksym-vanilla-mlxsw-afk-clear \
ksym-vanilla-mlxsw-afk-create \
ksym-vanilla-mlxsw-afk-destroy \
ksym-vanilla-mlxsw-afk-encode \
ksym-vanilla-mlxsw-afk-key-info-block-encoding-get \
ksym-vanilla-mlxsw-afk-key-info-blocks-count-get \
ksym-vanilla-mlxsw-afk-key-info-get \
ksym-vanilla-mlxsw-afk-key-info-put \
ksym-vanilla-mlxsw-afk-key-info-subset \
ksym-vanilla-mlxsw-afk-values-add-buf \
ksym-vanilla-mlxsw-afk-values-add-u32 \
ksym-vanilla-mlxsw-cmd-exec \
ksym-vanilla-mlxsw-core-bus-device-register \
ksym-vanilla-mlxsw-core-bus-device-unregister \
ksym-vanilla-mlxsw-core-cpu-port-fini \
ksym-vanilla-mlxsw-core-cpu-port-init \
ksym-vanilla-mlxsw-core-driver-priv \
ksym-vanilla-mlxsw-core-driver-register \
ksym-vanilla-mlxsw-core-driver-unregister \
ksym-vanilla-mlxsw-core-event-listener-register \
ksym-vanilla-mlxsw-core-event-listener-unregister \
ksym-vanilla-mlxsw-core-flood-mode \
ksym-vanilla-mlxsw-core-flush-owq \
ksym-vanilla-mlxsw-core-fw-rev-minor-subminor-validate \
ksym-vanilla-mlxsw-core-irq-event-handler-register \
ksym-vanilla-mlxsw-core-irq-event-handler-unregister \
ksym-vanilla-mlxsw-core-irq-event-handlers-call \
ksym-vanilla-mlxsw-core-kvd-sizes-get \
ksym-vanilla-mlxsw-core-lag-mapping-clear \
ksym-vanilla-mlxsw-core-lag-mapping-get \
ksym-vanilla-mlxsw-core-lag-mapping-set \
ksym-vanilla-mlxsw-core-lag-mode \
ksym-vanilla-mlxsw-core-max-lag \
ksym-vanilla-mlxsw-core-max-ports \
ksym-vanilla-mlxsw-core-port-devlink-port-get \
ksym-vanilla-mlxsw-core-port-driver-priv \
ksym-vanilla-mlxsw-core-port-fini \
ksym-vanilla-mlxsw-core-port-init \
ksym-vanilla-mlxsw-core-port-netdev-link \
ksym-vanilla-mlxsw-core-ptp-transmitted \
ksym-vanilla-mlxsw-core-read-frc-h \
ksym-vanilla-mlxsw-core-read-frc-l \
ksym-vanilla-mlxsw-core-read-utc-nsec \
ksym-vanilla-mlxsw-core-read-utc-sec \
ksym-vanilla-mlxsw-core-res-get \
ksym-vanilla-mlxsw-core-res-valid \
ksym-vanilla-mlxsw-core-resources-query \
ksym-vanilla-mlxsw-core-rx-listener-register \
ksym-vanilla-mlxsw-core-rx-listener-unregister \
ksym-vanilla-mlxsw-core-schedule-dw \
ksym-vanilla-mlxsw-core-schedule-work \
ksym-vanilla-mlxsw-core-sdq-supports-cqe-v2 \
ksym-vanilla-mlxsw-core-skb-receive \
ksym-vanilla-mlxsw-core-skb-transmit \
ksym-vanilla-mlxsw-core-skb-transmit-busy \
ksym-vanilla-mlxsw-core-trap-register \
ksym-vanilla-mlxsw-core-trap-state-set \
ksym-vanilla-mlxsw-core-trap-unregister \
ksym-vanilla-mlxsw-core-traps-register \
ksym-vanilla-mlxsw-core-traps-unregister \
ksym-vanilla-mlxsw-env-get-module-eeprom \
ksym-vanilla-mlxsw-env-get-module-eeprom-by-page \
ksym-vanilla-mlxsw-env-get-module-info \
ksym-vanilla-mlxsw-env-get-module-power-mode \
ksym-vanilla-mlxsw-env-module-overheat-counter-get \
ksym-vanilla-mlxsw-env-module-port-down \
ksym-vanilla-mlxsw-env-module-port-map \
ksym-vanilla-mlxsw-env-module-port-unmap \
ksym-vanilla-mlxsw-env-module-port-up \
ksym-vanilla-mlxsw-env-reset-module \
ksym-vanilla-mlxsw-env-set-module-eeprom-by-page \
ksym-vanilla-mlxsw-env-set-module-power-mode \
ksym-vanilla-mlxsw-i2c-driver-register \
ksym-vanilla-mlxsw-i2c-driver-unregister \
ksym-vanilla-mlxsw-linecards-event-ops-register \
ksym-vanilla-mlxsw-linecards-event-ops-unregister \
ksym-vanilla-mlxsw-pci-driver-register \
ksym-vanilla-mlxsw-pci-driver-unregister \
ksym-vanilla-mlxsw-reg-query \
ksym-vanilla-mlxsw-reg-trans-bulk-wait \
ksym-vanilla-mlxsw-reg-trans-query \
ksym-vanilla-mlxsw-reg-trans-write \
ksym-vanilla-mlxsw-reg-write \
ksym-vanilla-mm-account-pinned-pages \
ksym-vanilla-mm-get-unmapped-area \
ksym-vanilla-mm-unaccount-pinned-pages \
ksym-vanilla-mma7455-core-probe \
ksym-vanilla-mma7455-core-regmap \
ksym-vanilla-mma7455-core-remove \
ksym-vanilla-mma9551-app-reset \
ksym-vanilla-mma9551-gpio-config \
ksym-vanilla-mma9551-read-accel-chan \
ksym-vanilla-mma9551-read-accel-scale \
ksym-vanilla-mma9551-read-config-byte \
ksym-vanilla-mma9551-read-config-word \
ksym-vanilla-mma9551-read-config-words \
ksym-vanilla-mma9551-read-status-byte \
ksym-vanilla-mma9551-read-status-word \
ksym-vanilla-mma9551-read-status-words \
ksym-vanilla-mma9551-read-version \
ksym-vanilla-mma9551-set-device-state \
ksym-vanilla-mma9551-set-power-state \
ksym-vanilla-mma9551-sleep \
ksym-vanilla-mma9551-update-config-bits \
ksym-vanilla-mma9551-write-config-byte \
ksym-vanilla-mma9551-write-config-word \
ksym-vanilla-mma9551-write-config-words \
ksym-vanilla-mmal-vchi-buffer-cleanup \
ksym-vanilla-mmal-vchi-buffer-init \
ksym-vanilla-mmap-action-complete \
ksym-vanilla-mmap-action-prepare \
ksym-vanilla-mmaxi-0-clk \
ksym-vanilla-mmaxi-1-clk \
ksym-vanilla-mmb-fsync \
ksym-vanilla-mmb-fsync-noflush \
ksym-vanilla-mmb-has-buffers \
ksym-vanilla-mmb-init \
ksym-vanilla-mmb-invalidate \
ksym-vanilla-mmb-mark-buffer-dirty \
ksym-vanilla-mmb-sync \
ksym-vanilla-mmc-add-host \
ksym-vanilla-mmc-alloc-host \
ksym-vanilla-mmc-app-cmd \
ksym-vanilla-mmc-calc-max-discard \
ksym-vanilla-mmc-card-alternative-gpt-sector \
ksym-vanilla-mmc-card-can-cmd23 \
ksym-vanilla-mmc-card-can-discard \
ksym-vanilla-mmc-card-can-erase \
ksym-vanilla-mmc-card-can-secure-erase-trim \
ksym-vanilla-mmc-card-can-trim \
ksym-vanilla-mmc-card-is-blockaddr \
ksym-vanilla-mmc-cmdq-disable \
ksym-vanilla-mmc-cmdq-enable \
ksym-vanilla-mmc-command-done \
ksym-vanilla-mmc-cqe-post-req \
ksym-vanilla-mmc-cqe-recovery \
ksym-vanilla-mmc-cqe-request-done \
ksym-vanilla-mmc-cqe-start-req \
ksym-vanilla-mmc-crypto-prepare-req \
ksym-vanilla-mmc-crypto-setup-queue \
ksym-vanilla-mmc-detect-card-removed \
ksym-vanilla-mmc-detect-change \
ksym-vanilla-mmc-erase \
ksym-vanilla-mmc-erase-group-aligned \
ksym-vanilla-mmc-free-host \
ksym-vanilla-mmc-get-card \
ksym-vanilla-mmc-get-ext-csd \
ksym-vanilla-mmc-gpio-get-cd \
ksym-vanilla-mmc-gpio-get-ro \
ksym-vanilla-mmc-gpio-set-cd-irq \
ksym-vanilla-mmc-gpio-set-cd-wake \
ksym-vanilla-mmc-gpiod-request-cd \
ksym-vanilla-mmc-gpiod-request-cd-irq \
ksym-vanilla-mmc-gpiod-request-ro \
ksym-vanilla-mmc-gpiod-set-cd-config \
ksym-vanilla-mmc-host-can-gpio-cd \
ksym-vanilla-mmc-host-can-gpio-ro \
ksym-vanilla-mmc-hsq-finalize-request \
ksym-vanilla-mmc-hsq-init \
ksym-vanilla-mmc-hsq-resume \
ksym-vanilla-mmc-hsq-suspend \
ksym-vanilla-mmc-hw-reset \
ksym-vanilla-mmc-is-req-done \
ksym-vanilla-mmc-of-parse \
ksym-vanilla-mmc-of-parse-clk-phase \
ksym-vanilla-mmc-of-parse-voltage \
ksym-vanilla-mmc-poll-for-busy \
ksym-vanilla-mmc-prepare-busy-cmd \
ksym-vanilla-mmc-put-card \
ksym-vanilla-mmc-pwrseq-register \
ksym-vanilla-mmc-pwrseq-unregister \
ksym-vanilla-mmc-read-tuning \
ksym-vanilla-mmc-register-driver \
ksym-vanilla-mmc-regulator-disable-vqmmc \
ksym-vanilla-mmc-regulator-enable-vqmmc \
ksym-vanilla-mmc-regulator-get-supply \
ksym-vanilla-mmc-regulator-set-ocr \
ksym-vanilla-mmc-regulator-set-vqmmc \
ksym-vanilla-mmc-regulator-set-vqmmc2 \
ksym-vanilla-mmc-release-host \
ksym-vanilla-mmc-remove-host \
ksym-vanilla-mmc-request-done \
ksym-vanilla-mmc-retune-pause \
ksym-vanilla-mmc-retune-release \
ksym-vanilla-mmc-retune-timer-stop \
ksym-vanilla-mmc-retune-unpause \
ksym-vanilla-mmc-run-bkops \
ksym-vanilla-mmc-sanitize \
ksym-vanilla-mmc-sd-switch \
ksym-vanilla-mmc-send-abort-tuning \
ksym-vanilla-mmc-send-status \
ksym-vanilla-mmc-send-tuning \
ksym-vanilla-mmc-set-blocklen \
ksym-vanilla-mmc-set-data-timeout \
ksym-vanilla-mmc-start-request \
ksym-vanilla-mmc-sw-reset \
ksym-vanilla-mmc-switch \
ksym-vanilla-mmc-unregister-driver \
ksym-vanilla-mmc-wait-for-cmd \
ksym-vanilla-mmc-wait-for-req \
ksym-vanilla-mmc-wait-for-req-done \
ksym-vanilla-mmd-phy-read \
ksym-vanilla-mmd-phy-write \
ksym-vanilla-mmput \
ksym-vanilla-mmput-async \
ksym-vanilla-mmu-interval-notifier-insert \
ksym-vanilla-mmu-interval-notifier-insert-locked \
ksym-vanilla-mmu-interval-notifier-remove \
ksym-vanilla-mmu-interval-read-begin \
ksym-vanilla-mmu-notifier-get-locked \
ksym-vanilla-mmu-notifier-put \
ksym-vanilla-mmu-notifier-register \
ksym-vanilla-mmu-notifier-synchronize \
ksym-vanilla-mmu-notifier-unregister \
ksym-vanilla-mnt-drop-write \
ksym-vanilla-mnt-drop-write-file \
ksym-vanilla-mnt-get-write-access \
ksym-vanilla-mnt-idmap-get \
ksym-vanilla-mnt-idmap-put \
ksym-vanilla-mnt-put-write-access \
ksym-vanilla-mnt-set-expiry \
ksym-vanilla-mnt-want-write \
ksym-vanilla-mnt-want-write-file \
ksym-vanilla-mntget \
ksym-vanilla-mntput \
ksym-vanilla-mock-phc-create \
ksym-vanilla-mock-phc-destroy \
ksym-vanilla-mock-phc-index \
ksym-vanilla-mod-delayed-work-on \
ksym-vanilla-mod-node-page-state \
ksym-vanilla-mod-timer \
ksym-vanilla-mod-timer-pending \
ksym-vanilla-mod-zone-page-state \
ksym-vanilla-mode-strip-sgid \
ksym-vanilla-modify-ftrace-direct \
ksym-vanilla-modify-ftrace-direct-nolock \
ksym-vanilla-modify-user-hw-breakpoint \
ksym-vanilla-module-layout \
ksym-vanilla-module-put \
ksym-vanilla-module-refcount \
ksym-vanilla-mount-subtree \
ksym-vanilla-movable-zone \
ksym-vanilla-moxtet-device-read \
ksym-vanilla-moxtet-device-write \
ksym-vanilla-moxtet-device-written \
ksym-vanilla-mpage-read-folio \
ksym-vanilla-mpage-readahead \
ksym-vanilla-mpam-register-requestor \
ksym-vanilla-mpc8xxx-spi-probe \
ksym-vanilla-mpc8xxx-spi-rx-buf-u16 \
ksym-vanilla-mpc8xxx-spi-rx-buf-u32 \
ksym-vanilla-mpc8xxx-spi-rx-buf-u8 \
ksym-vanilla-mpc8xxx-spi-strmode \
ksym-vanilla-mpc8xxx-spi-tx-buf-u16 \
ksym-vanilla-mpc8xxx-spi-tx-buf-u32 \
ksym-vanilla-mpc8xxx-spi-tx-buf-u8 \
ksym-vanilla-mpfs-blocking-transaction \
ksym-vanilla-mpfs-reset-controller-register \
ksym-vanilla-mpfs-sys-controller-get \
ksym-vanilla-mpfs-sys-controller-get-flash \
ksym-vanilla-mpi-add \
ksym-vanilla-mpi-addm \
ksym-vanilla-mpi-alloc \
ksym-vanilla-mpi-cmp \
ksym-vanilla-mpi-cmp-ui \
ksym-vanilla-mpi-free \
ksym-vanilla-mpi-get-buffer \
ksym-vanilla-mpi-get-nbits \
ksym-vanilla-mpi-mul \
ksym-vanilla-mpi-mulm \
ksym-vanilla-mpi-powm \
ksym-vanilla-mpi-read-buffer \
ksym-vanilla-mpi-read-from-buffer \
ksym-vanilla-mpi-read-raw-data \
ksym-vanilla-mpi-read-raw-from-sgl \
ksym-vanilla-mpi-rshift \
ksym-vanilla-mpi-set-bit \
ksym-vanilla-mpi-sub \
ksym-vanilla-mpi-sub-ui \
ksym-vanilla-mpi-subm \
ksym-vanilla-mpi-test-bit \
ksym-vanilla-mpi-write-to-sgl \
ksym-vanilla-mpl115-dev-pm-ops \
ksym-vanilla-mpl115-probe \
ksym-vanilla-mpls-dev-mtu \
ksym-vanilla-mpls-output-possible \
ksym-vanilla-mpls-pkt-too-big \
ksym-vanilla-mpls-stats-inc-outucastpkts \
ksym-vanilla-mpol-free-shared-policy \
ksym-vanilla-mpol-set-shared-policy \
ksym-vanilla-mpol-shared-policy-init \
ksym-vanilla-mpol-shared-policy-lookup \
ksym-vanilla-mpr-common-probe \
ksym-vanilla-mpt-GetIocState \
ksym-vanilla-mpt-HardResetHandler \
ksym-vanilla-mpt-Soft-Hard-ResetHandler \
ksym-vanilla-mpt-alloc-fw-memory \
ksym-vanilla-mpt-attach \
ksym-vanilla-mpt-clear-taskmgmt-in-progress-flag \
ksym-vanilla-mpt-config \
ksym-vanilla-mpt-deregister \
ksym-vanilla-mpt-detach \
ksym-vanilla-mpt-device-driver-deregister \
ksym-vanilla-mpt-device-driver-register \
ksym-vanilla-mpt-event-deregister \
ksym-vanilla-mpt-event-register \
ksym-vanilla-mpt-findImVolumes \
ksym-vanilla-mpt-free-fw-memory \
ksym-vanilla-mpt-free-msg-frame \
ksym-vanilla-mpt-fwfault-debug \
ksym-vanilla-mpt-get-msg-frame \
ksym-vanilla-mpt-halt-firmware \
ksym-vanilla-mpt-print-ioc-summary \
ksym-vanilla-mpt-put-msg-frame \
ksym-vanilla-mpt-put-msg-frame-hi-pri \
ksym-vanilla-mpt-raid-phys-disk-get-num-paths \
ksym-vanilla-mpt-raid-phys-disk-pg0 \
ksym-vanilla-mpt-raid-phys-disk-pg1 \
ksym-vanilla-mpt-register \
ksym-vanilla-mpt-reset-deregister \
ksym-vanilla-mpt-reset-register \
ksym-vanilla-mpt-resume \
ksym-vanilla-mpt-send-handshake-request \
ksym-vanilla-mpt-set-taskmgmt-in-progress-flag \
ksym-vanilla-mpt-suspend \
ksym-vanilla-mpt-verify-adapter \
ksym-vanilla-mpt3sas-get-device-count \
ksym-vanilla-mpt3sas-send-mctp-passthru-req \
ksym-vanilla-mptbase-sas-persist-operation \
ksym-vanilla-mptcp-diag-fill-info \
ksym-vanilla-mptcp-get-reset-option \
ksym-vanilla-mptcp-pm-get-endp-fullmesh-max \
ksym-vanilla-mptcp-pm-get-endp-laminar-max \
ksym-vanilla-mptcp-pm-get-endp-signal-max \
ksym-vanilla-mptcp-pm-get-endp-subflow-max \
ksym-vanilla-mptcp-pm-get-limit-add-addr-accepted \
ksym-vanilla-mptcp-pm-get-limit-extra-subflows \
ksym-vanilla-mptcp-subflow-init-cookie-req \
ksym-vanilla-mptcp-subflow-reqsk-alloc \
ksym-vanilla-mptcp-token-get-sock \
ksym-vanilla-mptcp-token-iter-next \
ksym-vanilla-mptscsih-IssueTaskMgmt \
ksym-vanilla-mptscsih-abort \
ksym-vanilla-mptscsih-bios-param \
ksym-vanilla-mptscsih-bus-reset \
ksym-vanilla-mptscsih-change-queue-depth \
ksym-vanilla-mptscsih-dev-reset \
ksym-vanilla-mptscsih-event-process \
ksym-vanilla-mptscsih-flush-running-cmds \
ksym-vanilla-mptscsih-get-scsi-lookup \
ksym-vanilla-mptscsih-host-attr-groups \
ksym-vanilla-mptscsih-host-reset \
ksym-vanilla-mptscsih-info \
ksym-vanilla-mptscsih-io-done \
ksym-vanilla-mptscsih-ioc-reset \
ksym-vanilla-mptscsih-is-phys-disk \
ksym-vanilla-mptscsih-qcmd \
ksym-vanilla-mptscsih-raid-id-to-num \
ksym-vanilla-mptscsih-remove \
ksym-vanilla-mptscsih-resume \
ksym-vanilla-mptscsih-scandv-complete \
ksym-vanilla-mptscsih-sdev-configure \
ksym-vanilla-mptscsih-sdev-destroy \
ksym-vanilla-mptscsih-show-info \
ksym-vanilla-mptscsih-shutdown \
ksym-vanilla-mptscsih-suspend \
ksym-vanilla-mptscsih-taskmgmt-complete \
ksym-vanilla-mptscsih-taskmgmt-response-code \
ksym-vanilla-mq-attach \
ksym-vanilla-mq-change-real-num-tx \
ksym-vanilla-mq-destroy-common \
ksym-vanilla-mq-dump-class \
ksym-vanilla-mq-dump-class-stats \
ksym-vanilla-mq-dump-common \
ksym-vanilla-mq-find \
ksym-vanilla-mq-init-common \
ksym-vanilla-mq-leaf \
ksym-vanilla-mq-select-queue \
ksym-vanilla-mq-walk \
ksym-vanilla-mqprio-fp-to-offload \
ksym-vanilla-mqprio-qopt-reconstruct \
ksym-vanilla-mqprio-validate-qopt \
ksym-vanilla-mraid-mm-adapter-app-handle \
ksym-vanilla-mraid-mm-register-adp \
ksym-vanilla-mraid-mm-unregister-adp \
ksym-vanilla-mroute6-is-socket \
ksym-vanilla-mrp-init-applicant \
ksym-vanilla-mrp-register-application \
ksym-vanilla-mrp-request-join \
ksym-vanilla-mrp-request-leave \
ksym-vanilla-mrp-uninit-applicant \
ksym-vanilla-mrp-unregister-application \
ksym-vanilla-ms-hyperv \
ksym-vanilla-ms-sensors-convert-and-read \
ksym-vanilla-ms-sensors-ht-read-humidity \
ksym-vanilla-ms-sensors-ht-read-temperature \
ksym-vanilla-ms-sensors-read-prom-word \
ksym-vanilla-ms-sensors-read-serial \
ksym-vanilla-ms-sensors-read-temp-and-pressure \
ksym-vanilla-ms-sensors-reset \
ksym-vanilla-ms-sensors-show-battery-low \
ksym-vanilla-ms-sensors-show-heater \
ksym-vanilla-ms-sensors-tp-read-prom \
ksym-vanilla-ms-sensors-write-heater \
ksym-vanilla-ms-sensors-write-resolution \
ksym-vanilla-mscc-miim-setup \
ksym-vanilla-msg-type-name \
ksym-vanilla-msg-zerocopy-put-abort \
ksym-vanilla-msg-zerocopy-realloc \
ksym-vanilla-msg-zerocopy-ubuf-ops \
ksym-vanilla-msi-create-parent-irq-domain \
ksym-vanilla-msi-desc-to-pci-dev \
ksym-vanilla-msi-device-has-isolated-msi \
ksym-vanilla-msi-domain-alloc-irqs-range \
ksym-vanilla-msi-domain-first-desc \
ksym-vanilla-msi-domain-free-irqs-all \
ksym-vanilla-msi-domain-get-virq \
ksym-vanilla-msi-lib-init-dev-msi-info \
ksym-vanilla-msi-lib-irq-domain-select \
ksym-vanilla-msi-next-desc \
ksym-vanilla-msleep \
ksym-vanilla-msleep-interruptible \
ksym-vanilla-msm-pinctrl-dev-pm-ops \
ksym-vanilla-msm-pinctrl-probe \
ksym-vanilla-mt-calc-adistance \
ksym-vanilla-mt-find \
ksym-vanilla-mt-find-after \
ksym-vanilla-mt-find-alloc-memory-type \
ksym-vanilla-mt-next \
ksym-vanilla-mt-perf-to-adistance \
ksym-vanilla-mt-prev \
ksym-vanilla-mt-put-memory-types \
ksym-vanilla-mt2060-attach \
ksym-vanilla-mt2063-attach \
ksym-vanilla-mt2131-attach \
ksym-vanilla-mt2266-attach \
ksym-vanilla-mt312-attach \
ksym-vanilla-mt352-attach \
ksym-vanilla-mt6358-set-mtkaif-protocol \
ksym-vanilla-mt6359-accdet-enable-jack-detect \
ksym-vanilla-mt6359-mtkaif-calibration-disable \
ksym-vanilla-mt6359-mtkaif-calibration-enable \
ksym-vanilla-mt6359-set-mtkaif-calibration-phase \
ksym-vanilla-mt6359-set-mtkaif-protocol \
ksym-vanilla-mt7530-probe-common \
ksym-vanilla-mt7530-remove-common \
ksym-vanilla-mt753x-table \
ksym-vanilla-mt76-abort-roc \
ksym-vanilla-mt76-abort-scan \
ksym-vanilla-mt76-ac-to-hwq \
ksym-vanilla-mt76-add-chanctx \
ksym-vanilla-mt76-alloc-device \
ksym-vanilla-mt76-alloc-phy \
ksym-vanilla-mt76-alloc-radio-phy \
ksym-vanilla-mt76-assign-vif-chanctx \
ksym-vanilla-mt76-beacon-mon-check \
ksym-vanilla-mt76-cancel-hw-scan \
ksym-vanilla-mt76-cancel-remain-on-channel \
ksym-vanilla-mt76-change-chanctx \
ksym-vanilla-mt76-connac-free-pending-tx-skbs \
ksym-vanilla-mt76-connac-gen-ppe-thresh \
ksym-vanilla-mt76-connac-get-ch-power \
ksym-vanilla-mt76-connac-get-eht-phy-cap \
ksym-vanilla-mt76-connac-get-he-phy-cap \
ksym-vanilla-mt76-connac-get-phy-mode \
ksym-vanilla-mt76-connac-get-phy-mode-ext \
ksym-vanilla-mt76-connac-get-phy-mode-v2 \
ksym-vanilla-mt76-connac-get-rate-power-limit \
ksym-vanilla-mt76-connac-init-tx-queues \
ksym-vanilla-mt76-connac-mcu-add-key \
ksym-vanilla-mt76-connac-mcu-add-nested-tlv \
ksym-vanilla-mt76-connac-mcu-alloc-wtbl-req \
ksym-vanilla-mt76-connac-mcu-beacon-loss-iter \
ksym-vanilla-mt76-connac-mcu-bss-basic-tlv \
ksym-vanilla-mt76-connac-mcu-bss-ext-tlv \
ksym-vanilla-mt76-connac-mcu-bss-omac-tlv \
ksym-vanilla-mt76-connac-mcu-build-rnr-scan-param \
ksym-vanilla-mt76-connac-mcu-cancel-hw-scan \
ksym-vanilla-mt76-connac-mcu-chip-config \
ksym-vanilla-mt76-connac-mcu-coredump-event \
ksym-vanilla-mt76-connac-mcu-del-wtbl-all \
ksym-vanilla-mt76-connac-mcu-hw-scan \
ksym-vanilla-mt76-connac-mcu-init-download \
ksym-vanilla-mt76-connac-mcu-patch-sem-ctrl \
ksym-vanilla-mt76-connac-mcu-rdd-cmd \
ksym-vanilla-mt76-connac-mcu-reg-rr \
ksym-vanilla-mt76-connac-mcu-reg-wr \
ksym-vanilla-mt76-connac-mcu-restart \
ksym-vanilla-mt76-connac-mcu-sched-scan-enable \
ksym-vanilla-mt76-connac-mcu-sched-scan-req \
ksym-vanilla-mt76-connac-mcu-set-channel-domain \
ksym-vanilla-mt76-connac-mcu-set-deep-sleep \
ksym-vanilla-mt76-connac-mcu-set-gtk-rekey \
ksym-vanilla-mt76-connac-mcu-set-hif-suspend \
ksym-vanilla-mt76-connac-mcu-set-mac-enable \
ksym-vanilla-mt76-connac-mcu-set-p2p-oppps \
ksym-vanilla-mt76-connac-mcu-set-pm \
ksym-vanilla-mt76-connac-mcu-set-rate-txpower \
ksym-vanilla-mt76-connac-mcu-set-rts-thresh \
ksym-vanilla-mt76-connac-mcu-set-suspend-iter \
ksym-vanilla-mt76-connac-mcu-set-suspend-mode \
ksym-vanilla-mt76-connac-mcu-set-vif-ps \
ksym-vanilla-mt76-connac-mcu-set-wow-ctrl \
ksym-vanilla-mt76-connac-mcu-sta-ba \
ksym-vanilla-mt76-connac-mcu-sta-ba-tlv \
ksym-vanilla-mt76-connac-mcu-sta-basic-tlv \
ksym-vanilla-mt76-connac-mcu-sta-cmd \
ksym-vanilla-mt76-connac-mcu-sta-he-tlv-v2 \
ksym-vanilla-mt76-connac-mcu-sta-tlv \
ksym-vanilla-mt76-connac-mcu-sta-uapsd \
ksym-vanilla-mt76-connac-mcu-sta-update-hdr-trans \
ksym-vanilla-mt76-connac-mcu-sta-wed-update \
ksym-vanilla-mt76-connac-mcu-start-firmware \
ksym-vanilla-mt76-connac-mcu-start-patch \
ksym-vanilla-mt76-connac-mcu-uni-add-bss \
ksym-vanilla-mt76-connac-mcu-uni-add-dev \
ksym-vanilla-mt76-connac-mcu-uni-set-chctx \
ksym-vanilla-mt76-connac-mcu-update-arp-filter \
ksym-vanilla-mt76-connac-mcu-update-gtk-rekey \
ksym-vanilla-mt76-connac-mcu-wtbl-ba-tlv \
ksym-vanilla-mt76-connac-mcu-wtbl-generic-tlv \
ksym-vanilla-mt76-connac-mcu-wtbl-hdr-trans-tlv \
ksym-vanilla-mt76-connac-mcu-wtbl-ht-tlv \
ksym-vanilla-mt76-connac-mcu-wtbl-smps-tlv \
ksym-vanilla-mt76-connac-mcu-wtbl-update-hdr-trans \
ksym-vanilla-mt76-connac-pm-dequeue-skbs \
ksym-vanilla-mt76-connac-pm-queue-skb \
ksym-vanilla-mt76-connac-pm-wake \
ksym-vanilla-mt76-connac-power-save-sched \
ksym-vanilla-mt76-connac-set-txpower-cur \
ksym-vanilla-mt76-connac-sta-state-dp \
ksym-vanilla-mt76-connac-tx-complete-skb \
ksym-vanilla-mt76-connac-txp-skb-unmap \
ksym-vanilla-mt76-connac-wowlan-support \
ksym-vanilla-mt76-connac-write-hw-txp \
ksym-vanilla-mt76-connac2-load-patch \
ksym-vanilla-mt76-connac2-load-ram \
ksym-vanilla-mt76-connac2-mac-add-txs-skb \
ksym-vanilla-mt76-connac2-mac-decode-he-radiotap \
ksym-vanilla-mt76-connac2-mac-fill-rx-rate \
ksym-vanilla-mt76-connac2-mac-fill-txs \
ksym-vanilla-mt76-connac2-mac-tx-rate-val \
ksym-vanilla-mt76-connac2-mac-write-txwi \
ksym-vanilla-mt76-connac2-mcu-fill-message \
ksym-vanilla-mt76-connac2-reverse-frag0-hdr-trans \
ksym-vanilla-mt76-connac2-tx-check-aggr \
ksym-vanilla-mt76-connac2-tx-token-put \
ksym-vanilla-mt76-connac2-txwi-free \
ksym-vanilla-mt76-connac3-mac-decode-eht-radiotap \
ksym-vanilla-mt76-connac3-mac-decode-he-radiotap \
ksym-vanilla-mt76-create-page-pool \
ksym-vanilla-mt76-csa-check \
ksym-vanilla-mt76-csa-finish \
ksym-vanilla-mt76-dma-attach \
ksym-vanilla-mt76-dma-cleanup \
ksym-vanilla-mt76-dma-rx-poll \
ksym-vanilla-mt76-eeprom-init \
ksym-vanilla-mt76-eeprom-override \
ksym-vanilla-mt76-ethtool-page-pool-stats \
ksym-vanilla-mt76-ethtool-worker \
ksym-vanilla-mt76-find-channel-node \
ksym-vanilla-mt76-find-power-limits-node \
ksym-vanilla-mt76-free-device \
ksym-vanilla-mt76-free-pending-rxwi \
ksym-vanilla-mt76-get-antenna \
ksym-vanilla-mt76-get-min-avg-rssi \
ksym-vanilla-mt76-get-of-data-from-mtd \
ksym-vanilla-mt76-get-of-data-from-nvmem \
ksym-vanilla-mt76-get-power-bound \
ksym-vanilla-mt76-get-rate \
ksym-vanilla-mt76-get-rate-power-limits \
ksym-vanilla-mt76-get-rxwi \
ksym-vanilla-mt76-get-sar-power \
ksym-vanilla-mt76-get-survey \
ksym-vanilla-mt76-get-txpower \
ksym-vanilla-mt76-has-tx-pending \
ksym-vanilla-mt76-hw-scan \
ksym-vanilla-mt76-init-queue \
ksym-vanilla-mt76-init-sar-power \
ksym-vanilla-mt76-insert-ccmp-hdr \
ksym-vanilla-mt76-mcu-get-response \
ksym-vanilla-mt76-mcu-rx-event \
ksym-vanilla-mt76-mcu-send-and-get-msg \
ksym-vanilla-mt76-mcu-skb-send-and-get-msg \
ksym-vanilla-mt76-mmio-init \
ksym-vanilla-mt76-offchannel-notify \
ksym-vanilla-mt76-pci-aspm-supported \
ksym-vanilla-mt76-pci-disable-aspm \
ksym-vanilla-mt76-phy-dfs-state \
ksym-vanilla-mt76-put-rxwi \
ksym-vanilla-mt76-put-txwi \
ksym-vanilla-mt76-queue-tx-complete \
ksym-vanilla-mt76-queues-read \
ksym-vanilla-mt76-rates \
ksym-vanilla-mt76-register-debugfs-fops \
ksym-vanilla-mt76-register-device \
ksym-vanilla-mt76-register-phy \
ksym-vanilla-mt76-release-buffered-frames \
ksym-vanilla-mt76-remain-on-channel \
ksym-vanilla-mt76-remove-chanctx \
ksym-vanilla-mt76-reset-device \
ksym-vanilla-mt76-rx \
ksym-vanilla-mt76-rx-aggr-start \
ksym-vanilla-mt76-rx-aggr-stop \
ksym-vanilla-mt76-rx-beacon \
ksym-vanilla-mt76-rx-poll-complete \
ksym-vanilla-mt76-rx-signal \
ksym-vanilla-mt76-rx-token-consume \
ksym-vanilla-mt76-rx-token-release \
ksym-vanilla-mt76-select-links \
ksym-vanilla-mt76-seq-puts-array \
ksym-vanilla-mt76-set-irq-mask \
ksym-vanilla-mt76-set-stream-caps \
ksym-vanilla-mt76-set-tim \
ksym-vanilla-mt76-skb-adjust-pad \
ksym-vanilla-mt76-sta-pre-rcu-remove \
ksym-vanilla-mt76-sta-state \
ksym-vanilla-mt76-stop-tx-queues \
ksym-vanilla-mt76-sw-scan \
ksym-vanilla-mt76-sw-scan-complete \
ksym-vanilla-mt76-switch-vif-chanctx \
ksym-vanilla-mt76-token-consume \
ksym-vanilla-mt76-token-release \
ksym-vanilla-mt76-tx \
ksym-vanilla-mt76-tx-check-agg-ssn \
ksym-vanilla-mt76-tx-status-check \
ksym-vanilla-mt76-tx-status-lock \
ksym-vanilla-mt76-tx-status-skb-add \
ksym-vanilla-mt76-tx-status-skb-done \
ksym-vanilla-mt76-tx-status-skb-get \
ksym-vanilla-mt76-tx-status-unlock \
ksym-vanilla-mt76-tx-worker-run \
ksym-vanilla-mt76-txq-schedule \
ksym-vanilla-mt76-txq-schedule-all \
ksym-vanilla-mt76-unassign-vif-chanctx \
ksym-vanilla-mt76-unregister-device \
ksym-vanilla-mt76-unregister-phy \
ksym-vanilla-mt76-update-channel \
ksym-vanilla-mt76-update-survey \
ksym-vanilla-mt76-update-survey-active-time \
ksym-vanilla-mt76-vif-cleanup \
ksym-vanilla-mt76-vif-phy \
ksym-vanilla-mt76-wake-tx-queue \
ksym-vanilla-mt76-wcid-add-poll \
ksym-vanilla-mt76-wcid-alloc \
ksym-vanilla-mt76-wcid-cleanup \
ksym-vanilla-mt76-wcid-init \
ksym-vanilla-mt76-wcid-key-setup \
ksym-vanilla-mt76-wed-dma-reset \
ksym-vanilla-mt76-wed-dma-setup \
ksym-vanilla-mt76-wed-init-rx-buf \
ksym-vanilla-mt76-wed-net-setup-tc \
ksym-vanilla-mt76-wed-offload-disable \
ksym-vanilla-mt76-wed-offload-enable \
ksym-vanilla-mt76-wed-release-rx-buf \
ksym-vanilla-mt76-wed-reset-complete \
ksym-vanilla-mt76-write-mac-initvals \
ksym-vanilla-mt7615-dma-reset \
ksym-vanilla-mt7615-eeprom-init \
ksym-vanilla-mt7615-init-debugfs \
ksym-vanilla-mt7615-init-device \
ksym-vanilla-mt7615-init-txpower \
ksym-vanilla-mt7615-init-work \
ksym-vanilla-mt7615-led-set-blink \
ksym-vanilla-mt7615-led-set-brightness \
ksym-vanilla-mt7615-mac-set-rates \
ksym-vanilla-mt7615-mac-sta-add \
ksym-vanilla-mt7615-mac-sta-poll \
ksym-vanilla-mt7615-mac-sta-remove \
ksym-vanilla-mt7615-mac-write-txwi \
ksym-vanilla-mt7615-mcu-exit \
ksym-vanilla-mt7615-mcu-fill-msg \
ksym-vanilla-mt7615-mcu-init \
ksym-vanilla-mt7615-mcu-parse-response \
ksym-vanilla-mt7615-mcu-restart \
ksym-vanilla-mt7615-ops \
ksym-vanilla-mt7615-queue-rx-skb \
ksym-vanilla-mt7615-reg-map \
ksym-vanilla-mt7615-register-ext-phy \
ksym-vanilla-mt7615-rx-check \
ksym-vanilla-mt7615-set-channel \
ksym-vanilla-mt7615-thermal-init \
ksym-vanilla-mt7615-tx-token-put \
ksym-vanilla-mt7615-unregister-ext-phy \
ksym-vanilla-mt7615-update-channel \
ksym-vanilla-mt7615-wait-for-mcu-init \
ksym-vanilla-mt7622-trigger-hif-int \
ksym-vanilla-mt7663-usb-sdio-reg-map \
ksym-vanilla-mt7663-usb-sdio-register-device \
ksym-vanilla-mt7663-usb-sdio-tx-complete-skb \
ksym-vanilla-mt7663-usb-sdio-tx-prepare-skb \
ksym-vanilla-mt7663-usb-sdio-tx-status-data \
ksym-vanilla-mt76s-alloc-rx-queue \
ksym-vanilla-mt76s-alloc-tx \
ksym-vanilla-mt76s-deinit \
ksym-vanilla-mt76s-hw-init \
ksym-vanilla-mt76s-init \
ksym-vanilla-mt76s-rd-rp \
ksym-vanilla-mt76s-read-copy \
ksym-vanilla-mt76s-read-pcr \
ksym-vanilla-mt76s-rmw \
ksym-vanilla-mt76s-rr \
ksym-vanilla-mt76s-sdio-irq \
ksym-vanilla-mt76s-txqs-empty \
ksym-vanilla-mt76s-txrx-worker \
ksym-vanilla-mt76s-wr \
ksym-vanilla-mt76s-wr-rp \
ksym-vanilla-mt76s-write-copy \
ksym-vanilla-mt76u-alloc-mcu-queue \
ksym-vanilla-mt76u-alloc-queues \
ksym-vanilla-mt76u-init \
ksym-vanilla-mt76u-queues-deinit \
ksym-vanilla-mt76u-read-copy \
ksym-vanilla-mt76u-resume-rx \
ksym-vanilla-mt76u-single-wr \
ksym-vanilla-mt76u-stop-rx \
ksym-vanilla-mt76u-stop-tx \
ksym-vanilla-mt76u-vendor-request \
ksym-vanilla-mt76x0-chip-onoff \
ksym-vanilla-mt76x0-config \
ksym-vanilla-mt76x0-init-hardware \
ksym-vanilla-mt76x0-mac-stop \
ksym-vanilla-mt76x0-phy-calibrate \
ksym-vanilla-mt76x0-register-device \
ksym-vanilla-mt76x0-set-channel \
ksym-vanilla-mt76x0-set-sar-specs \
ksym-vanilla-mt76x02-add-interface \
ksym-vanilla-mt76x02-add-rate-power-offset \
ksym-vanilla-mt76x02-ampdu-action \
ksym-vanilla-mt76x02-bss-info-changed \
ksym-vanilla-mt76x02-conf-tx \
ksym-vanilla-mt76x02-config-mac-addr-list \
ksym-vanilla-mt76x02-configure-filter \
ksym-vanilla-mt76x02-dfs-init-params \
ksym-vanilla-mt76x02-dma-disable \
ksym-vanilla-mt76x02-dma-init \
ksym-vanilla-mt76x02-edcca-init \
ksym-vanilla-mt76x02-eeprom-copy \
ksym-vanilla-mt76x02-eeprom-parse-hw-cap \
ksym-vanilla-mt76x02-enqueue-buffered-bc \
ksym-vanilla-mt76x02-ext-pa-enabled \
ksym-vanilla-mt76x02-get-efuse-data \
ksym-vanilla-mt76x02-get-lna-gain \
ksym-vanilla-mt76x02-get-max-rate-power \
ksym-vanilla-mt76x02-get-rx-gain \
ksym-vanilla-mt76x02-init-agc-gain \
ksym-vanilla-mt76x02-init-beacon-config \
ksym-vanilla-mt76x02-init-debugfs \
ksym-vanilla-mt76x02-init-device \
ksym-vanilla-mt76x02-irq-handler \
ksym-vanilla-mt76x02-limit-rate-power \
ksym-vanilla-mt76x02-mac-cc-reset \
ksym-vanilla-mt76x02-mac-reset-counters \
ksym-vanilla-mt76x02-mac-set-beacon \
ksym-vanilla-mt76x02-mac-setaddr \
ksym-vanilla-mt76x02-mac-shared-key-setup \
ksym-vanilla-mt76x02-mac-start \
ksym-vanilla-mt76x02-mac-wcid-setup \
ksym-vanilla-mt76x02-mac-write-txwi \
ksym-vanilla-mt76x02-mcu-calibrate \
ksym-vanilla-mt76x02-mcu-cleanup \
ksym-vanilla-mt76x02-mcu-function-select \
ksym-vanilla-mt76x02-mcu-msg-send \
ksym-vanilla-mt76x02-mcu-parse-response \
ksym-vanilla-mt76x02-mcu-set-radio-state \
ksym-vanilla-mt76x02-phy-adjust-vga-gain \
ksym-vanilla-mt76x02-phy-dfs-adjust-agc \
ksym-vanilla-mt76x02-phy-set-band \
ksym-vanilla-mt76x02-phy-set-bw \
ksym-vanilla-mt76x02-phy-set-rxpath \
ksym-vanilla-mt76x02-phy-set-txdac \
ksym-vanilla-mt76x02-phy-set-txpower \
ksym-vanilla-mt76x02-queue-rx-skb \
ksym-vanilla-mt76x02-rates \
ksym-vanilla-mt76x02-reconfig-complete \
ksym-vanilla-mt76x02-remove-hdr-pad \
ksym-vanilla-mt76x02-remove-interface \
ksym-vanilla-mt76x02-resync-beacon-timer \
ksym-vanilla-mt76x02-rx-poll-complete \
ksym-vanilla-mt76x02-set-coverage-class \
ksym-vanilla-mt76x02-set-ethtool-fwver \
ksym-vanilla-mt76x02-set-key \
ksym-vanilla-mt76x02-set-rts-threshold \
ksym-vanilla-mt76x02-set-tx-ackto \
ksym-vanilla-mt76x02-sta-add \
ksym-vanilla-mt76x02-sta-ps \
ksym-vanilla-mt76x02-sta-rate-tbl-update \
ksym-vanilla-mt76x02-sta-remove \
ksym-vanilla-mt76x02-sw-scan-complete \
ksym-vanilla-mt76x02-tx \
ksym-vanilla-mt76x02-tx-complete-skb \
ksym-vanilla-mt76x02-tx-prepare-skb \
ksym-vanilla-mt76x02-tx-set-txpwr-auto \
ksym-vanilla-mt76x02-tx-status-data \
ksym-vanilla-mt76x02-update-beacon-iter \
ksym-vanilla-mt76x02-update-channel \
ksym-vanilla-mt76x02e-init-beacon-config \
ksym-vanilla-mt76x02u-exit-beacon-config \
ksym-vanilla-mt76x02u-init-beacon-config \
ksym-vanilla-mt76x02u-init-mcu \
ksym-vanilla-mt76x02u-mac-start \
ksym-vanilla-mt76x02u-mcu-fw-reset \
ksym-vanilla-mt76x02u-mcu-fw-send-data \
ksym-vanilla-mt76x02u-tx-complete-skb \
ksym-vanilla-mt76x02u-tx-prepare-skb \
ksym-vanilla-mt76x2-apply-gain-adj \
ksym-vanilla-mt76x2-configure-tx-delay \
ksym-vanilla-mt76x2-eeprom-init \
ksym-vanilla-mt76x2-get-power-info \
ksym-vanilla-mt76x2-get-rate-power \
ksym-vanilla-mt76x2-get-temp-comp \
ksym-vanilla-mt76x2-init-txpower \
ksym-vanilla-mt76x2-mac-stop \
ksym-vanilla-mt76x2-mcu-init-gain \
ksym-vanilla-mt76x2-mcu-load-cr \
ksym-vanilla-mt76x2-mcu-set-channel \
ksym-vanilla-mt76x2-mcu-tssi-comp \
ksym-vanilla-mt76x2-phy-set-txpower \
ksym-vanilla-mt76x2-phy-set-txpower-regs \
ksym-vanilla-mt76x2-phy-tssi-compensate \
ksym-vanilla-mt76x2-phy-update-channel-gain \
ksym-vanilla-mt76x2-read-rx-gain \
ksym-vanilla-mt76x2-reset-wlan \
ksym-vanilla-mt76x2-set-sar-specs \
ksym-vanilla-mt7921-mac-init \
ksym-vanilla-mt7921-mac-sta-add \
ksym-vanilla-mt7921-mac-sta-event \
ksym-vanilla-mt7921-mac-sta-remove \
ksym-vanilla-mt7921-mcu-parse-response \
ksym-vanilla-mt7921-mcu-radio-led-ctrl \
ksym-vanilla-mt7921-mcu-regd-update \
ksym-vanilla-mt7921-mcu-set-eeprom \
ksym-vanilla-mt7921-ops \
ksym-vanilla-mt7921-queue-rx-skb \
ksym-vanilla-mt7921-register-device \
ksym-vanilla-mt7921-roc-abort-sync \
ksym-vanilla-mt7921-run-firmware \
ksym-vanilla-mt7921-rx-check \
ksym-vanilla-mt7921-set-channel \
ksym-vanilla-mt7921-usb-sdio-tx-complete-skb \
ksym-vanilla-mt7921-usb-sdio-tx-prepare-skb \
ksym-vanilla-mt7921-usb-sdio-tx-status-data \
ksym-vanilla-mt7925-mac-init \
ksym-vanilla-mt7925-mac-sta-add \
ksym-vanilla-mt7925-mac-sta-event \
ksym-vanilla-mt7925-mac-sta-remove \
ksym-vanilla-mt7925-mac-write-txwi \
ksym-vanilla-mt7925-mcu-cancel-hw-scan \
ksym-vanilla-mt7925-mcu-fill-message \
ksym-vanilla-mt7925-mcu-hw-scan \
ksym-vanilla-mt7925-mcu-parse-response \
ksym-vanilla-mt7925-mcu-regd-update \
ksym-vanilla-mt7925-mcu-regval \
ksym-vanilla-mt7925-mcu-sched-scan-req \
ksym-vanilla-mt7925-mcu-set-channel-domain \
ksym-vanilla-mt7925-mcu-set-dbdc \
ksym-vanilla-mt7925-mcu-set-deep-sleep \
ksym-vanilla-mt7925-mcu-set-eeprom \
ksym-vanilla-mt7925-mcu-set-thermal-protect \
ksym-vanilla-mt7925-ops \
ksym-vanilla-mt7925-queue-rx-skb \
ksym-vanilla-mt7925-regd-change \
ksym-vanilla-mt7925-register-device \
ksym-vanilla-mt7925-roc-abort-sync \
ksym-vanilla-mt7925-run-firmware \
ksym-vanilla-mt7925-rx-check \
ksym-vanilla-mt7925-txwi-free \
ksym-vanilla-mt7925-usb-sdio-tx-complete-skb \
ksym-vanilla-mt7925-usb-sdio-tx-prepare-skb \
ksym-vanilla-mt7925-usb-sdio-tx-status-data \
ksym-vanilla-mt792x-acpi-get-flags \
ksym-vanilla-mt792x-acpi-get-mtcl-conf \
ksym-vanilla-mt792x-assign-vif-chanctx \
ksym-vanilla-mt792x-conf-tx \
ksym-vanilla-mt792x-config-mac-addr-list \
ksym-vanilla-mt792x-csa-timer \
ksym-vanilla-mt792x-dma-alloc-queues \
ksym-vanilla-mt792x-dma-cleanup \
ksym-vanilla-mt792x-dma-disable \
ksym-vanilla-mt792x-dma-enable \
ksym-vanilla-mt792x-flush \
ksym-vanilla-mt792x-get-et-sset-count \
ksym-vanilla-mt792x-get-et-stats \
ksym-vanilla-mt792x-get-et-strings \
ksym-vanilla-mt792x-get-mac80211-ops \
ksym-vanilla-mt792x-get-stats \
ksym-vanilla-mt792x-get-tsf \
ksym-vanilla-mt792x-get-txpower \
ksym-vanilla-mt792x-init-acpi-sar \
ksym-vanilla-mt792x-init-acpi-sar-power \
ksym-vanilla-mt792x-init-wcid \
ksym-vanilla-mt792x-init-wiphy \
ksym-vanilla-mt792x-irq-handler \
ksym-vanilla-mt792x-irq-tasklet \
ksym-vanilla-mt792x-load-firmware \
ksym-vanilla-mt792x-mac-assoc-rssi \
ksym-vanilla-mt792x-mac-init-band \
ksym-vanilla-mt792x-mac-link-bss-remove \
ksym-vanilla-mt792x-mac-reset-counters \
ksym-vanilla-mt792x-mac-set-timeing \
ksym-vanilla-mt792x-mac-update-mib-stats \
ksym-vanilla-mt792x-mac-work \
ksym-vanilla-mt792x-mcu-drv-pmctrl \
ksym-vanilla-mt792x-mcu-fw-pmctrl \
ksym-vanilla-mt792x-pm-idle-timeout-get \
ksym-vanilla-mt792x-pm-idle-timeout-set \
ksym-vanilla-mt792x-pm-power-save-work \
ksym-vanilla-mt792x-pm-stats \
ksym-vanilla-mt792x-pm-wake-work \
ksym-vanilla-mt792x-poll-rx \
ksym-vanilla-mt792x-poll-tx \
ksym-vanilla-mt792x-queues-acq \
ksym-vanilla-mt792x-queues-read \
ksym-vanilla-mt792x-remove-interface \
ksym-vanilla-mt792x-reset \
ksym-vanilla-mt792x-roc-timer \
ksym-vanilla-mt792x-rx-get-wcid \
ksym-vanilla-mt792x-rx-poll-complete \
ksym-vanilla-mt792x-set-coverage-class \
ksym-vanilla-mt792x-set-tsf \
ksym-vanilla-mt792x-set-wakeup \
ksym-vanilla-mt792x-sta-statistics \
ksym-vanilla-mt792x-stop \
ksym-vanilla-mt792x-tx \
ksym-vanilla-mt792x-tx-stats-show \
ksym-vanilla-mt792x-tx-worker \
ksym-vanilla-mt792x-unassign-vif-chanctx \
ksym-vanilla-mt792x-update-channel \
ksym-vanilla-mt792x-wfsys-reset \
ksym-vanilla-mt792x-wpdma-reinit-cond \
ksym-vanilla-mt792x-wpdma-reset \
ksym-vanilla-mt792xe-mcu-drv-pmctrl \
ksym-vanilla-mt792xe-mcu-fw-pmctrl \
ksym-vanilla-mt792xu-check-bus \
ksym-vanilla-mt792xu-copy \
ksym-vanilla-mt792xu-disconnect \
ksym-vanilla-mt792xu-dma-init \
ksym-vanilla-mt792xu-init-reset \
ksym-vanilla-mt792xu-mcu-power-on \
ksym-vanilla-mt792xu-reset-on-bus-error \
ksym-vanilla-mt792xu-reset-work-cleanup \
ksym-vanilla-mt792xu-reset-work-init \
ksym-vanilla-mt792xu-rmw \
ksym-vanilla-mt792xu-rr \
ksym-vanilla-mt792xu-stop \
ksym-vanilla-mt792xu-wfsys-reset \
ksym-vanilla-mt792xu-wr \
ksym-vanilla-mt8183-dai-i2s-set-share \
ksym-vanilla-mt8186-afe-gpio-init \
ksym-vanilla-mt8186-dai-i2s-set-share \
ksym-vanilla-mt8186-mt6366-card-set-be-link \
ksym-vanilla-mt8186-mt6366-init \
ksym-vanilla-mt8188-afe-disable-clk \
ksym-vanilla-mt8188-afe-enable-clk \
ksym-vanilla-mt8189-afe-disable-clk \
ksym-vanilla-mt8189-afe-enable-clk \
ksym-vanilla-mt8192-afe-gpio-init \
ksym-vanilla-mt8192-afe-gpio-request \
ksym-vanilla-mt8192-dai-i2s-set-share \
ksym-vanilla-mt8195-afe-disable-clk \
ksym-vanilla-mt8195-afe-enable-clk \
ksym-vanilla-mt8196-afe-disable-clk \
ksym-vanilla-mt8196-afe-enable-clk \
ksym-vanilla-mtd-add-partition \
ksym-vanilla-mtd-blktrans-cease-background \
ksym-vanilla-mtd-block-isbad \
ksym-vanilla-mtd-block-isreserved \
ksym-vanilla-mtd-block-markbad \
ksym-vanilla-mtd-check-expert-analysis-mode \
ksym-vanilla-mtd-concat-create \
ksym-vanilla-mtd-concat-destroy \
ksym-vanilla-mtd-del-partition \
ksym-vanilla-mtd-device-parse-register \
ksym-vanilla-mtd-device-unregister \
ksym-vanilla-mtd-do-chip-probe \
ksym-vanilla-mtd-erase \
ksym-vanilla-mtd-erase-user-prot-reg \
ksym-vanilla-mtd-get-device-size \
ksym-vanilla-mtd-get-fact-prot-info \
ksym-vanilla-mtd-get-unmapped-area \
ksym-vanilla-mtd-get-user-prot-info \
ksym-vanilla-mtd-is-locked \
ksym-vanilla-mtd-kmalloc-up-to \
ksym-vanilla-mtd-lock \
ksym-vanilla-mtd-lock-user-prot-reg \
ksym-vanilla-mtd-ooblayout-count-eccbytes \
ksym-vanilla-mtd-ooblayout-count-freebytes \
ksym-vanilla-mtd-ooblayout-ecc \
ksym-vanilla-mtd-ooblayout-find-eccregion \
ksym-vanilla-mtd-ooblayout-free \
ksym-vanilla-mtd-ooblayout-get-databytes \
ksym-vanilla-mtd-ooblayout-get-eccbytes \
ksym-vanilla-mtd-ooblayout-set-databytes \
ksym-vanilla-mtd-ooblayout-set-eccbytes \
ksym-vanilla-mtd-pairing-groups \
ksym-vanilla-mtd-pairing-info-to-wunit \
ksym-vanilla-mtd-panic-write \
ksym-vanilla-mtd-point \
ksym-vanilla-mtd-read \
ksym-vanilla-mtd-read-fact-prot-reg \
ksym-vanilla-mtd-read-oob \
ksym-vanilla-mtd-read-user-prot-reg \
ksym-vanilla-mtd-table-mutex \
ksym-vanilla-mtd-unlock \
ksym-vanilla-mtd-unpoint \
ksym-vanilla-mtd-write \
ksym-vanilla-mtd-write-oob \
ksym-vanilla-mtd-write-user-prot-reg \
ksym-vanilla-mtd-writev \
ksym-vanilla-mtd-wunit-to-pairing-info \
ksym-vanilla-mtdtest-erase-eraseblock \
ksym-vanilla-mtdtest-erase-good-eraseblocks \
ksym-vanilla-mtdtest-read \
ksym-vanilla-mtdtest-scan-for-bad-eraseblocks \
ksym-vanilla-mtdtest-write \
ksym-vanilla-mtk-adda-dl-rate-transform \
ksym-vanilla-mtk-adda-ul-rate-transform \
ksym-vanilla-mtk-adsp-dump \
ksym-vanilla-mtk-adsp-get-bar-index \
ksym-vanilla-mtk-adsp-handle-reply \
ksym-vanilla-mtk-adsp-handle-request \
ksym-vanilla-mtk-adsp-ipc-send \
ksym-vanilla-mtk-adsp-send-msg \
ksym-vanilla-mtk-adsp-stream-pcm-hw-params \
ksym-vanilla-mtk-adsp-stream-pcm-pointer \
ksym-vanilla-mtk-afe-add-sub-dai-control \
ksym-vanilla-mtk-afe-combine-sub-dai \
ksym-vanilla-mtk-afe-fe-hw-free \
ksym-vanilla-mtk-afe-fe-hw-params \
ksym-vanilla-mtk-afe-fe-ops \
ksym-vanilla-mtk-afe-fe-prepare \
ksym-vanilla-mtk-afe-fe-shutdown \
ksym-vanilla-mtk-afe-fe-startup \
ksym-vanilla-mtk-afe-fe-trigger \
ksym-vanilla-mtk-afe-pcm-new \
ksym-vanilla-mtk-afe-pcm-platform \
ksym-vanilla-mtk-afe-pcm-pointer \
ksym-vanilla-mtk-afe-resume \
ksym-vanilla-mtk-afe-suspend \
ksym-vanilla-mtk-alloc-clk-data \
ksym-vanilla-mtk-build-eint \
ksym-vanilla-mtk-cec-hpd-high \
ksym-vanilla-mtk-cec-set-hpd-event \
ksym-vanilla-mtk-clk-dummy-ops \
ksym-vanilla-mtk-clk-gate-hwv-ops-setclr \
ksym-vanilla-mtk-clk-gate-hwv-ops-setclr-inv \
ksym-vanilla-mtk-clk-gate-ops-no-setclr \
ksym-vanilla-mtk-clk-gate-ops-no-setclr-inv \
ksym-vanilla-mtk-clk-gate-ops-setclr \
ksym-vanilla-mtk-clk-gate-ops-setclr-inv \
ksym-vanilla-mtk-clk-get-hwv-regmap \
ksym-vanilla-mtk-clk-pdev-probe \
ksym-vanilla-mtk-clk-pdev-remove \
ksym-vanilla-mtk-clk-register-composites \
ksym-vanilla-mtk-clk-register-cpumuxes \
ksym-vanilla-mtk-clk-register-dividers \
ksym-vanilla-mtk-clk-register-factors \
ksym-vanilla-mtk-clk-register-fixed-clks \
ksym-vanilla-mtk-clk-register-gates \
ksym-vanilla-mtk-clk-register-muxes \
ksym-vanilla-mtk-clk-register-pllfhs \
ksym-vanilla-mtk-clk-register-plls \
ksym-vanilla-mtk-clk-register-ref2usb-tx \
ksym-vanilla-mtk-clk-simple-probe \
ksym-vanilla-mtk-clk-simple-remove \
ksym-vanilla-mtk-clk-unregister-composites \
ksym-vanilla-mtk-clk-unregister-cpumuxes \
ksym-vanilla-mtk-clk-unregister-dividers \
ksym-vanilla-mtk-clk-unregister-factors \
ksym-vanilla-mtk-clk-unregister-fixed-clks \
ksym-vanilla-mtk-clk-unregister-gates \
ksym-vanilla-mtk-clk-unregister-muxes \
ksym-vanilla-mtk-clk-unregister-pllfhs \
ksym-vanilla-mtk-clk-unregister-plls \
ksym-vanilla-mtk-clk-unregister-ref2usb-tx \
ksym-vanilla-mtk-devm-alloc-clk-data \
ksym-vanilla-mtk-dvfsrc-query-info \
ksym-vanilla-mtk-dvfsrc-send-request \
ksym-vanilla-mtk-dynamic-irq-acquire \
ksym-vanilla-mtk-dynamic-irq-release \
ksym-vanilla-mtk-ecc-adjust-strength \
ksym-vanilla-mtk-ecc-disable \
ksym-vanilla-mtk-ecc-enable \
ksym-vanilla-mtk-ecc-encode \
ksym-vanilla-mtk-ecc-get-parity-bits \
ksym-vanilla-mtk-ecc-get-stats \
ksym-vanilla-mtk-ecc-release \
ksym-vanilla-mtk-ecc-wait-done \
ksym-vanilla-mtk-eint-do-init \
ksym-vanilla-mtk-eint-do-resume \
ksym-vanilla-mtk-eint-do-suspend \
ksym-vanilla-mtk-eint-find-irq \
ksym-vanilla-mtk-eint-pm-ops \
ksym-vanilla-mtk-eint-set-debounce \
ksym-vanilla-mtk-emi-icc-probe \
ksym-vanilla-mtk-emi-icc-remove \
ksym-vanilla-mtk-free-clk-data \
ksym-vanilla-mtk-hdmi-audio-get-eld \
ksym-vanilla-mtk-hdmi-audio-params \
ksym-vanilla-mtk-hdmi-audio-set-plugged-cb \
ksym-vanilla-mtk-hdmi-bridge-mode-fixup \
ksym-vanilla-mtk-hdmi-bridge-mode-set \
ksym-vanilla-mtk-hdmi-common-probe \
ksym-vanilla-mtk-hdmi-get-ncts \
ksym-vanilla-mtk-hw-get-value \
ksym-vanilla-mtk-hw-set-value \
ksym-vanilla-mtk-is-virt-gpio \
ksym-vanilla-mtk-jpeg-dec-enum-result \
ksym-vanilla-mtk-jpeg-dec-fill-param \
ksym-vanilla-mtk-jpeg-dec-get-int-status \
ksym-vanilla-mtk-jpeg-dec-reset \
ksym-vanilla-mtk-jpeg-dec-set-config \
ksym-vanilla-mtk-jpeg-dec-start \
ksym-vanilla-mtk-jpeg-enc-get-file-size \
ksym-vanilla-mtk-jpeg-enc-reset \
ksym-vanilla-mtk-jpeg-enc-start \
ksym-vanilla-mtk-jpeg-set-enc-dst \
ksym-vanilla-mtk-jpeg-set-enc-params \
ksym-vanilla-mtk-jpeg-set-enc-src \
ksym-vanilla-mtk-mdp-dbg-level \
ksym-vanilla-mtk-memif-set-addr \
ksym-vanilla-mtk-memif-set-channel \
ksym-vanilla-mtk-memif-set-disable \
ksym-vanilla-mtk-memif-set-enable \
ksym-vanilla-mtk-memif-set-format \
ksym-vanilla-mtk-memif-set-pbuf-size \
ksym-vanilla-mtk-memif-set-rate-substream \
ksym-vanilla-mtk-mmsys-ddp-connect \
ksym-vanilla-mtk-mmsys-ddp-disconnect \
ksym-vanilla-mtk-mmsys-ddp-dpi-fmt-config \
ksym-vanilla-mtk-mmsys-hdr-config \
ksym-vanilla-mtk-mmsys-merge-async-config \
ksym-vanilla-mtk-mmsys-mixer-in-channel-swap \
ksym-vanilla-mtk-mmsys-mixer-in-config \
ksym-vanilla-mtk-mmsys-vpp-rsz-dcm-config \
ksym-vanilla-mtk-mmsys-vpp-rsz-merge-config \
ksym-vanilla-mtk-mutex-acquire \
ksym-vanilla-mtk-mutex-add-comp \
ksym-vanilla-mtk-mutex-disable \
ksym-vanilla-mtk-mutex-enable \
ksym-vanilla-mtk-mutex-enable-by-cmdq \
ksym-vanilla-mtk-mutex-get \
ksym-vanilla-mtk-mutex-prepare \
ksym-vanilla-mtk-mutex-put \
ksym-vanilla-mtk-mutex-release \
ksym-vanilla-mtk-mutex-remove-comp \
ksym-vanilla-mtk-mutex-unprepare \
ksym-vanilla-mtk-mutex-write-mod \
ksym-vanilla-mtk-mutex-write-sof \
ksym-vanilla-mtk-mux-clr-set-upd-ops \
ksym-vanilla-mtk-mux-gate-clr-set-upd-ops \
ksym-vanilla-mtk-mux-gate-fenc-clr-set-upd-ops \
ksym-vanilla-mtk-mux-gate-hwv-fenc-clr-set-upd-ops \
ksym-vanilla-mtk-paris-pinctrl-pm-ops \
ksym-vanilla-mtk-paris-pinctrl-probe \
ksym-vanilla-mtk-pcs-lynxi-create \
ksym-vanilla-mtk-pcs-lynxi-destroy \
ksym-vanilla-mtk-pctrl-show-one-pin \
ksym-vanilla-mtk-phy-hw-led-blink-set \
ksym-vanilla-mtk-phy-hw-led-on-set \
ksym-vanilla-mtk-phy-led-hw-ctrl-get \
ksym-vanilla-mtk-phy-led-hw-ctrl-set \
ksym-vanilla-mtk-phy-led-hw-is-supported \
ksym-vanilla-mtk-phy-led-num-dly-cfg \
ksym-vanilla-mtk-phy-leds-state-init \
ksym-vanilla-mtk-phy-read-page \
ksym-vanilla-mtk-phy-write-page \
ksym-vanilla-mtk-pinconf-adv-drive-get \
ksym-vanilla-mtk-pinconf-adv-drive-get-raw \
ksym-vanilla-mtk-pinconf-adv-drive-set \
ksym-vanilla-mtk-pinconf-adv-drive-set-raw \
ksym-vanilla-mtk-pinconf-adv-pull-get \
ksym-vanilla-mtk-pinconf-adv-pull-set \
ksym-vanilla-mtk-pinconf-bias-disable-get \
ksym-vanilla-mtk-pinconf-bias-disable-get-rev1 \
ksym-vanilla-mtk-pinconf-bias-disable-set \
ksym-vanilla-mtk-pinconf-bias-disable-set-rev1 \
ksym-vanilla-mtk-pinconf-bias-get \
ksym-vanilla-mtk-pinconf-bias-get-combo \
ksym-vanilla-mtk-pinconf-bias-get-rev1 \
ksym-vanilla-mtk-pinconf-bias-set \
ksym-vanilla-mtk-pinconf-bias-set-combo \
ksym-vanilla-mtk-pinconf-bias-set-rev1 \
ksym-vanilla-mtk-pinconf-drive-get \
ksym-vanilla-mtk-pinconf-drive-get-raw \
ksym-vanilla-mtk-pinconf-drive-get-rev1 \
ksym-vanilla-mtk-pinconf-drive-set \
ksym-vanilla-mtk-pinconf-drive-set-raw \
ksym-vanilla-mtk-pinconf-drive-set-rev1 \
ksym-vanilla-mtk-pll-fenc-clr-set-ops \
ksym-vanilla-mtk-register-reset-controller-with-dev \
ksym-vanilla-mtk-rpmsg-create-rproc-subdev \
ksym-vanilla-mtk-rpmsg-destroy-rproc-subdev \
ksym-vanilla-mtk-soc-wed-ops \
ksym-vanilla-mtk-sof-card-late-probe \
ksym-vanilla-mtk-sof-card-probe \
ksym-vanilla-mtk-sof-dai-link-fixup \
ksym-vanilla-mtk-sof-dailink-parse-of \
ksym-vanilla-mtk-soundcard-common-capture-ops \
ksym-vanilla-mtk-soundcard-common-playback-ops \
ksym-vanilla-mtk-soundcard-common-probe \
ksym-vanilla-mtk-soundcard-startup \
ksym-vanilla-mtk-tr-modify \
ksym-vanilla-mtk-v4l2-dbg-level \
ksym-vanilla-mtk-vcodec-dbg \
ksym-vanilla-mtk-vcodec-dbgfs-create \
ksym-vanilla-mtk-vcodec-dbgfs-deinit \
ksym-vanilla-mtk-vcodec-dbgfs-init \
ksym-vanilla-mtk-vcodec-dbgfs-remove \
ksym-vanilla-mtk-vcodec-dec-disable-hardware \
ksym-vanilla-mtk-vcodec-dec-enable-hardware \
ksym-vanilla-mtk-vcodec-fw-get-type \
ksym-vanilla-mtk-vcodec-fw-get-vdec-capa \
ksym-vanilla-mtk-vcodec-fw-get-venc-capa \
ksym-vanilla-mtk-vcodec-fw-ipi-register \
ksym-vanilla-mtk-vcodec-fw-ipi-send \
ksym-vanilla-mtk-vcodec-fw-load-firmware \
ksym-vanilla-mtk-vcodec-fw-map-dm-addr \
ksym-vanilla-mtk-vcodec-fw-release \
ksym-vanilla-mtk-vcodec-fw-select \
ksym-vanilla-mtk-vcodec-get-curr-ctx \
ksym-vanilla-mtk-vcodec-get-hw-dev \
ksym-vanilla-mtk-vcodec-get-reg-addr \
ksym-vanilla-mtk-vcodec-init-dec-clk \
ksym-vanilla-mtk-vcodec-mem-alloc \
ksym-vanilla-mtk-vcodec-mem-free \
ksym-vanilla-mtk-vcodec-set-curr-ctx \
ksym-vanilla-mtk-vcodec-wait-for-done-ctx \
ksym-vanilla-mtk-vcodec-write-vdecsys \
ksym-vanilla-mtree-alloc-cyclic \
ksym-vanilla-mtree-alloc-range \
ksym-vanilla-mtree-alloc-rrange \
ksym-vanilla-mtree-destroy \
ksym-vanilla-mtree-dup \
ksym-vanilla-mtree-erase \
ksym-vanilla-mtree-insert \
ksym-vanilla-mtree-insert-range \
ksym-vanilla-mtree-load \
ksym-vanilla-mtree-store \
ksym-vanilla-mtree-store-range \
ksym-vanilla-mul-u64-add-u64-div-u64 \
ksym-vanilla-mult-to-ib-rate \
ksym-vanilla-musb-clearb \
ksym-vanilla-musb-clearw \
ksym-vanilla-musb-get-mode \
ksym-vanilla-musb-interrupt \
ksym-vanilla-musb-mailbox \
ksym-vanilla-musb-queue-resume-work \
ksym-vanilla-musb-readb \
ksym-vanilla-musb-readl \
ksym-vanilla-musb-readw \
ksym-vanilla-musb-root-disconnect \
ksym-vanilla-musb-set-host \
ksym-vanilla-musb-set-peripheral \
ksym-vanilla-musb-writeb \
ksym-vanilla-musb-writel \
ksym-vanilla-musb-writew \
ksym-vanilla-mutex-init-generic \
ksym-vanilla-mutex-is-locked \
ksym-vanilla-mutex-lock \
ksym-vanilla-mutex-lock-interruptible \
ksym-vanilla-mutex-lock-io \
ksym-vanilla-mutex-lock-killable \
ksym-vanilla-mutex-trylock \
ksym-vanilla-mutex-unlock \
ksym-vanilla-mux-chip-alloc \
ksym-vanilla-mux-chip-free \
ksym-vanilla-mux-chip-register \
ksym-vanilla-mux-chip-unregister \
ksym-vanilla-mux-control-deselect \
ksym-vanilla-mux-control-get \
ksym-vanilla-mux-control-get-optional \
ksym-vanilla-mux-control-put \
ksym-vanilla-mux-control-select-delay \
ksym-vanilla-mux-control-states \
ksym-vanilla-mux-control-try-select-delay \
ksym-vanilla-mux-div-set-src-div \
ksym-vanilla-mux-state-deselect \
ksym-vanilla-mux-state-select-delay \
ksym-vanilla-mux-state-try-select-delay \
ksym-vanilla-mwifiex-add-card \
ksym-vanilla-mwifiex-add-virtual-intf \
ksym-vanilla-mwifiex-alloc-dma-align-buf \
ksym-vanilla-mwifiex-cancel-hs \
ksym-vanilla-mwifiex-deauthenticate-all \
ksym-vanilla-mwifiex-del-virtual-intf \
ksym-vanilla-mwifiex-disable-auto-ds \
ksym-vanilla-mwifiex-dnld-fw \
ksym-vanilla-mwifiex-drv-info-dump \
ksym-vanilla-mwifiex-enable-hs \
ksym-vanilla-mwifiex-fw-dump-event \
ksym-vanilla-mwifiex-handle-rx-packet \
ksym-vanilla-mwifiex-init-shutdown-fw \
ksym-vanilla-mwifiex-main-process \
ksym-vanilla-mwifiex-multi-chan-resync \
ksym-vanilla-mwifiex-prepare-fw-dump-info \
ksym-vanilla-mwifiex-process-hs-config \
ksym-vanilla-mwifiex-process-sleep-confirm-resp \
ksym-vanilla-mwifiex-queue-main-work \
ksym-vanilla-mwifiex-reinit-sw \
ksym-vanilla-mwifiex-remove-card \
ksym-vanilla-mwifiex-shutdown-sw \
ksym-vanilla-mwifiex-upload-device-dump \
ksym-vanilla-mwifiex-write-data-complete \
ksym-vanilla-mxic-ecc-get-pipelined-engine \
ksym-vanilla-mxic-ecc-get-pipelined-ops \
ksym-vanilla-mxic-ecc-process-data-pipelined \
ksym-vanilla-mxic-ecc-put-pipelined-engine \
ksym-vanilla-mxl111sf-demod-attach \
ksym-vanilla-mxl111sf-tuner-attach \
ksym-vanilla-mxl5005s-attach \
ksym-vanilla-mxl5007t-attach \
ksym-vanilla-mxl5xx-attach \
ksym-vanilla-n-tty-inherit-ops \
ksym-vanilla-n-tty-ioctl-helper \
ksym-vanilla-nal-h264-read-filler \
ksym-vanilla-nal-h264-read-pps \
ksym-vanilla-nal-h264-read-sps \
ksym-vanilla-nal-h264-write-filler \
ksym-vanilla-nal-h264-write-pps \
ksym-vanilla-nal-h264-write-sps \
ksym-vanilla-nal-hevc-read-filler \
ksym-vanilla-nal-hevc-read-pps \
ksym-vanilla-nal-hevc-read-sps \
ksym-vanilla-nal-hevc-read-vps \
ksym-vanilla-nal-hevc-write-filler \
ksym-vanilla-nal-hevc-write-pps \
ksym-vanilla-nal-hevc-write-sps \
ksym-vanilla-nal-hevc-write-vps \
ksym-vanilla-nand-change-read-column-op \
ksym-vanilla-nand-change-write-column-op \
ksym-vanilla-nand-check-erased-ecc-chunk \
ksym-vanilla-nand-cleanup \
ksym-vanilla-nand-create-bbt \
ksym-vanilla-nand-decode-ext-id \
ksym-vanilla-nand-deselect-target \
ksym-vanilla-nand-ecc-choose-conf \
ksym-vanilla-nand-ecc-cleanup-ctx \
ksym-vanilla-nand-ecc-cleanup-req-tweaking \
ksym-vanilla-nand-ecc-finish-io-req \
ksym-vanilla-nand-ecc-get-on-die-hw-engine \
ksym-vanilla-nand-ecc-get-on-host-hw-engine \
ksym-vanilla-nand-ecc-get-sw-engine \
ksym-vanilla-nand-ecc-init-ctx \
ksym-vanilla-nand-ecc-init-req-tweaking \
ksym-vanilla-nand-ecc-is-strong-enough \
ksym-vanilla-nand-ecc-prepare-io-req \
ksym-vanilla-nand-ecc-put-on-host-hw-engine \
ksym-vanilla-nand-ecc-register-on-host-hw-engine \
ksym-vanilla-nand-ecc-restore-req \
ksym-vanilla-nand-ecc-sw-bch-calculate \
ksym-vanilla-nand-ecc-sw-bch-cleanup-ctx \
ksym-vanilla-nand-ecc-sw-bch-correct \
ksym-vanilla-nand-ecc-sw-bch-get-engine \
ksym-vanilla-nand-ecc-sw-bch-init-ctx \
ksym-vanilla-nand-ecc-sw-hamming-calculate \
ksym-vanilla-nand-ecc-sw-hamming-cleanup-ctx \
ksym-vanilla-nand-ecc-sw-hamming-correct \
ksym-vanilla-nand-ecc-sw-hamming-get-engine \
ksym-vanilla-nand-ecc-sw-hamming-init-ctx \
ksym-vanilla-nand-ecc-tweak-req \
ksym-vanilla-nand-ecc-unregister-on-host-hw-engine \
ksym-vanilla-nand-erase-op \
ksym-vanilla-nand-exit-status-op \
ksym-vanilla-nand-extract-bits \
ksym-vanilla-nand-get-large-page-hamming-ooblayout \
ksym-vanilla-nand-get-large-page-ooblayout \
ksym-vanilla-nand-get-set-features-notsupp \
ksym-vanilla-nand-get-small-page-ooblayout \
ksym-vanilla-nand-gpio-waitrdy \
ksym-vanilla-nand-monolithic-read-page-raw \
ksym-vanilla-nand-monolithic-write-page-raw \
ksym-vanilla-nand-op-parser-exec-op \
ksym-vanilla-nand-prog-page-begin-op \
ksym-vanilla-nand-prog-page-end-op \
ksym-vanilla-nand-prog-page-op \
ksym-vanilla-nand-read-data-op \
ksym-vanilla-nand-read-oob-op \
ksym-vanilla-nand-read-oob-std \
ksym-vanilla-nand-read-page-hwecc-oob-first \
ksym-vanilla-nand-read-page-op \
ksym-vanilla-nand-read-page-raw \
ksym-vanilla-nand-readid-op \
ksym-vanilla-nand-reset \
ksym-vanilla-nand-reset-op \
ksym-vanilla-nand-scan-with-ids \
ksym-vanilla-nand-select-target \
ksym-vanilla-nand-soft-waitrdy \
ksym-vanilla-nand-status-op \
ksym-vanilla-nand-subop-get-addr-start-off \
ksym-vanilla-nand-subop-get-data-len \
ksym-vanilla-nand-subop-get-data-start-off \
ksym-vanilla-nand-subop-get-num-addr-cyc \
ksym-vanilla-nand-wait-ready \
ksym-vanilla-nand-write-data-op \
ksym-vanilla-nand-write-oob-std \
ksym-vanilla-nand-write-page-raw \
ksym-vanilla-nanddev-bbt-cleanup \
ksym-vanilla-nanddev-bbt-get-block-status \
ksym-vanilla-nanddev-bbt-init \
ksym-vanilla-nanddev-bbt-set-block-status \
ksym-vanilla-nanddev-bbt-update \
ksym-vanilla-nanddev-cleanup \
ksym-vanilla-nanddev-ecc-engine-cleanup \
ksym-vanilla-nanddev-ecc-engine-init \
ksym-vanilla-nanddev-init \
ksym-vanilla-nanddev-isbad \
ksym-vanilla-nanddev-isreserved \
ksym-vanilla-nanddev-markbad \
ksym-vanilla-nanddev-mtd-erase \
ksym-vanilla-nanddev-mtd-max-bad-blocks \
ksym-vanilla-napi-alloc-skb \
ksym-vanilla-napi-build-skb \
ksym-vanilla-napi-busy-loop \
ksym-vanilla-napi-complete-done \
ksym-vanilla-napi-consume-skb \
ksym-vanilla-napi-disable \
ksym-vanilla-napi-disable-locked \
ksym-vanilla-napi-enable \
ksym-vanilla-napi-enable-locked \
ksym-vanilla-napi-get-frags \
ksym-vanilla-napi-gro-frags \
ksym-vanilla-napi-pp-put-page \
ksym-vanilla-napi-schedule-prep \
ksym-vanilla-napi-skb-cache-get-bulk \
ksym-vanilla-nau8821-enable-jack-detect \
ksym-vanilla-nau8824-components \
ksym-vanilla-nau8824-enable-jack-detect \
ksym-vanilla-nau8825-enable-jack-detect \
ksym-vanilla-nbcon-can-proceed \
ksym-vanilla-nbcon-device-release \
ksym-vanilla-nbcon-device-try-acquire \
ksym-vanilla-nbcon-enter-unsafe \
ksym-vanilla-nbcon-exit-unsafe \
ksym-vanilla-nbcon-reacquire-nobuf \
ksym-vanilla-nci-allocate-device \
ksym-vanilla-nci-conn-max-data-pkt-payload-size \
ksym-vanilla-nci-core-cmd \
ksym-vanilla-nci-core-conn-close \
ksym-vanilla-nci-core-conn-create \
ksym-vanilla-nci-core-init \
ksym-vanilla-nci-core-reset \
ksym-vanilla-nci-free-device \
ksym-vanilla-nci-get-conn-info-by-dest-type-params \
ksym-vanilla-nci-hci-clear-all-pipes \
ksym-vanilla-nci-hci-connect-gate \
ksym-vanilla-nci-hci-dev-session-init \
ksym-vanilla-nci-hci-get-param \
ksym-vanilla-nci-hci-open-pipe \
ksym-vanilla-nci-hci-send-cmd \
ksym-vanilla-nci-hci-send-event \
ksym-vanilla-nci-hci-set-param \
ksym-vanilla-nci-nfcc-loopback \
ksym-vanilla-nci-nfcee-discover \
ksym-vanilla-nci-nfcee-mode-set \
ksym-vanilla-nci-prop-cmd \
ksym-vanilla-nci-recv-frame \
ksym-vanilla-nci-register-device \
ksym-vanilla-nci-req-complete \
ksym-vanilla-nci-send-cmd \
ksym-vanilla-nci-send-data \
ksym-vanilla-nci-send-frame \
ksym-vanilla-nci-set-config \
ksym-vanilla-nci-to-errno \
ksym-vanilla-nci-uart-register \
ksym-vanilla-nci-uart-set-config \
ksym-vanilla-nci-uart-unregister \
ksym-vanilla-nci-unregister-device \
ksym-vanilla-ncsi-register-dev \
ksym-vanilla-ncsi-start-dev \
ksym-vanilla-ncsi-stop-dev \
ksym-vanilla-ncsi-unregister-dev \
ksym-vanilla-ncsi-vlan-rx-add-vid \
ksym-vanilla-ncsi-vlan-rx-kill-vid \
ksym-vanilla-nct6694-read-msg \
ksym-vanilla-nct6694-write-msg \
ksym-vanilla-nct6775-probe \
ksym-vanilla-nct6775-reg-is-word-sized \
ksym-vanilla-nct6775-show-alarm \
ksym-vanilla-nct6775-show-beep \
ksym-vanilla-nct6775-store-beep \
ksym-vanilla-nct6775-update-device \
ksym-vanilla-nd-btt-arena-is-valid \
ksym-vanilla-nd-btt-probe \
ksym-vanilla-nd-btt-version \
ksym-vanilla-nd-cmd-bus-desc \
ksym-vanilla-nd-cmd-dimm-desc \
ksym-vanilla-nd-cmd-in-size \
ksym-vanilla-nd-cmd-out-size \
ksym-vanilla-nd-dax-probe \
ksym-vanilla-nd-dev-to-uuid \
ksym-vanilla-nd-device-notify \
ksym-vanilla-nd-device-register \
ksym-vanilla-nd-device-unregister \
ksym-vanilla-nd-fletcher64 \
ksym-vanilla-nd-pfn-probe \
ksym-vanilla-nd-pfn-validate \
ksym-vanilla-nd-region-acquire-lane \
ksym-vanilla-nd-region-dev \
ksym-vanilla-nd-region-provider-data \
ksym-vanilla-nd-region-release-lane \
ksym-vanilla-nd-region-to-nstype \
ksym-vanilla-nd-sb-checksum \
ksym-vanilla-nd-synchronize \
ksym-vanilla-nd-tbl \
ksym-vanilla-ndisc-mc-map \
ksym-vanilla-ndisc-ns-create \
ksym-vanilla-ndisc-send-na \
ksym-vanilla-ndisc-send-skb \
ksym-vanilla-ndlc-close \
ksym-vanilla-ndlc-open \
ksym-vanilla-ndlc-probe \
ksym-vanilla-ndlc-recv \
ksym-vanilla-ndlc-remove \
ksym-vanilla-ndlc-send \
ksym-vanilla-ndo-dflt-bridge-getlink \
ksym-vanilla-ndo-dflt-fdb-add \
ksym-vanilla-ndo-dflt-fdb-del \
ksym-vanilla-ndo-dflt-fdb-dump \
ksym-vanilla-nearest-node-nodemask \
ksym-vanilla-neigh-app-ns \
ksym-vanilla-neigh-destroy \
ksym-vanilla-neigh-event-ns \
ksym-vanilla-neigh-for-each \
ksym-vanilla-neigh-lookup \
ksym-vanilla-neigh-parms-alloc \
ksym-vanilla-neigh-parms-release \
ksym-vanilla-neigh-proc-dointvec \
ksym-vanilla-neigh-proc-dointvec-jiffies \
ksym-vanilla-neigh-proc-dointvec-ms-jiffies \
ksym-vanilla-neigh-rand-reach-time \
ksym-vanilla-neigh-resolve-output \
ksym-vanilla-neigh-seq-next \
ksym-vanilla-neigh-seq-start \
ksym-vanilla-neigh-seq-stop \
ksym-vanilla-neigh-sysctl-register \
ksym-vanilla-neigh-sysctl-unregister \
ksym-vanilla-neigh-update \
ksym-vanilla-neigh-xmit \
ksym-vanilla-neon-aes-cbc-cts-decrypt \
ksym-vanilla-neon-aes-cbc-cts-encrypt \
ksym-vanilla-neon-aes-cbc-decrypt \
ksym-vanilla-neon-aes-cbc-encrypt \
ksym-vanilla-neon-aes-ctr-encrypt \
ksym-vanilla-neon-aes-ecb-decrypt \
ksym-vanilla-neon-aes-ecb-encrypt \
ksym-vanilla-neon-aes-essiv-cbc-decrypt \
ksym-vanilla-neon-aes-essiv-cbc-encrypt \
ksym-vanilla-neon-aes-xctr-encrypt \
ksym-vanilla-neon-aes-xts-decrypt \
ksym-vanilla-neon-aes-xts-encrypt \
ksym-vanilla-net-cls-cgrp-subsys-enabled-key \
ksym-vanilla-net-cls-cgrp-subsys-on-dfl-key \
ksym-vanilla-net-dec-egress-queue \
ksym-vanilla-net-dec-ingress-queue \
ksym-vanilla-net-dim \
ksym-vanilla-net-dim-free-irq-moder \
ksym-vanilla-net-dim-get-def-rx-moderation \
ksym-vanilla-net-dim-get-def-tx-moderation \
ksym-vanilla-net-dim-get-rx-irq-moder \
ksym-vanilla-net-dim-get-rx-moderation \
ksym-vanilla-net-dim-get-tx-irq-moder \
ksym-vanilla-net-dim-get-tx-moderation \
ksym-vanilla-net-dim-init-irq-moder \
ksym-vanilla-net-dim-set-rx-mode \
ksym-vanilla-net-dim-set-tx-mode \
ksym-vanilla-net-dim-setting \
ksym-vanilla-net-dim-work-cancel \
ksym-vanilla-net-disable-timestamp \
ksym-vanilla-net-enable-timestamp \
ksym-vanilla-net-failover-create \
ksym-vanilla-net-failover-destroy \
ksym-vanilla-net-hotdata \
ksym-vanilla-net-inc-egress-queue \
ksym-vanilla-net-inc-ingress-queue \
ksym-vanilla-net-namespace-list \
ksym-vanilla-net-ns-barrier \
ksym-vanilla-net-ns-get-ownership \
ksym-vanilla-net-ns-tree \
ksym-vanilla-net-ns-type-operations \
ksym-vanilla-net-ratelimit \
ksym-vanilla-net-rwsem \
ksym-vanilla-net-selftest \
ksym-vanilla-net-selftest-get-count \
ksym-vanilla-net-selftest-get-strings \
ksym-vanilla-net-test-get-skb \
ksym-vanilla-netdev-adjacent-change-abort \
ksym-vanilla-netdev-adjacent-change-commit \
ksym-vanilla-netdev-adjacent-change-prepare \
ksym-vanilla-netdev-adjacent-get-private \
ksym-vanilla-netdev-alert \
ksym-vanilla-netdev-bind-sb-channel-queue \
ksym-vanilla-netdev-bonding-info-change \
ksym-vanilla-netdev-change-features \
ksym-vanilla-netdev-class-create-file-ns \
ksym-vanilla-netdev-class-remove-file-ns \
ksym-vanilla-netdev-cmd-to-name \
ksym-vanilla-netdev-compute-master-upper-features \
ksym-vanilla-netdev-core-stats-inc \
ksym-vanilla-netdev-crit \
ksym-vanilla-netdev-emerg \
ksym-vanilla-netdev-err \
ksym-vanilla-netdev-features-change \
ksym-vanilla-netdev-get-by-index \
ksym-vanilla-netdev-get-by-name \
ksym-vanilla-netdev-get-xmit-slave \
ksym-vanilla-netdev-has-any-upper-dev \
ksym-vanilla-netdev-has-upper-dev \
ksym-vanilla-netdev-has-upper-dev-all-rcu \
ksym-vanilla-netdev-increment-features \
ksym-vanilla-netdev-info \
ksym-vanilla-netdev-is-rx-handler-busy \
ksym-vanilla-netdev-lower-dev-get-private \
ksym-vanilla-netdev-lower-get-first-private-rcu \
ksym-vanilla-netdev-lower-get-next \
ksym-vanilla-netdev-lower-get-next-private \
ksym-vanilla-netdev-lower-get-next-private-rcu \
ksym-vanilla-netdev-lower-state-changed \
ksym-vanilla-netdev-master-upper-dev-get \
ksym-vanilla-netdev-master-upper-dev-get-rcu \
ksym-vanilla-netdev-master-upper-dev-link \
ksym-vanilla-netdev-name-in-use \
ksym-vanilla-netdev-next-lower-dev-rcu \
ksym-vanilla-netdev-notice \
ksym-vanilla-netdev-notify-peers \
ksym-vanilla-netdev-offload-xstats-disable \
ksym-vanilla-netdev-offload-xstats-enable \
ksym-vanilla-netdev-offload-xstats-enabled \
ksym-vanilla-netdev-offload-xstats-get \
ksym-vanilla-netdev-offload-xstats-push-delta \
ksym-vanilla-netdev-offload-xstats-report-delta \
ksym-vanilla-netdev-offload-xstats-report-used \
ksym-vanilla-netdev-pick-tx \
ksym-vanilla-netdev-port-same-parent-id \
ksym-vanilla-netdev-printk \
ksym-vanilla-netdev-queue-config \
ksym-vanilla-netdev-refcnt-read \
ksym-vanilla-netdev-reset-tc \
ksym-vanilla-netdev-rss-key-fill \
ksym-vanilla-netdev-rx-csum-fault \
ksym-vanilla-netdev-rx-handler-register \
ksym-vanilla-netdev-rx-handler-unregister \
ksym-vanilla-netdev-rx-queue-restart \
ksym-vanilla-netdev-set-default-ethtool-ops \
ksym-vanilla-netdev-set-num-tc \
ksym-vanilla-netdev-set-sb-channel \
ksym-vanilla-netdev-set-tc-queue \
ksym-vanilla-netdev-sk-get-lowest-dev \
ksym-vanilla-netdev-stat-queue-sum \
ksym-vanilla-netdev-state-change \
ksym-vanilla-netdev-stats-to-stats64 \
ksym-vanilla-netdev-sw-irq-coalesce-default-on \
ksym-vanilla-netdev-txq-to-tc \
ksym-vanilla-netdev-unbind-sb-channel \
ksym-vanilla-netdev-update-features \
ksym-vanilla-netdev-upper-dev-link \
ksym-vanilla-netdev-upper-dev-unlink \
ksym-vanilla-netdev-upper-get-next-dev-rcu \
ksym-vanilla-netdev-walk-all-lower-dev \
ksym-vanilla-netdev-walk-all-lower-dev-rcu \
ksym-vanilla-netdev-walk-all-upper-dev-rcu \
ksym-vanilla-netdev-warn \
ksym-vanilla-netdev-watchdog-up \
ksym-vanilla-netdev-work-cancel \
ksym-vanilla-netdev-work-sched \
ksym-vanilla-netdev-xmit-skip-txqueue \
ksym-vanilla-netfs-alloc-folioq-buffer \
ksym-vanilla-netfs-buffered-read-iter \
ksym-vanilla-netfs-buffered-write-iter-locked \
ksym-vanilla-netfs-clear-inode-writeback \
ksym-vanilla-netfs-dirty-folio \
ksym-vanilla-netfs-end-io-direct \
ksym-vanilla-netfs-end-io-read \
ksym-vanilla-netfs-end-io-write \
ksym-vanilla-netfs-extract-user-iter \
ksym-vanilla-netfs-file-read-iter \
ksym-vanilla-netfs-file-write-iter \
ksym-vanilla-netfs-folioq-alloc \
ksym-vanilla-netfs-folioq-free \
ksym-vanilla-netfs-free-folioq-buffer \
ksym-vanilla-netfs-invalidate-folio \
ksym-vanilla-netfs-limit-iter \
ksym-vanilla-netfs-page-mkwrite \
ksym-vanilla-netfs-perform-write \
ksym-vanilla-netfs-prepare-write-failed \
ksym-vanilla-netfs-read-folio \
ksym-vanilla-netfs-read-single \
ksym-vanilla-netfs-read-subreq-progress \
ksym-vanilla-netfs-read-subreq-terminated \
ksym-vanilla-netfs-readahead \
ksym-vanilla-netfs-release-folio \
ksym-vanilla-netfs-single-mark-inode-dirty \
ksym-vanilla-netfs-start-io-direct \
ksym-vanilla-netfs-start-io-read \
ksym-vanilla-netfs-start-io-write \
ksym-vanilla-netfs-stats-show \
ksym-vanilla-netfs-unbuffered-read-iter \
ksym-vanilla-netfs-unbuffered-read-iter-locked \
ksym-vanilla-netfs-unbuffered-write-iter \
ksym-vanilla-netfs-unbuffered-write-iter-locked \
ksym-vanilla-netfs-unpin-writeback \
ksym-vanilla-netfs-wb-begin \
ksym-vanilla-netfs-wb-end \
ksym-vanilla-netfs-write-begin \
ksym-vanilla-netfs-write-subrequest-terminated \
ksym-vanilla-netfs-writeback-single \
ksym-vanilla-netfs-writepages \
ksym-vanilla-netif-carrier-event \
ksym-vanilla-netif-carrier-off \
ksym-vanilla-netif-carrier-on \
ksym-vanilla-netif-change-flags \
ksym-vanilla-netif-close \
ksym-vanilla-netif-close-many \
ksym-vanilla-netif-device-attach \
ksym-vanilla-netif-device-detach \
ksym-vanilla-netif-enable-cpu-rmap \
ksym-vanilla-netif-get-flags \
ksym-vanilla-netif-get-link-ksettings \
ksym-vanilla-netif-get-mac-address \
ksym-vanilla-netif-get-num-default-rss-queues \
ksym-vanilla-netif-get-port-parent-id \
ksym-vanilla-netif-inherit-tso-max \
ksym-vanilla-netif-is-rxfh-configured \
ksym-vanilla-netif-napi-add-weight-locked \
ksym-vanilla-netif-napi-set-irq-locked \
ksym-vanilla-netif-open \
ksym-vanilla-netif-pre-changeaddr-notify \
ksym-vanilla-netif-queue-set-napi \
ksym-vanilla-netif-receive-skb \
ksym-vanilla-netif-receive-skb-core \
ksym-vanilla-netif-receive-skb-list \
ksym-vanilla-netif-rx \
ksym-vanilla-netif-rx-mode-schedule-retry \
ksym-vanilla-netif-rxq-has-unreadable-mp \
ksym-vanilla-netif-schedule-queue \
ksym-vanilla-netif-set-affinity-auto \
ksym-vanilla-netif-set-mtu \
ksym-vanilla-netif-set-operstate \
ksym-vanilla-netif-set-real-num-queues \
ksym-vanilla-netif-set-real-num-rx-queues \
ksym-vanilla-netif-set-real-num-tx-queues \
ksym-vanilla-netif-set-tso-max-segs \
ksym-vanilla-netif-set-tso-max-size \
ksym-vanilla-netif-set-xps-queue \
ksym-vanilla-netif-skb-features \
ksym-vanilla-netif-stacked-transfer-operstate \
ksym-vanilla-netif-threaded-enable \
ksym-vanilla-netif-tx-lock \
ksym-vanilla-netif-tx-stop-all-queues \
ksym-vanilla-netif-tx-unlock \
ksym-vanilla-netif-tx-wake-queue \
ksym-vanilla-netif-xdp-propagate \
ksym-vanilla-netlbl-audit-start \
ksym-vanilla-netlbl-bitmap-setbit \
ksym-vanilla-netlbl-bitmap-walk \
ksym-vanilla-netlbl-calipso-ops-register \
ksym-vanilla-netlbl-catmap-setbit \
ksym-vanilla-netlbl-catmap-walk \
ksym-vanilla-netlink-ack \
ksym-vanilla-netlink-add-tap \
ksym-vanilla-netlink-broadcast \
ksym-vanilla-netlink-broadcast-filtered \
ksym-vanilla-netlink-capable \
ksym-vanilla-netlink-has-listeners \
ksym-vanilla-netlink-kernel-release \
ksym-vanilla-netlink-net-capable \
ksym-vanilla-netlink-ns-capable \
ksym-vanilla-netlink-rcv-skb \
ksym-vanilla-netlink-register-notifier \
ksym-vanilla-netlink-remove-tap \
ksym-vanilla-netlink-set-err \
ksym-vanilla-netlink-strict-get-check \
ksym-vanilla-netlink-unicast \
ksym-vanilla-netlink-unregister-notifier \
ksym-vanilla-netpoll-cleanup \
ksym-vanilla-netpoll-poll-dev \
ksym-vanilla-netpoll-send-skb \
ksym-vanilla-netpoll-setup \
ksym-vanilla-netpoll-zap-completion-queue \
ksym-vanilla-netstamp-needed-key \
ksym-vanilla-new-inode \
ksym-vanilla-next-arg \
ksym-vanilla-nexthop-bucket-set-hw-flags \
ksym-vanilla-nexthop-find-by-id \
ksym-vanilla-nexthop-for-each-fib6-nh \
ksym-vanilla-nexthop-free-rcu \
ksym-vanilla-nexthop-res-grp-activity-update \
ksym-vanilla-nexthop-select-path \
ksym-vanilla-nexthop-set-hw-flags \
ksym-vanilla-nf-br-ops \
ksym-vanilla-nf-checksum \
ksym-vanilla-nf-checksum-partial \
ksym-vanilla-nf-confirm \
ksym-vanilla-nf-conn-btf-access-lock \
ksym-vanilla-nf-conn-pernet-ecache \
ksym-vanilla-nf-conncount-add-skb \
ksym-vanilla-nf-conncount-cache-free \
ksym-vanilla-nf-conncount-count-skb \
ksym-vanilla-nf-conncount-destroy \
ksym-vanilla-nf-conncount-gc-list \
ksym-vanilla-nf-conncount-init \
ksym-vanilla-nf-conncount-list-init \
ksym-vanilla-nf-connlabels-get \
ksym-vanilla-nf-connlabels-put \
ksym-vanilla-nf-connlabels-replace \
ksym-vanilla-nf-conntrack-alloc \
ksym-vanilla-nf-conntrack-broadcast-help \
ksym-vanilla-nf-conntrack-count \
ksym-vanilla-nf-conntrack-destroy \
ksym-vanilla-nf-conntrack-eventmask-report \
ksym-vanilla-nf-conntrack-expect-lock \
ksym-vanilla-nf-conntrack-find-get \
ksym-vanilla-nf-conntrack-free \
ksym-vanilla-nf-conntrack-hash \
ksym-vanilla-nf-conntrack-hash-check-insert \
ksym-vanilla-nf-conntrack-helper-put \
ksym-vanilla-nf-conntrack-helper-register \
ksym-vanilla-nf-conntrack-helper-try-module-get \
ksym-vanilla-nf-conntrack-helper-unregister \
ksym-vanilla-nf-conntrack-helpers-register \
ksym-vanilla-nf-conntrack-helpers-unregister \
ksym-vanilla-nf-conntrack-htable-size \
ksym-vanilla-nf-conntrack-in \
ksym-vanilla-nf-conntrack-lock \
ksym-vanilla-nf-conntrack-locks \
ksym-vanilla-nf-conntrack-max \
ksym-vanilla-nf-conntrack-register-notifier \
ksym-vanilla-nf-conntrack-tuple-taken \
ksym-vanilla-nf-conntrack-unregister-notifier \
ksym-vanilla-nf-ct-acct-add \
ksym-vanilla-nf-ct-add-helper \
ksym-vanilla-nf-ct-alloc-hashtable \
ksym-vanilla-nf-ct-attach \
ksym-vanilla-nf-ct-bridge-register \
ksym-vanilla-nf-ct-bridge-unregister \
ksym-vanilla-nf-ct-change-status-common \
ksym-vanilla-nf-ct-delete \
ksym-vanilla-nf-ct-deliver-cached-events \
ksym-vanilla-nf-ct-destroy \
ksym-vanilla-nf-ct-destroy-timeout \
ksym-vanilla-nf-ct-ecache-ext-add \
ksym-vanilla-nf-ct-expect-alloc \
ksym-vanilla-nf-ct-expect-find-get \
ksym-vanilla-nf-ct-expect-hash \
ksym-vanilla-nf-ct-expect-hsize \
ksym-vanilla-nf-ct-expect-init \
ksym-vanilla-nf-ct-expect-iterate-destroy \
ksym-vanilla-nf-ct-expect-iterate-net \
ksym-vanilla-nf-ct-expect-put \
ksym-vanilla-nf-ct-expect-related-pair \
ksym-vanilla-nf-ct-expect-related-report \
ksym-vanilla-nf-ct-ext-add \
ksym-vanilla-nf-ct-frag6-gather \
ksym-vanilla-nf-ct-get-id \
ksym-vanilla-nf-ct-get-tuple-skb \
ksym-vanilla-nf-ct-get-tuplepr \
ksym-vanilla-nf-ct-gre-keymap-add \
ksym-vanilla-nf-ct-gre-keymap-destroy \
ksym-vanilla-nf-ct-handle-fragments \
ksym-vanilla-nf-ct-helper \
ksym-vanilla-nf-ct-helper-expectfn-destroy \
ksym-vanilla-nf-ct-helper-expectfn-find-by-name \
ksym-vanilla-nf-ct-helper-expectfn-find-by-symbol \
ksym-vanilla-nf-ct-helper-expectfn-register \
ksym-vanilla-nf-ct-helper-expectfn-unregister \
ksym-vanilla-nf-ct-helper-ext-add \
ksym-vanilla-nf-ct-helper-hash \
ksym-vanilla-nf-ct-helper-hsize \
ksym-vanilla-nf-ct-helper-init \
ksym-vanilla-nf-ct-helper-log \
ksym-vanilla-nf-ct-hook \
ksym-vanilla-nf-ct-invert-tuple \
ksym-vanilla-nf-ct-iterate-cleanup-net \
ksym-vanilla-nf-ct-iterate-destroy \
ksym-vanilla-nf-ct-kill-acct \
ksym-vanilla-nf-ct-l4proto-find \
ksym-vanilla-nf-ct-l4proto-log-invalid \
ksym-vanilla-nf-ct-nat \
ksym-vanilla-nf-ct-nat-ext-add \
ksym-vanilla-nf-ct-netns-get \
ksym-vanilla-nf-ct-netns-put \
ksym-vanilla-nf-ct-port-nla-policy \
ksym-vanilla-nf-ct-port-nlattr-to-tuple \
ksym-vanilla-nf-ct-port-nlattr-tuple-size \
ksym-vanilla-nf-ct-port-tuple-to-nlattr \
ksym-vanilla-nf-ct-remove-expectations \
ksym-vanilla-nf-ct-seq-adjust \
ksym-vanilla-nf-ct-seq-offset \
ksym-vanilla-nf-ct-seqadj-init \
ksym-vanilla-nf-ct-seqadj-set \
ksym-vanilla-nf-ct-set-closing \
ksym-vanilla-nf-ct-set-timeout \
ksym-vanilla-nf-ct-skb-network-trim \
ksym-vanilla-nf-ct-tcp-seqadj-set \
ksym-vanilla-nf-ct-timeout-hook \
ksym-vanilla-nf-ct-tmpl-alloc \
ksym-vanilla-nf-ct-tmpl-free \
ksym-vanilla-nf-ct-unexpect-related \
ksym-vanilla-nf-ct-unlink-expect-report \
ksym-vanilla-nf-ct-untimeout \
ksym-vanilla-nf-ct-zone-dflt \
ksym-vanilla-nf-ctnetlink-has-listener \
ksym-vanilla-nf-defrag-ipv4-disable \
ksym-vanilla-nf-defrag-ipv4-enable \
ksym-vanilla-nf-defrag-ipv6-disable \
ksym-vanilla-nf-defrag-ipv6-enable \
ksym-vanilla-nf-defrag-v4-hook \
ksym-vanilla-nf-defrag-v6-hook \
ksym-vanilla-nf-dup-ipv4 \
ksym-vanilla-nf-dup-ipv6 \
ksym-vanilla-nf-dup-netdev-egress \
ksym-vanilla-nf-flow-dnat-port \
ksym-vanilla-nf-flow-offload-ip-hook \
ksym-vanilla-nf-flow-offload-ipv6-hook \
ksym-vanilla-nf-flow-register-bpf \
ksym-vanilla-nf-flow-rule-route-ipv4 \
ksym-vanilla-nf-flow-rule-route-ipv6 \
ksym-vanilla-nf-flow-snat-port \
ksym-vanilla-nf-flow-table-cleanup \
ksym-vanilla-nf-flow-table-free \
ksym-vanilla-nf-flow-table-init \
ksym-vanilla-nf-flow-table-offload-setup \
ksym-vanilla-nf-fwd-netdev-egress \
ksym-vanilla-nf-getsockopt \
ksym-vanilla-nf-hook-entries-delete-raw \
ksym-vanilla-nf-hook-entries-insert-raw \
ksym-vanilla-nf-hook-slow \
ksym-vanilla-nf-hook-slow-list \
ksym-vanilla-nf-hooks-lwtunnel-enabled \
ksym-vanilla-nf-hooks-lwtunnel-sysctl-handler \
ksym-vanilla-nf-hooks-needed \
ksym-vanilla-nf-ip-checksum \
ksym-vanilla-nf-ip-route \
ksym-vanilla-nf-ip6-check-hbh-len \
ksym-vanilla-nf-ip6-checksum \
ksym-vanilla-nf-l4proto-log-invalid \
ksym-vanilla-nf-log-bind-pf \
ksym-vanilla-nf-log-buf-add \
ksym-vanilla-nf-log-buf-close \
ksym-vanilla-nf-log-buf-open \
ksym-vanilla-nf-log-is-registered \
ksym-vanilla-nf-log-packet \
ksym-vanilla-nf-log-register \
ksym-vanilla-nf-log-set \
ksym-vanilla-nf-log-trace \
ksym-vanilla-nf-log-unbind-pf \
ksym-vanilla-nf-log-unregister \
ksym-vanilla-nf-log-unset \
ksym-vanilla-nf-logger-find-get \
ksym-vanilla-nf-logger-put \
ksym-vanilla-nf-nat-alloc-null-binding \
ksym-vanilla-nf-nat-amanda-hook \
ksym-vanilla-nf-nat-exp-find-port \
ksym-vanilla-nf-nat-follow-master \
ksym-vanilla-nf-nat-ftp-hook \
ksym-vanilla-nf-nat-helper-put \
ksym-vanilla-nf-nat-helper-register \
ksym-vanilla-nf-nat-helper-try-module-get \
ksym-vanilla-nf-nat-helper-unregister \
ksym-vanilla-nf-nat-hook \
ksym-vanilla-nf-nat-icmp-reply-translation \
ksym-vanilla-nf-nat-icmpv6-reply-translation \
ksym-vanilla-nf-nat-inet-fn \
ksym-vanilla-nf-nat-inet-register-fn \
ksym-vanilla-nf-nat-inet-unregister-fn \
ksym-vanilla-nf-nat-ipv4-register-fn \
ksym-vanilla-nf-nat-ipv4-unregister-fn \
ksym-vanilla-nf-nat-ipv6-register-fn \
ksym-vanilla-nf-nat-ipv6-unregister-fn \
ksym-vanilla-nf-nat-irc-hook \
ksym-vanilla-nf-nat-mangle-udp-packet \
ksym-vanilla-nf-nat-masquerade-inet-register-notifiers \
ksym-vanilla-nf-nat-masquerade-inet-unregister-notifiers \
ksym-vanilla-nf-nat-masquerade-ipv4 \
ksym-vanilla-nf-nat-masquerade-ipv6 \
ksym-vanilla-nf-nat-packet \
ksym-vanilla-nf-nat-pptp-hook \
ksym-vanilla-nf-nat-redirect-ipv4 \
ksym-vanilla-nf-nat-redirect-ipv6 \
ksym-vanilla-nf-nat-setup-info \
ksym-vanilla-nf-nat-sip-hooks \
ksym-vanilla-nf-nat-snmp-hook \
ksym-vanilla-nf-nat-tftp-hook \
ksym-vanilla-nf-osf-find \
ksym-vanilla-nf-osf-fingers \
ksym-vanilla-nf-osf-match \
ksym-vanilla-nf-queue \
ksym-vanilla-nf-queue-entry-free \
ksym-vanilla-nf-queue-entry-get-refs \
ksym-vanilla-nf-queue-nf-hook-drop \
ksym-vanilla-nf-register-net-hook \
ksym-vanilla-nf-register-net-hooks \
ksym-vanilla-nf-register-queue-handler \
ksym-vanilla-nf-register-sockopt \
ksym-vanilla-nf-reject-skb-v4-tcp-reset \
ksym-vanilla-nf-reject-skb-v4-unreach \
ksym-vanilla-nf-reject-skb-v6-tcp-reset \
ksym-vanilla-nf-reject-skb-v6-unreach \
ksym-vanilla-nf-route \
ksym-vanilla-nf-send-reset \
ksym-vanilla-nf-send-reset6 \
ksym-vanilla-nf-send-unreach \
ksym-vanilla-nf-send-unreach6 \
ksym-vanilla-nf-setsockopt \
ksym-vanilla-nf-sk-lookup-slow-v4 \
ksym-vanilla-nf-sk-lookup-slow-v6 \
ksym-vanilla-nf-synproxy-ipv4-fini \
ksym-vanilla-nf-synproxy-ipv4-init \
ksym-vanilla-nf-synproxy-ipv6-fini \
ksym-vanilla-nf-synproxy-ipv6-init \
ksym-vanilla-nf-tables-deactivate-flowtable \
ksym-vanilla-nf-tables-trans-destroy-flush-work \
ksym-vanilla-nf-tproxy-get-sock-v4 \
ksym-vanilla-nf-tproxy-get-sock-v6 \
ksym-vanilla-nf-tproxy-handle-time-wait4 \
ksym-vanilla-nf-tproxy-handle-time-wait6 \
ksym-vanilla-nf-tproxy-laddr4 \
ksym-vanilla-nf-tproxy-laddr6 \
ksym-vanilla-nf-unregister-net-hook \
ksym-vanilla-nf-unregister-net-hooks \
ksym-vanilla-nf-unregister-queue-handler \
ksym-vanilla-nf-unregister-sockopt \
ksym-vanilla-nfc-add-se \
ksym-vanilla-nfc-alloc-recv-skb \
ksym-vanilla-nfc-allocate-device \
ksym-vanilla-nfc-class \
ksym-vanilla-nfc-dep-link-is-up \
ksym-vanilla-nfc-digital-allocate-device \
ksym-vanilla-nfc-digital-free-device \
ksym-vanilla-nfc-digital-register-device \
ksym-vanilla-nfc-digital-unregister-device \
ksym-vanilla-nfc-driver-failure \
ksym-vanilla-nfc-find-se \
ksym-vanilla-nfc-fw-download-done \
ksym-vanilla-nfc-get-local-general-bytes \
ksym-vanilla-nfc-hci-allocate-device \
ksym-vanilla-nfc-hci-connect-gate \
ksym-vanilla-nfc-hci-disconnect-all-gates \
ksym-vanilla-nfc-hci-disconnect-gate \
ksym-vanilla-nfc-hci-driver-failure \
ksym-vanilla-nfc-hci-free-device \
ksym-vanilla-nfc-hci-get-clientdata \
ksym-vanilla-nfc-hci-get-param \
ksym-vanilla-nfc-hci-recv-frame \
ksym-vanilla-nfc-hci-register-device \
ksym-vanilla-nfc-hci-reset-pipes \
ksym-vanilla-nfc-hci-reset-pipes-per-host \
ksym-vanilla-nfc-hci-result-to-errno \
ksym-vanilla-nfc-hci-sak-to-protocol \
ksym-vanilla-nfc-hci-send-cmd \
ksym-vanilla-nfc-hci-send-cmd-async \
ksym-vanilla-nfc-hci-send-event \
ksym-vanilla-nfc-hci-set-clientdata \
ksym-vanilla-nfc-hci-set-param \
ksym-vanilla-nfc-hci-target-discovered \
ksym-vanilla-nfc-hci-unregister-device \
ksym-vanilla-nfc-llc-start \
ksym-vanilla-nfc-llc-stop \
ksym-vanilla-nfc-proto-register \
ksym-vanilla-nfc-proto-unregister \
ksym-vanilla-nfc-register-device \
ksym-vanilla-nfc-remove-device \
ksym-vanilla-nfc-remove-se \
ksym-vanilla-nfc-se-connectivity \
ksym-vanilla-nfc-se-transaction \
ksym-vanilla-nfc-send-to-raw-sock \
ksym-vanilla-nfc-set-remote-general-bytes \
ksym-vanilla-nfc-target-lost \
ksym-vanilla-nfc-targets-found \
ksym-vanilla-nfc-tm-activated \
ksym-vanilla-nfc-tm-data-received \
ksym-vanilla-nfc-tm-deactivated \
ksym-vanilla-nfc-unregister-device \
ksym-vanilla-nfc-unregister-rfkill \
ksym-vanilla-nfc-vendor-cmd-reply \
ksym-vanilla-nfcmrvl-nci-recv-frame \
ksym-vanilla-nfcmrvl-nci-register-dev \
ksym-vanilla-nfcmrvl-nci-unregister-dev \
ksym-vanilla-nfcmrvl-parse-dt \
ksym-vanilla-nfct-btf-struct-access \
ksym-vanilla-nfct-h323-nat-hook \
ksym-vanilla-nfit-get-smbios-id \
ksym-vanilla-nfnetlink-broadcast \
ksym-vanilla-nfnetlink-has-listeners \
ksym-vanilla-nfnetlink-send \
ksym-vanilla-nfnetlink-set-err \
ksym-vanilla-nfnetlink-subsys-register \
ksym-vanilla-nfnetlink-subsys-unregister \
ksym-vanilla-nfnetlink-unicast \
ksym-vanilla-nfnl-acct-find-get \
ksym-vanilla-nfnl-acct-overquota \
ksym-vanilla-nfnl-acct-put \
ksym-vanilla-nfnl-acct-update \
ksym-vanilla-nfnl-ct-hook \
ksym-vanilla-nfnl-lock \
ksym-vanilla-nfnl-unlock \
ksym-vanilla-nfs-access-add-cache \
ksym-vanilla-nfs-access-get-cached \
ksym-vanilla-nfs-access-set-mask \
ksym-vanilla-nfs-access-zap-cache \
ksym-vanilla-nfs-add-or-obtain \
ksym-vanilla-nfs-alloc-client \
ksym-vanilla-nfs-alloc-fattr \
ksym-vanilla-nfs-alloc-fattr-with-label \
ksym-vanilla-nfs-alloc-fhandle \
ksym-vanilla-nfs-alloc-inode \
ksym-vanilla-nfs-alloc-server \
ksym-vanilla-nfs-async-iocounter-wait \
ksym-vanilla-nfs-atomic-open \
ksym-vanilla-nfs-atomic-open-v23 \
ksym-vanilla-nfs-auth-info-match \
ksym-vanilla-nfs-callback-nr-threads \
ksym-vanilla-nfs-callback-set-tcpport \
ksym-vanilla-nfs-check-cache-invalid \
ksym-vanilla-nfs-check-flags \
ksym-vanilla-nfs-clear-inode \
ksym-vanilla-nfs-clear-verifier-delegated \
ksym-vanilla-nfs-client-for-each-server \
ksym-vanilla-nfs-client-init-is-complete \
ksym-vanilla-nfs-client-init-status \
ksym-vanilla-nfs-clone-server \
ksym-vanilla-nfs-close-context \
ksym-vanilla-nfs-commit-free \
ksym-vanilla-nfs-commit-inode \
ksym-vanilla-nfs-commitdata-alloc \
ksym-vanilla-nfs-commitdata-release \
ksym-vanilla-nfs-create \
ksym-vanilla-nfs-create-rpc-client \
ksym-vanilla-nfs-create-server \
ksym-vanilla-nfs-d-prune-case-insensitive-aliases \
ksym-vanilla-nfs-debug \
ksym-vanilla-nfs-delay-retrans \
ksym-vanilla-nfs-dentry-operations \
ksym-vanilla-nfs-do-submount \
ksym-vanilla-nfs-dreq-bytes-left \
ksym-vanilla-nfs-drop-inode \
ksym-vanilla-nfs-end-io-write \
ksym-vanilla-nfs-fattr-init \
ksym-vanilla-nfs-fhget \
ksym-vanilla-nfs-file-fsync \
ksym-vanilla-nfs-file-llseek \
ksym-vanilla-nfs-file-mmap-prepare \
ksym-vanilla-nfs-file-operations \
ksym-vanilla-nfs-file-read \
ksym-vanilla-nfs-file-release \
ksym-vanilla-nfs-file-set-open-context \
ksym-vanilla-nfs-file-splice-read \
ksym-vanilla-nfs-file-write \
ksym-vanilla-nfs-fileattr-get \
ksym-vanilla-nfs-filemap-write-and-wait-range \
ksym-vanilla-nfs-flock \
ksym-vanilla-nfs-force-lookup-revalidate \
ksym-vanilla-nfs-free-client \
ksym-vanilla-nfs-free-inode \
ksym-vanilla-nfs-free-server \
ksym-vanilla-nfs-fs-type \
ksym-vanilla-nfs-fscache-open-file \
ksym-vanilla-nfs-generic-pg-test \
ksym-vanilla-nfs-generic-pgio \
ksym-vanilla-nfs-get-client \
ksym-vanilla-nfs-get-lock-context \
ksym-vanilla-nfs-getattr \
ksym-vanilla-nfs-idmap-cache-timeout \
ksym-vanilla-nfs-inc-attr-generation-counter \
ksym-vanilla-nfs-init-cinfo \
ksym-vanilla-nfs-init-client \
ksym-vanilla-nfs-init-commit \
ksym-vanilla-nfs-init-server-rpcclient \
ksym-vanilla-nfs-init-timeout-values \
ksym-vanilla-nfs-initiate-commit \
ksym-vanilla-nfs-initiate-pgio \
ksym-vanilla-nfs-inode-attach-open-context \
ksym-vanilla-nfs-instantiate \
ksym-vanilla-nfs-invalidate-atime \
ksym-vanilla-nfs-kill-super \
ksym-vanilla-nfs-link \
ksym-vanilla-nfs-localio-errno-to-nfs4-stat \
ksym-vanilla-nfs-lock \
ksym-vanilla-nfs-lookup \
ksym-vanilla-nfs-map-string-to-numeric \
ksym-vanilla-nfs-mark-client-ready \
ksym-vanilla-nfs-may-open \
ksym-vanilla-nfs-mkdir \
ksym-vanilla-nfs-mknod \
ksym-vanilla-nfs-net-id \
ksym-vanilla-nfs-pageio-init-read \
ksym-vanilla-nfs-pageio-init-write \
ksym-vanilla-nfs-pageio-resend \
ksym-vanilla-nfs-pageio-reset-read-mds \
ksym-vanilla-nfs-pageio-reset-write-mds \
ksym-vanilla-nfs-path \
ksym-vanilla-nfs-permission \
ksym-vanilla-nfs-pgheader-init \
ksym-vanilla-nfs-pgio-current-mirror \
ksym-vanilla-nfs-pgio-header-alloc \
ksym-vanilla-nfs-pgio-header-free \
ksym-vanilla-nfs-post-op-update-inode \
ksym-vanilla-nfs-post-op-update-inode-force-wcc \
ksym-vanilla-nfs-probe-server \
ksym-vanilla-nfs-put-client \
ksym-vanilla-nfs-put-lock-context \
ksym-vanilla-nfs-read-alloc-scratch \
ksym-vanilla-nfs-reconfigure \
ksym-vanilla-nfs-refresh-inode \
ksym-vanilla-nfs-release-request \
ksym-vanilla-nfs-remove-bad-delegation \
ksym-vanilla-nfs-rename \
ksym-vanilla-nfs-request-add-commit-list \
ksym-vanilla-nfs-request-add-commit-list-locked \
ksym-vanilla-nfs-request-remove-commit-list \
ksym-vanilla-nfs-retry-commit \
ksym-vanilla-nfs-revalidate-inode \
ksym-vanilla-nfs-rmdir \
ksym-vanilla-nfs-sb-active \
ksym-vanilla-nfs-sb-deactive \
ksym-vanilla-nfs-scan-commit-list \
ksym-vanilla-nfs-server-copy-userdata \
ksym-vanilla-nfs-server-insert-lists \
ksym-vanilla-nfs-server-remove-lists \
ksym-vanilla-nfs-server-set-init-caps \
ksym-vanilla-nfs-set-cache-invalid \
ksym-vanilla-nfs-set-verifier \
ksym-vanilla-nfs-setattr \
ksym-vanilla-nfs-setattr-update-inode \
ksym-vanilla-nfs-setsecurity \
ksym-vanilla-nfs-show-devname \
ksym-vanilla-nfs-show-options \
ksym-vanilla-nfs-show-path \
ksym-vanilla-nfs-show-stats \
ksym-vanilla-nfs-sops \
ksym-vanilla-nfs-ssc-client-tbl \
ksym-vanilla-nfs-ssc-register \
ksym-vanilla-nfs-ssc-unregister \
ksym-vanilla-nfs-start-io-write \
ksym-vanilla-nfs-stat-to-errno \
ksym-vanilla-nfs-statfs \
ksym-vanilla-nfs-stream-decode-acl \
ksym-vanilla-nfs-stream-encode-acl \
ksym-vanilla-nfs-submount \
ksym-vanilla-nfs-symlink \
ksym-vanilla-nfs-sync-inode \
ksym-vanilla-nfs-sysfs-add-server \
ksym-vanilla-nfs-sysfs-link-rpc-client \
ksym-vanilla-nfs-truncate-last-folio \
ksym-vanilla-nfs-try-get-tree \
ksym-vanilla-nfs-umount-begin \
ksym-vanilla-nfs-unlink \
ksym-vanilla-nfs-update-delegated-mtime \
ksym-vanilla-nfs-wait-bit-killable \
ksym-vanilla-nfs-wait-client-init-complete \
ksym-vanilla-nfs-wb-all \
ksym-vanilla-nfs-write-inode \
ksym-vanilla-nfs-writeback-update-inode \
ksym-vanilla-nfs-zap-acl-cache \
ksym-vanilla-nfs3-set-ds-client \
ksym-vanilla-nfs4-client-id-uniquifier \
ksym-vanilla-nfs4-decode-mp-ds-addr \
ksym-vanilla-nfs4-delete-deviceid \
ksym-vanilla-nfs4-dentry-operations \
ksym-vanilla-nfs4-disable-idmapping \
ksym-vanilla-nfs4-find-get-deviceid \
ksym-vanilla-nfs4-find-or-create-ds-client \
ksym-vanilla-nfs4-fs-type \
ksym-vanilla-nfs4-init-deviceid-node \
ksym-vanilla-nfs4-init-ds-session \
ksym-vanilla-nfs4-label-alloc \
ksym-vanilla-nfs4-mark-deviceid-available \
ksym-vanilla-nfs4-mark-deviceid-unavailable \
ksym-vanilla-nfs4-pnfs-ds-add \
ksym-vanilla-nfs4-pnfs-ds-connect \
ksym-vanilla-nfs4-pnfs-ds-put \
ksym-vanilla-nfs4-print-deviceid \
ksym-vanilla-nfs4-proc-getdeviceinfo \
ksym-vanilla-nfs4-put-deviceid-node \
ksym-vanilla-nfs4-schedule-lease-moved-recovery \
ksym-vanilla-nfs4-schedule-lease-recovery \
ksym-vanilla-nfs4-schedule-migration-recovery \
ksym-vanilla-nfs4-schedule-session-recovery \
ksym-vanilla-nfs4-schedule-stateid-recovery \
ksym-vanilla-nfs4-sequence-done \
ksym-vanilla-nfs4-set-ds-client \
ksym-vanilla-nfs4-set-rw-stateid \
ksym-vanilla-nfs4-setup-sequence \
ksym-vanilla-nfs4-stat-to-errno \
ksym-vanilla-nfs4-test-deviceid-unavailable \
ksym-vanilla-nfs4-test-session-trunk \
ksym-vanilla-nfs41-maxgetdevinfo-overhead \
ksym-vanilla-nfs41-sequence-done \
ksym-vanilla-nfs42-proc-layouterror \
ksym-vanilla-nfs42-ssc-register \
ksym-vanilla-nfs42-ssc-unregister \
ksym-vanilla-nfsacl-decode \
ksym-vanilla-nfsacl-encode \
ksym-vanilla-nfsd-debug \
ksym-vanilla-nfsiod-workqueue \
ksym-vanilla-nft-chain-validate-dependency \
ksym-vanilla-nft-chain-validate-hooks \
ksym-vanilla-nft-data-init \
ksym-vanilla-nft-do-chain \
ksym-vanilla-nft-dump-register \
ksym-vanilla-nft-fib-dump \
ksym-vanilla-nft-fib-init \
ksym-vanilla-nft-fib-policy \
ksym-vanilla-nft-fib-store-result \
ksym-vanilla-nft-fib-validate \
ksym-vanilla-nft-fib4-eval \
ksym-vanilla-nft-fib4-eval-type \
ksym-vanilla-nft-fib6-eval \
ksym-vanilla-nft-fib6-eval-type \
ksym-vanilla-nft-flow-route \
ksym-vanilla-nft-flowtable-lookup \
ksym-vanilla-nft-fwd-dup-netdev-offload \
ksym-vanilla-nft-hook-find-ops \
ksym-vanilla-nft-hook-find-ops-rcu \
ksym-vanilla-nft-meta-get-dump \
ksym-vanilla-nft-meta-get-eval \
ksym-vanilla-nft-meta-get-init \
ksym-vanilla-nft-meta-get-validate \
ksym-vanilla-nft-meta-inner-eval \
ksym-vanilla-nft-meta-policy \
ksym-vanilla-nft-meta-set-destroy \
ksym-vanilla-nft-meta-set-dump \
ksym-vanilla-nft-meta-set-eval \
ksym-vanilla-nft-meta-set-init \
ksym-vanilla-nft-meta-set-validate \
ksym-vanilla-nft-obj-notify \
ksym-vanilla-nft-parse-register-load \
ksym-vanilla-nft-parse-register-store \
ksym-vanilla-nft-parse-u32-check \
ksym-vanilla-nft-register-chain-type \
ksym-vanilla-nft-register-expr \
ksym-vanilla-nft-register-flowtable-type \
ksym-vanilla-nft-register-obj \
ksym-vanilla-nft-reject-dump \
ksym-vanilla-nft-reject-icmp-code \
ksym-vanilla-nft-reject-icmpv6-code \
ksym-vanilla-nft-reject-init \
ksym-vanilla-nft-reject-policy \
ksym-vanilla-nft-reject-validate \
ksym-vanilla-nft-request-module \
ksym-vanilla-nft-set-do-lookup \
ksym-vanilla-nft-trace-enabled \
ksym-vanilla-nft-unregister-chain-type \
ksym-vanilla-nft-unregister-expr \
ksym-vanilla-nft-unregister-flowtable-type \
ksym-vanilla-nft-unregister-obj \
ksym-vanilla-nh \
ksym-vanilla-nh-grp-hw-stats-report-delta \
ksym-vanilla-nl-table \
ksym-vanilla-nl-table-lock \
ksym-vanilla-nl80211-chan-width-to-mhz \
ksym-vanilla-nl80211-mlo-reconf-add-done \
ksym-vanilla-nl80211-send-chandef \
ksym-vanilla-nl802154-beaconing-done \
ksym-vanilla-nl802154-scan-done \
ksym-vanilla-nl802154-scan-event \
ksym-vanilla-nl802154-scan-started \
ksym-vanilla-nla-append \
ksym-vanilla-nla-find \
ksym-vanilla-nla-get-labels \
ksym-vanilla-nla-memcmp \
ksym-vanilla-nla-memcpy \
ksym-vanilla-nla-policy-len \
ksym-vanilla-nla-put \
ksym-vanilla-nla-put-64bit \
ksym-vanilla-nla-put-labels \
ksym-vanilla-nla-put-nohdr \
ksym-vanilla-nla-reserve \
ksym-vanilla-nla-reserve-64bit \
ksym-vanilla-nla-reserve-nohdr \
ksym-vanilla-nla-strcmp \
ksym-vanilla-nla-strdup \
ksym-vanilla-nla-strscpy \
ksym-vanilla-nlm-debug \
ksym-vanilla-nlmclnt-done \
ksym-vanilla-nlmclnt-init \
ksym-vanilla-nlmclnt-proc \
ksym-vanilla-nlmclnt-rpc-clnt \
ksym-vanilla-nlmclnt-shutdown-rpc-clnt \
ksym-vanilla-nlmsg-notify \
ksym-vanilla-nlmsvc-ops \
ksym-vanilla-nlmsvc-unlock-all-by-ip \
ksym-vanilla-nlmsvc-unlock-all-by-sb \
ksym-vanilla-nmi-panic \
ksym-vanilla-no-action \
ksym-vanilla-no-hash-pointers \
ksym-vanilla-no-seek-end-llseek \
ksym-vanilla-no-seek-end-llseek-size \
ksym-vanilla-node-data \
ksym-vanilla-node-set-perf-attrs \
ksym-vanilla-node-states \
ksym-vanilla-node-to-cpumask-map \
ksym-vanilla-node-to-pxm \
ksym-vanilla-node-update-perf-attrs \
ksym-vanilla-nonseekable-open \
ksym-vanilla-noop-backing-dev-info \
ksym-vanilla-noop-direct-IO \
ksym-vanilla-noop-dirty-folio \
ksym-vanilla-noop-fsync \
ksym-vanilla-noop-llseek \
ksym-vanilla-noop-qdisc \
ksym-vanilla-nop-mnt-idmap \
ksym-vanilla-nop-posix-acl-access \
ksym-vanilla-nop-posix-acl-default \
ksym-vanilla-nosteal-pipe-buf-ops \
ksym-vanilla-notifier-err-inject-dir \
ksym-vanilla-notifier-err-inject-init \
ksym-vanilla-notify-change \
ksym-vanilla-nr-cpu-ids \
ksym-vanilla-nr-free-buffer-pages \
ksym-vanilla-nr-node-ids \
ksym-vanilla-nr-online-nodes \
ksym-vanilla-nr-swap-pages \
ksym-vanilla-ns-capable \
ksym-vanilla-ns-capable-noaudit \
ksym-vanilla-ns-capable-setid \
ksym-vanilla-ns-to-kernel-old-timeval \
ksym-vanilla-ns-to-timespec64 \
ksym-vanilla-nsecs-to-jiffies \
ksym-vanilla-nsecs-to-jiffies64 \
ksym-vanilla-nsh-pop \
ksym-vanilla-nsh-push \
ksym-vanilla-ntb-clear-ctx \
ksym-vanilla-ntb-db-event \
ksym-vanilla-ntb-default-peer-port-count \
ksym-vanilla-ntb-default-peer-port-idx \
ksym-vanilla-ntb-default-peer-port-number \
ksym-vanilla-ntb-default-port-number \
ksym-vanilla-ntb-link-event \
ksym-vanilla-ntb-msg-event \
ksym-vanilla-ntb-msi-clear-mws \
ksym-vanilla-ntb-msi-init \
ksym-vanilla-ntb-msi-peer-trigger \
ksym-vanilla-ntb-msi-setup-mws \
ksym-vanilla-ntb-register-device \
ksym-vanilla-ntb-set-ctx \
ksym-vanilla-ntb-transport-create-queue \
ksym-vanilla-ntb-transport-free-queue \
ksym-vanilla-ntb-transport-link-down \
ksym-vanilla-ntb-transport-link-query \
ksym-vanilla-ntb-transport-link-up \
ksym-vanilla-ntb-transport-max-size \
ksym-vanilla-ntb-transport-qp-num \
ksym-vanilla-ntb-transport-register-client \
ksym-vanilla-ntb-transport-register-client-dev \
ksym-vanilla-ntb-transport-rx-enqueue \
ksym-vanilla-ntb-transport-rx-remove \
ksym-vanilla-ntb-transport-tx-enqueue \
ksym-vanilla-ntb-transport-tx-free-entry \
ksym-vanilla-ntb-transport-unregister-client \
ksym-vanilla-ntb-transport-unregister-client-dev \
ksym-vanilla-ntb-unregister-client \
ksym-vanilla-ntb-unregister-device \
ksym-vanilla-ntbm-msi-request-threaded-irq \
ksym-vanilla-ntmp-bpt-update-entry \
ksym-vanilla-ntmp-clear-eid-bitmap \
ksym-vanilla-ntmp-ect-update-entry \
ksym-vanilla-ntmp-ett-add-entry \
ksym-vanilla-ntmp-ett-delete-entry \
ksym-vanilla-ntmp-ett-update-entry \
ksym-vanilla-ntmp-fdbt-add-entry \
ksym-vanilla-ntmp-fdbt-delete-ageing-entries \
ksym-vanilla-ntmp-fdbt-delete-entry \
ksym-vanilla-ntmp-fdbt-delete-port-dynamic-entries \
ksym-vanilla-ntmp-fdbt-search-port-entry \
ksym-vanilla-ntmp-fdbt-update-activity-element \
ksym-vanilla-ntmp-fdbt-update-entry \
ksym-vanilla-ntmp-free-cbdr \
ksym-vanilla-ntmp-init-cbdr \
ksym-vanilla-ntmp-ipft-add-entry \
ksym-vanilla-ntmp-ipft-delete-entry \
ksym-vanilla-ntmp-lookup-free-eid \
ksym-vanilla-ntmp-maft-add-entry \
ksym-vanilla-ntmp-maft-delete-entry \
ksym-vanilla-ntmp-maft-query-entry \
ksym-vanilla-ntmp-rsst-query-entry \
ksym-vanilla-ntmp-rsst-update-entry \
ksym-vanilla-ntmp-vft-add-entry \
ksym-vanilla-ntmp-vft-delete-entry \
ksym-vanilla-ntmp-vft-update-entry \
ksym-vanilla-null-dailink-component \
ksym-vanilla-numa-nearest-node \
ksym-vanilla-numa-node \
ksym-vanilla-nvdimm-badblocks-populate \
ksym-vanilla-nvdimm-bus-add-badrange \
ksym-vanilla-nvdimm-bus-check-dimm-count \
ksym-vanilla-nvdimm-bus-lock \
ksym-vanilla-nvdimm-bus-register \
ksym-vanilla-nvdimm-bus-unlock \
ksym-vanilla-nvdimm-bus-unregister \
ksym-vanilla-nvdimm-check-and-set-ro \
ksym-vanilla-nvdimm-clear-poison \
ksym-vanilla-nvdimm-cmd-mask \
ksym-vanilla-nvdimm-delete \
ksym-vanilla-nvdimm-flush \
ksym-vanilla-nvdimm-has-cache \
ksym-vanilla-nvdimm-has-flush \
ksym-vanilla-nvdimm-in-overwrite \
ksym-vanilla-nvdimm-kobj \
ksym-vanilla-nvdimm-name \
ksym-vanilla-nvdimm-namespace-attach-btt \
ksym-vanilla-nvdimm-namespace-capacity \
ksym-vanilla-nvdimm-namespace-common-probe \
ksym-vanilla-nvdimm-namespace-detach-btt \
ksym-vanilla-nvdimm-namespace-disk-name \
ksym-vanilla-nvdimm-namespace-locked \
ksym-vanilla-nvdimm-pmem-region-create \
ksym-vanilla-nvdimm-provider-data \
ksym-vanilla-nvdimm-region-delete \
ksym-vanilla-nvdimm-region-notify \
ksym-vanilla-nvdimm-security-setup-events \
ksym-vanilla-nvdimm-setup-pfn \
ksym-vanilla-nvdimm-to-bus \
ksym-vanilla-nvdimm-volatile-region-create \
ksym-vanilla-nvec-msg-free \
ksym-vanilla-nvec-register-notifier \
ksym-vanilla-nvec-unregister-notifier \
ksym-vanilla-nvec-write-async \
ksym-vanilla-nvec-write-sync \
ksym-vanilla-nvme-add-ctrl \
ksym-vanilla-nvme-alloc-admin-tag-set \
ksym-vanilla-nvme-alloc-io-tag-set \
ksym-vanilla-nvme-auth-alloc-key \
ksym-vanilla-nvme-auth-augmented-challenge \
ksym-vanilla-nvme-auth-derive-tls-psk \
ksym-vanilla-nvme-auth-dhgroup-id \
ksym-vanilla-nvme-auth-dhgroup-kpp \
ksym-vanilla-nvme-auth-dhgroup-name \
ksym-vanilla-nvme-auth-extract-key \
ksym-vanilla-nvme-auth-free \
ksym-vanilla-nvme-auth-free-key \
ksym-vanilla-nvme-auth-gen-privkey \
ksym-vanilla-nvme-auth-gen-pubkey \
ksym-vanilla-nvme-auth-gen-session-key \
ksym-vanilla-nvme-auth-generate-digest \
ksym-vanilla-nvme-auth-generate-psk \
ksym-vanilla-nvme-auth-get-seqnum \
ksym-vanilla-nvme-auth-hmac-final \
ksym-vanilla-nvme-auth-hmac-hash-len \
ksym-vanilla-nvme-auth-hmac-id \
ksym-vanilla-nvme-auth-hmac-init \
ksym-vanilla-nvme-auth-hmac-name \
ksym-vanilla-nvme-auth-hmac-update \
ksym-vanilla-nvme-auth-init-ctrl \
ksym-vanilla-nvme-auth-key-struct-size \
ksym-vanilla-nvme-auth-negotiate \
ksym-vanilla-nvme-auth-parse-key \
ksym-vanilla-nvme-auth-revoke-tls-key \
ksym-vanilla-nvme-auth-stop \
ksym-vanilla-nvme-auth-transform-key \
ksym-vanilla-nvme-auth-wait \
ksym-vanilla-nvme-cancel-admin-tagset \
ksym-vanilla-nvme-cancel-request \
ksym-vanilla-nvme-cancel-tagset \
ksym-vanilla-nvme-change-ctrl-state \
ksym-vanilla-nvme-cleanup-cmd \
ksym-vanilla-nvme-command-effects \
ksym-vanilla-nvme-complete-async-event \
ksym-vanilla-nvme-complete-batch-req \
ksym-vanilla-nvme-complete-rq \
ksym-vanilla-nvme-ctrl-from-file \
ksym-vanilla-nvme-delete-ctrl \
ksym-vanilla-nvme-delete-wq \
ksym-vanilla-nvme-dev-attrs-group \
ksym-vanilla-nvme-dev-diag-attrs-group \
ksym-vanilla-nvme-disable-ctrl \
ksym-vanilla-nvme-enable-ctrl \
ksym-vanilla-nvme-execute-rq \
ksym-vanilla-nvme-fail-nonready-command \
ksym-vanilla-nvme-fc-io-getuuid \
ksym-vanilla-nvme-fc-rcv-ls-req \
ksym-vanilla-nvme-fc-register-localport \
ksym-vanilla-nvme-fc-register-remoteport \
ksym-vanilla-nvme-fc-rescan-remoteport \
ksym-vanilla-nvme-fc-set-remoteport-devloss \
ksym-vanilla-nvme-fc-unregister-localport \
ksym-vanilla-nvme-fc-unregister-remoteport \
ksym-vanilla-nvme-find-get-ns \
ksym-vanilla-nvme-get-features \
ksym-vanilla-nvme-host-path-error \
ksym-vanilla-nvme-init-ctrl \
ksym-vanilla-nvme-init-ctrl-finish \
ksym-vanilla-nvme-init-request \
ksym-vanilla-nvme-io-timeout \
ksym-vanilla-nvme-keyring-id \
ksym-vanilla-nvme-mark-namespaces-dead \
ksym-vanilla-nvme-mpath-start-request \
ksym-vanilla-nvme-passthru-end \
ksym-vanilla-nvme-passthru-start \
ksym-vanilla-nvme-put-ns \
ksym-vanilla-nvme-quiesce-admin-queue \
ksym-vanilla-nvme-quiesce-io-queues \
ksym-vanilla-nvme-remove-admin-tag-set \
ksym-vanilla-nvme-remove-io-tag-set \
ksym-vanilla-nvme-remove-namespaces \
ksym-vanilla-nvme-reset-ctrl \
ksym-vanilla-nvme-reset-wq \
ksym-vanilla-nvme-set-features \
ksym-vanilla-nvme-set-queue-count \
ksym-vanilla-nvme-setup-cmd \
ksym-vanilla-nvme-should-fail \
ksym-vanilla-nvme-start-ctrl \
ksym-vanilla-nvme-start-freeze \
ksym-vanilla-nvme-stop-ctrl \
ksym-vanilla-nvme-stop-keep-alive \
ksym-vanilla-nvme-submit-sync-cmd \
ksym-vanilla-nvme-sync-io-queues \
ksym-vanilla-nvme-sync-queues \
ksym-vanilla-nvme-tls-key-lookup \
ksym-vanilla-nvme-tls-psk-default \
ksym-vanilla-nvme-tls-psk-refresh \
ksym-vanilla-nvme-try-sched-reset \
ksym-vanilla-nvme-unfreeze \
ksym-vanilla-nvme-uninit-ctrl \
ksym-vanilla-nvme-unquiesce-admin-queue \
ksym-vanilla-nvme-unquiesce-io-queues \
ksym-vanilla-nvme-wait-freeze \
ksym-vanilla-nvme-wait-freeze-timeout \
ksym-vanilla-nvme-wait-reset \
ksym-vanilla-nvme-wq \
ksym-vanilla-nvmem-add-cell-lookups \
ksym-vanilla-nvmem-add-cells-from-dt \
ksym-vanilla-nvmem-add-one-cell \
ksym-vanilla-nvmem-cell-get \
ksym-vanilla-nvmem-cell-put \
ksym-vanilla-nvmem-cell-read \
ksym-vanilla-nvmem-cell-read-u16 \
ksym-vanilla-nvmem-cell-read-u32 \
ksym-vanilla-nvmem-cell-read-u64 \
ksym-vanilla-nvmem-cell-read-u8 \
ksym-vanilla-nvmem-cell-read-variable-le-u32 \
ksym-vanilla-nvmem-cell-read-variable-le-u64 \
ksym-vanilla-nvmem-cell-write \
ksym-vanilla-nvmem-del-cell-lookups \
ksym-vanilla-nvmem-dev-name \
ksym-vanilla-nvmem-dev-size \
ksym-vanilla-nvmem-device-cell-read \
ksym-vanilla-nvmem-device-cell-write \
ksym-vanilla-nvmem-device-find \
ksym-vanilla-nvmem-device-get \
ksym-vanilla-nvmem-device-put \
ksym-vanilla-nvmem-device-read \
ksym-vanilla-nvmem-device-write \
ksym-vanilla-nvmem-layout-driver-unregister \
ksym-vanilla-nvmem-layout-register \
ksym-vanilla-nvmem-layout-unregister \
ksym-vanilla-nvmem-register \
ksym-vanilla-nvmem-register-notifier \
ksym-vanilla-nvmem-unregister \
ksym-vanilla-nvmem-unregister-notifier \
ksym-vanilla-nvmet-aen-wq \
ksym-vanilla-nvmet-alloc-ctrl \
ksym-vanilla-nvmet-check-transfer-len \
ksym-vanilla-nvmet-cq-create \
ksym-vanilla-nvmet-cq-get \
ksym-vanilla-nvmet-cq-in-use \
ksym-vanilla-nvmet-cq-init \
ksym-vanilla-nvmet-cq-put \
ksym-vanilla-nvmet-ctrl-fatal-error \
ksym-vanilla-nvmet-ctrl-put \
ksym-vanilla-nvmet-fc-invalidate-host \
ksym-vanilla-nvmet-fc-rcv-fcp-abort \
ksym-vanilla-nvmet-fc-rcv-fcp-req \
ksym-vanilla-nvmet-fc-rcv-ls-req \
ksym-vanilla-nvmet-fc-register-targetport \
ksym-vanilla-nvmet-fc-unregister-targetport \
ksym-vanilla-nvmet-register-transport \
ksym-vanilla-nvmet-req-alloc-sgls \
ksym-vanilla-nvmet-req-complete \
ksym-vanilla-nvmet-req-free-sgls \
ksym-vanilla-nvmet-req-init \
ksym-vanilla-nvmet-req-transfer-len \
ksym-vanilla-nvmet-req-uninit \
ksym-vanilla-nvmet-sq-create \
ksym-vanilla-nvmet-sq-destroy \
ksym-vanilla-nvmet-sq-init \
ksym-vanilla-nvmet-unregister-transport \
ksym-vanilla-nvmet-update-cc \
ksym-vanilla-nvmet-wq \
ksym-vanilla-nvmf-connect-admin-queue \
ksym-vanilla-nvmf-connect-io-queue \
ksym-vanilla-nvmf-free-options \
ksym-vanilla-nvmf-get-address \
ksym-vanilla-nvmf-ip-options-match \
ksym-vanilla-nvmf-map-queues \
ksym-vanilla-nvmf-reg-read32 \
ksym-vanilla-nvmf-reg-read64 \
ksym-vanilla-nvmf-reg-write32 \
ksym-vanilla-nvmf-register-transport \
ksym-vanilla-nvmf-set-io-queues \
ksym-vanilla-nvmf-should-reconnect \
ksym-vanilla-nvmf-subsystem-reset \
ksym-vanilla-nvmf-unregister-transport \
ksym-vanilla-nxp-nci-fw-recv-frame \
ksym-vanilla-nxp-nci-probe \
ksym-vanilla-nxp-nci-remove \
ksym-vanilla-nxt200x-attach \
ksym-vanilla-nxt6000-attach \
ksym-vanilla-o2hb-check-node-heartbeating-from-callback \
ksym-vanilla-o2hb-check-node-heartbeating-no-sem \
ksym-vanilla-o2hb-fill-node-map \
ksym-vanilla-o2hb-get-all-regions \
ksym-vanilla-o2hb-global-heartbeat-active \
ksym-vanilla-o2hb-register-callback \
ksym-vanilla-o2hb-setup-callback \
ksym-vanilla-o2hb-stop-all-regions \
ksym-vanilla-o2hb-unregister-callback \
ksym-vanilla-o2net-fill-node-map \
ksym-vanilla-o2net-register-handler \
ksym-vanilla-o2net-send-message \
ksym-vanilla-o2net-send-message-vec \
ksym-vanilla-o2net-unregister-handler-list \
ksym-vanilla-o2nm-configured-node-map \
ksym-vanilla-o2nm-get-node-by-ip \
ksym-vanilla-o2nm-get-node-by-num \
ksym-vanilla-o2nm-node-get \
ksym-vanilla-o2nm-node-put \
ksym-vanilla-o2nm-this-node \
ksym-vanilla-oa-1000bt1-get-ethtool-cable-result-code \
ksym-vanilla-oa-1000bt1-get-tdr-distance \
ksym-vanilla-oa-tc6-exit \
ksym-vanilla-oa-tc6-init \
ksym-vanilla-oa-tc6-read-register \
ksym-vanilla-oa-tc6-read-registers \
ksym-vanilla-oa-tc6-start-xmit \
ksym-vanilla-oa-tc6-write-register \
ksym-vanilla-oa-tc6-write-registers \
ksym-vanilla-oa-tc6-zero-align-receive-frame-enable \
ksym-vanilla-objagg-create \
ksym-vanilla-objagg-destroy \
ksym-vanilla-objagg-hints-get \
ksym-vanilla-objagg-hints-put \
ksym-vanilla-objagg-hints-stats-get \
ksym-vanilla-objagg-obj-delta-priv \
ksym-vanilla-objagg-obj-get \
ksym-vanilla-objagg-obj-put \
ksym-vanilla-objagg-obj-raw \
ksym-vanilla-objagg-obj-root-priv \
ksym-vanilla-objagg-stats-get \
ksym-vanilla-objagg-stats-put \
ksym-vanilla-objpool-drop \
ksym-vanilla-objpool-fini \
ksym-vanilla-objpool-free \
ksym-vanilla-objpool-init \
ksym-vanilla-ocelot-bond-get-id \
ksym-vanilla-ocelot-bridge-num-find \
ksym-vanilla-ocelot-bridge-stp-state-set \
ksym-vanilla-ocelot-can-inject \
ksym-vanilla-ocelot-chip-reset \
ksym-vanilla-ocelot-cls-flower-destroy \
ksym-vanilla-ocelot-cls-flower-replace \
ksym-vanilla-ocelot-cls-flower-stats \
ksym-vanilla-ocelot-core-init \
ksym-vanilla-ocelot-deinit \
ksym-vanilla-ocelot-deinit-port \
ksym-vanilla-ocelot-deinit-timestamp \
ksym-vanilla-ocelot-devlink-sb-register \
ksym-vanilla-ocelot-devlink-sb-unregister \
ksym-vanilla-ocelot-drain-cpu-queue \
ksym-vanilla-ocelot-fdb-add \
ksym-vanilla-ocelot-fdb-del \
ksym-vanilla-ocelot-fdb-dump \
ksym-vanilla-ocelot-get-bridge-fwd-mask \
ksym-vanilla-ocelot-get-ethtool-stats \
ksym-vanilla-ocelot-get-max-mtu \
ksym-vanilla-ocelot-get-sset-count \
ksym-vanilla-ocelot-get-strings \
ksym-vanilla-ocelot-get-ts-info \
ksym-vanilla-ocelot-get-txtstamp \
ksym-vanilla-ocelot-hwstamp-get \
ksym-vanilla-ocelot-hwstamp-set \
ksym-vanilla-ocelot-ifh-set-basic \
ksym-vanilla-ocelot-init \
ksym-vanilla-ocelot-init-port \
ksym-vanilla-ocelot-init-timestamp \
ksym-vanilla-ocelot-lag-fdb-add \
ksym-vanilla-ocelot-lag-fdb-del \
ksym-vanilla-ocelot-lock-inj-grp \
ksym-vanilla-ocelot-lock-xtr-grp \
ksym-vanilla-ocelot-lock-xtr-grp-bh \
ksym-vanilla-ocelot-mact-flush \
ksym-vanilla-ocelot-mact-forget \
ksym-vanilla-ocelot-mact-learn \
ksym-vanilla-ocelot-mact-learn-streamdata \
ksym-vanilla-ocelot-mact-lookup \
ksym-vanilla-ocelot-migrate-mdbs \
ksym-vanilla-ocelot-mm-irq \
ksym-vanilla-ocelot-mrp-add \
ksym-vanilla-ocelot-mrp-add-ring-role \
ksym-vanilla-ocelot-mrp-del \
ksym-vanilla-ocelot-mrp-del-ring-role \
ksym-vanilla-ocelot-phylink-mac-config \
ksym-vanilla-ocelot-phylink-mac-link-down \
ksym-vanilla-ocelot-phylink-mac-link-up \
ksym-vanilla-ocelot-pll5-init \
ksym-vanilla-ocelot-policer-validate \
ksym-vanilla-ocelot-port-add-dscp-prio \
ksym-vanilla-ocelot-port-assign-dsa-8021q-cpu \
ksym-vanilla-ocelot-port-assigned-dsa-8021q-cpu-mask \
ksym-vanilla-ocelot-port-bridge-flags \
ksym-vanilla-ocelot-port-bridge-join \
ksym-vanilla-ocelot-port-bridge-leave \
ksym-vanilla-ocelot-port-configure-serdes \
ksym-vanilla-ocelot-port-del-dscp-prio \
ksym-vanilla-ocelot-port-get-default-prio \
ksym-vanilla-ocelot-port-get-dscp-prio \
ksym-vanilla-ocelot-port-get-eth-ctrl-stats \
ksym-vanilla-ocelot-port-get-eth-mac-stats \
ksym-vanilla-ocelot-port-get-eth-phy-stats \
ksym-vanilla-ocelot-port-get-mm \
ksym-vanilla-ocelot-port-get-mm-stats \
ksym-vanilla-ocelot-port-get-pause-stats \
ksym-vanilla-ocelot-port-get-rmon-stats \
ksym-vanilla-ocelot-port-get-stats64 \
ksym-vanilla-ocelot-port-get-ts-stats \
ksym-vanilla-ocelot-port-inject-frame \
ksym-vanilla-ocelot-port-lag-change \
ksym-vanilla-ocelot-port-lag-join \
ksym-vanilla-ocelot-port-lag-leave \
ksym-vanilla-ocelot-port-mdb-add \
ksym-vanilla-ocelot-port-mdb-del \
ksym-vanilla-ocelot-port-mirror-add \
ksym-vanilla-ocelot-port-mirror-del \
ksym-vanilla-ocelot-port-mqprio \
ksym-vanilla-ocelot-port-policer-add \
ksym-vanilla-ocelot-port-policer-del \
ksym-vanilla-ocelot-port-pre-bridge-flags \
ksym-vanilla-ocelot-port-readl \
ksym-vanilla-ocelot-port-rmwl \
ksym-vanilla-ocelot-port-set-default-prio \
ksym-vanilla-ocelot-port-set-maxlen \
ksym-vanilla-ocelot-port-set-mm \
ksym-vanilla-ocelot-port-setup-dsa-8021q-cpu \
ksym-vanilla-ocelot-port-teardown-dsa-8021q-cpu \
ksym-vanilla-ocelot-port-txtstamp-request \
ksym-vanilla-ocelot-port-unassign-dsa-8021q-cpu \
ksym-vanilla-ocelot-port-vlan-filtering \
ksym-vanilla-ocelot-port-writel \
ksym-vanilla-ocelot-ptp-adjfine \
ksym-vanilla-ocelot-ptp-adjtime \
ksym-vanilla-ocelot-ptp-enable \
ksym-vanilla-ocelot-ptp-gettime64 \
ksym-vanilla-ocelot-ptp-rx-timestamp \
ksym-vanilla-ocelot-ptp-settime64 \
ksym-vanilla-ocelot-ptp-verify \
ksym-vanilla-ocelot-regfields-init \
ksym-vanilla-ocelot-regmap-init \
ksym-vanilla-ocelot-reset \
ksym-vanilla-ocelot-sb-occ-max-clear \
ksym-vanilla-ocelot-sb-occ-port-pool-get \
ksym-vanilla-ocelot-sb-occ-snapshot \
ksym-vanilla-ocelot-sb-occ-tc-port-bind-get \
ksym-vanilla-ocelot-sb-pool-get \
ksym-vanilla-ocelot-sb-pool-set \
ksym-vanilla-ocelot-sb-port-pool-get \
ksym-vanilla-ocelot-sb-port-pool-set \
ksym-vanilla-ocelot-sb-tc-pool-bind-get \
ksym-vanilla-ocelot-sb-tc-pool-bind-set \
ksym-vanilla-ocelot-set-ageing-time \
ksym-vanilla-ocelot-spi-init-regmap \
ksym-vanilla-ocelot-unlock-inj-grp \
ksym-vanilla-ocelot-unlock-xtr-grp \
ksym-vanilla-ocelot-unlock-xtr-grp-bh \
ksym-vanilla-ocelot-vcap-block-find-filter-by-id \
ksym-vanilla-ocelot-vcap-filter-add \
ksym-vanilla-ocelot-vcap-filter-del \
ksym-vanilla-ocelot-vcap-filter-replace \
ksym-vanilla-ocelot-vcap-policer-add \
ksym-vanilla-ocelot-vcap-policer-del \
ksym-vanilla-ocelot-vlan-add \
ksym-vanilla-ocelot-vlan-del \
ksym-vanilla-ocelot-vlan-prepare \
ksym-vanilla-ocelot-wm-dec \
ksym-vanilla-ocelot-wm-enc \
ksym-vanilla-ocelot-wm-stat \
ksym-vanilla-ocelot-xtr-poll-frame \
ksym-vanilla-ocfs2-cluster-connect \
ksym-vanilla-ocfs2-cluster-connect-agnostic \
ksym-vanilla-ocfs2-cluster-disconnect \
ksym-vanilla-ocfs2-cluster-hangup \
ksym-vanilla-ocfs2-cluster-this-node \
ksym-vanilla-ocfs2-dlm-dump-lksb \
ksym-vanilla-ocfs2-dlm-lock \
ksym-vanilla-ocfs2-dlm-lock-status \
ksym-vanilla-ocfs2-dlm-lvb \
ksym-vanilla-ocfs2-dlm-lvb-valid \
ksym-vanilla-ocfs2-dlm-unlock \
ksym-vanilla-ocfs2-kset \
ksym-vanilla-ocfs2-plock \
ksym-vanilla-ocfs2-stack-glue-register \
ksym-vanilla-ocfs2-stack-glue-set-max-proto-version \
ksym-vanilla-ocfs2-stack-glue-unregister \
ksym-vanilla-ocfs2-stack-supports-plocks \
ksym-vanilla-ocmem-allocate \
ksym-vanilla-ocmem-free \
ksym-vanilla-octeon-alloc-soft-command \
ksym-vanilla-octeon-alloc-soft-command-resp \
ksym-vanilla-octeon-allocate-device \
ksym-vanilla-octeon-allocate-ioq-vector \
ksym-vanilla-octeon-core-drv-init \
ksym-vanilla-octeon-delete-dispatch-list \
ksym-vanilla-octeon-delete-droq \
ksym-vanilla-octeon-delete-instr-queue \
ksym-vanilla-octeon-delete-response-list \
ksym-vanilla-octeon-deregister-device \
ksym-vanilla-octeon-droq-check-hw-for-pkts \
ksym-vanilla-octeon-droq-process-packets \
ksym-vanilla-octeon-free-device-mem \
ksym-vanilla-octeon-free-ioq-vector \
ksym-vanilla-octeon-free-sc-buffer-pool \
ksym-vanilla-octeon-free-sc-done-list \
ksym-vanilla-octeon-free-sc-zombie-list \
ksym-vanilla-octeon-free-soft-command \
ksym-vanilla-octeon-get-conf \
ksym-vanilla-octeon-get-rx-qsize \
ksym-vanilla-octeon-get-tx-qsize \
ksym-vanilla-octeon-init-device-list \
ksym-vanilla-octeon-init-dispatch-list \
ksym-vanilla-octeon-mem-access-ok \
ksym-vanilla-octeon-pci-read-core-mem \
ksym-vanilla-octeon-pci-write-core-mem \
ksym-vanilla-octeon-prepare-soft-command \
ksym-vanilla-octeon-read-device-mem32 \
ksym-vanilla-octeon-read-device-mem64 \
ksym-vanilla-octeon-register-device \
ksym-vanilla-octeon-register-dispatch-fn \
ksym-vanilla-octeon-register-reqtype-free-fn \
ksym-vanilla-octeon-ring-doorbell-locked \
ksym-vanilla-octeon-send-command \
ksym-vanilla-octeon-send-soft-command \
ksym-vanilla-octeon-set-io-queues-off \
ksym-vanilla-octeon-setup-instr-queues \
ksym-vanilla-octeon-setup-interrupt \
ksym-vanilla-octeon-setup-output-queues \
ksym-vanilla-octeon-setup-response-list \
ksym-vanilla-octeon-setup-sc-buffer-pool \
ksym-vanilla-octeon-unregister-droq-ops \
ksym-vanilla-octeon-wait-for-ddr-init \
ksym-vanilla-octeon-write-device-mem32 \
ksym-vanilla-octnet-send-nic-ctrl-pkt \
ksym-vanilla-octnet-send-nic-data-pkt \
ksym-vanilla-od-register-powersave-bias-handler \
ksym-vanilla-od-unregister-powersave-bias-handler \
ksym-vanilla-of-add-property \
ksym-vanilla-of-address-to-resource \
ksym-vanilla-of-alias-from-compatible \
ksym-vanilla-of-alias-get-highest-id \
ksym-vanilla-of-alias-get-id \
ksym-vanilla-of-bcm-voter-get \
ksym-vanilla-of-can-transceiver \
ksym-vanilla-of-changeset-action \
ksym-vanilla-of-changeset-add-prop-bool \
ksym-vanilla-of-changeset-add-prop-string \
ksym-vanilla-of-changeset-add-prop-string-array \
ksym-vanilla-of-changeset-add-prop-u32-array \
ksym-vanilla-of-changeset-apply \
ksym-vanilla-of-changeset-create-node \
ksym-vanilla-of-changeset-destroy \
ksym-vanilla-of-changeset-init \
ksym-vanilla-of-changeset-revert \
ksym-vanilla-of-changeset-update-prop-string \
ksym-vanilla-of-chosen \
ksym-vanilla-of-clk-add-hw-provider \
ksym-vanilla-of-clk-add-provider \
ksym-vanilla-of-clk-del-provider \
ksym-vanilla-of-clk-get \
ksym-vanilla-of-clk-get-by-name \
ksym-vanilla-of-clk-get-from-provider \
ksym-vanilla-of-clk-get-parent-count \
ksym-vanilla-of-clk-get-parent-name \
ksym-vanilla-of-clk-hw-onecell-get \
ksym-vanilla-of-clk-hw-register \
ksym-vanilla-of-clk-hw-simple-get \
ksym-vanilla-of-clk-parent-fill \
ksym-vanilla-of-clk-set-defaults \
ksym-vanilla-of-clk-src-onecell-get \
ksym-vanilla-of-clk-src-simple-get \
ksym-vanilla-of-console-check \
ksym-vanilla-of-count-phandle-with-args \
ksym-vanilla-of-cpu-device-node-get \
ksym-vanilla-of-cpu-node-to-id \
ksym-vanilla-of-cpufreq-cooling-register \
ksym-vanilla-of-css \
ksym-vanilla-of-detach-node \
ksym-vanilla-of-devfreq-cooling-register \
ksym-vanilla-of-devfreq-cooling-register-power \
ksym-vanilla-of-device-alloc \
ksym-vanilla-of-device-compatible-match \
ksym-vanilla-of-device-get-match-data \
ksym-vanilla-of-device-is-available \
ksym-vanilla-of-device-is-big-endian \
ksym-vanilla-of-device-is-compatible \
ksym-vanilla-of-device-make-bus-id \
ksym-vanilla-of-device-modalias \
ksym-vanilla-of-device-register \
ksym-vanilla-of-device-uevent \
ksym-vanilla-of-device-uevent-modalias \
ksym-vanilla-of-device-unregister \
ksym-vanilla-of-dma-configure-id \
ksym-vanilla-of-dma-controller-free \
ksym-vanilla-of-dma-controller-register \
ksym-vanilla-of-dma-is-coherent \
ksym-vanilla-of-dma-request-slave-channel \
ksym-vanilla-of-dma-router-register \
ksym-vanilla-of-dma-simple-xlate \
ksym-vanilla-of-dma-xlate-by-chan-id \
ksym-vanilla-of-dp-aux-depopulate-bus \
ksym-vanilla-of-dp-aux-populate-bus \
ksym-vanilla-of-drm-find-and-get-bridge \
ksym-vanilla-of-drm-find-bridge \
ksym-vanilla-of-drm-find-panel \
ksym-vanilla-of-drm-get-bridge-by-endpoint \
ksym-vanilla-of-drm-get-panel-orientation \
ksym-vanilla-of-fdt-unflatten-tree \
ksym-vanilla-of-find-all-nodes \
ksym-vanilla-of-find-backlight-by-node \
ksym-vanilla-of-find-compatible-node \
ksym-vanilla-of-find-device-by-node \
ksym-vanilla-of-find-matching-node-and-match \
ksym-vanilla-of-find-mipi-dsi-device-by-node \
ksym-vanilla-of-find-mipi-dsi-host-by-node \
ksym-vanilla-of-find-net-device-by-node \
ksym-vanilla-of-find-node-by-name \
ksym-vanilla-of-find-node-by-phandle \
ksym-vanilla-of-find-node-by-type \
ksym-vanilla-of-find-node-opts-by-path \
ksym-vanilla-of-find-node-with-property \
ksym-vanilla-of-find-property \
ksym-vanilla-of-find-serdev-controller-by-node \
ksym-vanilla-of-find-spi-controller-by-node \
ksym-vanilla-of-fpga-bridge-get \
ksym-vanilla-of-fpga-bridge-get-to-list \
ksym-vanilla-of-fpga-mgr-get \
ksym-vanilla-of-fwnode-ops \
ksym-vanilla-of-gen-pool-get \
ksym-vanilla-of-genpd-add-child-ids \
ksym-vanilla-of-genpd-add-device \
ksym-vanilla-of-genpd-add-provider-onecell \
ksym-vanilla-of-genpd-add-provider-simple \
ksym-vanilla-of-genpd-add-subdomain \
ksym-vanilla-of-genpd-del-provider \
ksym-vanilla-of-genpd-parse-idle-states \
ksym-vanilla-of-genpd-remove-child-ids \
ksym-vanilla-of-genpd-remove-last \
ksym-vanilla-of-genpd-remove-subdomain \
ksym-vanilla-of-genpd-sync-state \
ksym-vanilla-of-get-available-child-by-name \
ksym-vanilla-of-get-child-by-name \
ksym-vanilla-of-get-compatible-child \
ksym-vanilla-of-get-cpu-node \
ksym-vanilla-of-get-cpu-state-node \
ksym-vanilla-of-get-display-timing \
ksym-vanilla-of-get-display-timings \
ksym-vanilla-of-get-drm-display-mode \
ksym-vanilla-of-get-drm-panel-display-mode \
ksym-vanilla-of-get-ethdev-address \
ksym-vanilla-of-get-fb-videomode \
ksym-vanilla-of-get-mac-address \
ksym-vanilla-of-get-mac-address-nvmem \
ksym-vanilla-of-get-mtd-device-by-node \
ksym-vanilla-of-get-nand-ecc-user-config \
ksym-vanilla-of-get-next-available-child \
ksym-vanilla-of-get-next-child \
ksym-vanilla-of-get-next-child-with-prefix \
ksym-vanilla-of-get-next-cpu-node \
ksym-vanilla-of-get-next-parent \
ksym-vanilla-of-get-next-reserved-child \
ksym-vanilla-of-get-ocmem \
ksym-vanilla-of-get-parent \
ksym-vanilla-of-get-pci-domain-nr \
ksym-vanilla-of-get-phy-mode \
ksym-vanilla-of-get-property \
ksym-vanilla-of-get-regulator-init-data \
ksym-vanilla-of-get-required-opp-performance-state \
ksym-vanilla-of-get-videomode \
ksym-vanilla-of-graph-get-endpoint-by-regs \
ksym-vanilla-of-graph-get-endpoint-count \
ksym-vanilla-of-graph-get-next-endpoint \
ksym-vanilla-of-graph-get-next-port \
ksym-vanilla-of-graph-get-next-port-endpoint \
ksym-vanilla-of-graph-get-port-by-id \
ksym-vanilla-of-graph-get-port-count \
ksym-vanilla-of-graph-get-port-parent \
ksym-vanilla-of-graph-get-remote-endpoint \
ksym-vanilla-of-graph-get-remote-node \
ksym-vanilla-of-graph-get-remote-port \
ksym-vanilla-of-graph-get-remote-port-parent \
ksym-vanilla-of-graph-is-present \
ksym-vanilla-of-graph-parse-endpoint \
ksym-vanilla-of-hte-req-count \
ksym-vanilla-of-hwspin-lock-get-id \
ksym-vanilla-of-hwspin-lock-get-id-byname \
ksym-vanilla-of-i2c-get-board-info \
ksym-vanilla-of-icc-bulk-get \
ksym-vanilla-of-icc-get \
ksym-vanilla-of-icc-get-by-index \
ksym-vanilla-of-icc-get-from-provider \
ksym-vanilla-of-icc-xlate-onecell \
ksym-vanilla-of-imap-parser-init \
ksym-vanilla-of-imap-parser-one \
ksym-vanilla-of-io-request-and-map \
ksym-vanilla-of-iomap \
ksym-vanilla-of-iommu-get-resv-regions \
ksym-vanilla-of-irq-count \
ksym-vanilla-of-irq-find-parent \
ksym-vanilla-of-irq-get \
ksym-vanilla-of-irq-get-byname \
ksym-vanilla-of-irq-parse-and-map-pci \
ksym-vanilla-of-irq-parse-one \
ksym-vanilla-of-irq-parse-raw \
ksym-vanilla-of-irq-to-resource \
ksym-vanilla-of-irq-to-resource-table \
ksym-vanilla-of-machine-compatible-match \
ksym-vanilla-of-machine-get-match \
ksym-vanilla-of-machine-get-match-data \
ksym-vanilla-of-machine-read-compatible \
ksym-vanilla-of-machine-read-model \
ksym-vanilla-of-map-id \
ksym-vanilla-of-map-iommu-id \
ksym-vanilla-of-map-msi-id \
ksym-vanilla-of-match-device \
ksym-vanilla-of-match-node \
ksym-vanilla-of-mdio-find-bus \
ksym-vanilla-of-mdio-find-device \
ksym-vanilla-of-mdiobus-child-is-phy \
ksym-vanilla-of-mdiobus-phy-device-register \
ksym-vanilla-of-mpc8xxx-spi-probe \
ksym-vanilla-of-msi-configure \
ksym-vanilla-of-msi-get-domain \
ksym-vanilla-of-msi-xlate \
ksym-vanilla-of-mtk-ecc-get \
ksym-vanilla-of-n-addr-cells \
ksym-vanilla-of-n-size-cells \
ksym-vanilla-of-node-get \
ksym-vanilla-of-node-name-eq \
ksym-vanilla-of-node-name-prefix \
ksym-vanilla-of-node-put \
ksym-vanilla-of-nvmem-cell-get \
ksym-vanilla-of-nvmem-device-get \
ksym-vanilla-of-nvmem-layout-get-container \
ksym-vanilla-of-overlay-fdt-apply \
ksym-vanilla-of-overlay-notifier-register \
ksym-vanilla-of-overlay-notifier-unregister \
ksym-vanilla-of-overlay-remove \
ksym-vanilla-of-overlay-remove-all \
ksym-vanilla-of-parse-phandle-with-args-map \
ksym-vanilla-of-pci-address-to-resource \
ksym-vanilla-of-pci-check-probe-only \
ksym-vanilla-of-pci-dma-range-parser-init \
ksym-vanilla-of-pci-find-child-device \
ksym-vanilla-of-pci-get-devfn \
ksym-vanilla-of-pci-get-equalization-presets \
ksym-vanilla-of-pci-get-max-link-speed \
ksym-vanilla-of-pci-get-slot-power-limit \
ksym-vanilla-of-pci-range-parser-init \
ksym-vanilla-of-pci-range-parser-one \
ksym-vanilla-of-pci-range-to-resource \
ksym-vanilla-of-pci-supply-present \
ksym-vanilla-of-phandle-args-to-fwspec \
ksym-vanilla-of-phandle-iterator-init \
ksym-vanilla-of-phandle-iterator-next \
ksym-vanilla-of-phy-connect \
ksym-vanilla-of-phy-deregister-fixed-link \
ksym-vanilla-of-phy-find-device \
ksym-vanilla-of-phy-get \
ksym-vanilla-of-phy-get-and-connect \
ksym-vanilla-of-phy-is-fixed-link \
ksym-vanilla-of-phy-package-join \
ksym-vanilla-of-phy-provider-unregister \
ksym-vanilla-of-phy-put \
ksym-vanilla-of-phy-register-fixed-link \
ksym-vanilla-of-phy-simple-xlate \
ksym-vanilla-of-pinctrl-get \
ksym-vanilla-of-platform-bus-probe \
ksym-vanilla-of-platform-default-populate \
ksym-vanilla-of-platform-depopulate \
ksym-vanilla-of-platform-device-create \
ksym-vanilla-of-platform-device-destroy \
ksym-vanilla-of-platform-populate \
ksym-vanilla-of-pm-clk-add-clks \
ksym-vanilla-of-prop-next-string \
ksym-vanilla-of-prop-next-u32 \
ksym-vanilla-of-property-count-elems-of-size \
ksym-vanilla-of-property-match-string \
ksym-vanilla-of-property-read-bool \
ksym-vanilla-of-property-read-reg \
ksym-vanilla-of-property-read-string \
ksym-vanilla-of-property-read-string-helper \
ksym-vanilla-of-property-read-u16-index \
ksym-vanilla-of-property-read-u32-index \
ksym-vanilla-of-property-read-u64 \
ksym-vanilla-of-property-read-u64-index \
ksym-vanilla-of-property-read-u8-index \
ksym-vanilla-of-property-read-variable-u16-array \
ksym-vanilla-of-property-read-variable-u32-array \
ksym-vanilla-of-property-read-variable-u64-array \
ksym-vanilla-of-property-read-variable-u8-array \
ksym-vanilla-of-pse-control-get \
ksym-vanilla-of-pwm-single-xlate \
ksym-vanilla-of-pwm-xlate-with-flags \
ksym-vanilla-of-range-to-resource \
ksym-vanilla-of-reconfig-get-state-change \
ksym-vanilla-of-reconfig-notifier-register \
ksym-vanilla-of-reconfig-notifier-unregister \
ksym-vanilla-of-regulator-bulk-get-all \
ksym-vanilla-of-regulator-get \
ksym-vanilla-of-regulator-get-optional \
ksym-vanilla-of-regulator-match \
ksym-vanilla-of-remove-property \
ksym-vanilla-of-request-module \
ksym-vanilla-of-reserved-mem-device-init-by-idx \
ksym-vanilla-of-reserved-mem-device-init-by-name \
ksym-vanilla-of-reserved-mem-device-release \
ksym-vanilla-of-reserved-mem-lookup \
ksym-vanilla-of-reserved-mem-region-count \
ksym-vanilla-of-reserved-mem-region-to-resource \
ksym-vanilla-of-reserved-mem-region-to-resource-byname \
ksym-vanilla-of-resolve-phandles \
ksym-vanilla-of-root \
ksym-vanilla-of-sdw-find-device-by-node \
ksym-vanilla-of-slim-get-device \
ksym-vanilla-of-syscon-register-regmap \
ksym-vanilla-of-translate-address \
ksym-vanilla-of-translate-dma-address \
ksym-vanilla-of-translate-dma-region \
ksym-vanilla-of-usb-get-dr-mode-by-phy \
ksym-vanilla-of-usb-get-phy-mode \
ksym-vanilla-of-usb-host-tpl-support \
ksym-vanilla-of-usb-update-otg-caps \
ksym-vanilla-offline-and-remove-memory \
ksym-vanilla-ohci-hub-control \
ksym-vanilla-ohci-hub-status-data \
ksym-vanilla-ohci-init-driver \
ksym-vanilla-ohci-restart \
ksym-vanilla-ohci-resume \
ksym-vanilla-ohci-setup \
ksym-vanilla-ohci-suspend \
ksym-vanilla-olpc-ec-cmd \
ksym-vanilla-olpc-ec-driver-register \
ksym-vanilla-olpc-ec-mask-write \
ksym-vanilla-olpc-ec-sci-query \
ksym-vanilla-olpc-ec-wakeup-available \
ksym-vanilla-olpc-ec-wakeup-clear \
ksym-vanilla-olpc-ec-wakeup-set \
ksym-vanilla-on-each-cpu-cond-mask \
ksym-vanilla-onboard-dev-create-pdevs \
ksym-vanilla-onboard-dev-destroy-pdevs \
ksym-vanilla-onenand-addr \
ksym-vanilla-onenand-release \
ksym-vanilla-onenand-scan \
ksym-vanilla-oops-in-progress \
ksym-vanilla-opal-unlock-from-suspend \
ksym-vanilla-open-candev \
ksym-vanilla-open-exec \
ksym-vanilla-open-related-ns \
ksym-vanilla-opens-in-grace \
ksym-vanilla-or51132-attach \
ksym-vanilla-or51211-attach \
ksym-vanilla-orderly-poweroff \
ksym-vanilla-orderly-reboot \
ksym-vanilla-osc-cpc-flexible-adr-space-confirmed \
ksym-vanilla-osc-pc-lpi-support-confirmed \
ksym-vanilla-osc-sb-native-usb4-control \
ksym-vanilla-osc-sb-native-usb4-support-confirmed \
ksym-vanilla-osd-req-op-alloc-hint-init \
ksym-vanilla-osd-req-op-cls-init \
ksym-vanilla-osd-req-op-cls-request-data-bvecs \
ksym-vanilla-osd-req-op-cls-request-data-pages \
ksym-vanilla-osd-req-op-cls-response-data-pages \
ksym-vanilla-osd-req-op-copy-from-init \
ksym-vanilla-osd-req-op-extent-dup-last \
ksym-vanilla-osd-req-op-extent-init \
ksym-vanilla-osd-req-op-extent-osd-data \
ksym-vanilla-osd-req-op-extent-osd-data-bio \
ksym-vanilla-osd-req-op-extent-osd-data-bvec-pos \
ksym-vanilla-osd-req-op-extent-osd-data-bvecs \
ksym-vanilla-osd-req-op-extent-osd-data-pages \
ksym-vanilla-osd-req-op-extent-osd-iter \
ksym-vanilla-osd-req-op-extent-update \
ksym-vanilla-osd-req-op-init \
ksym-vanilla-osd-req-op-raw-data-in-pages \
ksym-vanilla-osd-req-op-xattr-init \
ksym-vanilla-otg-statemachine \
ksym-vanilla-otx-cpt-uc-supports-eng-type \
ksym-vanilla-otx2-alloc-mcam-entries \
ksym-vanilla-otx2-alloc-queue-mem \
ksym-vanilla-otx2-attach-npa-nix \
ksym-vanilla-otx2-config-hwtstamp-get \
ksym-vanilla-otx2-config-hwtstamp-set \
ksym-vanilla-otx2-config-pause-frm \
ksym-vanilla-otx2-config-priority-flow-ctrl \
ksym-vanilla-otx2-cpt-add-write-af-reg \
ksym-vanilla-otx2-cpt-detach-rsrcs-msg \
ksym-vanilla-otx2-cpt-lf-reset-msg \
ksym-vanilla-otx2-cpt-lmtst-tbl-setup-msg \
ksym-vanilla-otx2-cpt-msix-offset-msg \
ksym-vanilla-otx2-cpt-read-af-reg \
ksym-vanilla-otx2-cpt-send-af-reg-requests \
ksym-vanilla-otx2-cpt-send-mbox-msg \
ksym-vanilla-otx2-cpt-send-ready-msg \
ksym-vanilla-otx2-cpt-sync-mbox-msg \
ksym-vanilla-otx2-cpt-write-af-reg \
ksym-vanilla-otx2-cptlf-free-irqs-affinity \
ksym-vanilla-otx2-cptlf-init \
ksym-vanilla-otx2-cptlf-register-done-interrupts \
ksym-vanilla-otx2-cptlf-register-misc-interrupts \
ksym-vanilla-otx2-cptlf-set-irqs-affinity \
ksym-vanilla-otx2-cptlf-shutdown \
ksym-vanilla-otx2-cptlf-unregister-done-interrupts \
ksym-vanilla-otx2-cptlf-unregister-misc-interrupts \
ksym-vanilla-otx2-cq-intr-handler \
ksym-vanilla-otx2-dcbnl-set-ops \
ksym-vanilla-otx2-detach-resources \
ksym-vanilla-otx2-disable-mbox-intr \
ksym-vanilla-otx2-disable-napi \
ksym-vanilla-otx2-free-cints \
ksym-vanilla-otx2-free-hw-resources \
ksym-vanilla-otx2-free-queue-mem \
ksym-vanilla-otx2-get-mac-from-af \
ksym-vanilla-otx2-get-max-mtu \
ksym-vanilla-otx2-get-maxflows \
ksym-vanilla-otx2-get-stats64 \
ksym-vanilla-otx2-handle-ntuple-tc-features \
ksym-vanilla-otx2-hw-set-mtu \
ksym-vanilla-otx2-init-hw-ops \
ksym-vanilla-otx2-init-hw-resources \
ksym-vanilla-otx2-init-rsrc \
ksym-vanilla-otx2-init-tc \
ksym-vanilla-otx2-mbox-alloc-msg-rsp \
ksym-vanilla-otx2-mbox-busy-poll-for-rsp \
ksym-vanilla-otx2-mbox-check-rsp-msgs \
ksym-vanilla-otx2-mbox-destroy \
ksym-vanilla-otx2-mbox-get-rsp \
ksym-vanilla-otx2-mbox-id2name \
ksym-vanilla-otx2-mbox-init \
ksym-vanilla-otx2-mbox-msg-send \
ksym-vanilla-otx2-mbox-msg-send-up \
ksym-vanilla-otx2-mbox-nonempty \
ksym-vanilla-otx2-mbox-regions-init \
ksym-vanilla-otx2-mbox-reset \
ksym-vanilla-otx2-mbox-up-handler-cgx-link-event \
ksym-vanilla-otx2-mbox-up-handler-mcs-intr-notify \
ksym-vanilla-otx2-mbox-wait-for-rsp \
ksym-vanilla-otx2-mbox-wait-for-zero \
ksym-vanilla-otx2-mcam-entry-init \
ksym-vanilla-otx2-mcam-flow-del \
ksym-vanilla-otx2-napi-handler \
ksym-vanilla-otx2-nix-config-bp \
ksym-vanilla-otx2-nix-cpt-config-bp \
ksym-vanilla-otx2-open \
ksym-vanilla-otx2-pfaf-mbox-destroy \
ksym-vanilla-otx2-pfc-txschq-alloc \
ksym-vanilla-otx2-pfc-txschq-config \
ksym-vanilla-otx2-pfc-txschq-stop \
ksym-vanilla-otx2-pfc-txschq-update \
ksym-vanilla-otx2-ptp-clock-index \
ksym-vanilla-otx2-ptp-destroy \
ksym-vanilla-otx2-ptp-init \
ksym-vanilla-otx2-ptp-tstamp2time \
ksym-vanilla-otx2-realloc-msix-vectors \
ksym-vanilla-otx2-register-dl \
ksym-vanilla-otx2-reply-invalid-msg \
ksym-vanilla-otx2-select-queue \
ksym-vanilla-otx2-set-mac-address \
ksym-vanilla-otx2-set-real-num-queues \
ksym-vanilla-otx2-setup-tc \
ksym-vanilla-otx2-setup-tc-cls-flower \
ksym-vanilla-otx2-shutdown-tc \
ksym-vanilla-otx2-smq-flush \
ksym-vanilla-otx2-sq-append-skb \
ksym-vanilla-otx2-stop \
ksym-vanilla-otx2-tc-apply-ingress-police-rules \
ksym-vanilla-otx2-tx-timeout \
ksym-vanilla-otx2-txschq-config \
ksym-vanilla-otx2-txschq-free-one \
ksym-vanilla-otx2-unregister-dl \
ksym-vanilla-otx2-update-bpid-in-rqctx \
ksym-vanilla-otx2-update-rq-stats \
ksym-vanilla-otx2-update-sq-stats \
ksym-vanilla-otx2vf-mcam-flow-init \
ksym-vanilla-otx2vf-set-ethtool-ops \
ksym-vanilla-out-of-line-wait-on-bit \
ksym-vanilla-out-of-line-wait-on-bit-lock \
ksym-vanilla-out-of-line-wait-on-bit-timeout \
ksym-vanilla-overflowgid \
ksym-vanilla-overflowuid \
ksym-vanilla-ovs-netdev-link \
ksym-vanilla-ovs-netdev-tunnel-destroy \
ksym-vanilla-ovs-vport-alloc \
ksym-vanilla-ovs-vport-free \
ksym-vanilla-ovs-vport-ops-unregister \
ksym-vanilla-owl-sps-set-pg \
ksym-vanilla-oxygen-pci-pm \
ksym-vanilla-oxygen-pci-probe \
ksym-vanilla-oxygen-pci-shutdown \
ksym-vanilla-oxygen-read-ac97 \
ksym-vanilla-oxygen-read16 \
ksym-vanilla-oxygen-read32 \
ksym-vanilla-oxygen-read8 \
ksym-vanilla-oxygen-reset-uart \
ksym-vanilla-oxygen-update-dac-routing \
ksym-vanilla-oxygen-write-ac97 \
ksym-vanilla-oxygen-write-ac97-masked \
ksym-vanilla-oxygen-write-i2c \
ksym-vanilla-oxygen-write-spi \
ksym-vanilla-oxygen-write-uart \
ksym-vanilla-oxygen-write16 \
ksym-vanilla-oxygen-write16-masked \
ksym-vanilla-oxygen-write32 \
ksym-vanilla-oxygen-write32-masked \
ksym-vanilla-oxygen-write8 \
ksym-vanilla-oxygen-write8-masked \
ksym-vanilla-p54-free-common \
ksym-vanilla-p54-free-skb \
ksym-vanilla-p54-init-common \
ksym-vanilla-p54-parse-eeprom \
ksym-vanilla-p54-parse-firmware \
ksym-vanilla-p54-read-eeprom \
ksym-vanilla-p54-register-common \
ksym-vanilla-p54-rx \
ksym-vanilla-p54-unregister-common \
ksym-vanilla-p9-client-attach \
ksym-vanilla-p9-client-begin-disconnect \
ksym-vanilla-p9-client-cb \
ksym-vanilla-p9-client-clunk \
ksym-vanilla-p9-client-create \
ksym-vanilla-p9-client-create-dotl \
ksym-vanilla-p9-client-destroy \
ksym-vanilla-p9-client-disconnect \
ksym-vanilla-p9-client-fcreate \
ksym-vanilla-p9-client-fsync \
ksym-vanilla-p9-client-getattr-dotl \
ksym-vanilla-p9-client-getlock-dotl \
ksym-vanilla-p9-client-link \
ksym-vanilla-p9-client-lock-dotl \
ksym-vanilla-p9-client-mkdir-dotl \
ksym-vanilla-p9-client-mknod-dotl \
ksym-vanilla-p9-client-open \
ksym-vanilla-p9-client-read \
ksym-vanilla-p9-client-read-once \
ksym-vanilla-p9-client-readdir \
ksym-vanilla-p9-client-readlink \
ksym-vanilla-p9-client-remove \
ksym-vanilla-p9-client-rename \
ksym-vanilla-p9-client-renameat \
ksym-vanilla-p9-client-setattr \
ksym-vanilla-p9-client-stat \
ksym-vanilla-p9-client-statfs \
ksym-vanilla-p9-client-symlink \
ksym-vanilla-p9-client-unlinkat \
ksym-vanilla-p9-client-walk \
ksym-vanilla-p9-client-write \
ksym-vanilla-p9-client-write-subreq \
ksym-vanilla-p9-client-wstat \
ksym-vanilla-p9-client-xattrcreate \
ksym-vanilla-p9-client-xattrwalk \
ksym-vanilla-p9-error-init \
ksym-vanilla-p9-errstr2errno \
ksym-vanilla-p9-fcall-fini \
ksym-vanilla-p9-is-proto-dotl \
ksym-vanilla-p9-is-proto-dotu \
ksym-vanilla-p9-parse-header \
ksym-vanilla-p9-release-pages \
ksym-vanilla-p9-req-put \
ksym-vanilla-p9-show-client-options \
ksym-vanilla-p9-tag-lookup \
ksym-vanilla-p9dirent-read \
ksym-vanilla-p9stat-free \
ksym-vanilla-p9stat-read \
ksym-vanilla-pack \
ksym-vanilla-pack-fields-u16 \
ksym-vanilla-pack-fields-u8 \
ksym-vanilla-packing \
ksym-vanilla-padata-alloc \
ksym-vanilla-padata-alloc-shell \
ksym-vanilla-padata-do-parallel \
ksym-vanilla-padata-do-serial \
ksym-vanilla-padata-free \
ksym-vanilla-padata-free-shell \
ksym-vanilla-padata-set-cpumask \
ksym-vanilla-paddr-vmcoreinfo-note \
ksym-vanilla-page-cache-async-ra \
ksym-vanilla-page-cache-next-miss \
ksym-vanilla-page-cache-prev-miss \
ksym-vanilla-page-cache-ra-unbounded \
ksym-vanilla-page-cache-sync-ra \
ksym-vanilla-page-cgroup-ino \
ksym-vanilla-page-frag-cache-drain \
ksym-vanilla-page-frag-free \
ksym-vanilla-page-get-link \
ksym-vanilla-page-get-link-raw \
ksym-vanilla-page-is-ram \
ksym-vanilla-page-offline-begin \
ksym-vanilla-page-offline-end \
ksym-vanilla-page-pool-alloc-frag \
ksym-vanilla-page-pool-alloc-frag-netmem \
ksym-vanilla-page-pool-alloc-netmems \
ksym-vanilla-page-pool-alloc-pages \
ksym-vanilla-page-pool-create \
ksym-vanilla-page-pool-create-percpu \
ksym-vanilla-page-pool-destroy \
ksym-vanilla-page-pool-disable-direct-recycling \
ksym-vanilla-page-pool-enable-direct-recycling \
ksym-vanilla-page-pool-ethtool-stats-get \
ksym-vanilla-page-pool-ethtool-stats-get-count \
ksym-vanilla-page-pool-ethtool-stats-get-strings \
ksym-vanilla-page-pool-get-stats \
ksym-vanilla-page-pool-put-netmem-bulk \
ksym-vanilla-page-pool-put-unrefed-netmem \
ksym-vanilla-page-pool-put-unrefed-page \
ksym-vanilla-page-pool-update-nid \
ksym-vanilla-page-put-link \
ksym-vanilla-page-readlink \
ksym-vanilla-page-reporting-order \
ksym-vanilla-page-reporting-register \
ksym-vanilla-page-reporting-unregister \
ksym-vanilla-page-symlink \
ksym-vanilla-page-symlink-inode-operations \
ksym-vanilla-page-table-check-disabled \
ksym-vanilla-pagecache-get-page \
ksym-vanilla-pagecache-isize-extended \
ksym-vanilla-panfrost-pm-ops \
ksym-vanilla-panic \
ksym-vanilla-panic-blink \
ksym-vanilla-panic-in-progress \
ksym-vanilla-panic-notifier-list \
ksym-vanilla-panic-on-other-cpu \
ksym-vanilla-panic-on-this-cpu \
ksym-vanilla-panic-reset \
ksym-vanilla-panic-timeout \
ksym-vanilla-panic-try-start \
ksym-vanilla-par-io-config-pin \
ksym-vanilla-par-io-data-set \
ksym-vanilla-par-io-of-config \
ksym-vanilla-param-array-ops \
ksym-vanilla-param-free-charp \
ksym-vanilla-param-get-bool \
ksym-vanilla-param-get-byte \
ksym-vanilla-param-get-charp \
ksym-vanilla-param-get-dyndbg-classes \
ksym-vanilla-param-get-hexint \
ksym-vanilla-param-get-int \
ksym-vanilla-param-get-invbool \
ksym-vanilla-param-get-long \
ksym-vanilla-param-get-short \
ksym-vanilla-param-get-string \
ksym-vanilla-param-get-uint \
ksym-vanilla-param-get-ullong \
ksym-vanilla-param-get-ulong \
ksym-vanilla-param-get-ushort \
ksym-vanilla-param-ops-bint \
ksym-vanilla-param-ops-bool \
ksym-vanilla-param-ops-bool-enable-only \
ksym-vanilla-param-ops-byte \
ksym-vanilla-param-ops-charp \
ksym-vanilla-param-ops-dyndbg-classes \
ksym-vanilla-param-ops-hexint \
ksym-vanilla-param-ops-int \
ksym-vanilla-param-ops-invbool \
ksym-vanilla-param-ops-long \
ksym-vanilla-param-ops-short \
ksym-vanilla-param-ops-string \
ksym-vanilla-param-ops-uint \
ksym-vanilla-param-ops-ullong \
ksym-vanilla-param-ops-ulong \
ksym-vanilla-param-ops-ushort \
ksym-vanilla-param-set-bint \
ksym-vanilla-param-set-bool \
ksym-vanilla-param-set-bool-enable-only \
ksym-vanilla-param-set-byte \
ksym-vanilla-param-set-charp \
ksym-vanilla-param-set-copystring \
ksym-vanilla-param-set-dyndbg-classes \
ksym-vanilla-param-set-hexint \
ksym-vanilla-param-set-int \
ksym-vanilla-param-set-invbool \
ksym-vanilla-param-set-long \
ksym-vanilla-param-set-short \
ksym-vanilla-param-set-uint \
ksym-vanilla-param-set-uint-minmax \
ksym-vanilla-param-set-ullong \
ksym-vanilla-param-set-ulong \
ksym-vanilla-param-set-ushort \
ksym-vanilla-parman-create \
ksym-vanilla-parman-destroy \
ksym-vanilla-parman-item-add \
ksym-vanilla-parman-item-remove \
ksym-vanilla-parman-prio-fini \
ksym-vanilla-parman-prio-init \
ksym-vanilla-parport-announce-port \
ksym-vanilla-parport-claim \
ksym-vanilla-parport-claim-or-block \
ksym-vanilla-parport-del-port \
ksym-vanilla-parport-find-base \
ksym-vanilla-parport-find-number \
ksym-vanilla-parport-get-port \
ksym-vanilla-parport-ieee1284-ecp-read-data \
ksym-vanilla-parport-ieee1284-ecp-write-addr \
ksym-vanilla-parport-ieee1284-ecp-write-data \
ksym-vanilla-parport-ieee1284-epp-read-addr \
ksym-vanilla-parport-ieee1284-epp-read-data \
ksym-vanilla-parport-ieee1284-epp-write-addr \
ksym-vanilla-parport-ieee1284-epp-write-data \
ksym-vanilla-parport-ieee1284-interrupt \
ksym-vanilla-parport-ieee1284-read-byte \
ksym-vanilla-parport-ieee1284-read-nibble \
ksym-vanilla-parport-ieee1284-write-compat \
ksym-vanilla-parport-irq-handler \
ksym-vanilla-parport-negotiate \
ksym-vanilla-parport-pc-probe-port \
ksym-vanilla-parport-pc-unregister-port \
ksym-vanilla-parport-put-port \
ksym-vanilla-parport-read \
ksym-vanilla-parport-register-dev-model \
ksym-vanilla-parport-register-port \
ksym-vanilla-parport-release \
ksym-vanilla-parport-remove-port \
ksym-vanilla-parport-set-timeout \
ksym-vanilla-parport-unregister-device \
ksym-vanilla-parport-unregister-driver \
ksym-vanilla-parport-wait-event \
ksym-vanilla-parport-wait-peripheral \
ksym-vanilla-parport-write \
ksym-vanilla-parse-OID \
ksym-vanilla-parse-dai-link-info \
ksym-vanilla-parse-int-array \
ksym-vanilla-parse-int-array-user \
ksym-vanilla-pasemi-i2c-common-probe \
ksym-vanilla-pasemi-irq-handler \
ksym-vanilla-passthrough-attrib-attrs \
ksym-vanilla-passthrough-parse-cdb \
ksym-vanilla-passthrough-pr-attrib-attrs \
ksym-vanilla-passthru-features-check \
ksym-vanilla-paste-selection \
ksym-vanilla-pata-parport-register-driver \
ksym-vanilla-pata-parport-unregister-driver \
ksym-vanilla-path-get \
ksym-vanilla-path-has-submounts \
ksym-vanilla-path-is-mountpoint \
ksym-vanilla-path-is-under \
ksym-vanilla-path-put \
ksym-vanilla-pcc-mbox-free-channel \
ksym-vanilla-pcc-mbox-request-channel \
ksym-vanilla-pci-acpi-clear-companion-lookup-hook \
ksym-vanilla-pci-acpi-set-companion-lookup-hook \
ksym-vanilla-pci-add-dynid \
ksym-vanilla-pci-add-new-bus \
ksym-vanilla-pci-add-resource \
ksym-vanilla-pci-add-resource-offset \
ksym-vanilla-pci-aer-clear-nonfatal-status \
ksym-vanilla-pci-aer-unmask-internal-errors \
ksym-vanilla-pci-alloc-dev \
ksym-vanilla-pci-alloc-host-bridge \
ksym-vanilla-pci-alloc-irq-vectors \
ksym-vanilla-pci-alloc-irq-vectors-affinity \
ksym-vanilla-pci-alloc-p2pmem \
ksym-vanilla-pci-assign-resource \
ksym-vanilla-pci-assign-unassigned-bridge-resources \
ksym-vanilla-pci-assign-unassigned-bus-resources \
ksym-vanilla-pci-ats-disabled \
ksym-vanilla-pci-ats-required \
ksym-vanilla-pci-ats-supported \
ksym-vanilla-pci-back-from-sleep \
ksym-vanilla-pci-bridge-emul-cleanup \
ksym-vanilla-pci-bridge-emul-conf-read \
ksym-vanilla-pci-bridge-emul-conf-write \
ksym-vanilla-pci-bridge-emul-init \
ksym-vanilla-pci-bridge-secondary-bus-reset \
ksym-vanilla-pci-bus-add-device \
ksym-vanilla-pci-bus-add-devices \
ksym-vanilla-pci-bus-alloc-resource \
ksym-vanilla-pci-bus-assign-resources \
ksym-vanilla-pci-bus-claim-resources \
ksym-vanilla-pci-bus-find-capability \
ksym-vanilla-pci-bus-find-emul-domain-nr \
ksym-vanilla-pci-bus-max-busnr \
ksym-vanilla-pci-bus-read-config-byte \
ksym-vanilla-pci-bus-read-config-dword \
ksym-vanilla-pci-bus-read-config-word \
ksym-vanilla-pci-bus-read-dev-vendor-id \
ksym-vanilla-pci-bus-release-emul-domain-nr \
ksym-vanilla-pci-bus-resource-n \
ksym-vanilla-pci-bus-set-ops \
ksym-vanilla-pci-bus-size-bridges \
ksym-vanilla-pci-bus-type \
ksym-vanilla-pci-bus-write-config-byte \
ksym-vanilla-pci-bus-write-config-dword \
ksym-vanilla-pci-bus-write-config-word \
ksym-vanilla-pci-cfg-access-lock \
ksym-vanilla-pci-cfg-access-trylock \
ksym-vanilla-pci-cfg-access-unlock \
ksym-vanilla-pci-check-and-mask-intx \
ksym-vanilla-pci-check-and-unmask-intx \
ksym-vanilla-pci-choose-state \
ksym-vanilla-pci-claim-resource \
ksym-vanilla-pci-clear-and-set-config-dword \
ksym-vanilla-pci-clear-master \
ksym-vanilla-pci-clear-mwi \
ksym-vanilla-pci-common-swizzle \
ksym-vanilla-pci-create-root-bus \
ksym-vanilla-pci-create-slot \
ksym-vanilla-pci-d3cold-disable \
ksym-vanilla-pci-d3cold-enable \
ksym-vanilla-pci-destroy-slot \
ksym-vanilla-pci-dev-driver \
ksym-vanilla-pci-dev-get \
ksym-vanilla-pci-dev-lock \
ksym-vanilla-pci-dev-present \
ksym-vanilla-pci-dev-put \
ksym-vanilla-pci-dev-reset-iommu-done \
ksym-vanilla-pci-dev-reset-iommu-prepare \
ksym-vanilla-pci-dev-run-wake \
ksym-vanilla-pci-dev-trylock \
ksym-vanilla-pci-dev-unlock \
ksym-vanilla-pci-device-group \
ksym-vanilla-pci-device-is-present \
ksym-vanilla-pci-disable-ats \
ksym-vanilla-pci-disable-device \
ksym-vanilla-pci-disable-link-state \
ksym-vanilla-pci-disable-link-state-locked \
ksym-vanilla-pci-disable-msi \
ksym-vanilla-pci-disable-msix \
ksym-vanilla-pci-disable-pasid \
ksym-vanilla-pci-disable-pri \
ksym-vanilla-pci-disable-ptm \
ksym-vanilla-pci-disable-rom \
ksym-vanilla-pci-disable-sriov \
ksym-vanilla-pci-doe \
ksym-vanilla-pci-ecam-create \
ksym-vanilla-pci-ecam-free \
ksym-vanilla-pci-ecam-map-bus \
ksym-vanilla-pci-enable-atomic-ops-to-root \
ksym-vanilla-pci-enable-ats \
ksym-vanilla-pci-enable-device \
ksym-vanilla-pci-enable-device-mem \
ksym-vanilla-pci-enable-link-state \
ksym-vanilla-pci-enable-link-state-locked \
ksym-vanilla-pci-enable-msi \
ksym-vanilla-pci-enable-msix-range \
ksym-vanilla-pci-enable-pasid \
ksym-vanilla-pci-enable-ptm \
ksym-vanilla-pci-enable-rom \
ksym-vanilla-pci-enable-sriov \
ksym-vanilla-pci-enable-wake \
ksym-vanilla-pci-ep-cfs-add-epc-group \
ksym-vanilla-pci-ep-cfs-add-epf-group \
ksym-vanilla-pci-ep-cfs-remove-epc-group \
ksym-vanilla-pci-ep-cfs-remove-epf-group \
ksym-vanilla-pci-epc-add-epf \
ksym-vanilla-pci-epc-bar-size-to-rebar-cap \
ksym-vanilla-pci-epc-bus-master-enable-notify \
ksym-vanilla-pci-epc-clear-bar \
ksym-vanilla-pci-epc-deinit-notify \
ksym-vanilla-pci-epc-destroy \
ksym-vanilla-pci-epc-get \
ksym-vanilla-pci-epc-get-aux-resources \
ksym-vanilla-pci-epc-get-aux-resources-count \
ksym-vanilla-pci-epc-get-features \
ksym-vanilla-pci-epc-get-first-free-bar \
ksym-vanilla-pci-epc-get-msi \
ksym-vanilla-pci-epc-get-msix \
ksym-vanilla-pci-epc-get-next-free-bar \
ksym-vanilla-pci-epc-init-notify \
ksym-vanilla-pci-epc-linkdown \
ksym-vanilla-pci-epc-linkup \
ksym-vanilla-pci-epc-map-addr \
ksym-vanilla-pci-epc-map-msi-irq \
ksym-vanilla-pci-epc-mem-alloc-addr \
ksym-vanilla-pci-epc-mem-exit \
ksym-vanilla-pci-epc-mem-free-addr \
ksym-vanilla-pci-epc-mem-init \
ksym-vanilla-pci-epc-mem-map \
ksym-vanilla-pci-epc-mem-unmap \
ksym-vanilla-pci-epc-multi-mem-init \
ksym-vanilla-pci-epc-notify-pending-init \
ksym-vanilla-pci-epc-put \
ksym-vanilla-pci-epc-raise-irq \
ksym-vanilla-pci-epc-remove-epf \
ksym-vanilla-pci-epc-set-bar \
ksym-vanilla-pci-epc-set-msi \
ksym-vanilla-pci-epc-set-msix \
ksym-vanilla-pci-epc-start \
ksym-vanilla-pci-epc-stop \
ksym-vanilla-pci-epc-unmap-addr \
ksym-vanilla-pci-epc-write-header \
ksym-vanilla-pci-epf-add-vepf \
ksym-vanilla-pci-epf-align-inbound-addr \
ksym-vanilla-pci-epf-alloc-doorbell \
ksym-vanilla-pci-epf-alloc-space \
ksym-vanilla-pci-epf-assign-bar-space \
ksym-vanilla-pci-epf-bind \
ksym-vanilla-pci-epf-create \
ksym-vanilla-pci-epf-destroy \
ksym-vanilla-pci-epf-free-doorbell \
ksym-vanilla-pci-epf-free-space \
ksym-vanilla-pci-epf-remove-vepf \
ksym-vanilla-pci-epf-unbind \
ksym-vanilla-pci-epf-unregister-driver \
ksym-vanilla-pci-find-bus \
ksym-vanilla-pci-find-capability \
ksym-vanilla-pci-find-doe-mailbox \
ksym-vanilla-pci-find-dvsec-capability \
ksym-vanilla-pci-find-ext-capability \
ksym-vanilla-pci-find-host-bridge \
ksym-vanilla-pci-find-ht-capability \
ksym-vanilla-pci-find-next-bus \
ksym-vanilla-pci-find-next-capability \
ksym-vanilla-pci-find-next-ext-capability \
ksym-vanilla-pci-find-next-ht-capability \
ksym-vanilla-pci-find-parent-resource \
ksym-vanilla-pci-find-resource \
ksym-vanilla-pci-find-vsec-capability \
ksym-vanilla-pci-fixup-device \
ksym-vanilla-pci-flags \
ksym-vanilla-pci-free-host-bridge \
ksym-vanilla-pci-free-irq \
ksym-vanilla-pci-free-irq-vectors \
ksym-vanilla-pci-free-p2pmem \
ksym-vanilla-pci-free-resource-list \
ksym-vanilla-pci-generic-cam-ops \
ksym-vanilla-pci-generic-config-read \
ksym-vanilla-pci-generic-config-read32 \
ksym-vanilla-pci-generic-config-write \
ksym-vanilla-pci-generic-config-write32 \
ksym-vanilla-pci-generic-ecam-ops \
ksym-vanilla-pci-get-base-class \
ksym-vanilla-pci-get-class \
ksym-vanilla-pci-get-device \
ksym-vanilla-pci-get-device-reverse \
ksym-vanilla-pci-get-domain-bus-and-slot \
ksym-vanilla-pci-get-dsn \
ksym-vanilla-pci-get-host-bridge-device \
ksym-vanilla-pci-get-slot \
ksym-vanilla-pci-get-subsys \
ksym-vanilla-pci-host-common-d3cold-possible \
ksym-vanilla-pci-host-common-delete-ports \
ksym-vanilla-pci-host-common-ecam-create \
ksym-vanilla-pci-host-common-init \
ksym-vanilla-pci-host-common-parse-ports \
ksym-vanilla-pci-host-common-probe \
ksym-vanilla-pci-host-common-remove \
ksym-vanilla-pci-host-probe \
ksym-vanilla-pci-hp-add \
ksym-vanilla-pci-hp-add-bridge \
ksym-vanilla-pci-hp-del \
ksym-vanilla-pci-hp-deregister \
ksym-vanilla-pci-hp-destroy \
ksym-vanilla-pci-ide-set-nr-streams \
ksym-vanilla-pci-ide-stream-alloc \
ksym-vanilla-pci-ide-stream-disable \
ksym-vanilla-pci-ide-stream-enable \
ksym-vanilla-pci-ide-stream-free \
ksym-vanilla-pci-ide-stream-register \
ksym-vanilla-pci-ide-stream-release \
ksym-vanilla-pci-ide-stream-setup \
ksym-vanilla-pci-ide-stream-teardown \
ksym-vanilla-pci-ide-stream-unregister \
ksym-vanilla-pci-ide-to-settings \
ksym-vanilla-pci-ignore-hotplug \
ksym-vanilla-pci-intx \
ksym-vanilla-pci-iomap \
ksym-vanilla-pci-iomap-range \
ksym-vanilla-pci-iomap-wc \
ksym-vanilla-pci-iomap-wc-range \
ksym-vanilla-pci-ioremap-bar \
ksym-vanilla-pci-ioremap-wc-bar \
ksym-vanilla-pci-iounmap \
ksym-vanilla-pci-iov-get-pf-drvdata \
ksym-vanilla-pci-iov-vf-bar-get-sizes \
ksym-vanilla-pci-iov-vf-bar-set-size \
ksym-vanilla-pci-iov-vf-id \
ksym-vanilla-pci-iov-virtfn-devfn \
ksym-vanilla-pci-irq-get-affinity \
ksym-vanilla-pci-irq-vector \
ksym-vanilla-pci-load-and-free-saved-state \
ksym-vanilla-pci-load-saved-state \
ksym-vanilla-pci-lock-rescan-remove \
ksym-vanilla-pci-map-rom \
ksym-vanilla-pci-match-id \
ksym-vanilla-pci-max-pasids \
ksym-vanilla-pci-msi-enabled \
ksym-vanilla-pci-msi-mask-irq \
ksym-vanilla-pci-msi-unmask-irq \
ksym-vanilla-pci-msi-vec-count \
ksym-vanilla-pci-msix-alloc-irq-at \
ksym-vanilla-pci-msix-can-alloc-dyn \
ksym-vanilla-pci-msix-free-irq \
ksym-vanilla-pci-msix-prepare-desc \
ksym-vanilla-pci-msix-vec-count \
ksym-vanilla-pci-num-vf \
ksym-vanilla-pci-p2pdma-add-resource \
ksym-vanilla-pci-p2pdma-distance-many \
ksym-vanilla-pci-p2pdma-enable-show \
ksym-vanilla-pci-p2pdma-enable-store \
ksym-vanilla-pci-p2pmem-alloc-sgl \
ksym-vanilla-pci-p2pmem-find-many \
ksym-vanilla-pci-p2pmem-free-sgl \
ksym-vanilla-pci-p2pmem-publish \
ksym-vanilla-pci-p2pmem-virt-to-bus \
ksym-vanilla-pci-pasid-features \
ksym-vanilla-pci-pasid-status \
ksym-vanilla-pci-pci-problems \
ksym-vanilla-pci-pio-to-address \
ksym-vanilla-pci-platform-power-transition \
ksym-vanilla-pci-pme-active \
ksym-vanilla-pci-pme-capable \
ksym-vanilla-pci-power-names \
ksym-vanilla-pci-pr3-present \
ksym-vanilla-pci-prepare-ats \
ksym-vanilla-pci-prepare-to-sleep \
ksym-vanilla-pci-pri-supported \
ksym-vanilla-pci-print-aer \
ksym-vanilla-pci-probe-reset-bus \
ksym-vanilla-pci-probe-reset-slot \
ksym-vanilla-pci-pwrctrl-create-devices \
ksym-vanilla-pci-pwrctrl-destroy-devices \
ksym-vanilla-pci-pwrctrl-device-set-ready \
ksym-vanilla-pci-pwrctrl-device-unset-ready \
ksym-vanilla-pci-pwrctrl-init \
ksym-vanilla-pci-pwrctrl-power-off-devices \
ksym-vanilla-pci-pwrctrl-power-on-devices \
ksym-vanilla-pci-read-config-byte \
ksym-vanilla-pci-read-config-dword \
ksym-vanilla-pci-read-config-word \
ksym-vanilla-pci-read-vpd \
ksym-vanilla-pci-read-vpd-any \
ksym-vanilla-pci-rebar-bytes-to-size \
ksym-vanilla-pci-rebar-get-max-size \
ksym-vanilla-pci-rebar-get-possible-sizes \
ksym-vanilla-pci-rebar-size-supported \
ksym-vanilla-pci-rebar-size-to-bytes \
ksym-vanilla-pci-reenable-device \
ksym-vanilla-pci-release-region \
ksym-vanilla-pci-release-regions \
ksym-vanilla-pci-release-resource \
ksym-vanilla-pci-release-selected-regions \
ksym-vanilla-pci-remap-iospace \
ksym-vanilla-pci-remove-bus \
ksym-vanilla-pci-remove-root-bus \
ksym-vanilla-pci-request-irq \
ksym-vanilla-pci-request-region \
ksym-vanilla-pci-request-regions \
ksym-vanilla-pci-request-regions-exclusive \
ksym-vanilla-pci-request-selected-regions \
ksym-vanilla-pci-request-selected-regions-exclusive \
ksym-vanilla-pci-rescan-bus \
ksym-vanilla-pci-reset-bus \
ksym-vanilla-pci-reset-function \
ksym-vanilla-pci-reset-function-locked \
ksym-vanilla-pci-resize-resource \
ksym-vanilla-pci-restore-msi-state \
ksym-vanilla-pci-restore-state \
ksym-vanilla-pci-root-buses \
ksym-vanilla-pci-save-state \
ksym-vanilla-pci-scan-bridge \
ksym-vanilla-pci-scan-bus \
ksym-vanilla-pci-scan-child-bus \
ksym-vanilla-pci-scan-root-bus \
ksym-vanilla-pci-scan-root-bus-bridge \
ksym-vanilla-pci-scan-single-device \
ksym-vanilla-pci-scan-slot \
ksym-vanilla-pci-select-bars \
ksym-vanilla-pci-set-cacheline-size \
ksym-vanilla-pci-set-host-bridge-release \
ksym-vanilla-pci-set-master \
ksym-vanilla-pci-set-mwi \
ksym-vanilla-pci-set-pcie-reset-state \
ksym-vanilla-pci-set-power-state \
ksym-vanilla-pci-set-power-state-locked \
ksym-vanilla-pci-slots-kset \
ksym-vanilla-pci-speed-string \
ksym-vanilla-pci-sriov-configure-simple \
ksym-vanilla-pci-sriov-get-totalvfs \
ksym-vanilla-pci-sriov-set-totalvfs \
ksym-vanilla-pci-status-get-and-clear-errors \
ksym-vanilla-pci-stop-and-remove-bus-device \
ksym-vanilla-pci-stop-and-remove-bus-device-locked \
ksym-vanilla-pci-stop-root-bus \
ksym-vanilla-pci-store-saved-state \
ksym-vanilla-pci-suspend-retains-context \
ksym-vanilla-pci-test-config-bits \
ksym-vanilla-pci-try-reset-function \
ksym-vanilla-pci-try-set-mwi \
ksym-vanilla-pci-tsm-bind \
ksym-vanilla-pci-tsm-doe-transfer \
ksym-vanilla-pci-tsm-guest-req \
ksym-vanilla-pci-tsm-link-constructor \
ksym-vanilla-pci-tsm-pf0-constructor \
ksym-vanilla-pci-tsm-pf0-destructor \
ksym-vanilla-pci-tsm-tdi-constructor \
ksym-vanilla-pci-tsm-unbind \
ksym-vanilla-pci-unlock-rescan-remove \
ksym-vanilla-pci-unmap-iospace \
ksym-vanilla-pci-unmap-rom \
ksym-vanilla-pci-unregister-driver \
ksym-vanilla-pci-user-read-config-byte \
ksym-vanilla-pci-user-read-config-dword \
ksym-vanilla-pci-user-read-config-word \
ksym-vanilla-pci-user-write-config-byte \
ksym-vanilla-pci-user-write-config-dword \
ksym-vanilla-pci-user-write-config-word \
ksym-vanilla-pci-vfs-assigned \
ksym-vanilla-pci-vpd-alloc \
ksym-vanilla-pci-vpd-check-csum \
ksym-vanilla-pci-vpd-find-id-string \
ksym-vanilla-pci-vpd-find-ro-info-keyword \
ksym-vanilla-pci-wait-for-pending-transaction \
ksym-vanilla-pci-wake-from-d3 \
ksym-vanilla-pci-walk-bus \
ksym-vanilla-pci-walk-bus-reverse \
ksym-vanilla-pci-write-config-byte \
ksym-vanilla-pci-write-config-dword \
ksym-vanilla-pci-write-config-word \
ksym-vanilla-pci-write-msi-msg \
ksym-vanilla-pci-write-vpd \
ksym-vanilla-pci-write-vpd-any \
ksym-vanilla-pcibios-bus-to-resource \
ksym-vanilla-pcibios-resource-to-bus \
ksym-vanilla-pcibus-to-node \
ksym-vanilla-pcie-aer-is-native \
ksym-vanilla-pcie-aspm-enabled \
ksym-vanilla-pcie-bandwidth-available \
ksym-vanilla-pcie-bus-configure-settings \
ksym-vanilla-pcie-capability-clear-and-set-dword \
ksym-vanilla-pcie-capability-clear-and-set-word-locked \
ksym-vanilla-pcie-capability-clear-and-set-word-unlocked \
ksym-vanilla-pcie-capability-read-dword \
ksym-vanilla-pcie-capability-read-word \
ksym-vanilla-pcie-capability-write-dword \
ksym-vanilla-pcie-capability-write-word \
ksym-vanilla-pcie-disable-tph \
ksym-vanilla-pcie-enable-tph \
ksym-vanilla-pcie-encode-t-power-on \
ksym-vanilla-pcie-flr \
ksym-vanilla-pcie-get-link-speed \
ksym-vanilla-pcie-get-mps \
ksym-vanilla-pcie-get-readrq \
ksym-vanilla-pcie-get-speed-cap \
ksym-vanilla-pcie-get-width-cap \
ksym-vanilla-pcie-link-speed \
ksym-vanilla-pcie-link-speed-mbps \
ksym-vanilla-pcie-port-find-device \
ksym-vanilla-pcie-print-link-status \
ksym-vanilla-pcie-ptm-create-debugfs \
ksym-vanilla-pcie-ptm-destroy-debugfs \
ksym-vanilla-pcie-ptm-enabled \
ksym-vanilla-pcie-relaxed-ordering-enabled \
ksym-vanilla-pcie-reset-flr \
ksym-vanilla-pcie-set-mps \
ksym-vanilla-pcie-set-readrq \
ksym-vanilla-pcie-tph-get-cpu-st \
ksym-vanilla-pcie-tph-get-st-table-loc \
ksym-vanilla-pcie-tph-get-st-table-size \
ksym-vanilla-pcie-tph-set-st-entry \
ksym-vanilla-pcie-update-link-speed \
ksym-vanilla-pcim-enable-device \
ksym-vanilla-pcim-intx \
ksym-vanilla-pcim-iomap \
ksym-vanilla-pcim-iomap-range \
ksym-vanilla-pcim-iomap-region \
ksym-vanilla-pcim-iomap-regions \
ksym-vanilla-pcim-iomap-table \
ksym-vanilla-pcim-iounmap \
ksym-vanilla-pcim-iounmap-region \
ksym-vanilla-pcim-p2pdma-init \
ksym-vanilla-pcim-p2pdma-provider \
ksym-vanilla-pcim-pin-device \
ksym-vanilla-pcim-request-all-regions \
ksym-vanilla-pcim-request-region \
ksym-vanilla-pcim-set-mwi \
ksym-vanilla-pciserial-init-ports \
ksym-vanilla-pciserial-remove-ports \
ksym-vanilla-pciserial-resume-ports \
ksym-vanilla-pciserial-suspend-ports \
ksym-vanilla-pcix-get-max-mmrbc \
ksym-vanilla-pcix-get-mmrbc \
ksym-vanilla-pcix-set-mmrbc \
ksym-vanilla-pcm1789-common-exit \
ksym-vanilla-pcm1789-common-init \
ksym-vanilla-pcm1789-regmap-config \
ksym-vanilla-pcm179x-common-init \
ksym-vanilla-pcm179x-regmap-config \
ksym-vanilla-pcm186x-probe \
ksym-vanilla-pcm186x-regmap \
ksym-vanilla-pcm3060-probe \
ksym-vanilla-pcm3060-regmap \
ksym-vanilla-pcm512x-pm-ops \
ksym-vanilla-pcm512x-probe \
ksym-vanilla-pcm512x-regmap \
ksym-vanilla-pcm512x-remove \
ksym-vanilla-pcpu-alloc-noprof \
ksym-vanilla-pdr-add-lookup \
ksym-vanilla-pdr-handle-alloc \
ksym-vanilla-pdr-handle-release \
ksym-vanilla-pdr-restart-pd \
ksym-vanilla-pds-client-adminq-cmd \
ksym-vanilla-pds-client-register \
ksym-vanilla-pds-client-unregister \
ksym-vanilla-pdsc-adminq-post \
ksym-vanilla-pdsc-get-pf-struct \
ksym-vanilla-pdsc-register-notify \
ksym-vanilla-pdsc-unregister-notify \
ksym-vanilla-peernet2id \
ksym-vanilla-peernet2id-alloc \
ksym-vanilla-pef2256-get-regmap \
ksym-vanilla-pef2256-get-version \
ksym-vanilla-percpu-counter-add-batch \
ksym-vanilla-percpu-counter-batch \
ksym-vanilla-percpu-counter-destroy-many \
ksym-vanilla-percpu-counter-set \
ksym-vanilla-percpu-counter-sync \
ksym-vanilla-percpu-down-write \
ksym-vanilla-percpu-free-rwsem \
ksym-vanilla-percpu-is-read-locked \
ksym-vanilla-percpu-ref-exit \
ksym-vanilla-percpu-ref-init \
ksym-vanilla-percpu-ref-is-zero \
ksym-vanilla-percpu-ref-kill-and-confirm \
ksym-vanilla-percpu-ref-reinit \
ksym-vanilla-percpu-ref-resurrect \
ksym-vanilla-percpu-ref-switch-to-atomic \
ksym-vanilla-percpu-ref-switch-to-atomic-sync \
ksym-vanilla-percpu-ref-switch-to-percpu \
ksym-vanilla-percpu-up-write \
ksym-vanilla-perf-allow-kernel \
ksym-vanilla-perf-aux-output-begin \
ksym-vanilla-perf-aux-output-end \
ksym-vanilla-perf-aux-output-flag \
ksym-vanilla-perf-aux-output-skip \
ksym-vanilla-perf-event-addr-filters-sync \
ksym-vanilla-perf-event-cgrp-subsys-enabled-key \
ksym-vanilla-perf-event-cgrp-subsys-on-dfl-key \
ksym-vanilla-perf-event-create-kernel-counter \
ksym-vanilla-perf-event-disable \
ksym-vanilla-perf-event-enable \
ksym-vanilla-perf-event-pause \
ksym-vanilla-perf-event-period \
ksym-vanilla-perf-event-read-value \
ksym-vanilla-perf-event-refresh \
ksym-vanilla-perf-event-release-kernel \
ksym-vanilla-perf-event-sysfs-show \
ksym-vanilla-perf-event-update-userpage \
ksym-vanilla-perf-get-aux \
ksym-vanilla-perf-pmu-migrate-context \
ksym-vanilla-perf-pmu-register \
ksym-vanilla-perf-pmu-unregister \
ksym-vanilla-perf-register-guest-info-callbacks \
ksym-vanilla-perf-report-aux-output-id \
ksym-vanilla-perf-swevent-get-recursion-context \
ksym-vanilla-perf-tp-event \
ksym-vanilla-perf-trace-buf-alloc \
ksym-vanilla-perf-trace-run-bpf-submit \
ksym-vanilla-perf-unregister-guest-info-callbacks \
ksym-vanilla-pfifo-fast-ops \
ksym-vanilla-pfifo-qdisc-ops \
ksym-vanilla-pfn-is-map-memory \
ksym-vanilla-pfn-to-online-page \
ksym-vanilla-phonet-header-ops \
ksym-vanilla-phonet-proto-register \
ksym-vanilla-phonet-proto-unregister \
ksym-vanilla-phonet-stream-ops \
ksym-vanilla-phy-10gbit-features \
ksym-vanilla-phy-advertise-eee-all \
ksym-vanilla-phy-advertise-supported \
ksym-vanilla-phy-aneg-done \
ksym-vanilla-phy-attach-direct \
ksym-vanilla-phy-attached-info \
ksym-vanilla-phy-attached-info-irq \
ksym-vanilla-phy-attached-print \
ksym-vanilla-phy-basic-features \
ksym-vanilla-phy-basic-ports-array \
ksym-vanilla-phy-basic-t1-features \
ksym-vanilla-phy-basic-t1s-p2mp-features \
ksym-vanilla-phy-calibrate \
ksym-vanilla-phy-caps-from-interface \
ksym-vanilla-phy-caps-linkmodes \
ksym-vanilla-phy-caps-lookup \
ksym-vanilla-phy-caps-medium-get-supported \
ksym-vanilla-phy-caps-mediums-from-linkmodes \
ksym-vanilla-phy-check-valid \
ksym-vanilla-phy-config-aneg \
ksym-vanilla-phy-config-inband \
ksym-vanilla-phy-configure \
ksym-vanilla-phy-connect \
ksym-vanilla-phy-connect-direct \
ksym-vanilla-phy-create \
ksym-vanilla-phy-create-lookup \
ksym-vanilla-phy-destroy \
ksym-vanilla-phy-detach \
ksym-vanilla-phy-device-create \
ksym-vanilla-phy-device-free \
ksym-vanilla-phy-device-register \
ksym-vanilla-phy-device-remove \
ksym-vanilla-phy-disable-eee \
ksym-vanilla-phy-disconnect \
ksym-vanilla-phy-do-ioctl \
ksym-vanilla-phy-do-ioctl-running \
ksym-vanilla-phy-drivers-register \
ksym-vanilla-phy-drivers-unregister \
ksym-vanilla-phy-duplex-to-str \
ksym-vanilla-phy-eee-cap1-features \
ksym-vanilla-phy-eee-cap2-features \
ksym-vanilla-phy-eee-rx-clock-stop \
ksym-vanilla-phy-eee-tx-clock-stop-capable \
ksym-vanilla-phy-error \
ksym-vanilla-phy-ethtool-get-eee \
ksym-vanilla-phy-ethtool-get-link-ksettings \
ksym-vanilla-phy-ethtool-get-sset-count \
ksym-vanilla-phy-ethtool-get-stats \
ksym-vanilla-phy-ethtool-get-strings \
ksym-vanilla-phy-ethtool-get-wol \
ksym-vanilla-phy-ethtool-ksettings-get \
ksym-vanilla-phy-ethtool-ksettings-set \
ksym-vanilla-phy-ethtool-nway-reset \
ksym-vanilla-phy-ethtool-set-eee \
ksym-vanilla-phy-ethtool-set-link-ksettings \
ksym-vanilla-phy-ethtool-set-wol \
ksym-vanilla-phy-exit \
ksym-vanilla-phy-find-next \
ksym-vanilla-phy-fix-phy-mode-for-mac-delays \
ksym-vanilla-phy-free-interrupt \
ksym-vanilla-phy-gbit-features \
ksym-vanilla-phy-gbit-fibre-features \
ksym-vanilla-phy-get \
ksym-vanilla-phy-get-c45-ids \
ksym-vanilla-phy-get-eee-err \
ksym-vanilla-phy-get-internal-delay \
ksym-vanilla-phy-get-mac-termination \
ksym-vanilla-phy-get-manual-rx-polarity \
ksym-vanilla-phy-get-manual-tx-polarity \
ksym-vanilla-phy-get-pause \
ksym-vanilla-phy-get-rate-matching \
ksym-vanilla-phy-get-rx-polarity \
ksym-vanilla-phy-get-sfp-port \
ksym-vanilla-phy-get-tx-amplitude-gain \
ksym-vanilla-phy-get-tx-polarity \
ksym-vanilla-phy-inband-caps \
ksym-vanilla-phy-init \
ksym-vanilla-phy-init-eee \
ksym-vanilla-phy-init-hw \
ksym-vanilla-phy-interface-num-ports \
ksym-vanilla-phy-interface-to-lane-mode \
ksym-vanilla-phy-led-trigger-change-speed \
ksym-vanilla-phy-led-triggers-register \
ksym-vanilla-phy-led-triggers-unregister \
ksym-vanilla-phy-link-topo-add-phy \
ksym-vanilla-phy-link-topo-del-phy \
ksym-vanilla-phy-loopback \
ksym-vanilla-phy-mac-interrupt \
ksym-vanilla-phy-may-wakeup \
ksym-vanilla-phy-mii-ioctl \
ksym-vanilla-phy-mipi-dphy-config-validate \
ksym-vanilla-phy-mipi-dphy-get-default-config \
ksym-vanilla-phy-mipi-dphy-get-default-config-for-hsclk \
ksym-vanilla-phy-modify \
ksym-vanilla-phy-modify-changed \
ksym-vanilla-phy-modify-mmd \
ksym-vanilla-phy-modify-mmd-changed \
ksym-vanilla-phy-modify-paged \
ksym-vanilla-phy-modify-paged-changed \
ksym-vanilla-phy-notify-connect \
ksym-vanilla-phy-notify-disconnect \
ksym-vanilla-phy-notify-state \
ksym-vanilla-phy-of-parse-port \
ksym-vanilla-phy-package-get-node \
ksym-vanilla-phy-package-get-priv \
ksym-vanilla-phy-package-init-once \
ksym-vanilla-phy-package-join \
ksym-vanilla-phy-package-leave \
ksym-vanilla-phy-package-probe-once \
ksym-vanilla-phy-pm-runtime-get \
ksym-vanilla-phy-pm-runtime-get-sync \
ksym-vanilla-phy-pm-runtime-put \
ksym-vanilla-phy-pm-runtime-put-sync \
ksym-vanilla-phy-port-alloc \
ksym-vanilla-phy-port-destroy \
ksym-vanilla-phy-port-get-type \
ksym-vanilla-phy-port-restrict-mediums \
ksym-vanilla-phy-port-update-supported \
ksym-vanilla-phy-power-off \
ksym-vanilla-phy-power-on \
ksym-vanilla-phy-print-status \
ksym-vanilla-phy-put \
ksym-vanilla-phy-rate-matching-to-str \
ksym-vanilla-phy-read-mmd \
ksym-vanilla-phy-read-paged \
ksym-vanilla-phy-register-fixup-for-id \
ksym-vanilla-phy-register-fixup-for-uid \
ksym-vanilla-phy-remove-link-mode \
ksym-vanilla-phy-remove-lookup \
ksym-vanilla-phy-request-interrupt \
ksym-vanilla-phy-reset \
ksym-vanilla-phy-reset-after-clk-enable \
ksym-vanilla-phy-resolve-aneg-linkmode \
ksym-vanilla-phy-resolve-aneg-pause \
ksym-vanilla-phy-restart-aneg \
ksym-vanilla-phy-restore-page \
ksym-vanilla-phy-resume \
ksym-vanilla-phy-save-page \
ksym-vanilla-phy-select-page \
ksym-vanilla-phy-set-asym-pause \
ksym-vanilla-phy-set-max-speed \
ksym-vanilla-phy-set-media \
ksym-vanilla-phy-set-mode-ext \
ksym-vanilla-phy-set-speed \
ksym-vanilla-phy-set-sym-pause \
ksym-vanilla-phy-speed-down \
ksym-vanilla-phy-speed-to-str \
ksym-vanilla-phy-speed-up \
ksym-vanilla-phy-start \
ksym-vanilla-phy-start-aneg \
ksym-vanilla-phy-start-cable-test \
ksym-vanilla-phy-start-cable-test-tdr \
ksym-vanilla-phy-start-machine \
ksym-vanilla-phy-stop \
ksym-vanilla-phy-support-asym-pause \
ksym-vanilla-phy-support-eee \
ksym-vanilla-phy-support-sym-pause \
ksym-vanilla-phy-suspend \
ksym-vanilla-phy-trigger-machine \
ksym-vanilla-phy-validate \
ksym-vanilla-phy-validate-pause \
ksym-vanilla-phy-write-mmd \
ksym-vanilla-phy-write-paged \
ksym-vanilla-phylib-stubs \
ksym-vanilla-phylink-connect-phy \
ksym-vanilla-phylink-create \
ksym-vanilla-phylink-decode-usxgmii-word \
ksym-vanilla-phylink-destroy \
ksym-vanilla-phylink-disconnect-phy \
ksym-vanilla-phylink-ethtool-get-eee \
ksym-vanilla-phylink-ethtool-get-pauseparam \
ksym-vanilla-phylink-ethtool-get-wol \
ksym-vanilla-phylink-ethtool-ksettings-get \
ksym-vanilla-phylink-ethtool-ksettings-set \
ksym-vanilla-phylink-ethtool-nway-reset \
ksym-vanilla-phylink-ethtool-set-eee \
ksym-vanilla-phylink-ethtool-set-pauseparam \
ksym-vanilla-phylink-ethtool-set-wol \
ksym-vanilla-phylink-expects-phy \
ksym-vanilla-phylink-fwnode-phy-connect \
ksym-vanilla-phylink-get-eee-err \
ksym-vanilla-phylink-limit-mac-speed \
ksym-vanilla-phylink-mac-change \
ksym-vanilla-phylink-mii-c22-pcs-an-restart \
ksym-vanilla-phylink-mii-c22-pcs-config \
ksym-vanilla-phylink-mii-c22-pcs-decode-state \
ksym-vanilla-phylink-mii-c22-pcs-encode-advertisement \
ksym-vanilla-phylink-mii-c22-pcs-get-state \
ksym-vanilla-phylink-mii-c45-pcs-get-state \
ksym-vanilla-phylink-mii-ioctl \
ksym-vanilla-phylink-of-phy-connect \
ksym-vanilla-phylink-pcs-change \
ksym-vanilla-phylink-pcs-pre-init \
ksym-vanilla-phylink-prepare-resume \
ksym-vanilla-phylink-replay-link-begin \
ksym-vanilla-phylink-replay-link-end \
ksym-vanilla-phylink-resolve-c73 \
ksym-vanilla-phylink-resume \
ksym-vanilla-phylink-rx-clk-stop-block \
ksym-vanilla-phylink-rx-clk-stop-unblock \
ksym-vanilla-phylink-set-fixed-link \
ksym-vanilla-phylink-set-port-modes \
ksym-vanilla-phylink-speed-down \
ksym-vanilla-phylink-speed-up \
ksym-vanilla-phylink-start \
ksym-vanilla-phylink-stop \
ksym-vanilla-phylink-suspend \
ksym-vanilla-phys-mem-access-prot \
ksym-vanilla-phys-to-target-node \
ksym-vanilla-pid-nr-ns \
ksym-vanilla-pid-task \
ksym-vanilla-pid-vnr \
ksym-vanilla-pids-cgrp-subsys-enabled-key \
ksym-vanilla-pids-cgrp-subsys-on-dfl-key \
ksym-vanilla-pie-calculate-probability \
ksym-vanilla-pie-drop-early \
ksym-vanilla-pie-process-dequeue \
ksym-vanilla-piix4-sb800-port-sel \
ksym-vanilla-piix4-sb800-region-release \
ksym-vanilla-piix4-sb800-region-request \
ksym-vanilla-piix4-transaction \
ksym-vanilla-pin-get-name \
ksym-vanilla-pin-user-pages \
ksym-vanilla-pin-user-pages-fast \
ksym-vanilla-pin-user-pages-remote \
ksym-vanilla-pin-user-pages-unlocked \
ksym-vanilla-pinconf-generic-dt-free-map \
ksym-vanilla-pinconf-generic-dt-node-to-map \
ksym-vanilla-pinconf-generic-dt-subnode-to-map \
ksym-vanilla-pinconf-generic-dump-config \
ksym-vanilla-pinconf-generic-parse-dt-config \
ksym-vanilla-pinconf-generic-parse-dt-pinmux \
ksym-vanilla-pinctrl-add-gpio-range \
ksym-vanilla-pinctrl-add-gpio-ranges \
ksym-vanilla-pinctrl-count-index-with-args \
ksym-vanilla-pinctrl-dev-get-devname \
ksym-vanilla-pinctrl-dev-get-drvdata \
ksym-vanilla-pinctrl-dev-get-name \
ksym-vanilla-pinctrl-enable \
ksym-vanilla-pinctrl-find-and-add-gpio-range \
ksym-vanilla-pinctrl-find-gpio-range-from-pin \
ksym-vanilla-pinctrl-find-gpio-range-from-pin-nolock \
ksym-vanilla-pinctrl-force-default \
ksym-vanilla-pinctrl-force-sleep \
ksym-vanilla-pinctrl-generic-add-group \
ksym-vanilla-pinctrl-generic-get-group \
ksym-vanilla-pinctrl-generic-get-group-count \
ksym-vanilla-pinctrl-generic-get-group-name \
ksym-vanilla-pinctrl-generic-get-group-pins \
ksym-vanilla-pinctrl-generic-pinmux-dt-node-to-map \
ksym-vanilla-pinctrl-generic-pins-function-dt-node-to-map \
ksym-vanilla-pinctrl-generic-remove-group \
ksym-vanilla-pinctrl-generic-to-map \
ksym-vanilla-pinctrl-get \
ksym-vanilla-pinctrl-get-group-pins \
ksym-vanilla-pinctrl-get-group-selector \
ksym-vanilla-pinctrl-gpio-can-use-line \
ksym-vanilla-pinctrl-gpio-direction-input \
ksym-vanilla-pinctrl-gpio-direction-output \
ksym-vanilla-pinctrl-gpio-free \
ksym-vanilla-pinctrl-gpio-get-config \
ksym-vanilla-pinctrl-gpio-request \
ksym-vanilla-pinctrl-gpio-set-config \
ksym-vanilla-pinctrl-lookup-state \
ksym-vanilla-pinctrl-parse-index-with-args \
ksym-vanilla-pinctrl-pm-select-default-state \
ksym-vanilla-pinctrl-pm-select-idle-state \
ksym-vanilla-pinctrl-pm-select-init-state \
ksym-vanilla-pinctrl-pm-select-sleep-state \
ksym-vanilla-pinctrl-provide-dummies \
ksym-vanilla-pinctrl-put \
ksym-vanilla-pinctrl-register \
ksym-vanilla-pinctrl-register-and-init \
ksym-vanilla-pinctrl-register-mappings \
ksym-vanilla-pinctrl-remove-gpio-range \
ksym-vanilla-pinctrl-select-default-state \
ksym-vanilla-pinctrl-select-state \
ksym-vanilla-pinctrl-unregister \
ksym-vanilla-pinctrl-unregister-mappings \
ksym-vanilla-pinctrl-utils-add-config \
ksym-vanilla-pinctrl-utils-add-map-configs \
ksym-vanilla-pinctrl-utils-add-map-mux \
ksym-vanilla-pinctrl-utils-free-map \
ksym-vanilla-pinctrl-utils-reserve-map \
ksym-vanilla-pingv6-prot \
ksym-vanilla-pinmux-generic-add-function \
ksym-vanilla-pinmux-generic-add-pinfunction \
ksym-vanilla-pinmux-generic-function-is-gpio \
ksym-vanilla-pinmux-generic-get-function \
ksym-vanilla-pinmux-generic-get-function-count \
ksym-vanilla-pinmux-generic-get-function-groups \
ksym-vanilla-pinmux-generic-get-function-name \
ksym-vanilla-pinmux-generic-remove-function \
ksym-vanilla-pipe-lock \
ksym-vanilla-pipe-unlock \
ksym-vanilla-pkcs7-free-message \
ksym-vanilla-pkcs7-get-content-data \
ksym-vanilla-pkcs7-parse-message \
ksym-vanilla-pkcs7-supply-detached-data \
ksym-vanilla-pkcs7-validate-trust \
ksym-vanilla-pkcs7-verify \
ksym-vanilla-pktgen-xfrm-outer-mode-output \
ksym-vanilla-pl111-versatile-init \
ksym-vanilla-platform-add-devices \
ksym-vanilla-platform-bus \
ksym-vanilla-platform-bus-type \
ksym-vanilla-platform-device-add \
ksym-vanilla-platform-device-add-data \
ksym-vanilla-platform-device-add-resources \
ksym-vanilla-platform-device-alloc \
ksym-vanilla-platform-device-del \
ksym-vanilla-platform-device-msi-free-irqs-all \
ksym-vanilla-platform-device-msi-init-and-alloc-irqs \
ksym-vanilla-platform-device-put \
ksym-vanilla-platform-device-register \
ksym-vanilla-platform-device-register-full \
ksym-vanilla-platform-device-unregister \
ksym-vanilla-platform-driver-unregister \
ksym-vanilla-platform-find-device-by-driver \
ksym-vanilla-platform-get-ethdev-address \
ksym-vanilla-platform-get-irq \
ksym-vanilla-platform-get-irq-affinity \
ksym-vanilla-platform-get-irq-byname \
ksym-vanilla-platform-get-irq-byname-optional \
ksym-vanilla-platform-get-irq-optional \
ksym-vanilla-platform-get-mem-or-io \
ksym-vanilla-platform-get-resource \
ksym-vanilla-platform-get-resource-byname \
ksym-vanilla-platform-irq-count \
ksym-vanilla-platform-irqchip-probe \
ksym-vanilla-platform-profile-cycle \
ksym-vanilla-platform-profile-notify \
ksym-vanilla-platform-profile-register \
ksym-vanilla-platform-profile-remove \
ksym-vanilla-platform-unregister-drivers \
ksym-vanilla-play-idle-precise \
ksym-vanilla-plda-init-interrupts \
ksym-vanilla-plda-pcie-host-deinit \
ksym-vanilla-plda-pcie-host-init \
ksym-vanilla-plda-pcie-map-bus \
ksym-vanilla-plda-pcie-setup-inbound-address-translation \
ksym-vanilla-plda-pcie-setup-iomems \
ksym-vanilla-plda-pcie-setup-window \
ksym-vanilla-pldmfw-flash-image \
ksym-vanilla-pldmfw-op-pci-match-record \
ksym-vanilla-pm-clk-add \
ksym-vanilla-pm-clk-add-clk \
ksym-vanilla-pm-clk-add-notifier \
ksym-vanilla-pm-clk-create \
ksym-vanilla-pm-clk-destroy \
ksym-vanilla-pm-clk-init \
ksym-vanilla-pm-clk-remove-clk \
ksym-vanilla-pm-clk-resume \
ksym-vanilla-pm-clk-runtime-resume \
ksym-vanilla-pm-clk-runtime-suspend \
ksym-vanilla-pm-clk-suspend \
ksym-vanilla-pm-debug-messages-should-print \
ksym-vanilla-pm-generic-freeze \
ksym-vanilla-pm-generic-freeze-noirq \
ksym-vanilla-pm-generic-poweroff \
ksym-vanilla-pm-generic-poweroff-late \
ksym-vanilla-pm-generic-poweroff-noirq \
ksym-vanilla-pm-generic-restore \
ksym-vanilla-pm-generic-restore-early \
ksym-vanilla-pm-generic-restore-noirq \
ksym-vanilla-pm-generic-resume \
ksym-vanilla-pm-generic-resume-early \
ksym-vanilla-pm-generic-resume-noirq \
ksym-vanilla-pm-generic-runtime-resume \
ksym-vanilla-pm-generic-runtime-suspend \
ksym-vanilla-pm-generic-suspend \
ksym-vanilla-pm-generic-suspend-late \
ksym-vanilla-pm-generic-suspend-noirq \
ksym-vanilla-pm-generic-thaw \
ksym-vanilla-pm-generic-thaw-noirq \
ksym-vanilla-pm-genpd-add-device \
ksym-vanilla-pm-genpd-add-subdomain \
ksym-vanilla-pm-genpd-inc-rejected \
ksym-vanilla-pm-genpd-init \
ksym-vanilla-pm-genpd-remove \
ksym-vanilla-pm-genpd-remove-device \
ksym-vanilla-pm-genpd-remove-subdomain \
ksym-vanilla-pm-hibernate-is-recovering \
ksym-vanilla-pm-hibernation-mode-is-suspend \
ksym-vanilla-pm-power-off \
ksym-vanilla-pm-print-active-wakeup-sources \
ksym-vanilla-pm-relax \
ksym-vanilla-pm-report-hw-sleep-time \
ksym-vanilla-pm-report-max-hw-sleep \
ksym-vanilla-pm-runtime-allow \
ksym-vanilla-pm-runtime-autosuspend-expiration \
ksym-vanilla-pm-runtime-barrier \
ksym-vanilla-pm-runtime-enable \
ksym-vanilla-pm-runtime-forbid \
ksym-vanilla-pm-runtime-force-resume \
ksym-vanilla-pm-runtime-force-suspend \
ksym-vanilla-pm-runtime-get-if-active \
ksym-vanilla-pm-runtime-get-if-in-use \
ksym-vanilla-pm-runtime-irq-safe \
ksym-vanilla-pm-runtime-no-callbacks \
ksym-vanilla-pm-runtime-set-autosuspend-delay \
ksym-vanilla-pm-runtime-set-memalloc-noio \
ksym-vanilla-pm-runtime-suspended-time \
ksym-vanilla-pm-schedule-suspend \
ksym-vanilla-pm-set-vt-switch \
ksym-vanilla-pm-stay-awake \
ksym-vanilla-pm-suspend \
ksym-vanilla-pm-suspend-default-s2idle \
ksym-vanilla-pm-suspend-global-flags \
ksym-vanilla-pm-suspend-target-state \
ksym-vanilla-pm-system-wakeup \
ksym-vanilla-pm-vt-switch-required \
ksym-vanilla-pm-vt-switch-unregister \
ksym-vanilla-pm-wakeup-dev-event \
ksym-vanilla-pm-wakeup-pending \
ksym-vanilla-pm-wakeup-ws-event \
ksym-vanilla-pm-wq \
ksym-vanilla-pm4125-sdw-hw-params \
ksym-vanilla-pmbus-check-byte-register \
ksym-vanilla-pmbus-check-word-register \
ksym-vanilla-pmbus-clear-cache \
ksym-vanilla-pmbus-clear-faults \
ksym-vanilla-pmbus-do-probe \
ksym-vanilla-pmbus-get-debugfs-dir \
ksym-vanilla-pmbus-get-driver-info \
ksym-vanilla-pmbus-get-fan-rate-cached \
ksym-vanilla-pmbus-get-fan-rate-device \
ksym-vanilla-pmbus-lock \
ksym-vanilla-pmbus-lock-interruptible \
ksym-vanilla-pmbus-read-byte-data \
ksym-vanilla-pmbus-read-word-data \
ksym-vanilla-pmbus-regulator-init-cb \
ksym-vanilla-pmbus-regulator-ops \
ksym-vanilla-pmbus-set-page \
ksym-vanilla-pmbus-set-update \
ksym-vanilla-pmbus-unlock \
ksym-vanilla-pmbus-update-byte-data \
ksym-vanilla-pmbus-update-fan \
ksym-vanilla-pmbus-update-ts \
ksym-vanilla-pmbus-wait \
ksym-vanilla-pmbus-write-byte \
ksym-vanilla-pmbus-write-byte-data \
ksym-vanilla-pmbus-write-word-data \
ksym-vanilla-pmem-sector-size \
ksym-vanilla-pmem-should-map-pages \
ksym-vanilla-pmic-glink-client-register \
ksym-vanilla-pmic-glink-send \
ksym-vanilla-pn-skb-send \
ksym-vanilla-pn-sock-get-port \
ksym-vanilla-pn-sock-hash \
ksym-vanilla-pn-sock-unhash \
ksym-vanilla-pn532-i2c-nfc-alloc \
ksym-vanilla-pn533-finalize-setup \
ksym-vanilla-pn533-recv-frame \
ksym-vanilla-pn533-rx-frame-is-ack \
ksym-vanilla-pn533-rx-frame-is-cmd-response \
ksym-vanilla-pn53x-common-clean \
ksym-vanilla-pn53x-common-init \
ksym-vanilla-pn53x-register-nfc \
ksym-vanilla-pn53x-unregister-nfc \
ksym-vanilla-pn544-hci-probe \
ksym-vanilla-pn544-hci-remove \
ksym-vanilla-pneigh-enqueue \
ksym-vanilla-pnfs-add-commit-array \
ksym-vanilla-pnfs-alloc-commit-array \
ksym-vanilla-pnfs-destroy-layout \
ksym-vanilla-pnfs-error-mark-layout-for-return \
ksym-vanilla-pnfs-free-commit-array \
ksym-vanilla-pnfs-generic-clear-request-commit \
ksym-vanilla-pnfs-generic-commit-pagelist \
ksym-vanilla-pnfs-generic-commit-release \
ksym-vanilla-pnfs-generic-ds-cinfo-destroy \
ksym-vanilla-pnfs-generic-ds-cinfo-release-lseg \
ksym-vanilla-pnfs-generic-layout-insert-lseg \
ksym-vanilla-pnfs-generic-pg-check-layout \
ksym-vanilla-pnfs-generic-pg-cleanup \
ksym-vanilla-pnfs-generic-pg-init-read \
ksym-vanilla-pnfs-generic-pg-init-write \
ksym-vanilla-pnfs-generic-pg-readpages \
ksym-vanilla-pnfs-generic-pg-test \
ksym-vanilla-pnfs-generic-pg-writepages \
ksym-vanilla-pnfs-generic-prepare-to-resend-writes \
ksym-vanilla-pnfs-generic-recover-commit-reqs \
ksym-vanilla-pnfs-generic-rw-release \
ksym-vanilla-pnfs-generic-scan-commit-lists \
ksym-vanilla-pnfs-generic-sync \
ksym-vanilla-pnfs-generic-write-commit-done \
ksym-vanilla-pnfs-layout-mark-request-commit \
ksym-vanilla-pnfs-layoutcommit-inode \
ksym-vanilla-pnfs-ld-read-done \
ksym-vanilla-pnfs-ld-write-done \
ksym-vanilla-pnfs-nfs-generic-sync \
ksym-vanilla-pnfs-put-lseg \
ksym-vanilla-pnfs-read-done-resend-to-mds \
ksym-vanilla-pnfs-read-resend-pnfs \
ksym-vanilla-pnfs-register-layoutdriver \
ksym-vanilla-pnfs-report-layoutstat \
ksym-vanilla-pnfs-set-layoutcommit \
ksym-vanilla-pnfs-set-lo-fail \
ksym-vanilla-pnfs-unregister-layoutdriver \
ksym-vanilla-pnfs-update-layout \
ksym-vanilla-pnfs-write-done-resend-to-mds \
ksym-vanilla-pnp-activate-dev \
ksym-vanilla-pnp-device-attach \
ksym-vanilla-pnp-device-detach \
ksym-vanilla-pnp-disable-dev \
ksym-vanilla-pnp-get-resource \
ksym-vanilla-pnp-is-active \
ksym-vanilla-pnp-platform-devices \
ksym-vanilla-pnp-possible-config \
ksym-vanilla-pnp-range-reserved \
ksym-vanilla-pnp-register-card-driver \
ksym-vanilla-pnp-register-driver \
ksym-vanilla-pnp-release-card-device \
ksym-vanilla-pnp-request-card-device \
ksym-vanilla-pnp-start-dev \
ksym-vanilla-pnp-stop-dev \
ksym-vanilla-pnp-unregister-card-driver \
ksym-vanilla-pnp-unregister-driver \
ksym-vanilla-pnpacpi-protocol \
ksym-vanilla-poll-freewait \
ksym-vanilla-poll-initwait \
ksym-vanilla-poll-state-synchronize-rcu \
ksym-vanilla-poll-state-synchronize-rcu-full \
ksym-vanilla-poll-state-synchronize-srcu \
ksym-vanilla-poly1305-core-blocks \
ksym-vanilla-poly1305-core-emit \
ksym-vanilla-poly1305-core-setkey \
ksym-vanilla-poly1305-final \
ksym-vanilla-poly1305-init \
ksym-vanilla-poly1305-update \
ksym-vanilla-polynomial-calc \
ksym-vanilla-polyval-final \
ksym-vanilla-polyval-preparekey \
ksym-vanilla-polyval-update \
ksym-vanilla-posix-acl-alloc \
ksym-vanilla-posix-acl-chmod \
ksym-vanilla-posix-acl-clone \
ksym-vanilla-posix-acl-create \
ksym-vanilla-posix-acl-equiv-mode \
ksym-vanilla-posix-acl-from-mode \
ksym-vanilla-posix-acl-from-xattr \
ksym-vanilla-posix-acl-init \
ksym-vanilla-posix-acl-to-xattr \
ksym-vanilla-posix-acl-update-mode \
ksym-vanilla-posix-acl-valid \
ksym-vanilla-posix-clock-register \
ksym-vanilla-posix-clock-unregister \
ksym-vanilla-posix-lock-file \
ksym-vanilla-posix-test-lock \
ksym-vanilla-power-group-name \
ksym-vanilla-power-supply-am-i-supplied \
ksym-vanilla-power-supply-batinfo-ocv2cap \
ksym-vanilla-power-supply-battery-bti-in-range \
ksym-vanilla-power-supply-battery-info-get-prop \
ksym-vanilla-power-supply-battery-info-has-prop \
ksym-vanilla-power-supply-battery-info-properties \
ksym-vanilla-power-supply-battery-info-properties-size \
ksym-vanilla-power-supply-changed \
ksym-vanilla-power-supply-charge-behaviour-parse \
ksym-vanilla-power-supply-charge-behaviour-show \
ksym-vanilla-power-supply-charge-types-parse \
ksym-vanilla-power-supply-charge-types-show \
ksym-vanilla-power-supply-external-power-changed \
ksym-vanilla-power-supply-find-ocv2cap-table \
ksym-vanilla-power-supply-for-each-psy \
ksym-vanilla-power-supply-get-battery-info \
ksym-vanilla-power-supply-get-by-name \
ksym-vanilla-power-supply-get-by-reference \
ksym-vanilla-power-supply-get-drvdata \
ksym-vanilla-power-supply-get-maintenance-charging-setting \
ksym-vanilla-power-supply-get-property \
ksym-vanilla-power-supply-get-property-direct \
ksym-vanilla-power-supply-get-property-from-supplier \
ksym-vanilla-power-supply-is-system-supplied \
ksym-vanilla-power-supply-ocv2cap-simple \
ksym-vanilla-power-supply-powers \
ksym-vanilla-power-supply-put \
ksym-vanilla-power-supply-put-battery-info \
ksym-vanilla-power-supply-reg-notifier \
ksym-vanilla-power-supply-register \
ksym-vanilla-power-supply-register-extension \
ksym-vanilla-power-supply-set-property \
ksym-vanilla-power-supply-set-property-direct \
ksym-vanilla-power-supply-temp2resist-simple \
ksym-vanilla-power-supply-unreg-notifier \
ksym-vanilla-power-supply-unregister \
ksym-vanilla-power-supply-unregister-extension \
ksym-vanilla-power-supply-vbat2ri \
ksym-vanilla-ppp-channel-index \
ksym-vanilla-ppp-dev-name \
ksym-vanilla-ppp-input \
ksym-vanilla-ppp-input-error \
ksym-vanilla-ppp-output-wakeup \
ksym-vanilla-ppp-register-channel \
ksym-vanilla-ppp-register-compressor \
ksym-vanilla-ppp-register-net-channel \
ksym-vanilla-ppp-unit-number \
ksym-vanilla-ppp-unregister-channel \
ksym-vanilla-ppp-unregister-compressor \
ksym-vanilla-pppox-compat-ioctl \
ksym-vanilla-pppox-ioctl \
ksym-vanilla-pppox-unbind-sock \
ksym-vanilla-pps-event \
ksym-vanilla-pps-lookup-dev \
ksym-vanilla-pps-register-source \
ksym-vanilla-pps-unregister-source \
ksym-vanilla-pptp-msg-name \
ksym-vanilla-prandom-bytes-state \
ksym-vanilla-prandom-seed-full-state \
ksym-vanilla-prandom-u32-state \
ksym-vanilla-preempt-model-full \
ksym-vanilla-preempt-model-lazy \
ksym-vanilla-preempt-model-none \
ksym-vanilla-preempt-model-voluntary \
ksym-vanilla-preempt-notifier-dec \
ksym-vanilla-preempt-notifier-inc \
ksym-vanilla-preempt-notifier-register \
ksym-vanilla-preempt-notifier-unregister \
ksym-vanilla-preempt-schedule \
ksym-vanilla-preempt-schedule-notrace \
ksym-vanilla-prepare-creds \
ksym-vanilla-prepare-kernel-cred \
ksym-vanilla-prepare-to-swait-event \
ksym-vanilla-prepare-to-swait-exclusive \
ksym-vanilla-prepare-to-wait \
ksym-vanilla-prepare-to-wait-event \
ksym-vanilla-prepare-to-wait-exclusive \
ksym-vanilla-prestera-device-register \
ksym-vanilla-prestera-device-unregister \
ksym-vanilla-print-hex-dump \
ksym-vanilla-print-tuple \
ksym-vanilla-printk-timed-ratelimit \
ksym-vanilla-priv-to-devlink \
ksym-vanilla-probe-irq-mask \
ksym-vanilla-probe-irq-off \
ksym-vanilla-probe-irq-on \
ksym-vanilla-proc-create \
ksym-vanilla-proc-create-data \
ksym-vanilla-proc-create-mount-point \
ksym-vanilla-proc-create-net-data \
ksym-vanilla-proc-create-net-data-write \
ksym-vanilla-proc-create-net-single \
ksym-vanilla-proc-create-net-single-write \
ksym-vanilla-proc-create-seq-private \
ksym-vanilla-proc-create-single-data \
ksym-vanilla-proc-do-large-bitmap \
ksym-vanilla-proc-dobool \
ksym-vanilla-proc-dointvec \
ksym-vanilla-proc-dointvec-jiffies \
ksym-vanilla-proc-dointvec-minmax \
ksym-vanilla-proc-dointvec-ms-jiffies \
ksym-vanilla-proc-dointvec-userhz-jiffies \
ksym-vanilla-proc-dostring \
ksym-vanilla-proc-dou8vec-minmax \
ksym-vanilla-proc-douintvec \
ksym-vanilla-proc-douintvec-minmax \
ksym-vanilla-proc-doulongvec-minmax \
ksym-vanilla-proc-doulongvec-ms-jiffies-minmax \
ksym-vanilla-proc-get-parent-data \
ksym-vanilla-proc-mkdir \
ksym-vanilla-proc-mkdir-data \
ksym-vanilla-proc-mkdir-mode \
ksym-vanilla-proc-remove \
ksym-vanilla-proc-set-size \
ksym-vanilla-proc-set-user \
ksym-vanilla-proc-symlink \
ksym-vanilla-processors \
ksym-vanilla-prof-on \
ksym-vanilla-profile-hits \
ksym-vanilla-profile-pc \
ksym-vanilla-property-entries-dup \
ksym-vanilla-property-entries-free \
ksym-vanilla-prot-ns-shared \
ksym-vanilla-proto-register \
ksym-vanilla-proto-unregister \
ksym-vanilla-ps2-begin-command \
ksym-vanilla-ps2-command \
ksym-vanilla-ps2-drain \
ksym-vanilla-ps2-end-command \
ksym-vanilla-ps2-init \
ksym-vanilla-ps2-interrupt \
ksym-vanilla-ps2-is-keyboard-id \
ksym-vanilla-ps2-sendbyte \
ksym-vanilla-ps2-sliced-command \
ksym-vanilla-psample-group-get \
ksym-vanilla-psample-group-put \
ksym-vanilla-psample-group-take \
ksym-vanilla-psample-sample-packet \
ksym-vanilla-psched-ppscfg-precompute \
ksym-vanilla-psched-ratecfg-precompute \
ksym-vanilla-pse-control-put \
ksym-vanilla-pse-controller-register \
ksym-vanilla-pse-controller-unregister \
ksym-vanilla-pse-ethtool-get-status \
ksym-vanilla-pse-ethtool-set-config \
ksym-vanilla-pse-ethtool-set-prio \
ksym-vanilla-pse-ethtool-set-pw-limit \
ksym-vanilla-pse-has-c33 \
ksym-vanilla-pse-has-podl \
ksym-vanilla-psi-memstall-enter \
ksym-vanilla-psi-memstall-leave \
ksym-vanilla-pskb-expand-head \
ksym-vanilla-pskb-extract \
ksym-vanilla-pskb-put \
ksym-vanilla-pskb-trim-rcsum-slow \
ksym-vanilla-psp-dev-create \
ksym-vanilla-psp-dev-encapsulate \
ksym-vanilla-psp-dev-rcv \
ksym-vanilla-psp-dev-unregister \
ksym-vanilla-psp-key-size \
ksym-vanilla-pstore-blk-get-config \
ksym-vanilla-pstore-ftrace-combine-log \
ksym-vanilla-pstore-name-to-type \
ksym-vanilla-pstore-register \
ksym-vanilla-pstore-type-to-name \
ksym-vanilla-pstore-unregister \
ksym-vanilla-ptp-cancel-worker-sync \
ksym-vanilla-ptp-classify-raw \
ksym-vanilla-ptp-clock-event \
ksym-vanilla-ptp-clock-index \
ksym-vanilla-ptp-clock-index-by-dev \
ksym-vanilla-ptp-clock-index-by-of-node \
ksym-vanilla-ptp-clock-register \
ksym-vanilla-ptp-clock-unregister \
ksym-vanilla-ptp-convert-timestamp \
ksym-vanilla-ptp-find-pin \
ksym-vanilla-ptp-find-pin-unlocked \
ksym-vanilla-ptp-get-vclocks-index \
ksym-vanilla-ptp-msg-is-sync \
ksym-vanilla-ptp-parse-header \
ksym-vanilla-ptp-qoriq-adjfine \
ksym-vanilla-ptp-qoriq-adjtime \
ksym-vanilla-ptp-qoriq-enable \
ksym-vanilla-ptp-qoriq-free \
ksym-vanilla-ptp-qoriq-gettime \
ksym-vanilla-ptp-qoriq-init \
ksym-vanilla-ptp-qoriq-isr \
ksym-vanilla-ptp-qoriq-settime \
ksym-vanilla-ptp-schedule-worker \
ksym-vanilla-public-key-free \
ksym-vanilla-public-key-signature-free \
ksym-vanilla-public-key-subtype \
ksym-vanilla-public-key-verify-signature \
ksym-vanilla-put-cmsg \
ksym-vanilla-put-cmsg-scm-timestamping \
ksym-vanilla-put-cmsg-scm-timestamping64 \
ksym-vanilla-put-dax \
ksym-vanilla-put-device \
ksym-vanilla-put-disk \
ksym-vanilla-put-fs-context \
ksym-vanilla-put-io-context \
ksym-vanilla-put-iova-domain \
ksym-vanilla-put-itimerspec64 \
ksym-vanilla-put-memory-type \
ksym-vanilla-put-mtd-device \
ksym-vanilla-put-nfs-open-context \
ksym-vanilla-put-old-itimerspec32 \
ksym-vanilla-put-old-timespec32 \
ksym-vanilla-put-pid \
ksym-vanilla-put-pid-ns \
ksym-vanilla-put-rpccred \
ksym-vanilla-put-sg-io-hdr \
ksym-vanilla-put-timespec64 \
ksym-vanilla-put-unused-fd \
ksym-vanilla-put-user-ifreq \
ksym-vanilla-put-vaddr-frames \
ksym-vanilla-put-watch-queue \
ksym-vanilla-putname \
ksym-vanilla-pvclock-gtod-register-notifier \
ksym-vanilla-pvclock-gtod-unregister-notifier \
ksym-vanilla-pvpanic-dev-groups \
ksym-vanilla-pwm-adjust-config \
ksym-vanilla-pwm-apply-atomic \
ksym-vanilla-pwm-apply-might-sleep \
ksym-vanilla-pwm-get \
ksym-vanilla-pwm-get-state-hw \
ksym-vanilla-pwm-get-waveform-might-sleep \
ksym-vanilla-pwm-put \
ksym-vanilla-pwm-round-waveform-might-sleep \
ksym-vanilla-pwm-set-waveform-might-sleep \
ksym-vanilla-pwmchip-alloc \
ksym-vanilla-pwmchip-put \
ksym-vanilla-pwmchip-release \
ksym-vanilla-pwmchip-remove \
ksym-vanilla-pwrseq-device-get-drvdata \
ksym-vanilla-pwrseq-device-register \
ksym-vanilla-pwrseq-device-unregister \
ksym-vanilla-pwrseq-get \
ksym-vanilla-pwrseq-power-off \
ksym-vanilla-pwrseq-power-on \
ksym-vanilla-pwrseq-put \
ksym-vanilla-pwrseq-to-device \
ksym-vanilla-pxa-ssp-free \
ksym-vanilla-pxa-ssp-request \
ksym-vanilla-pxa-ssp-request-of \
ksym-vanilla-pxa2xx-spi-pm-ops \
ksym-vanilla-pxa2xx-spi-probe \
ksym-vanilla-pxa2xx-spi-remove \
ksym-vanilla-pxm-to-node \
ksym-vanilla-q6adm-close \
ksym-vanilla-q6adm-get-copp-id \
ksym-vanilla-q6adm-matrix-map \
ksym-vanilla-q6adm-open \
ksym-vanilla-q6afe-cdc-dma-port-prepare \
ksym-vanilla-q6afe-get-port-id \
ksym-vanilla-q6afe-hdmi-port-prepare \
ksym-vanilla-q6afe-i2s-port-prepare \
ksym-vanilla-q6afe-port-get-from-id \
ksym-vanilla-q6afe-port-put \
ksym-vanilla-q6afe-port-set-sysclk \
ksym-vanilla-q6afe-port-start \
ksym-vanilla-q6afe-port-stop \
ksym-vanilla-q6afe-set-lpass-clock \
ksym-vanilla-q6afe-slim-port-prepare \
ksym-vanilla-q6afe-tdm-port-prepare \
ksym-vanilla-q6afe-unvote-lpass-core-hw \
ksym-vanilla-q6afe-usb-port-prepare \
ksym-vanilla-q6afe-vote-lpass-core-hw \
ksym-vanilla-q6apm-alloc-fragments \
ksym-vanilla-q6apm-enable-compress-module \
ksym-vanilla-q6apm-free-fragments \
ksym-vanilla-q6apm-get-hw-pointer \
ksym-vanilla-q6apm-graph-close \
ksym-vanilla-q6apm-graph-flush \
ksym-vanilla-q6apm-graph-media-format-pcm \
ksym-vanilla-q6apm-graph-media-format-shmem \
ksym-vanilla-q6apm-graph-open \
ksym-vanilla-q6apm-graph-prepare \
ksym-vanilla-q6apm-graph-start \
ksym-vanilla-q6apm-graph-stop \
ksym-vanilla-q6apm-is-adsp-ready \
ksym-vanilla-q6apm-is-graph-in-push-pull-mode \
ksym-vanilla-q6apm-is-graph-in-push-pull-mode-from-id \
ksym-vanilla-q6apm-map-memory-fixed-region \
ksym-vanilla-q6apm-map-pos-buffer \
ksym-vanilla-q6apm-push-pull-config \
ksym-vanilla-q6apm-read \
ksym-vanilla-q6apm-register-watermark-event \
ksym-vanilla-q6apm-remove-initial-silence \
ksym-vanilla-q6apm-remove-trailing-silence \
ksym-vanilla-q6apm-set-real-module-id \
ksym-vanilla-q6apm-unmap-memory-fixed-region \
ksym-vanilla-q6apm-unmap-pos-buffer \
ksym-vanilla-q6apm-write-async \
ksym-vanilla-q6asm-audio-client-alloc \
ksym-vanilla-q6asm-audio-client-free \
ksym-vanilla-q6asm-cmd \
ksym-vanilla-q6asm-cmd-nowait \
ksym-vanilla-q6asm-enc-cfg-blk-pcm-format-support \
ksym-vanilla-q6asm-get-hw-pointer \
ksym-vanilla-q6asm-get-session-id \
ksym-vanilla-q6asm-map-memory-regions \
ksym-vanilla-q6asm-media-format-block-multi-ch-pcm \
ksym-vanilla-q6asm-open-read \
ksym-vanilla-q6asm-open-write \
ksym-vanilla-q6asm-read \
ksym-vanilla-q6asm-run \
ksym-vanilla-q6asm-run-nowait \
ksym-vanilla-q6asm-stream-media-format-block-alac \
ksym-vanilla-q6asm-stream-media-format-block-ape \
ksym-vanilla-q6asm-stream-media-format-block-flac \
ksym-vanilla-q6asm-stream-media-format-block-wma-v10 \
ksym-vanilla-q6asm-stream-media-format-block-wma-v9 \
ksym-vanilla-q6asm-stream-remove-initial-silence \
ksym-vanilla-q6asm-stream-remove-trailing-silence \
ksym-vanilla-q6asm-unmap-memory-regions \
ksym-vanilla-q6asm-write-async \
ksym-vanilla-q6core-get-svc-api-info \
ksym-vanilla-q6core-is-adsp-ready \
ksym-vanilla-q6dsp-audio-ports-of-xlate-dai-name \
ksym-vanilla-q6dsp-audio-ports-set-config \
ksym-vanilla-q6dsp-clock-dev-probe \
ksym-vanilla-q6dsp-get-channel-allocation \
ksym-vanilla-q6dsp-map-channels \
ksym-vanilla-q6prm-set-lpass-clock \
ksym-vanilla-q6prm-unvote-lpass-core-hw \
ksym-vanilla-q6prm-vote-lpass-core-hw \
ksym-vanilla-q6routing-stream-close \
ksym-vanilla-q6routing-stream-open \
ksym-vanilla-qat-vfmig-cleanup \
ksym-vanilla-qat-vfmig-close \
ksym-vanilla-qat-vfmig-create \
ksym-vanilla-qat-vfmig-destroy \
ksym-vanilla-qat-vfmig-init \
ksym-vanilla-qat-vfmig-load-setup \
ksym-vanilla-qat-vfmig-load-state \
ksym-vanilla-qat-vfmig-open \
ksym-vanilla-qat-vfmig-reset \
ksym-vanilla-qat-vfmig-resume \
ksym-vanilla-qat-vfmig-save-setup \
ksym-vanilla-qat-vfmig-save-state \
ksym-vanilla-qat-vfmig-suspend \
ksym-vanilla-qca-read-soc-version \
ksym-vanilla-qca-send-pre-shutdown-cmd \
ksym-vanilla-qca-set-bdaddr \
ksym-vanilla-qca-set-bdaddr-rome \
ksym-vanilla-qca-uart-setup \
ksym-vanilla-qca808x-cable-test-get-status \
ksym-vanilla-qca808x-led-reg-blink-set \
ksym-vanilla-qca808x-led-reg-brightness-set \
ksym-vanilla-qca808x-led-reg-hw-control-enable \
ksym-vanilla-qca808x-led-reg-hw-control-status \
ksym-vanilla-qcafrm-create-footer \
ksym-vanilla-qcafrm-create-header \
ksym-vanilla-qcafrm-fsm-decode \
ksym-vanilla-qcom-adc-tm5-gen2-temp-res-scale \
ksym-vanilla-qcom-adc-tm5-temp-volt-scale \
ksym-vanilla-qcom-adc5-avg-samples-from-dt \
ksym-vanilla-qcom-adc5-decimation-from-dt \
ksym-vanilla-qcom-adc5-hw-scale \
ksym-vanilla-qcom-adc5-hw-settle-time-from-dt \
ksym-vanilla-qcom-adc5-prescaling-from-dt \
ksym-vanilla-qcom-add-glink-subdev \
ksym-vanilla-qcom-add-pdm-subdev \
ksym-vanilla-qcom-add-smd-subdev \
ksym-vanilla-qcom-add-ssr-subdev \
ksym-vanilla-qcom-add-sysmon-subdev \
ksym-vanilla-qcom-alloc-bam-transaction \
ksym-vanilla-qcom-cc-map \
ksym-vanilla-qcom-cc-probe \
ksym-vanilla-qcom-cc-probe-by-index \
ksym-vanilla-qcom-cc-really-probe \
ksym-vanilla-qcom-cc-register-board-clk \
ksym-vanilla-qcom-cc-register-rcg-dfs \
ksym-vanilla-qcom-cc-register-sleep-clk \
ksym-vanilla-qcom-clear-bam-transaction \
ksym-vanilla-qcom-clear-read-regs \
ksym-vanilla-qcom-clk-alpha-pll-configure \
ksym-vanilla-qcom-find-cfg-index \
ksym-vanilla-qcom-find-freq \
ksym-vanilla-qcom-find-freq-floor \
ksym-vanilla-qcom-find-freq-multi \
ksym-vanilla-qcom-find-src-index \
ksym-vanilla-qcom-free-bam-transaction \
ksym-vanilla-qcom-glink-native-probe \
ksym-vanilla-qcom-glink-native-remove \
ksym-vanilla-qcom-glink-native-rx \
ksym-vanilla-qcom-glink-smem-register \
ksym-vanilla-qcom-glink-smem-unregister \
ksym-vanilla-qcom-glink-ssr-notify \
ksym-vanilla-qcom-icc-aggregate \
ksym-vanilla-qcom-icc-bcm-init \
ksym-vanilla-qcom-icc-bcm-voter-add \
ksym-vanilla-qcom-icc-bcm-voter-commit \
ksym-vanilla-qcom-icc-pre-aggregate \
ksym-vanilla-qcom-icc-rpm-set-bus-rate \
ksym-vanilla-qcom-icc-rpm-smd-available \
ksym-vanilla-qcom-icc-rpm-smd-send \
ksym-vanilla-qcom-icc-rpmh-probe \
ksym-vanilla-qcom-icc-rpmh-remove \
ksym-vanilla-qcom-icc-set \
ksym-vanilla-qcom-icc-xlate-extended \
ksym-vanilla-qcom-ice-derive-sw-secret \
ksym-vanilla-qcom-ice-enable \
ksym-vanilla-qcom-ice-evict-key \
ksym-vanilla-qcom-ice-generate-key \
ksym-vanilla-qcom-ice-get-supported-key-type \
ksym-vanilla-qcom-ice-import-key \
ksym-vanilla-qcom-ice-prepare-key \
ksym-vanilla-qcom-ice-program-key \
ksym-vanilla-qcom-ice-resume \
ksym-vanilla-qcom-ice-suspend \
ksym-vanilla-qcom-mdt-get-size \
ksym-vanilla-qcom-mdt-load \
ksym-vanilla-qcom-mdt-load-no-init \
ksym-vanilla-qcom-mdt-pas-load \
ksym-vanilla-qcom-mdt-read-metadata \
ksym-vanilla-qcom-minidump \
ksym-vanilla-qcom-nandc-alloc \
ksym-vanilla-qcom-nandc-dev-to-mem \
ksym-vanilla-qcom-nandc-unalloc \
ksym-vanilla-qcom-pbs-trigger-event \
ksym-vanilla-qcom-pcie-common-set-16gt-lane-margining \
ksym-vanilla-qcom-pcie-common-set-equalization \
ksym-vanilla-qcom-phy-counter-config \
ksym-vanilla-qcom-phy-get-stats \
ksym-vanilla-qcom-phy-update-stats \
ksym-vanilla-qcom-pil-info-store \
ksym-vanilla-qcom-pll-set-fsm-mode \
ksym-vanilla-qcom-pmic-get \
ksym-vanilla-qcom-prep-adm-dma-desc \
ksym-vanilla-qcom-prep-bam-dma-desc-cmd \
ksym-vanilla-qcom-prep-bam-dma-desc-data \
ksym-vanilla-qcom-prepare-bam-async-desc \
ksym-vanilla-qcom-q6v5-deinit \
ksym-vanilla-qcom-q6v5-init \
ksym-vanilla-qcom-q6v5-panic \
ksym-vanilla-qcom-q6v5-prepare \
ksym-vanilla-qcom-q6v5-request-stop \
ksym-vanilla-qcom-q6v5-unprepare \
ksym-vanilla-qcom-q6v5-wait-for-start \
ksym-vanilla-qcom-qpic-bam-dma-done \
ksym-vanilla-qcom-read-data-dma \
ksym-vanilla-qcom-read-reg-dma \
ksym-vanilla-qcom-register-dump-segments \
ksym-vanilla-qcom-register-ssr-notifier \
ksym-vanilla-qcom-remove-glink-subdev \
ksym-vanilla-qcom-remove-pdm-subdev \
ksym-vanilla-qcom-remove-smd-subdev \
ksym-vanilla-qcom-remove-ssr-subdev \
ksym-vanilla-qcom-remove-sysmon-subdev \
ksym-vanilla-qcom-reset-ops \
ksym-vanilla-qcom-rpm-smd-write \
ksym-vanilla-qcom-rpm-write \
ksym-vanilla-qcom-scm-assign-mem \
ksym-vanilla-qcom-scm-cpu-power-down \
ksym-vanilla-qcom-scm-derive-sw-secret \
ksym-vanilla-qcom-scm-generate-ice-key \
ksym-vanilla-qcom-scm-gpu-init-regs \
ksym-vanilla-qcom-scm-has-wrapped-key-support \
ksym-vanilla-qcom-scm-hdcp-available \
ksym-vanilla-qcom-scm-hdcp-req \
ksym-vanilla-qcom-scm-ice-available \
ksym-vanilla-qcom-scm-ice-invalidate-key \
ksym-vanilla-qcom-scm-ice-set-key \
ksym-vanilla-qcom-scm-import-ice-key \
ksym-vanilla-qcom-scm-io-readl \
ksym-vanilla-qcom-scm-io-writel \
ksym-vanilla-qcom-scm-iommu-secure-ptbl-init \
ksym-vanilla-qcom-scm-iommu-secure-ptbl-size \
ksym-vanilla-qcom-scm-iommu-set-cp-pool-size \
ksym-vanilla-qcom-scm-iommu-set-pt-format \
ksym-vanilla-qcom-scm-is-available \
ksym-vanilla-qcom-scm-lmh-dcvsh \
ksym-vanilla-qcom-scm-lmh-dcvsh-available \
ksym-vanilla-qcom-scm-lmh-profile-change \
ksym-vanilla-qcom-scm-mem-protect-video-var \
ksym-vanilla-qcom-scm-ocmem-lock \
ksym-vanilla-qcom-scm-ocmem-lock-available \
ksym-vanilla-qcom-scm-ocmem-unlock \
ksym-vanilla-qcom-scm-pas-auth-and-reset \
ksym-vanilla-qcom-scm-pas-get-rsc-table \
ksym-vanilla-qcom-scm-pas-init-image \
ksym-vanilla-qcom-scm-pas-mem-setup \
ksym-vanilla-qcom-scm-pas-metadata-release \
ksym-vanilla-qcom-scm-pas-prepare-and-auth-reset \
ksym-vanilla-qcom-scm-pas-shutdown \
ksym-vanilla-qcom-scm-pas-supported \
ksym-vanilla-qcom-scm-prepare-ice-key \
ksym-vanilla-qcom-scm-qseecom-app-get-id \
ksym-vanilla-qcom-scm-qseecom-app-send \
ksym-vanilla-qcom-scm-qsmmu500-wait-safe-toggle \
ksym-vanilla-qcom-scm-qtee-callback-response \
ksym-vanilla-qcom-scm-qtee-invoke-smc \
ksym-vanilla-qcom-scm-restore-sec-cfg \
ksym-vanilla-qcom-scm-restore-sec-cfg-available \
ksym-vanilla-qcom-scm-set-cold-boot-addr \
ksym-vanilla-qcom-scm-set-gpu-smmu-aperture \
ksym-vanilla-qcom-scm-set-gpu-smmu-aperture-is-available \
ksym-vanilla-qcom-scm-set-remote-state \
ksym-vanilla-qcom-scm-set-warm-boot-addr \
ksym-vanilla-qcom-scm-shm-bridge-create \
ksym-vanilla-qcom-scm-shm-bridge-delete \
ksym-vanilla-qcom-scm-shm-bridge-enable \
ksym-vanilla-qcom-smd-register-edge \
ksym-vanilla-qcom-smd-unregister-edge \
ksym-vanilla-qcom-smem-alloc \
ksym-vanilla-qcom-smem-bust-hwspin-lock-by-host \
ksym-vanilla-qcom-smem-get \
ksym-vanilla-qcom-smem-get-feature-code \
ksym-vanilla-qcom-smem-get-free-space \
ksym-vanilla-qcom-smem-get-soc-id \
ksym-vanilla-qcom-smem-is-available \
ksym-vanilla-qcom-smem-state-get \
ksym-vanilla-qcom-smem-state-put \
ksym-vanilla-qcom-smem-state-register \
ksym-vanilla-qcom-smem-state-unregister \
ksym-vanilla-qcom-smem-state-update-bits \
ksym-vanilla-qcom-smem-virt-to-phys \
ksym-vanilla-qcom-snd-dp-jack-setup \
ksym-vanilla-qcom-snd-parse-of \
ksym-vanilla-qcom-snd-sdw-get-stream \
ksym-vanilla-qcom-snd-sdw-hw-free \
ksym-vanilla-qcom-snd-sdw-prepare \
ksym-vanilla-qcom-snd-sdw-shutdown \
ksym-vanilla-qcom-snd-sdw-startup \
ksym-vanilla-qcom-snd-usb-offload-jack-remove \
ksym-vanilla-qcom-snd-usb-offload-jack-setup \
ksym-vanilla-qcom-snd-wcd-jack-setup \
ksym-vanilla-qcom-submit-descs \
ksym-vanilla-qcom-sysmon-shutdown-acked \
ksym-vanilla-qcom-tzmem-alloc \
ksym-vanilla-qcom-tzmem-enable \
ksym-vanilla-qcom-tzmem-free \
ksym-vanilla-qcom-tzmem-pool-free \
ksym-vanilla-qcom-tzmem-pool-new \
ksym-vanilla-qcom-tzmem-to-phys \
ksym-vanilla-qcom-ubwc-config-get-data \
ksym-vanilla-qcom-unregister-ssr-notifier \
ksym-vanilla-qcom-vadc-decimation-from-dt \
ksym-vanilla-qcom-vadc-scale \
ksym-vanilla-qcom-wcnss-open-channel \
ksym-vanilla-qcom-write-data-dma \
ksym-vanilla-qcom-write-reg-dma \
ksym-vanilla-qdf2400-e44-present \
ksym-vanilla-qdisc-class-hash-destroy \
ksym-vanilla-qdisc-class-hash-grow \
ksym-vanilla-qdisc-class-hash-init \
ksym-vanilla-qdisc-class-hash-insert \
ksym-vanilla-qdisc-class-hash-remove \
ksym-vanilla-qdisc-create-dflt \
ksym-vanilla-qdisc-get-rtab \
ksym-vanilla-qdisc-hash-add \
ksym-vanilla-qdisc-hash-del \
ksym-vanilla-qdisc-offload-dump-helper \
ksym-vanilla-qdisc-offload-graft-helper \
ksym-vanilla-qdisc-offload-query-caps \
ksym-vanilla-qdisc-put \
ksym-vanilla-qdisc-put-rtab \
ksym-vanilla-qdisc-put-stab \
ksym-vanilla-qdisc-put-unlocked \
ksym-vanilla-qdisc-reset \
ksym-vanilla-qdisc-tree-reduce-backlog \
ksym-vanilla-qdisc-watchdog-cancel \
ksym-vanilla-qdisc-watchdog-init \
ksym-vanilla-qdisc-watchdog-init-clockid \
ksym-vanilla-qdisc-watchdog-schedule-range-ns \
ksym-vanilla-qe-clock-source \
ksym-vanilla-qe-get-brg-clk \
ksym-vanilla-qe-get-firmware-info \
ksym-vanilla-qe-get-num-of-risc \
ksym-vanilla-qe-get-num-of-snums \
ksym-vanilla-qe-get-snum \
ksym-vanilla-qe-immr \
ksym-vanilla-qe-issue-cmd \
ksym-vanilla-qe-put-snum \
ksym-vanilla-qe-setbrg \
ksym-vanilla-qe-upload-firmware \
ksym-vanilla-qed-get-eth-ops \
ksym-vanilla-qed-get-fcoe-ops \
ksym-vanilla-qed-get-iscsi-ops \
ksym-vanilla-qed-get-rdma-ops \
ksym-vanilla-qed-put-eth-ops \
ksym-vanilla-qed-put-fcoe-ops \
ksym-vanilla-qed-put-iscsi-ops \
ksym-vanilla-qede-rdma-register-driver \
ksym-vanilla-qede-rdma-unregister-driver \
ksym-vanilla-qi-cache-alloc \
ksym-vanilla-qi-cache-free \
ksym-vanilla-qid-eq \
ksym-vanilla-qid-lt \
ksym-vanilla-qid-valid \
ksym-vanilla-qla2xxx-wake-dpc \
ksym-vanilla-qlt-abort-cmd \
ksym-vanilla-qlt-enable-vha \
ksym-vanilla-qlt-free-cmd \
ksym-vanilla-qlt-free-mcmd \
ksym-vanilla-qlt-lport-deregister \
ksym-vanilla-qlt-lport-register \
ksym-vanilla-qlt-rdy-to-xfer \
ksym-vanilla-qlt-send-term-exchange \
ksym-vanilla-qlt-srr-abort \
ksym-vanilla-qlt-stop-phase1 \
ksym-vanilla-qlt-stop-phase2 \
ksym-vanilla-qlt-unreg-sess \
ksym-vanilla-qlt-xmit-response \
ksym-vanilla-qlt-xmit-tm-rsp \
ksym-vanilla-qm-channel-caam \
ksym-vanilla-qm-channel-pool1 \
ksym-vanilla-qman-affine-channel \
ksym-vanilla-qman-affine-cpus \
ksym-vanilla-qman-alloc-cgrid-range \
ksym-vanilla-qman-alloc-fqid-range \
ksym-vanilla-qman-alloc-pool-range \
ksym-vanilla-qman-create-cgr \
ksym-vanilla-qman-create-fq \
ksym-vanilla-qman-delete-cgr \
ksym-vanilla-qman-delete-cgr-safe \
ksym-vanilla-qman-destroy-fq \
ksym-vanilla-qman-dma-portal \
ksym-vanilla-qman-dqrr-get-ithresh \
ksym-vanilla-qman-dqrr-set-ithresh \
ksym-vanilla-qman-enqueue \
ksym-vanilla-qman-fq-fqid \
ksym-vanilla-qman-get-affine-portal \
ksym-vanilla-qman-get-qm-portal-config \
ksym-vanilla-qman-init-fq \
ksym-vanilla-qman-ip-rev \
ksym-vanilla-qman-is-probed \
ksym-vanilla-qman-oos-fq \
ksym-vanilla-qman-p-irqsource-add \
ksym-vanilla-qman-p-irqsource-remove \
ksym-vanilla-qman-p-poll-dqrr \
ksym-vanilla-qman-p-static-dequeue-add \
ksym-vanilla-qman-portal-get-iperiod \
ksym-vanilla-qman-portal-set-iperiod \
ksym-vanilla-qman-portals-probed \
ksym-vanilla-qman-query-cgr-congested \
ksym-vanilla-qman-query-fq-np \
ksym-vanilla-qman-release-cgrid \
ksym-vanilla-qman-release-fqid \
ksym-vanilla-qman-release-pool \
ksym-vanilla-qman-retire-fq \
ksym-vanilla-qman-schedule-fq \
ksym-vanilla-qman-start-using-portal \
ksym-vanilla-qman-update-cgr-safe \
ksym-vanilla-qman-volatile-dequeue \
ksym-vanilla-qmi-add-lookup \
ksym-vanilla-qmi-add-server \
ksym-vanilla-qmi-decode-message \
ksym-vanilla-qmi-encode-message \
ksym-vanilla-qmi-handle-init \
ksym-vanilla-qmi-handle-release \
ksym-vanilla-qmi-response-type-v01-ei \
ksym-vanilla-qmi-send-indication \
ksym-vanilla-qmi-send-request \
ksym-vanilla-qmi-send-response \
ksym-vanilla-qmi-txn-cancel \
ksym-vanilla-qmi-txn-init \
ksym-vanilla-qmi-txn-wait \
ksym-vanilla-qmp-get \
ksym-vanilla-qmp-put \
ksym-vanilla-qmp-send \
ksym-vanilla-qnap-mcu-exec \
ksym-vanilla-qnap-mcu-exec-with-ack \
ksym-vanilla-qnoc-probe \
ksym-vanilla-qnoc-remove \
ksym-vanilla-qrtr-endpoint-post \
ksym-vanilla-qrtr-endpoint-register \
ksym-vanilla-qrtr-endpoint-unregister \
ksym-vanilla-qrtr-ns-init \
ksym-vanilla-qrtr-ns-remove \
ksym-vanilla-qt1010-attach \
ksym-vanilla-qtnf-chipid-to-string \
ksym-vanilla-qtnf-classify-skb \
ksym-vanilla-qtnf-core-attach \
ksym-vanilla-qtnf-core-detach \
ksym-vanilla-qtnf-get-debugfs-dir \
ksym-vanilla-qtnf-trans-handle-rx-ctl-packet \
ksym-vanilla-qtnf-wake-all-queues \
ksym-vanilla-qtree-delete-dquot \
ksym-vanilla-qtree-entry-unused \
ksym-vanilla-qtree-get-next-id \
ksym-vanilla-qtree-read-dquot \
ksym-vanilla-qtree-release-dquot \
ksym-vanilla-qtree-write-dquot \
ksym-vanilla-query-amp-caps \
ksym-vanilla-query-asymmetric-key \
ksym-vanilla-queue-delayed-work-on \
ksym-vanilla-queue-limits-commit-update \
ksym-vanilla-queue-limits-commit-update-frozen \
ksym-vanilla-queue-limits-set \
ksym-vanilla-queue-limits-stack-bdev \
ksym-vanilla-queue-limits-stack-integrity \
ksym-vanilla-queue-rcu-work \
ksym-vanilla-queue-work-node \
ksym-vanilla-queue-work-on \
ksym-vanilla-queued-read-lock-slowpath \
ksym-vanilla-queued-spin-lock-slowpath \
ksym-vanilla-queued-write-lock-slowpath \
ksym-vanilla-quota-send-warning \
ksym-vanilla-qup-clk \
ksym-vanilla-qword-add \
ksym-vanilla-qword-addhex \
ksym-vanilla-qword-get \
ksym-vanilla-r5c-journal-mode-set \
ksym-vanilla-r820t-attach \
ksym-vanilla-radio-tea5777-exit \
ksym-vanilla-radio-tea5777-init \
ksym-vanilla-radix-tree-delete \
ksym-vanilla-radix-tree-delete-item \
ksym-vanilla-radix-tree-gang-lookup \
ksym-vanilla-radix-tree-gang-lookup-tag \
ksym-vanilla-radix-tree-gang-lookup-tag-slot \
ksym-vanilla-radix-tree-insert \
ksym-vanilla-radix-tree-iter-delete \
ksym-vanilla-radix-tree-iter-resume \
ksym-vanilla-radix-tree-lookup \
ksym-vanilla-radix-tree-lookup-slot \
ksym-vanilla-radix-tree-maybe-preload \
ksym-vanilla-radix-tree-next-chunk \
ksym-vanilla-radix-tree-preload \
ksym-vanilla-radix-tree-preloads \
ksym-vanilla-radix-tree-replace-slot \
ksym-vanilla-radix-tree-tag-clear \
ksym-vanilla-radix-tree-tag-get \
ksym-vanilla-radix-tree-tag-set \
ksym-vanilla-radix-tree-tagged \
ksym-vanilla-raid-class-attach \
ksym-vanilla-raid-class-release \
ksym-vanilla-raid5-set-cache-size \
ksym-vanilla-raid6-can-xor-syndrome \
ksym-vanilla-raid6-gen-syndrome \
ksym-vanilla-raid6-gfexi \
ksym-vanilla-raid6-gfexp \
ksym-vanilla-raid6-gfinv \
ksym-vanilla-raid6-gflog \
ksym-vanilla-raid6-gfmul \
ksym-vanilla-raid6-recov-2data \
ksym-vanilla-raid6-recov-datap \
ksym-vanilla-raid6-vgfmul \
ksym-vanilla-raid6-xor-syndrome \
ksym-vanilla-ram-aops \
ksym-vanilla-random-get-entropy-fallback \
ksym-vanilla-random-kmalloc-seed \
ksym-vanilla-range-0-20mA \
ksym-vanilla-range-0-32mA \
ksym-vanilla-range-4-20mA \
ksym-vanilla-range-bipolar10 \
ksym-vanilla-range-bipolar2-5 \
ksym-vanilla-range-bipolar5 \
ksym-vanilla-range-unipolar10 \
ksym-vanilla-range-unipolar2-5 \
ksym-vanilla-range-unipolar5 \
ksym-vanilla-range-unknown \
ksym-vanilla-ras-get-debugfs-root \
ksym-vanilla-ras-userspace-consumers \
ksym-vanilla-rate-control-set-rates \
ksym-vanilla-rational-best-approximation \
ksym-vanilla-raw-notifier-call-chain \
ksym-vanilla-raw-notifier-call-chain-robust \
ksym-vanilla-raw-notifier-chain-register \
ksym-vanilla-raw-notifier-chain-unregister \
ksym-vanilla-raw-v4-hashinfo \
ksym-vanilla-raw-v4-match \
ksym-vanilla-raw-v6-hashinfo \
ksym-vanilla-raw-v6-match \
ksym-vanilla-rawnand-dt-parse-gpio-cs \
ksym-vanilla-rawnand-sw-bch-cleanup \
ksym-vanilla-rawnand-sw-bch-correct \
ksym-vanilla-rawnand-sw-bch-init \
ksym-vanilla-rawnand-sw-hamming-calculate \
ksym-vanilla-rawnand-sw-hamming-cleanup \
ksym-vanilla-rawnand-sw-hamming-correct \
ksym-vanilla-rawnand-sw-hamming-init \
ksym-vanilla-rawv6-mh-filter-register \
ksym-vanilla-rawv6-mh-filter-unregister \
ksym-vanilla-rb-erase \
ksym-vanilla-rb-erase-linked \
ksym-vanilla-rb-first-postorder \
ksym-vanilla-rb-insert-color \
ksym-vanilla-rb-next \
ksym-vanilla-rb-next-postorder \
ksym-vanilla-rb-prev \
ksym-vanilla-rb-replace-node \
ksym-vanilla-rb-replace-node-rcu \
ksym-vanilla-rc-allocate-device \
ksym-vanilla-rc-free-device \
ksym-vanilla-rc-g-keycode-from-table \
ksym-vanilla-rc-keydown \
ksym-vanilla-rc-keydown-notimeout \
ksym-vanilla-rc-keyup \
ksym-vanilla-rc-map-af9005-table \
ksym-vanilla-rc-map-af9005-table-size \
ksym-vanilla-rc-map-dibusb-table \
ksym-vanilla-rc-map-get \
ksym-vanilla-rc-map-register \
ksym-vanilla-rc-map-unregister \
ksym-vanilla-rc-register-device \
ksym-vanilla-rc-repeat \
ksym-vanilla-rc-unregister-device \
ksym-vanilla-rcar-cmm-disable \
ksym-vanilla-rcar-cmm-enable \
ksym-vanilla-rcar-cmm-init \
ksym-vanilla-rcar-cmm-setup \
ksym-vanilla-rcar-fcp-disable \
ksym-vanilla-rcar-fcp-enable \
ksym-vanilla-rcar-fcp-get \
ksym-vanilla-rcar-fcp-get-device \
ksym-vanilla-rcar-fcp-put \
ksym-vanilla-rcar-fcp-soft-reset \
ksym-vanilla-rcar-gen4-ptp-alloc \
ksym-vanilla-rcar-gen4-ptp-clock-index \
ksym-vanilla-rcar-gen4-ptp-gettime64 \
ksym-vanilla-rcar-gen4-ptp-register \
ksym-vanilla-rcar-gen4-ptp-unregister \
ksym-vanilla-rcar-lvds-dual-link \
ksym-vanilla-rcar-lvds-is-connected \
ksym-vanilla-rcar-lvds-pclk-disable \
ksym-vanilla-rcar-lvds-pclk-enable \
ksym-vanilla-rcar-mipi-dsi-pclk-disable \
ksym-vanilla-rcar-mipi-dsi-pclk-enable \
ksym-vanilla-rcar-rst-set-rproc-boot-addr \
ksym-vanilla-rcu-async-hurry \
ksym-vanilla-rcu-async-relax \
ksym-vanilla-rcu-async-should-hurry \
ksym-vanilla-rcu-barrier \
ksym-vanilla-rcu-barrier-tasks \
ksym-vanilla-rcu-bind-current-to-nocb \
ksym-vanilla-rcu-check-boost-fail \
ksym-vanilla-rcu-cpu-stall-notifiers \
ksym-vanilla-rcu-cpu-stall-suppress \
ksym-vanilla-rcu-cpu-stall-suppress-at-boot \
ksym-vanilla-rcu-exp-batches-completed \
ksym-vanilla-rcu-exp-jiffies-till-stall-check \
ksym-vanilla-rcu-expedite-gp \
ksym-vanilla-rcu-force-quiescent-state \
ksym-vanilla-rcu-fwd-progress-check \
ksym-vanilla-rcu-get-gp-kthreads-prio \
ksym-vanilla-rcu-get-gp-seq \
ksym-vanilla-rcu-get-gpwrap-count \
ksym-vanilla-rcu-gp-is-expedited \
ksym-vanilla-rcu-gp-is-normal \
ksym-vanilla-rcu-gp-set-torture-wait \
ksym-vanilla-rcu-gp-slow-register \
ksym-vanilla-rcu-gp-slow-unregister \
ksym-vanilla-rcu-inkernel-boot-has-ended \
ksym-vanilla-rcu-is-watching \
ksym-vanilla-rcu-jiffies-till-stall-check \
ksym-vanilla-rcu-momentary-eqs \
ksym-vanilla-rcu-nocb-cpu-deoffload \
ksym-vanilla-rcu-nocb-cpu-offload \
ksym-vanilla-rcu-nocb-flush-deferred-wakeup \
ksym-vanilla-rcu-note-context-switch \
ksym-vanilla-rcu-scheduler-active \
ksym-vanilla-rcu-set-gpwrap-lag \
ksym-vanilla-rcu-tasks-get-gp-data \
ksym-vanilla-rcu-tasks-rude-get-gp-data \
ksym-vanilla-rcu-tasks-rude-torture-stats-print \
ksym-vanilla-rcu-tasks-torture-stats-print \
ksym-vanilla-rcu-tasks-trace-srcu-struct \
ksym-vanilla-rcu-unexpedite-gp \
ksym-vanilla-rcuref-get-slowpath \
ksym-vanilla-rcuref-put-slowpath \
ksym-vanilla-rcutorture-format-gp-seqs \
ksym-vanilla-rcutorture-gather-gp-seqs \
ksym-vanilla-rcutorture-get-gp-data \
ksym-vanilla-rcuwait-wake-up \
ksym-vanilla-rdc-reset-state \
ksym-vanilla-rdev-clear-badblocks \
ksym-vanilla-rdev-get-dev \
ksym-vanilla-rdev-get-drvdata \
ksym-vanilla-rdev-get-id \
ksym-vanilla-rdev-get-name \
ksym-vanilla-rdev-get-regmap \
ksym-vanilla-rdev-set-badblocks \
ksym-vanilla-rdma-accept \
ksym-vanilla-rdma-accept-ece \
ksym-vanilla-rdma-addr-cancel \
ksym-vanilla-rdma-addr-size \
ksym-vanilla-rdma-addr-size-in6 \
ksym-vanilla-rdma-addr-size-kss \
ksym-vanilla-rdma-alloc-abort-uobject \
ksym-vanilla-rdma-alloc-begin-uobject \
ksym-vanilla-rdma-alloc-commit-uobject \
ksym-vanilla-rdma-alloc-hw-stats-struct \
ksym-vanilla-rdma-alloc-netdev \
ksym-vanilla-rdma-assign-uobject \
ksym-vanilla-rdma-bind-addr \
ksym-vanilla-rdma-cgrp-subsys-enabled-key \
ksym-vanilla-rdma-cgrp-subsys-on-dfl-key \
ksym-vanilla-rdma-connect \
ksym-vanilla-rdma-connect-ece \
ksym-vanilla-rdma-connect-locked \
ksym-vanilla-rdma-consumer-reject-data \
ksym-vanilla-rdma-copy-ah-attr \
ksym-vanilla-rdma-copy-src-l2-addr \
ksym-vanilla-rdma-create-ah \
ksym-vanilla-rdma-create-qp \
ksym-vanilla-rdma-create-user-ah \
ksym-vanilla-rdma-create-user-id \
ksym-vanilla-rdma-destroy-ah-attr \
ksym-vanilla-rdma-destroy-ah-user \
ksym-vanilla-rdma-destroy-id \
ksym-vanilla-rdma-destroy-qp \
ksym-vanilla-rdma-dev-access-netns \
ksym-vanilla-rdma-dev-has-raw-cap \
ksym-vanilla-rdma-dim \
ksym-vanilla-rdma-disconnect \
ksym-vanilla-rdma-event-msg \
ksym-vanilla-rdma-find-gid \
ksym-vanilla-rdma-find-gid-by-port \
ksym-vanilla-rdma-free-hw-stats-struct \
ksym-vanilla-rdma-get-gid-attr \
ksym-vanilla-rdma-get-service-id \
ksym-vanilla-rdma-hold-gid-attr \
ksym-vanilla-rdma-init-netdev \
ksym-vanilla-rdma-init-qp-attr \
ksym-vanilla-rdma-is-zero-gid \
ksym-vanilla-rdma-iw-cm-id \
ksym-vanilla-rdma-join-multicast \
ksym-vanilla-rdma-leave-multicast \
ksym-vanilla-rdma-link-register \
ksym-vanilla-rdma-link-unregister \
ksym-vanilla-rdma-listen \
ksym-vanilla-rdma-lock-handler \
ksym-vanilla-rdma-lookup-get-uobject \
ksym-vanilla-rdma-lookup-put-uobject \
ksym-vanilla-rdma-modify-ah \
ksym-vanilla-rdma-move-ah-attr \
ksym-vanilla-rdma-move-grh-sgid-attr \
ksym-vanilla-rdma-nl-chk-listeners \
ksym-vanilla-rdma-nl-get-privileged-qkey \
ksym-vanilla-rdma-nl-multicast \
ksym-vanilla-rdma-nl-put-driver-string \
ksym-vanilla-rdma-nl-put-driver-u32 \
ksym-vanilla-rdma-nl-put-driver-u32-hex \
ksym-vanilla-rdma-nl-put-driver-u64 \
ksym-vanilla-rdma-nl-put-driver-u64-hex \
ksym-vanilla-rdma-nl-register \
ksym-vanilla-rdma-nl-stat-hwcounter-entry \
ksym-vanilla-rdma-nl-unicast \
ksym-vanilla-rdma-nl-unicast-wait \
ksym-vanilla-rdma-nl-unregister \
ksym-vanilla-rdma-node-get-transport \
ksym-vanilla-rdma-notify \
ksym-vanilla-rdma-port-get-link-layer \
ksym-vanilla-rdma-put-gid-attr \
ksym-vanilla-rdma-query-ah \
ksym-vanilla-rdma-query-gid \
ksym-vanilla-rdma-query-gid-table \
ksym-vanilla-rdma-read-gid-attr-ndev-rcu \
ksym-vanilla-rdma-read-gid-hw-context \
ksym-vanilla-rdma-read-gid-l2-fields \
ksym-vanilla-rdma-read-gids \
ksym-vanilla-rdma-reject \
ksym-vanilla-rdma-reject-msg \
ksym-vanilla-rdma-replace-ah-attr \
ksym-vanilla-rdma-resolve-addr \
ksym-vanilla-rdma-resolve-ib-service \
ksym-vanilla-rdma-resolve-ip \
ksym-vanilla-rdma-resolve-route \
ksym-vanilla-rdma-restrack-add \
ksym-vanilla-rdma-restrack-count \
ksym-vanilla-rdma-restrack-del \
ksym-vanilla-rdma-restrack-get \
ksym-vanilla-rdma-restrack-get-byid \
ksym-vanilla-rdma-restrack-new \
ksym-vanilla-rdma-restrack-parent-name \
ksym-vanilla-rdma-restrack-put \
ksym-vanilla-rdma-restrack-set-name \
ksym-vanilla-rdma-restrack-sync \
ksym-vanilla-rdma-restrict-node-type \
ksym-vanilla-rdma-roce-rescan-device \
ksym-vanilla-rdma-roce-rescan-port \
ksym-vanilla-rdma-rw-ctx-destroy \
ksym-vanilla-rdma-rw-ctx-destroy-bvec \
ksym-vanilla-rdma-rw-ctx-destroy-signature \
ksym-vanilla-rdma-rw-ctx-init \
ksym-vanilla-rdma-rw-ctx-init-bvec \
ksym-vanilla-rdma-rw-ctx-post \
ksym-vanilla-rdma-rw-ctx-signature-init \
ksym-vanilla-rdma-rw-ctx-wrs \
ksym-vanilla-rdma-rw-max-send-wr \
ksym-vanilla-rdma-rw-mr-factor \
ksym-vanilla-rdma-set-ack-timeout \
ksym-vanilla-rdma-set-afonly \
ksym-vanilla-rdma-set-cq-moderation \
ksym-vanilla-rdma-set-ib-path \
ksym-vanilla-rdma-set-min-rnr-timer \
ksym-vanilla-rdma-set-reuseaddr \
ksym-vanilla-rdma-set-service-type \
ksym-vanilla-rdma-translate-ip \
ksym-vanilla-rdma-uattrs-has-raw-cap \
ksym-vanilla-rdma-umap-priv-init \
ksym-vanilla-rdma-unlock-handler \
ksym-vanilla-rdma-user-mmap-disassociate \
ksym-vanilla-rdma-user-mmap-entry-get \
ksym-vanilla-rdma-user-mmap-entry-get-pgoff \
ksym-vanilla-rdma-user-mmap-entry-insert \
ksym-vanilla-rdma-user-mmap-entry-insert-range \
ksym-vanilla-rdma-user-mmap-entry-put \
ksym-vanilla-rdma-user-mmap-entry-remove \
ksym-vanilla-rdma-user-mmap-io \
ksym-vanilla-rdmacg-register-device \
ksym-vanilla-rdmacg-try-charge \
ksym-vanilla-rdmacg-uncharge \
ksym-vanilla-rdmacg-unregister-device \
ksym-vanilla-rds-addr-cmp \
ksym-vanilla-rds-atomic-send-complete \
ksym-vanilla-rds-cong-map-updated \
ksym-vanilla-rds-conn-connect-if-down \
ksym-vanilla-rds-conn-create \
ksym-vanilla-rds-conn-create-outgoing \
ksym-vanilla-rds-conn-destroy \
ksym-vanilla-rds-conn-drop \
ksym-vanilla-rds-conn-path-connect-if-down \
ksym-vanilla-rds-conn-path-drop \
ksym-vanilla-rds-connect-complete \
ksym-vanilla-rds-connect-path-complete \
ksym-vanilla-rds-for-each-conn-info \
ksym-vanilla-rds-inc-init \
ksym-vanilla-rds-inc-path-init \
ksym-vanilla-rds-inc-put \
ksym-vanilla-rds-info-copy \
ksym-vanilla-rds-info-deregister-func \
ksym-vanilla-rds-info-register-func \
ksym-vanilla-rds-message-add-extension \
ksym-vanilla-rds-message-add-rdma-dest-extension \
ksym-vanilla-rds-message-addref \
ksym-vanilla-rds-message-populate-header \
ksym-vanilla-rds-message-put \
ksym-vanilla-rds-message-unmapped \
ksym-vanilla-rds-page-remainder-alloc \
ksym-vanilla-rds-rdma-send-complete \
ksym-vanilla-rds-recv-incoming \
ksym-vanilla-rds-send-drop-acked \
ksym-vanilla-rds-send-path-drop-acked \
ksym-vanilla-rds-send-path-reset \
ksym-vanilla-rds-send-ping \
ksym-vanilla-rds-send-xmit \
ksym-vanilla-rds-stats \
ksym-vanilla-rds-stats-info-copy \
ksym-vanilla-rds-trans-register \
ksym-vanilla-rds-trans-unregister \
ksym-vanilla-rds-wq \
ksym-vanilla-read-bytes-from-xdr-buf \
ksym-vanilla-read-cache-folio \
ksym-vanilla-read-cache-page \
ksym-vanilla-read-cache-page-gfp \
ksym-vanilla-read-cdat-data \
ksym-vanilla-read-dst \
ksym-vanilla-read-efuse-byte \
ksym-vanilla-read-sanitised-ftr-reg \
ksym-vanilla-readahead-expand \
ksym-vanilla-realtek-mdio-probe \
ksym-vanilla-realtek-mdio-remove \
ksym-vanilla-realtek-mdio-shutdown \
ksym-vanilla-realtek-pinctrl-pm-ops \
ksym-vanilla-realtek-smi-probe \
ksym-vanilla-realtek-smi-remove \
ksym-vanilla-realtek-smi-shutdown \
ksym-vanilla-reboot-mode \
ksym-vanilla-reboot-mode-register \
ksym-vanilla-reboot-mode-unregister \
ksym-vanilla-recalc-sigpending \
ksym-vanilla-receive-fd \
ksym-vanilla-reciprocal-value \
ksym-vanilla-reciprocal-value-adv \
ksym-vanilla-recover-lost-locks \
ksym-vanilla-redirty-page-for-writepage \
ksym-vanilla-redraw-screen \
ksym-vanilla-refcount-dec-and-lock \
ksym-vanilla-refcount-dec-and-lock-irqsave \
ksym-vanilla-refcount-dec-and-mutex-lock \
ksym-vanilla-refcount-dec-and-rtnl-lock \
ksym-vanilla-refcount-dec-if-one \
ksym-vanilla-refcount-dec-not-one \
ksym-vanilla-refcount-warn-saturate \
ksym-vanilla-refresh-frequency-limits \
ksym-vanilla-reg-initiator-name \
ksym-vanilla-reg-query-regdb-wmm \
ksym-vanilla-regcache-cache-bypass \
ksym-vanilla-regcache-cache-only \
ksym-vanilla-regcache-drop-region \
ksym-vanilla-regcache-mark-dirty \
ksym-vanilla-regcache-reg-cached \
ksym-vanilla-regcache-sort-defaults \
ksym-vanilla-regcache-sync \
ksym-vanilla-regcache-sync-region \
ksym-vanilla-region-intersects \
ksym-vanilla-region-intersects-soft-reserve \
ksym-vanilla-register-acpi-bus-type \
ksym-vanilla-register-acpi-hed-notifier \
ksym-vanilla-register-acpi-notifier \
ksym-vanilla-register-asymmetric-key-parser \
ksym-vanilla-register-atm-ioctl \
ksym-vanilla-register-atmdevice-notifier \
ksym-vanilla-register-blocking-lsm-notifier \
ksym-vanilla-register-btf-fmodret-id-set \
ksym-vanilla-register-btf-id-dtor-kfuncs \
ksym-vanilla-register-btf-kfunc-id-set \
ksym-vanilla-register-c-can-dev \
ksym-vanilla-register-candev \
ksym-vanilla-register-cdrom \
ksym-vanilla-register-chrdev-region \
ksym-vanilla-register-console \
ksym-vanilla-register-dcbevent-notifier \
ksym-vanilla-register-die-notifier \
ksym-vanilla-register-dpll-notifier \
ksym-vanilla-register-fib-notifier \
ksym-vanilla-register-filesystem \
ksym-vanilla-register-firmware-config-sysctl \
ksym-vanilla-register-framebuffer \
ksym-vanilla-register-ftrace-direct \
ksym-vanilla-register-ftrace-export \
ksym-vanilla-register-ftrace-function \
ksym-vanilla-register-hdlc-protocol \
ksym-vanilla-register-ife-op \
ksym-vanilla-register-inet6addr-notifier \
ksym-vanilla-register-inet6addr-validator-notifier \
ksym-vanilla-register-inetaddr-notifier \
ksym-vanilla-register-inetaddr-validator-notifier \
ksym-vanilla-register-ip-vs-app \
ksym-vanilla-register-ip-vs-app-inc \
ksym-vanilla-register-ip-vs-pe \
ksym-vanilla-register-ip-vs-scheduler \
ksym-vanilla-register-key-type \
ksym-vanilla-register-keyboard-notifier \
ksym-vanilla-register-kprobe \
ksym-vanilla-register-kprobes \
ksym-vanilla-register-kretprobe \
ksym-vanilla-register-kretprobes \
ksym-vanilla-register-md-submodule \
ksym-vanilla-register-memory-notifier \
ksym-vanilla-register-module-notifier \
ksym-vanilla-register-mt-adistance-algorithm \
ksym-vanilla-register-mtd-blktrans \
ksym-vanilla-register-mtd-chip-driver \
ksym-vanilla-register-mtd-user \
ksym-vanilla-register-net-sysctl-sz \
ksym-vanilla-register-netdev \
ksym-vanilla-register-netdevice \
ksym-vanilla-register-netdevice-notifier \
ksym-vanilla-register-netdevice-notifier-dev-net \
ksym-vanilla-register-netdevice-notifier-net \
ksym-vanilla-register-netevent-notifier \
ksym-vanilla-register-nexthop-notifier \
ksym-vanilla-register-nfs-version \
ksym-vanilla-register-node-notifier \
ksym-vanilla-register-nvdimm-pmu \
ksym-vanilla-register-oom-notifier \
ksym-vanilla-register-pernet-device \
ksym-vanilla-register-pernet-subsys \
ksym-vanilla-register-pfn-address-space \
ksym-vanilla-register-platform-power-off \
ksym-vanilla-register-pm-notifier \
ksym-vanilla-register-pppox-proto \
ksym-vanilla-register-pstore-device \
ksym-vanilla-register-pstore-zone \
ksym-vanilla-register-qdisc \
ksym-vanilla-register-quota-format \
ksym-vanilla-register-random-vmfork-notifier \
ksym-vanilla-register-reboot-notifier \
ksym-vanilla-register-restart-handler \
ksym-vanilla-register-sja1000dev \
ksym-vanilla-register-snap-client \
ksym-vanilla-register-sound-dsp \
ksym-vanilla-register-sound-mixer \
ksym-vanilla-register-sound-special \
ksym-vanilla-register-sound-special-device \
ksym-vanilla-register-switchdev-blocking-notifier \
ksym-vanilla-register-switchdev-notifier \
ksym-vanilla-register-sys-off-handler \
ksym-vanilla-register-syscore \
ksym-vanilla-register-sysctl-mount-point \
ksym-vanilla-register-sysctl-sz \
ksym-vanilla-register-sysrq-key \
ksym-vanilla-register-tcf-proto-ops \
ksym-vanilla-register-trace-event \
ksym-vanilla-register-tracepoint-module-notifier \
ksym-vanilla-register-user-hw-breakpoint \
ksym-vanilla-register-virtio-device \
ksym-vanilla-register-vmap-purge-notifier \
ksym-vanilla-register-vmcore-cb \
ksym-vanilla-register-vt-notifier \
ksym-vanilla-register-wide-hw-breakpoint \
ksym-vanilla-regmap-add-irq-chip \
ksym-vanilla-regmap-add-irq-chip-fwnode \
ksym-vanilla-regmap-async-complete \
ksym-vanilla-regmap-async-complete-cb \
ksym-vanilla-regmap-attach-dev \
