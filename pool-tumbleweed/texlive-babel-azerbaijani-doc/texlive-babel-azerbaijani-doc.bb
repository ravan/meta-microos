SUMMARY = "Documentation for texlive-babel-azerbaijani"
DESCRIPTION = "This package includes the documentation for texlive-babel-azerbaijani"
LICENSE = "LPPL-1.0"

PV = "2026.226.1.0asvn44197"

RPM_NAME = "texlive-babel-azerbaijani-doc-2026.226.1.0asvn44197-60.2.noarch.rpm"
RPM_HASH = "d4d147968d2a61f4d1336d4a200712c9064dbec9fdb9d2e6968f843f9d51e5461b419cc751d3467818d96e9f4b5db762b166055acc012574ff408cec5507e14c"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "texlive-babel-azerbaijani-doc"

RDEPENDS:${PN} += ""

inherit rpm
