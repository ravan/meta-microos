SUMMARY = "Hebrew fonts from the Culmus project"
DESCRIPTION = "Hebrew fonts from the Culmus Project. Both Type1 and \
Open/TrueType versions of the fonts are provided, as well as \
font definition files. It is recommended to use these fonts \
with the NHE8 font encoding, from the hebrew-fonts package."
LICENSE = "LPPL-1.0"

PV = "2026.226.1.1svn76924"

RPM_NAME = "texlive-culmus-2026.226.1.1svn76924-61.2.noarch.rpm"
RPM_HASH = "a8cdb47cb2ad031c6ffa2f59153ddebb057b4a71d1a3b7e16370887d5e629ccd6d7bf152a6d9b6bbb50e1047b9a06fba5b307251ec73e696a576ba10cdf90345"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-aharoni-new.tfm \
tex-aharoni-new.vf \
tex-aharoni.tfm \
tex-aharoni.vf \
tex-aharonib-new.tfm \
tex-aharonib-new.vf \
tex-aharonib.tfm \
tex-aharonib.vf \
tex-aharonibi-new.tfm \
tex-aharonibi-new.vf \
tex-aharonibi.tfm \
tex-aharonibi.vf \
tex-aharonii-new.tfm \
tex-aharonii-new.vf \
tex-aharonii.tfm \
tex-aharonii.vf \
tex-caladings-new.tfm \
tex-caladings-new.vf \
tex-caladings.tfm \
tex-caladings.vf \
tex-culmus-new.map \
tex-culmus.map \
tex-culmus.sty \
tex-david-new.tfm \
tex-david-new.vf \
tex-david.tfm \
tex-david.vf \
tex-davidb-new.tfm \
tex-davidb-new.vf \
tex-davidb.tfm \
tex-davidb.vf \
tex-davidbi-new.tfm \
tex-davidbi-new.vf \
tex-davidi-new.tfm \
tex-davidi-new.vf \
tex-davidi.tfm \
tex-davidi.vf \
tex-drugulinb-new.tfm \
tex-drugulinb-new.vf \
tex-drugulinb.tfm \
tex-drugulinb.vf \
tex-drugulinbi-new.tfm \
tex-drugulinbi-new.vf \
tex-drugulinbi.tfm \
tex-drugulinbi.vf \
tex-ellinia-new.tfm \
tex-ellinia-new.vf \
tex-ellinia.tfm \
tex-ellinia.vf \
tex-elliniab-new.tfm \
tex-elliniab-new.vf \
tex-elliniab.tfm \
tex-elliniab.vf \
tex-elliniabi-new.tfm \
tex-elliniabi-new.vf \
tex-elliniabi.tfm \
tex-elliniabi.vf \
tex-elliniai-new.tfm \
tex-elliniai-new.vf \
tex-elliniai.tfm \
tex-elliniai.vf \
tex-frank-new.tfm \
tex-frank-new.vf \
tex-frank.tfm \
tex-frank.vf \
tex-frankClmNkd.tfm \
tex-frankClmNkd.vf \
tex-frankClmNkdb.tfm \
tex-frankClmNkdb.vf \
tex-frankClmNkdbi.tfm \
tex-frankClmNkdbi.vf \
tex-frankClmNkdi.tfm \
tex-frankClmNkdi.vf \
tex-frankb-new.tfm \
tex-frankb-new.vf \
tex-frankb.tfm \
tex-frankb.vf \
tex-frankbi-new.tfm \
tex-frankbi-new.vf \
tex-frankbi.tfm \
tex-frankbi.vf \
tex-franki-new.tfm \
tex-franki-new.vf \
tex-franki.tfm \
tex-franki.vf \
tex-he8.enc \
tex-he8aharoni.fd \
tex-he8cmr.fd \
tex-he8cmss.fd \
tex-he8cmtt.fd \
tex-he8david.fd \
tex-he8drugulin.fd \
tex-he8ellinia.fd \
tex-he8frank.fd \
tex-he8miriam.fd \
tex-he8nachlieli.fd \
tex-he8yad.fd \
tex-miriam-new.tfm \
tex-miriam-new.vf \
tex-miriam.tfm \
tex-miriam.vf \
tex-miriamClmNkd.tfm \
tex-miriamClmNkd.vf \
tex-miriamClmNkdb.tfm \
tex-miriamClmNkdb.vf \
tex-miriamClmNkdbi.tfm \
tex-miriamClmNkdbi.vf \
tex-miriamClmNkdi.tfm \
tex-miriamClmNkdi.vf \
tex-miriamb-new.tfm \
tex-miriamb-new.vf \
tex-miriamb.tfm \
tex-miriamb.vf \
tex-miriambi-new.tfm \
tex-miriambi-new.vf \
tex-miriambi.tfm \
tex-miriambi.vf \
tex-miriami-new.tfm \
tex-miriami-new.vf \
tex-miriami.tfm \
tex-miriami.vf \
tex-nachlieli-new.tfm \
tex-nachlieli-new.vf \
tex-nachlieli.tfm \
tex-nachlieli.vf \
tex-nachlieliClmNkd.tfm \
tex-nachlieliClmNkd.vf \
tex-nachlieliClmNkdb.tfm \
tex-nachlieliClmNkdb.vf \
tex-nachlieliClmNkdbi.tfm \
tex-nachlieliClmNkdbi.vf \
tex-nachlieliClmNkdi.tfm \
tex-nachlieliClmNkdi.vf \
tex-nachlielib-new.tfm \
tex-nachlielib-new.vf \
tex-nachlielib.tfm \
tex-nachlielib.vf \
tex-nachlielibi-new.tfm \
tex-nachlielibi-new.vf \
tex-nachlielibi.tfm \
tex-nachlielibi.vf \
tex-nachlielii-new.tfm \
tex-nachlielii-new.vf \
tex-nachlielii.tfm \
tex-nachlielii.vf \
tex-nhe8.enc \
tex-nhe8aharoni.fd \
tex-nhe8cmr.fd \
tex-nhe8cmss.fd \
tex-nhe8cmtt.fd \
tex-nhe8david.fd \
tex-nhe8drugulin.fd \
tex-nhe8ellinia.fd \
tex-nhe8frank.fd \
tex-nhe8miriam.fd \
tex-nhe8nachlieli.fd \
tex-nhe8yad.fd \
tex-raharoni-new.tfm \
tex-raharoni.tfm \
tex-raharonib-new.tfm \
tex-raharonib.tfm \
tex-raharonibi-new.tfm \
tex-raharonibi.tfm \
tex-raharonii-new.tfm \
tex-raharonii.tfm \
tex-rcaladings-new.tfm \
tex-rcaladings.tfm \
tex-rdavid-new.tfm \
tex-rdavid.tfm \
tex-rdavidb-new.tfm \
tex-rdavidb.tfm \
tex-rdavidbi-new.tfm \
tex-rdavidi-new.tfm \
tex-rdavidi.tfm \
tex-rdrugulinb-new.tfm \
tex-rdrugulinb.tfm \
tex-rdrugulinbi-new.tfm \
tex-rdrugulinbi.tfm \
tex-rellinia-new.tfm \
tex-rellinia.tfm \
tex-relliniab-new.tfm \
tex-relliniab.tfm \
tex-relliniabi-new.tfm \
tex-relliniabi.tfm \
tex-relliniai-new.tfm \
tex-relliniai.tfm \
tex-rfrank-new.tfm \
tex-rfrank.tfm \
tex-rfrankClmNkd.tfm \
tex-rfrankClmNkdb.tfm \
tex-rfrankClmNkdbi.tfm \
tex-rfrankClmNkdi.tfm \
tex-rfrankb-new.tfm \
tex-rfrankb.tfm \
tex-rfrankbi-new.tfm \
tex-rfrankbi.tfm \
tex-rfranki-new.tfm \
tex-rfranki.tfm \
tex-rmiriam-new.tfm \
tex-rmiriam.tfm \
tex-rmiriamClmNkd.tfm \
tex-rmiriamClmNkdb.tfm \
tex-rmiriamClmNkdbi.tfm \
tex-rmiriamClmNkdi.tfm \
tex-rmiriamb-new.tfm \
tex-rmiriamb.tfm \
tex-rmiriambi-new.tfm \
tex-rmiriambi.tfm \
tex-rmiriami-new.tfm \
tex-rmiriami.tfm \
tex-rnachlieli-new.tfm \
tex-rnachlieli.tfm \
tex-rnachlieliClmNkd.tfm \
tex-rnachlieliClmNkdb.tfm \
tex-rnachlieliClmNkdbi.tfm \
tex-rnachlieliClmNkdi.tfm \
tex-rnachlielib-new.tfm \
tex-rnachlielib.tfm \
tex-rnachlielibi-new.tfm \
tex-rnachlielibi.tfm \
tex-rnachlielii-new.tfm \
tex-rnachlielii.tfm \
tex-ryadbi-new.tfm \
tex-ryadbi.tfm \
tex-ryadi-new.tfm \
tex-ryadi.tfm \
tex-ryehuda-new.tfm \
tex-ryehuda.tfm \
tex-ryehudab-new.tfm \
tex-ryehudab.tfm \
tex-yadbi-new.tfm \
tex-yadbi-new.vf \
tex-yadbi.tfm \
tex-yadbi.vf \
tex-yadi-new.tfm \
tex-yadi-new.vf \
tex-yadi.tfm \
tex-yadi.vf \
tex-yehuda-new.tfm \
tex-yehuda-new.vf \
tex-yehuda.tfm \
tex-yehuda.vf \
tex-yehudab-new.tfm \
tex-yehudab-new.vf \
tex-yehudab.tfm \
tex-yehudab.vf \
texlive-culmus"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-updmap.cfg \
texlive \
texlive-culmus-fonts \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
