SUMMARY = "Translations for package libKPim6Tnef6"
DESCRIPTION = "Provides translations for the 'libKPim6Tnef6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6Tnef6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "ed87604cf8a17c7a6c2dae987ddbe5fa77153a1c83c48de8039ec4d3f56869882a61a3bedf11a6098a6f38299af1bdd238ed4d4756e61ae45c524b865bbb2bcd"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6Tnef6-lang \
libKPim6Tnef6-lang-all \
locale-libKPim6Tnef6-ar \
locale-libKPim6Tnef6-ast \
locale-libKPim6Tnef6-be \
locale-libKPim6Tnef6-bs \
locale-libKPim6Tnef6-ca \
locale-libKPim6Tnef6-ca@valencia \
locale-libKPim6Tnef6-cs \
locale-libKPim6Tnef6-da \
locale-libKPim6Tnef6-de \
locale-libKPim6Tnef6-el \
locale-libKPim6Tnef6-en-GB \
locale-libKPim6Tnef6-eo \
locale-libKPim6Tnef6-es \
locale-libKPim6Tnef6-et \
locale-libKPim6Tnef6-eu \
locale-libKPim6Tnef6-fi \
locale-libKPim6Tnef6-fr \
locale-libKPim6Tnef6-ga \
locale-libKPim6Tnef6-gl \
locale-libKPim6Tnef6-he \
locale-libKPim6Tnef6-hi \
locale-libKPim6Tnef6-hu \
locale-libKPim6Tnef6-ia \
locale-libKPim6Tnef6-it \
locale-libKPim6Tnef6-ja \
locale-libKPim6Tnef6-ka \
locale-libKPim6Tnef6-kk \
locale-libKPim6Tnef6-km \
locale-libKPim6Tnef6-ko \
locale-libKPim6Tnef6-lt \
locale-libKPim6Tnef6-lv \
locale-libKPim6Tnef6-mai \
locale-libKPim6Tnef6-mr \
locale-libKPim6Tnef6-nb \
locale-libKPim6Tnef6-nds \
locale-libKPim6Tnef6-nl \
locale-libKPim6Tnef6-nn \
locale-libKPim6Tnef6-pa \
locale-libKPim6Tnef6-pl \
locale-libKPim6Tnef6-pt \
locale-libKPim6Tnef6-pt-BR \
locale-libKPim6Tnef6-ro \
locale-libKPim6Tnef6-ru \
locale-libKPim6Tnef6-sk \
locale-libKPim6Tnef6-sl \
locale-libKPim6Tnef6-sq \
locale-libKPim6Tnef6-sr \
locale-libKPim6Tnef6-sr@ijekavian \
locale-libKPim6Tnef6-sr@ijekavianlatin \
locale-libKPim6Tnef6-sr@latin \
locale-libKPim6Tnef6-sv \
locale-libKPim6Tnef6-tr \
locale-libKPim6Tnef6-ug \
locale-libKPim6Tnef6-uk \
locale-libKPim6Tnef6-zh-CN \
locale-libKPim6Tnef6-zh-TW"

RDEPENDS:${PN} += "libKPim6Tnef6"

inherit rpm
