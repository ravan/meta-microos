SUMMARY = "Translations for package libKF6TextWidgets6"
DESCRIPTION = "Provides translations for the 'libKF6TextWidgets6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6TextWidgets6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "4d04a44f4ec8406930fa45b0a1448e0d9fc1a1099da91388afc427f60b8bb6eaed772a035116575439d09ab4aa005d1ee8aef1d20316d41f6174aaa6f8e7d7f5"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6TextWidgets6-lang \
libKF6TextWidgets6-lang-all \
locale-libKF6TextWidgets6-af \
locale-libKF6TextWidgets6-ar \
locale-libKF6TextWidgets6-as \
locale-libKF6TextWidgets6-ast \
locale-libKF6TextWidgets6-az \
locale-libKF6TextWidgets6-be \
locale-libKF6TextWidgets6-be@latin \
locale-libKF6TextWidgets6-bg \
locale-libKF6TextWidgets6-bn \
locale-libKF6TextWidgets6-bn-IN \
locale-libKF6TextWidgets6-br \
locale-libKF6TextWidgets6-bs \
locale-libKF6TextWidgets6-ca \
locale-libKF6TextWidgets6-ca@valencia \
locale-libKF6TextWidgets6-cs \
locale-libKF6TextWidgets6-cy \
locale-libKF6TextWidgets6-da \
locale-libKF6TextWidgets6-de \
locale-libKF6TextWidgets6-el \
locale-libKF6TextWidgets6-en-GB \
locale-libKF6TextWidgets6-eo \
locale-libKF6TextWidgets6-es \
locale-libKF6TextWidgets6-et \
locale-libKF6TextWidgets6-eu \
locale-libKF6TextWidgets6-fa \
locale-libKF6TextWidgets6-fi \
locale-libKF6TextWidgets6-fr \
locale-libKF6TextWidgets6-ga \
locale-libKF6TextWidgets6-gd \
locale-libKF6TextWidgets6-gl \
locale-libKF6TextWidgets6-gu \
locale-libKF6TextWidgets6-he \
locale-libKF6TextWidgets6-hi \
locale-libKF6TextWidgets6-hr \
locale-libKF6TextWidgets6-hu \
locale-libKF6TextWidgets6-ia \
locale-libKF6TextWidgets6-id \
locale-libKF6TextWidgets6-is \
locale-libKF6TextWidgets6-it \
locale-libKF6TextWidgets6-ja \
locale-libKF6TextWidgets6-ka \
locale-libKF6TextWidgets6-kk \
locale-libKF6TextWidgets6-km \
locale-libKF6TextWidgets6-kn \
locale-libKF6TextWidgets6-ko \
locale-libKF6TextWidgets6-lt \
locale-libKF6TextWidgets6-lv \
locale-libKF6TextWidgets6-mai \
locale-libKF6TextWidgets6-mk \
locale-libKF6TextWidgets6-ml \
locale-libKF6TextWidgets6-mr \
locale-libKF6TextWidgets6-ms \
locale-libKF6TextWidgets6-nb \
locale-libKF6TextWidgets6-nds \
locale-libKF6TextWidgets6-ne \
locale-libKF6TextWidgets6-nl \
locale-libKF6TextWidgets6-nn \
locale-libKF6TextWidgets6-oc \
locale-libKF6TextWidgets6-or \
locale-libKF6TextWidgets6-pa \
locale-libKF6TextWidgets6-pl \
locale-libKF6TextWidgets6-pt \
locale-libKF6TextWidgets6-pt-BR \
locale-libKF6TextWidgets6-ro \
locale-libKF6TextWidgets6-ru \
locale-libKF6TextWidgets6-si \
locale-libKF6TextWidgets6-sk \
locale-libKF6TextWidgets6-sl \
locale-libKF6TextWidgets6-sq \
locale-libKF6TextWidgets6-sr \
locale-libKF6TextWidgets6-sr@ijekavian \
locale-libKF6TextWidgets6-sr@ijekavianlatin \
locale-libKF6TextWidgets6-sr@latin \
locale-libKF6TextWidgets6-sv \
locale-libKF6TextWidgets6-ta \
locale-libKF6TextWidgets6-te \
locale-libKF6TextWidgets6-th \
locale-libKF6TextWidgets6-tr \
locale-libKF6TextWidgets6-ug \
locale-libKF6TextWidgets6-uk \
locale-libKF6TextWidgets6-vi \
locale-libKF6TextWidgets6-wa \
locale-libKF6TextWidgets6-zh-CN \
locale-libKF6TextWidgets6-zh-HK \
locale-libKF6TextWidgets6-zh-TW"

RDEPENDS:${PN} += "libKF6TextWidgets6"

inherit rpm
