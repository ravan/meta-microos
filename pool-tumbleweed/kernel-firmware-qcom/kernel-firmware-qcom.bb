SUMMARY = "Kernel firmware files for Qualcomm device drivers"
DESCRIPTION = "This package contains kernel firmware files for Qualcomm device drivers."
LICENSE = "GPL-2.0-or-later & SUSE-Firmware"

PV = "20260828"

RPM_NAME = "kernel-firmware-qcom-20260828-1.1.noarch.rpm"
RPM_HASH = "cbc14632d1274e1c15ae6c295a16446708b6d5fd375e4f450bad98efc8dae662129493d9dd37ae92c099fbd8acbc28323eb35f45bd53d60d9d91a9ec00272f03"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "firmware-a300-pfp.fw \
firmware-a300-pm4.fw \
firmware-qcom/a225-pfp.fw \
firmware-qcom/a225-pm4.fw \
firmware-qcom/a300-pfp.fw \
firmware-qcom/a300-pm4.fw \
firmware-qcom/a330-pfp.fw \
firmware-qcom/a330-pm4.fw \
firmware-qcom/a420-pfp.fw \
firmware-qcom/a420-pm4.fw \
firmware-qcom/a530-pfp.fw \
firmware-qcom/a530-pm4.fw \
firmware-qcom/a530-zap.mdt \
firmware-qcom/a530v3-gpmu.fw2 \
firmware-qcom/a612-rgmu.bin \
firmware-qcom/a623-gmu.bin \
firmware-qcom/a630-gmu.bin \
firmware-qcom/a630-sqe.fw \
firmware-qcom/a640-gmu.bin \
firmware-qcom/a650-gmu.bin \
firmware-qcom/a650-sqe.fw \
firmware-qcom/a660-gmu.bin \
firmware-qcom/a660-sqe.fw \
firmware-qcom/a663-gmu.bin \
firmware-qcom/a702-sqe.fw \
firmware-qcom/a730-sqe.fw \
firmware-qcom/a740-sqe.fw \
firmware-qcom/aic100/fw1.bin \
firmware-qcom/aic100/fw10.bin \
firmware-qcom/aic100/fw2.bin \
firmware-qcom/aic100/fw5.bin \
firmware-qcom/aic100/fw9.bin \
firmware-qcom/aic100/sbl.bin \
firmware-qcom/apq8016/WCNSS-qcom-wlan-nv-sbc.bin \
firmware-qcom/apq8016/mba.mbn \
firmware-qcom/apq8016/modem.mbn \
firmware-qcom/apq8016/wcnss.mbn \
firmware-qcom/apq8096/a530-zap.mbn \
firmware-qcom/apq8096/adsp.mbn \
firmware-qcom/apq8096/adspr.jsn \
firmware-qcom/apq8096/adspua.jsn \
firmware-qcom/apq8096/mba.mbn \
firmware-qcom/apq8096/modem.mbn \
firmware-qcom/apq8096/modemr.jsn \
firmware-qcom/eliza/cdsp-dtb.mbn \
firmware-qcom/eliza/cdsp.mbn \
firmware-qcom/eliza/cdspr.jsn \
firmware-qcom/eliza/gen71700-zap.mbn \
firmware-qcom/gen70500-gmu.bin \
firmware-qcom/gen70500-sqe.fw \
firmware-qcom/gen70900-aqe.fw \
firmware-qcom/gen70900-sqe.fw \
firmware-qcom/gen71500-gmu.bin \
firmware-qcom/gen71500-sqe.fw \
firmware-qcom/gen71700-gmu.bin \
firmware-qcom/gen71700-sqe.fw \
firmware-qcom/gen80000-aqe.fw \
firmware-qcom/gen80000-gmu.bin \
firmware-qcom/gen80000-sqe.fw \
firmware-qcom/gen80100-aqe.fw \
firmware-qcom/gen80100-gmu.bin \
firmware-qcom/gen80100-sqe.fw \
firmware-qcom/gen80200-aqe.fw \
firmware-qcom/gen80200-gmu.bin \
firmware-qcom/gen80200-sqe.fw \
firmware-qcom/glymur/adsp-dtb.mbn \
firmware-qcom/glymur/adsp.mbn \
firmware-qcom/glymur/adspr.jsn \
firmware-qcom/glymur/adsps.jsn \
firmware-qcom/glymur/adspua.jsn \
firmware-qcom/glymur/cdsp-dtb.mbn \
firmware-qcom/glymur/cdsp.mbn \
firmware-qcom/glymur/cdspr.jsn \
firmware-qcom/glymur/gen80100-zap.mbn \
firmware-qcom/gmu-gen70000.bin \
firmware-qcom/gmu-gen70200.bin \
firmware-qcom/gmu-gen70900.bin \
firmware-qcom/hawi/adsp-dtb.mbn \
firmware-qcom/hawi/adsp.mbn \
firmware-qcom/hawi/adspr.jsn \
firmware-qcom/hawi/adsps.jsn \
firmware-qcom/hawi/adspua.jsn \
firmware-qcom/hawi/adspuo.jsn \
firmware-qcom/kaanapali/adsp-dtb.mbn \
firmware-qcom/kaanapali/adsp.mbn \
firmware-qcom/kaanapali/adspr.jsn \
firmware-qcom/kaanapali/adsps.jsn \
firmware-qcom/kaanapali/adspua.jsn \
firmware-qcom/kaanapali/adspuo.jsn \
firmware-qcom/kaanapali/cdsp-dtb.mbn \
firmware-qcom/kaanapali/cdsp.mbn \
firmware-qcom/kaanapali/cdspr.jsn \
firmware-qcom/kaanapali/gen80200-zap.mbn \
firmware-qcom/kaanapali/soccp-dtb.mbn \
firmware-qcom/kaanapali/soccp.mbn \
firmware-qcom/kaanapali/soccpr.jsn \
firmware-qcom/leia-pfp-470.fw \
firmware-qcom/leia-pm4-470.fw \
firmware-qcom/nord/adsp-dtb.mbn \
firmware-qcom/nord/adsp.mbn \
firmware-qcom/nord/adsp1-dtb.mbn \
firmware-qcom/nord/adsp1.mbn \
firmware-qcom/nord/adsp1r.jsn \
firmware-qcom/nord/adspr.jsn \
firmware-qcom/nord/adspua.jsn \
firmware-qcom/nord/cdsp-dtb.mbn \
firmware-qcom/nord/cdsp.mbn \
firmware-qcom/nord/cdspr.jsn \
firmware-qcom/nord/qupv3fw.elf \
firmware-qcom/qcm2290/a702-zap.mbn \
firmware-qcom/qcm2290/adsp.mbn \
firmware-qcom/qcm2290/adspr.jsn \
firmware-qcom/qcm2290/adsps.jsn \
firmware-qcom/qcm2290/adspua.jsn \
firmware-qcom/qcm2290/modem.mbn \
firmware-qcom/qcm2290/modemr.jsn \
firmware-qcom/qcm2290/modemuw.jsn \
firmware-qcom/qcm6490/a660-zap.mbn \
firmware-qcom/qcm6490/adsp.mbn \
firmware-qcom/qcm6490/adspr.jsn \
firmware-qcom/qcm6490/adsps.jsn \
firmware-qcom/qcm6490/adspua.jsn \
firmware-qcom/qcm6490/battmgr.jsn \
firmware-qcom/qcm6490/cdsp.mbn \
firmware-qcom/qcm6490/cdspr.jsn \
firmware-qcom/qcm6490/ipa-fws.mbn \
firmware-qcom/qcm6490/qupv3fw.elf \
firmware-qcom/qcs615/a612-zap.mbn \
firmware-qcom/qcs615/adsp.mbn \
firmware-qcom/qcs615/adspr.jsn \
firmware-qcom/qcs615/adsps.jsn \
firmware-qcom/qcs615/adspua.jsn \
firmware-qcom/qcs615/cdsp.mbn \
firmware-qcom/qcs615/cdspr.jsn \
firmware-qcom/qcs615/qupv3fw.elf \
firmware-qcom/qcs6490/Thundercomm/RubikPi3/adsp.mbn \
firmware-qcom/qcs6490/Thundercomm/RubikPi3/adspr.jsn \
firmware-qcom/qcs6490/Thundercomm/RubikPi3/adsps.jsn \
firmware-qcom/qcs6490/Thundercomm/RubikPi3/adspua.jsn \
firmware-qcom/qcs6490/a660-zap.mbn \
firmware-qcom/qcs6490/adsp.mbn \
firmware-qcom/qcs6490/adspr.jsn \
firmware-qcom/qcs6490/adsps.jsn \
firmware-qcom/qcs6490/adspua.jsn \
firmware-qcom/qcs6490/battmgr.jsn \
firmware-qcom/qcs6490/cdsp.mbn \
firmware-qcom/qcs6490/cdspr.jsn \
firmware-qcom/qcs6490/qupv3fw.elf \
firmware-qcom/qcs6490/radxa/dragon-q6a/adsp.mbn \
firmware-qcom/qcs6490/radxa/dragon-q6a/adspr.jsn \
firmware-qcom/qcs6490/radxa/dragon-q6a/adspua.jsn \
firmware-qcom/qcs6490/radxa/dragon-q6a/cdsp.mbn \
firmware-qcom/qcs6490/radxa/dragon-q6a/cdspr.jsn \
firmware-qcom/qcs8300/a623-zap.mbn \
firmware-qcom/qcs8300/adsp.mbn \
firmware-qcom/qcs8300/adspr.jsn \
firmware-qcom/qcs8300/adspua.jsn \
firmware-qcom/qcs8300/cdsp0.mbn \
firmware-qcom/qcs8300/cdspr.jsn \
firmware-qcom/qcs8300/gpdsp0.mbn \
firmware-qcom/qcs8300/gpdspr.jsn \
firmware-qcom/qcs8300/qupv3fw.elf \
firmware-qcom/qdu100/abl-userdebug.elf \
firmware-qcom/qdu100/aop-devcfg.mbn \
firmware-qcom/qdu100/aop.mbn \
firmware-qcom/qdu100/cpucp.elf \
firmware-qcom/qdu100/efs1.bin \
firmware-qcom/qdu100/efs2.bin \
firmware-qcom/qdu100/efs3.bin \
firmware-qcom/qdu100/fw-csm-gsi-3.0.elf \
firmware-qcom/qdu100/hypvm.mbn \
firmware-qcom/qdu100/mdmddr.mbn \
firmware-qcom/qdu100/multi-image-qti.mbn \
firmware-qcom/qdu100/multi-image.mbn \
firmware-qcom/qdu100/qdsp6sw-dtbs.elf \
firmware-qcom/qdu100/qdsp6sw.mbn.xz \
firmware-qcom/qdu100/qupv3fw.elf \
firmware-qcom/qdu100/shrm.elf \
firmware-qcom/qdu100/tz.mbn \
firmware-qcom/qdu100/uefi.elf \
firmware-qcom/qdu100/xbl-config.elf \
firmware-qcom/qdu100/xbl-ramdump.elf \
firmware-qcom/qdu100/xbl-s.melf \
firmware-qcom/qdu100/zeros-1sector.bin \
firmware-qcom/qrb4210/a610-zap.mbn \
firmware-qcom/qrb4210/adsp.mbn \
firmware-qcom/qrb4210/adspr.jsn \
firmware-qcom/qrb4210/adsps.jsn \
firmware-qcom/qrb4210/adspua.jsn \
firmware-qcom/qrb4210/cdsp.mbn \
firmware-qcom/qrb4210/cdspr.jsn \
firmware-qcom/qrb4210/modem.mbn \
firmware-qcom/qrb4210/modemr.jsn \
firmware-qcom/qrb4210/modemuw.jsn \
firmware-qcom/sa8775p/a663-zap.mbn \
firmware-qcom/sa8775p/adsp.mbn \
firmware-qcom/sa8775p/adspr.jsn \
firmware-qcom/sa8775p/adspua.jsn \
firmware-qcom/sa8775p/cdsp0.mbn \
firmware-qcom/sa8775p/cdsp1.mbn \
firmware-qcom/sa8775p/cdsp1r.jsn \
firmware-qcom/sa8775p/cdspr.jsn \
firmware-qcom/sa8775p/gpdsp0.mbn \
firmware-qcom/sa8775p/gpdsp1.mbn \
firmware-qcom/sa8775p/gpdsp1r.jsn \
firmware-qcom/sa8775p/gpdspr.jsn \
firmware-qcom/sa8775p/qupv3fw.elf \
firmware-qcom/sc8280xp/LENOVO/21BX/adspr.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/adspua.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/battmgr.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/cdspr.jsn \
firmware-qcom/sc8280xp/LENOVO/21BX/qcadsp8280.mbn \
firmware-qcom/sc8280xp/LENOVO/21BX/qccdsp8280.mbn \
firmware-qcom/sc8280xp/LENOVO/21BX/qcdxkmsuc8280.mbn \
firmware-qcom/sc8280xp/LENOVO/21BX/qcslpi8280.mbn \
firmware-qcom/sc8280xp/LENOVO/21BX/qcvss8280.mbn \
firmware-qcom/sdm845/Thundercomm/db845c/slpi.mbn \
firmware-qcom/sdm845/Thundercomm/db845c/slpir.jsn \
firmware-qcom/sdm845/Thundercomm/db845c/slpius.jsn \
firmware-qcom/sdm845/a630-zap.mbn \
firmware-qcom/sdm845/adsp.mbn \
firmware-qcom/sdm845/adspr.jsn \
firmware-qcom/sdm845/adspua.jsn \
firmware-qcom/sdm845/cdsp.mbn \
firmware-qcom/sdm845/cdspr.jsn \
firmware-qcom/sdm845/mba.mbn \
firmware-qcom/sdm845/modem-nm.mbn \
firmware-qcom/sdm845/modem.mbn \
firmware-qcom/sdm845/modemuw.jsn \
firmware-qcom/sdx35/foxconn/xbl-s-devprg-ns.melf \
firmware-qcom/sdx61/foxconn/prog-firehose-lite.elf \
firmware-qcom/shikra/a704-zap.mbn \
firmware-qcom/shikra/cdsp.mbn \
firmware-qcom/shikra/cdspr.jsn \
firmware-qcom/shikra/cqs/qdsp6sw.mbn \
firmware-qcom/shikra/lpaicp-dtb.mbn \
firmware-qcom/shikra/lpaicp.mbn \
firmware-qcom/shikra/lpaicpr.jsn \
firmware-qcom/shikra/qupv3fw.elf \
firmware-qcom/sm8150/a640-zap.mbn \
firmware-qcom/sm8250/Thundercomm/RB5/slpi.mbn \
firmware-qcom/sm8250/Thundercomm/RB5/slpir.jsn \
firmware-qcom/sm8250/Thundercomm/RB5/slpius.jsn \
firmware-qcom/sm8250/a650-zap.mbn \
firmware-qcom/sm8250/adsp.mbn \
firmware-qcom/sm8250/adspr.jsn \
firmware-qcom/sm8250/adspua.jsn \
firmware-qcom/sm8250/cdsp.mbn \
firmware-qcom/sm8250/cdspr.jsn \
firmware-qcom/sm8350/a660-zap.mbn \
firmware-qcom/sm8450/a730-zap.mbn \
firmware-qcom/sm8550/a740-zap.mbn \
firmware-qcom/sm8650/gen70900-zap.mbn \
firmware-qcom/sm8750/adsp-dtb.mbn \
firmware-qcom/sm8750/adsp.mbn \
firmware-qcom/sm8750/adspr.jsn \
firmware-qcom/sm8750/adsps.jsn \
firmware-qcom/sm8750/adspua.jsn \
firmware-qcom/sm8750/adspuo.jsn \
firmware-qcom/sm8750/cdsp-dtb.mbn \
firmware-qcom/sm8750/cdsp.mbn \
firmware-qcom/sm8750/cdspr.jsn \
firmware-qcom/sm8750/gen80000-zap.mbn \
firmware-qcom/x1e80100/LENOVO/21N1/adsp-dtbs.elf \
firmware-qcom/x1e80100/LENOVO/21N1/adspr.jsn \
firmware-qcom/x1e80100/LENOVO/21N1/adsps.jsn \
firmware-qcom/x1e80100/LENOVO/21N1/adspua.jsn \
firmware-qcom/x1e80100/LENOVO/21N1/battmgr.jsn \
firmware-qcom/x1e80100/LENOVO/21N1/cdsp-dtbs.elf \
firmware-qcom/x1e80100/LENOVO/21N1/cdspr.jsn \
firmware-qcom/x1e80100/LENOVO/21N1/qcadsp8380.mbn \
firmware-qcom/x1e80100/LENOVO/21N1/qccdsp8380.mbn \
firmware-qcom/x1e80100/LENOVO/21N1/qcdxkmsuc8380.mbn \
firmware-qcom/x1e80100/LENOVO/21N1/qcvss8380.mbn \
firmware-qcom/x1e80100/LENOVO/83ED/adsp-dtbs.elf \
firmware-qcom/x1e80100/LENOVO/83ED/adspr.jsn \
firmware-qcom/x1e80100/LENOVO/83ED/adsps.jsn \
firmware-qcom/x1e80100/LENOVO/83ED/adspua.jsn \
firmware-qcom/x1e80100/LENOVO/83ED/battmgr.jsn \
firmware-qcom/x1e80100/LENOVO/83ED/cdspr.jsn \
firmware-qcom/x1e80100/LENOVO/83ED/qcadsp8380.mbn \
firmware-qcom/x1e80100/LENOVO/83ED/qcav1e8380.mbn \
firmware-qcom/x1e80100/LENOVO/83ED/qccdsp8380.mbn \
firmware-qcom/x1e80100/LENOVO/83ED/qcdxkmsuc8380.mbn \
firmware-qcom/x1e80100/LENOVO/83ED/qcvss8380.mbn \
firmware-qcom/x1e80100/adsp-dtb.mbn \
firmware-qcom/x1e80100/adsp.mbn \
firmware-qcom/x1e80100/adspr.jsn \
firmware-qcom/x1e80100/adsps.jsn \
firmware-qcom/x1e80100/adspua.jsn \
firmware-qcom/x1e80100/battmgr.jsn \
firmware-qcom/x1e80100/cdsp-dtb.mbn \
firmware-qcom/x1e80100/cdsp.mbn \
firmware-qcom/x1e80100/cdspr.jsn \
firmware-qcom/x1e80100/dell/xps13-9345/adsp-dtbs.elf \
firmware-qcom/x1e80100/dell/xps13-9345/adspr.jsn \
firmware-qcom/x1e80100/dell/xps13-9345/adsps.jsn \
firmware-qcom/x1e80100/dell/xps13-9345/adspua.jsn \
firmware-qcom/x1e80100/dell/xps13-9345/battmgr.jsn \
firmware-qcom/x1e80100/dell/xps13-9345/cdsp-dtbs.elf \
firmware-qcom/x1e80100/dell/xps13-9345/cdspr.jsn \
firmware-qcom/x1e80100/dell/xps13-9345/qcadsp8380.mbn \
firmware-qcom/x1e80100/dell/xps13-9345/qccdsp8380.mbn \
firmware-qcom/x1e80100/dell/xps13-9345/qcdxkmsuc8380.mbn \
firmware-qcom/x1e80100/gen70500-zap.mbn \
firmware-qcom/x1e80100/qupv3fw.elf \
firmware-qcom/x1p42100/gen71500-zap.mbn \
firmware-qcom/yamato-pfp.fw \
firmware-qcom/yamato-pm4.fw \
kernel-firmware-qcom"

RDEPENDS:${PN} += "/usr/bin/mkdir \
/usr/bin/sh \
/usr/bin/touch \
dracut"

inherit rpm
