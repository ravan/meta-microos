SUMMARY = "The GNU versions of find utilities (find and xargs)"
DESCRIPTION = "The findutils package contains programs which will help you locate \
files on your system.  The find utility searches through a hierarchy \
of directories looking for files which match a certain set of criteria \
(such as a file name pattern).  The xargs utility builds and executes \
command lines from standard input arguments (usually lists of file \
names generated by the find command). \
 \
You should install findutils because it includes tools that are very \
useful for finding things on your system."
LICENSE = "GPL-3.0-or-later"

PV = "4.11.0"

RPM_NAME = "findutils-4.11.0-1.2.aarch64.rpm"
RPM_HASH = "3c474c75a47ab1afb8601634c81bbba8e01a8ebb56f9a9a7392d8c7811ac3ffa34e508e9273ef75787c52c992811f57e0fc084e21743d0b1b5dd8aff5bcf11dc"

RPROVIDES:${PN} += "find \
findutils"

RDEPENDS:${PN} += "ld-linux-aarch64.so.1 \
libc.so.6 \
libm.so.6 \
libselinux.so.1"

inherit rpm
