SUMMARY = "Configuration utilities for bcachefs"
DESCRIPTION = "Bcachefs is a filesystem for Linux, with an emphasis on reliability \
and robustness. \
 \
* Copy on write (COW) like zfs or btrfs \
* Full data and metadata checksumming \
* Multiple devices \
* Replication \
* Erasure coding \
* Caching \
* Compression \
* Encryption \
* Snapshots \
 \
This package contains utilities for creating and mounting bcachefs."
LICENSE = "Apache-2.0 & (Apache-2.0 | MIT) & (Apache-2.0 | Apache-2.0-with-LLVM-exception | MIT) & MIT & MPL-2.0 & (MIT | Unlicense) & BSD-3-Clause & GPL-2.0-only & GPL-2.0-or-later & LGPL-2.1-only"

PV = "1.39.6_k7.2.5_1"

RPM_NAME = "bcachefs-kmp-default-1.39.6_k7.2.5_1-1.1.aarch64.rpm"
RPM_HASH = "bab2befa3ebda4fe9baa2e5264a75698dcd9e64f37f7aab029275ef42063709ba4396c339192786c73eacbef97bd0761151c701f29c7d874efb468e57c58d375"

RPROVIDES:${PN} += "bcachefs-kmp \
bcachefs-kmp-default \
bcachefs-kmp-default-k7.2.5-1 \
kmod-bcachefs.ko \
ksym-default---six-lock-init \
ksym-default-bch2-run-thread-with-stdout \
ksym-default-mean-and-variance-get-mad \
ksym-default-mean-and-variance-get-mean \
ksym-default-mean-and-variance-get-median \
ksym-default-mean-and-variance-get-stddev \
ksym-default-six-lock-contended \
ksym-default-six-lock-counts \
ksym-default-six-lock-downgrade \
ksym-default-six-lock-exit \
ksym-default-six-lock-increment \
ksym-default-six-lock-ip-waiter \
ksym-default-six-lock-readers-add \
ksym-default-six-lock-tryupgrade \
ksym-default-six-lock-wakeup-all \
ksym-default-six-relock-ip \
ksym-default-six-trylock-convert \
ksym-default-six-trylock-ip \
ksym-default-six-unlock-ip \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
grep \
kernel-default \
ksym-default----ratelimit \
ksym-default---arch-clear-user \
ksym-default---arch-copy-from-user \
ksym-default---arch-copy-to-user \
ksym-default---audit-inode-child \
ksym-default---bio-advance \
ksym-default---bio-release-pages \
ksym-default---bitmap-and \
ksym-default---bitmap-andnot \
ksym-default---bitmap-or \
ksym-default---bitmap-weight \
ksym-default---check-object-size \
ksym-default---cpu-online-mask \
ksym-default---cpu-possible-mask \
ksym-default---destroy-inode \
ksym-default---dynamic-pr-debug \
ksym-default---filemap-get-folio-mpol \
ksym-default---filemap-set-wb-err \
ksym-default---folio-batch-release \
ksym-default---folio-lock \
ksym-default---folio-put \
ksym-default---folio-start-writeback \
ksym-default---fortify-panic \
ksym-default---genradix-free \
ksym-default---genradix-iter-peek \
ksym-default---genradix-iter-peek-prev \
ksym-default---genradix-prealloc \
ksym-default---genradix-ptr \
ksym-default---genradix-ptr-alloc \
ksym-default---get-random-u32-below \
ksym-default---init-rwsem \
ksym-default---init-swait-queue-head \
ksym-default---init-waitqueue-head \
ksym-default---kmalloc-cache-noprof \
ksym-default---kmalloc-noprof \
ksym-default---kmem-cache-create-args \
ksym-default---kvmalloc-node-noprof \
ksym-default---list-add-valid-or-report \
ksym-default---list-del-entry-valid-or-report \
ksym-default---module-get \
ksym-default---msecs-to-jiffies \
ksym-default---num-online-cpus \
ksym-default---num-possible-cpus \
ksym-default---per-cpu-offset \
ksym-default---percpu-down-read \
ksym-default---percpu-init-rwsem \
ksym-default---percpu-up-read \
ksym-default---posix-acl-chmod \
ksym-default---put-task-struct-rcu-cb \
ksym-default---rcu-read-lock \
ksym-default---rcu-read-unlock \
ksym-default---refrigerator \
ksym-default---register-chrdev \
ksym-default---rhashtable-init-noprof \
ksym-default---rhltable-init-noprof \
ksym-default---rht-bucket-nested \
ksym-default---seq-puts \
ksym-default---srcu-read-lock \
ksym-default---srcu-read-unlock \
ksym-default---stack-chk-fail \
ksym-default---sw-hweight32 \
ksym-default---sw-hweight64 \
ksym-default---trace-set-current-state \
ksym-default---trace-trigger-soft-disabled \
ksym-default---traceiter-contention-begin \
ksym-default---traceiter-contention-end \
ksym-default---tracepoint-contention-begin \
ksym-default---tracepoint-contention-end \
ksym-default---tracepoint-sched-set-state-tp \
ksym-default---unregister-chrdev \
ksym-default---vmalloc-noprof \
ksym-default---wake-up \
ksym-default---warn-printk \
ksym-default---zero-page \
ksym-default--find-first-bit \
ksym-default--find-next-andnot-bit \
ksym-default--find-next-bit \
ksym-default--find-next-zero-bit \
ksym-default--printk \
ksym-default--raw-spin-lock \
ksym-default--raw-spin-lock-irq \
ksym-default--raw-spin-lock-irqsave \
ksym-default--raw-spin-unlock \
ksym-default--raw-spin-unlock-irq \
ksym-default--raw-spin-unlock-irqrestore \
ksym-default--totalram-pages \
ksym-default-LZ4-compress-HC \
ksym-default-LZ4-compress-destSize \
ksym-default-LZ4-decompress-safe-partial \
ksym-default-alloc-workqueue-noprof \
ksym-default-alt-cb-patch-nops \
ksym-default-anon-inode-getfile \
ksym-default-arm64-use-ng-mappings \
ksym-default-balance-dirty-pages-ratelimited \
ksym-default-bdev-file-open-by-path \
ksym-default-bdev-fput \
ksym-default-bdev-freeze \
ksym-default-bdev-thaw \
ksym-default-bio-add-folio \
ksym-default-bio-add-folio-nofail \
ksym-default-bio-add-virt-nofail \
ksym-default-bio-add-vmalloc \
ksym-default-bio-alloc-bioset \
ksym-default-bio-alloc-clone \
ksym-default-bio-associate-blkg \
ksym-default-bio-chain \
ksym-default-bio-copy-data \
ksym-default-bio-endio \
ksym-default-bio-init \
ksym-default-bio-kmalloc \
ksym-default-bio-put \
ksym-default-bio-reset \
ksym-default-bio-split \
ksym-default-bioset-exit \
ksym-default-bioset-init \
ksym-default-bit-wait \
ksym-default-bit-wait-io \
ksym-default-blk-finish-plug \
ksym-default-blk-start-plug \
ksym-default-blkdev-issue-discard \
ksym-default-bpf-trace-run2 \
ksym-default-call-rcu \
ksym-default-call-srcu \
ksym-default-cancel-delayed-work \
ksym-default-cancel-delayed-work-sync \
ksym-default-cancel-work-sync \
ksym-default-capable \
ksym-default-chacha-crypt \
ksym-default-class-register \
ksym-default-class-unregister \
ksym-default-cleanup-srcu-struct \
ksym-default-clear-inode \
ksym-default-complete \
ksym-default-console-trylock \
ksym-default-console-unlock \
ksym-default-copy-folio-from-iter-atomic \
ksym-default-copy-from-user-nofault \
ksym-default-copy-to-user-nofault \
ksym-default-cpumask-local-spread \
ksym-default-crc32c \
ksym-default-crc64-be \
ksym-default-current-time \
ksym-default-d-instantiate \
ksym-default-d-invalidate \
ksym-default-d-make-root \
ksym-default-d-mark-dontcache \
ksym-default-d-mark-tmpfile \
ksym-default-d-obtain-alias \
ksym-default-d-parent-ino \
ksym-default-d-prune-aliases \
ksym-default-d-splice-alias \
ksym-default-deactivate-locked-super \
ksym-default-debugfs-create-dir \
ksym-default-debugfs-create-file-full \
ksym-default-debugfs-remove \
ksym-default-delayed-work-timer-fn \
ksym-default-destroy-workqueue \
ksym-default-device-create \
ksym-default-device-destroy \
ksym-default-device-unregister \
ksym-default-dget-parent \
ksym-default-discard-new-inode \
ksym-default-down-read \
ksym-default-down-read-trylock \
ksym-default-down-trylock \
ksym-default-down-write \
ksym-default-dput \
ksym-default-drain-workqueue \
ksym-default-dump-stack \
ksym-default-dynamic-cond-resched \
ksym-default-dynamic-might-resched \
ksym-default-dynamic-preempt-schedule \
ksym-default-dynamic-preempt-schedule-notrace \
ksym-default-end-creating-path \
ksym-default-errname \
ksym-default-errseq-set \
ksym-default-evict-inodes \
ksym-default-fault-in-iov-iter-readable \
ksym-default-fault-in-readable \
ksym-default-fault-in-writeable \
ksym-default-fd-install \
ksym-default-fiemap-fill-next-extent \
ksym-default-fiemap-prep \
ksym-default-file-bdev \
ksym-default-file-check-and-advance-wb-err \
ksym-default-file-modified \
ksym-default-file-remove-privs \
ksym-default-file-update-time \
ksym-default-file-write-and-wait-range \
ksym-default-fileattr-fill-xflags \
ksym-default-filemap-add-folio \
ksym-default-filemap-alloc-folio-noprof \
ksym-default-filemap-dirty-folio \
ksym-default-filemap-dontcache-kick-writeback \
ksym-default-filemap-fault \
ksym-default-filemap-get-folios \
ksym-default-filemap-map-pages \
ksym-default-filemap-migrate-folio \
ksym-default-filemap-read \
ksym-default-filemap-splice-read \
ksym-default-filemap-write-and-wait-range \
ksym-default-filp-open \
ksym-default-finish-open \
ksym-default-finish-wait \
ksym-default-flush-dcache-folio \
ksym-default-flush-dcache-page \
ksym-default-flush-work \
ksym-default-folio-end-read \
ksym-default-folio-end-writeback \
ksym-default-folio-mark-dirty \
ksym-default-folio-mkclean \
ksym-default-folio-unlock \
ksym-default-folio-wait-stable \
ksym-default-fput \
ksym-default-free-pages \
ksym-default-free-percpu \
ksym-default-freezer-active \
ksym-default-freezing-slow-path \
ksym-default-from-kgid \
ksym-default-from-kqid \
ksym-default-from-kuid \
ksym-default-from-vfsgid \
ksym-default-from-vfsuid \
ksym-default-fs-bio-set \
ksym-default-fs-kobj \
ksym-default-fsnotify \
ksym-default-generic-ci-d-compare \
ksym-default-generic-ci-d-hash \
ksym-default-generic-error-remove-folio \
ksym-default-generic-file-llseek \
ksym-default-generic-file-llseek-size \
ksym-default-generic-file-open \
ksym-default-generic-read-dir \
ksym-default-generic-remap-file-range-prep \
ksym-default-generic-shutdown-super \
ksym-default-generic-write-checks \
ksym-default-get-free-pages-noprof \
ksym-default-get-random-bytes \
ksym-default-get-random-u64 \
ksym-default-get-state-synchronize-rcu \
ksym-default-get-state-synchronize-srcu \
ksym-default-get-unused-fd-flags \
ksym-default-hex-asc \
ksym-default-hex2bin \
ksym-default-ida-alloc-range \
ksym-default-ida-destroy \
ksym-default-ida-find-first-range \
ksym-default-ida-free \
ksym-default-idr-alloc \
ksym-default-idr-find \
ksym-default-idr-remove \
ksym-default-igrab \
ksym-default-ihold \
ksym-default-import-ubuf \
ksym-default-in-group-or-capable \
ksym-default-init-special-inode \
ksym-default-init-srcu-struct \
ksym-default-init-user-ns \
ksym-default-init-wait-entry \
ksym-default-inode-bit-waitqueue \
ksym-default-inode-dio-wait \
ksym-default-inode-init-always-gfp \
ksym-default-inode-init-once \
ksym-default-inode-newsize-ok \
ksym-default-inode-nohighmem \
ksym-default-inode-owner-or-capable \
ksym-default-inode-permission \
ksym-default-inode-sb-list-add \
ksym-default-inode-set-ctime-to-ts \
ksym-default-invalidate-bdev \
ksym-default-invalidate-inode-pages2-range \
ksym-default-io-schedule-timeout \
ksym-default-iov-iter-advance \
ksym-default-iov-iter-extract-pages \
ksym-default-iov-iter-npages \
ksym-default-iov-iter-revert \
ksym-default-iov-iter-single-seg-count \
ksym-default-iput \
ksym-default-irq-work-queue \
ksym-default-is-bad-inode \
ksym-default-is-vmalloc-addr \
ksym-default-iter-file-splice-write \
ksym-default-jiffies \
ksym-default-kasprintf \
ksym-default-kernel-read \
ksym-default-key-put \
ksym-default-key-type-user \
ksym-default-kfree \
ksym-default-kmalloc-caches \
ksym-default-kmem-cache-alloc-lru-noprof \
ksym-default-kmem-cache-alloc-noprof \
ksym-default-kmem-cache-destroy \
ksym-default-kmem-cache-free \
ksym-default-kmem-cache-free-bulk \
ksym-default-kmemdup-noprof \
ksym-default-kobject-add \
ksym-default-kobject-del \
ksym-default-kobject-init \
ksym-default-kobject-put \
ksym-default-kobject-uevent-env \
ksym-default-krealloc-node-align-noprof \
ksym-default-kstrdup \
ksym-default-kstrtouint \
ksym-default-kstrtoull \
ksym-default-kthread-create-on-node \
ksym-default-kthread-should-stop \
ksym-default-kthread-stop \
ksym-default-kthread-unuse-mm \
ksym-default-kthread-use-mm \
ksym-default-ktime-get \
ksym-default-ktime-get-coarse-real-ts64 \
ksym-default-ktime-get-real-seconds \
ksym-default-ktime-get-with-offset \
ksym-default-kvfree \
ksym-default-kvfree-call-rcu \
ksym-default-kvrealloc-node-align-noprof \
ksym-default-llist-reverse-order \
ksym-default-lock-two-nondirectories \
ksym-default-lockref-get \
ksym-default-logfc \
ksym-default-lookup-bdev \
ksym-default-lookup-constant \
ksym-default-make-bad-inode \
ksym-default-make-kgid \
ksym-default-make-kprojid \
ksym-default-make-kuid \
ksym-default-make-vfsgid \
ksym-default-make-vfsuid \
ksym-default-match-string \
ksym-default-memchr \
ksym-default-memcmp \
ksym-default-memcpy \
ksym-default-memcpy-and-pad \
ksym-default-memmove \
ksym-default-mempool-alloc-noprof \
ksym-default-mempool-exit \
ksym-default-mempool-free \
ksym-default-mempool-init-noprof \
ksym-default-mempool-kfree \
ksym-default-mempool-kmalloc \
ksym-default-memscan \
ksym-default-memset \
ksym-default-migrate-disable \
ksym-default-migrate-enable \
ksym-default-mnt-drop-write \
ksym-default-mnt-drop-write-file \
ksym-default-mnt-want-write \
ksym-default-mnt-want-write-file \
ksym-default-mod-delayed-work-on \
ksym-default-module-layout \
ksym-default-module-put \
ksym-default-msleep \
ksym-default-mul-u64-add-u64-div-u64 \
ksym-default-mutex-init-generic \
ksym-default-mutex-lock \
ksym-default-mutex-trylock \
ksym-default-mutex-unlock \
ksym-default-nonseekable-open \
ksym-default-nop-posix-acl-access \
ksym-default-nop-posix-acl-default \
ksym-default-nr-cpu-ids \
ksym-default-nsecs-to-jiffies \
ksym-default-out-of-line-wait-on-bit \
ksym-default-out-of-line-wait-on-bit-lock \
ksym-default-out-of-line-wait-on-bit-timeout \
ksym-default-page-get-link \
ksym-default-page-symlink \
ksym-default-panic \
ksym-default-param-ops-bool \
ksym-default-param-ops-uint \
ksym-default-param-set-bool \
ksym-default-path-put \
ksym-default-pcpu-alloc-noprof \
ksym-default-percpu-down-write \
ksym-default-percpu-free-rwsem \
ksym-default-percpu-ref-exit \
ksym-default-percpu-ref-init \
ksym-default-percpu-ref-is-zero \
ksym-default-percpu-ref-kill-and-confirm \
ksym-default-percpu-ref-reinit \
ksym-default-percpu-up-write \
ksym-default-perf-trace-buf-alloc \
ksym-default-perf-trace-run-bpf-submit \
ksym-default-poll-state-synchronize-rcu \
ksym-default-poll-state-synchronize-srcu \
ksym-default-poly1305-final \
ksym-default-poly1305-init \
ksym-default-poly1305-update \
ksym-default-posix-acl-alloc \
ksym-default-posix-acl-create \
ksym-default-posix-acl-update-mode \
ksym-default-power-supply-is-system-supplied \
ksym-default-power-supply-reg-notifier \
ksym-default-power-supply-unreg-notifier \
ksym-default-prepare-to-wait \
ksym-default-prepare-to-wait-event \
ksym-default-put-unused-fd \
ksym-default-queue-delayed-work-on \
ksym-default-queue-work-on \
ksym-default-quota-send-warning \
ksym-default-raid6-gen-syndrome \
ksym-default-raid6-recov-2data \
ksym-default-raid6-recov-datap \
ksym-default-random-kmalloc-seed \
ksym-default-rcu-barrier \
ksym-default-refcount-warn-saturate \
ksym-default-register-filesystem \
ksym-default-request-key-tag \
ksym-default-rhashtable-destroy \
ksym-default-rhashtable-free-and-destroy \
ksym-default-rhashtable-insert-slow \
ksym-default-rht-bucket-nested \
ksym-default-rht-bucket-nested-insert \
ksym-default-rw-verify-area \
ksym-default-sched-clock \
ksym-default-schedule \
ksym-default-schedule-timeout \
ksym-default-scnprintf \
ksym-default-security-inode-init-security \
ksym-default-security-path-mkdir \
ksym-default-seq-buf-printf \
ksym-default-seq-printf \
ksym-default-seq-putc \
ksym-default-set-cached-acl \
ksym-default-set-freezable \
ksym-default-set-nlink \
ksym-default-set-normalized-timespec64 \
ksym-default-setattr-prepare \
ksym-default-sget-fc \
ksym-default-sha256 \
ksym-default-shrink-dcache-parent \
ksym-default-shrink-dcache-sb \
ksym-default-shrinker-alloc \
ksym-default-shrinker-free \
ksym-default-shrinker-register \
ksym-default-si-mem-available \
ksym-default-si-meminfo \
ksym-default-siphash-2u64 \
ksym-default-sized-strscpy \
ksym-default-snprintf \
ksym-default-sort \
ksym-default-sort-nonatomic \
ksym-default-sort-r \
ksym-default-sort-r-nonatomic \
ksym-default-sprintf \
ksym-default-srcu-barrier \
ksym-default-stack-trace-save-tsk \
ksym-default-start-creating-user-path \
ksym-default-start-poll-synchronize-rcu \
ksym-default-start-poll-synchronize-srcu \
ksym-default-start-removing-dentry \
ksym-default-static-key-count \
ksym-default-static-key-disable \
ksym-default-static-key-enable \
ksym-default-strchrnul \
ksym-default-strcmp \
ksym-default-strcspn \
ksym-default-strim \
ksym-default-strlen \
ksym-default-strncmp \
ksym-default-strncpy-from-user \
ksym-default-strndup-user \
ksym-default-strnlen \
ksym-default-strrchr \
ksym-default-strsep \
ksym-default-submit-bio \
ksym-default-submit-bio-wait \
ksym-default-super-setup-bdi \
ksym-default-sync-filesystem \
ksym-default-sync-inode-metadata \
ksym-default-sync-inodes-sb \
ksym-default-synchronize-rcu \
ksym-default-synchronize-srcu-expedited \
ksym-default-sysfs-create-bin-file \
ksym-default-sysfs-create-file-ns \
ksym-default-sysfs-create-link \
ksym-default-sysfs-remove-bin-file \
ksym-default-sysfs-remove-link \
ksym-default-system-dfl-wq \
ksym-default-system-highpri-wq \
ksym-default-system-long-wq \
ksym-default-system-percpu-wq \
ksym-default-thp-get-unmapped-area \
ksym-default-timer-init-key \
ksym-default-touch-atime \
ksym-default-trace-event-buffer-commit \
ksym-default-trace-event-buffer-reserve \
ksym-default-trace-event-printf \
ksym-default-trace-event-raw-init \
ksym-default-trace-event-reg \
ksym-default-trace-handle-return \
ksym-default-trace-raw-output-prep \
ksym-default-tracepoint-srcu \
ksym-default-truncate-inode-pages-final \
ksym-default-truncate-pagecache \
ksym-default-truncate-pagecache-range \
ksym-default-truncate-setsize \
ksym-default-try-module-get \
ksym-default-unlock-two-nondirectories \
ksym-default-unpin-user-folio \
ksym-default-unpin-user-page \
ksym-default-unregister-filesystem \
ksym-default-up \
ksym-default-up-read \
ksym-default-up-write \
ksym-default-user-path-at \
ksym-default-utf8-casefold \
ksym-default-utf8-load \
ksym-default-utf8-unload \
ksym-default-validate-usercopy-range \
ksym-default-vfs-fsync-range \
ksym-default-vfs-setpos \
ksym-default-vmalloc-noprof \
ksym-default-vmap \
ksym-default-vprintk \
ksym-default-vsnprintf \
ksym-default-vunmap \
ksym-default-wait-for-completion \
ksym-default-wait-for-completion-timeout \
ksym-default-wake-up-bit \
ksym-default-wake-up-process \
ksym-default-wake-up-var \
ksym-default-work-busy \
ksym-default-write-inode-now \
ksym-default-writeback-iter \
ksym-default-xa-load \
ksym-default-xor-gen \
ksym-default-xxh64-digest \
ksym-default-xxh64-reset \
ksym-default-xxh64-update \
ksym-default-zlib-deflate \
ksym-default-zlib-deflate-workspacesize \
ksym-default-zlib-deflateEnd \
ksym-default-zlib-deflateInit2 \
ksym-default-zlib-inflate \
ksym-default-zlib-inflate-workspacesize \
ksym-default-zlib-inflateInit2 \
ksym-default-zstd-cctx-workspace-bound \
ksym-default-zstd-compress-cctx \
ksym-default-zstd-dctx-workspace-bound \
ksym-default-zstd-decompress-dctx \
ksym-default-zstd-get-error-code \
ksym-default-zstd-get-params \
ksym-default-zstd-init-cctx \
ksym-default-zstd-init-dctx \
ksym-default-zstd-is-error \
ksym-default-zstd-max-clevel \
suse-kernel-rpm-scriptlets"

inherit rpm
