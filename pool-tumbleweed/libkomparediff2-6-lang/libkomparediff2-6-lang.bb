SUMMARY = "Translations for package libkomparediff2-6"
DESCRIPTION = "Provides translations for the 'libkomparediff2-6' package."
LICENSE = "GPL-2.0-or-later"

PV = "26.08.1"

RPM_NAME = "libkomparediff2-6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "ee7cc9f9dd4174418dfa62905696a3760c007fba40c3b03888d89ad8836350269ac260fefd811571081dcdf762d1badf458fe6554e397eb11610f8855e63b3e4"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libkomparediff2-6-lang \
libkomparediff2-6-lang-all \
locale-libkomparediff2-6-af \
locale-libkomparediff2-6-ar \
locale-libkomparediff2-6-be \
locale-libkomparediff2-6-bg \
locale-libkomparediff2-6-br \
locale-libkomparediff2-6-bs \
locale-libkomparediff2-6-ca \
locale-libkomparediff2-6-ca@valencia \
locale-libkomparediff2-6-cs \
locale-libkomparediff2-6-cy \
locale-libkomparediff2-6-da \
locale-libkomparediff2-6-de \
locale-libkomparediff2-6-el \
locale-libkomparediff2-6-en-GB \
locale-libkomparediff2-6-eo \
locale-libkomparediff2-6-es \
locale-libkomparediff2-6-et \
locale-libkomparediff2-6-eu \
locale-libkomparediff2-6-fa \
locale-libkomparediff2-6-fi \
locale-libkomparediff2-6-fr \
locale-libkomparediff2-6-ga \
locale-libkomparediff2-6-gl \
locale-libkomparediff2-6-he \
locale-libkomparediff2-6-hi \
locale-libkomparediff2-6-hr \
locale-libkomparediff2-6-hu \
locale-libkomparediff2-6-ia \
locale-libkomparediff2-6-is \
locale-libkomparediff2-6-it \
locale-libkomparediff2-6-ja \
locale-libkomparediff2-6-ka \
locale-libkomparediff2-6-kk \
locale-libkomparediff2-6-km \
locale-libkomparediff2-6-ko \
locale-libkomparediff2-6-lt \
locale-libkomparediff2-6-lv \
locale-libkomparediff2-6-mai \
locale-libkomparediff2-6-mk \
locale-libkomparediff2-6-mr \
locale-libkomparediff2-6-ms \
locale-libkomparediff2-6-nb \
locale-libkomparediff2-6-nds \
locale-libkomparediff2-6-ne \
locale-libkomparediff2-6-nl \
locale-libkomparediff2-6-nn \
locale-libkomparediff2-6-oc \
locale-libkomparediff2-6-pa \
locale-libkomparediff2-6-pl \
locale-libkomparediff2-6-pt \
locale-libkomparediff2-6-pt-BR \
locale-libkomparediff2-6-ro \
locale-libkomparediff2-6-ru \
locale-libkomparediff2-6-sk \
locale-libkomparediff2-6-sl \
locale-libkomparediff2-6-sq \
locale-libkomparediff2-6-sr \
locale-libkomparediff2-6-sr@ijekavian \
locale-libkomparediff2-6-sr@ijekavianlatin \
locale-libkomparediff2-6-sr@latin \
locale-libkomparediff2-6-sv \
locale-libkomparediff2-6-ta \
locale-libkomparediff2-6-tr \
locale-libkomparediff2-6-ug \
locale-libkomparediff2-6-uk \
locale-libkomparediff2-6-zh-CN \
locale-libkomparediff2-6-zh-TW"

RDEPENDS:${PN} += "libkomparediff2-6"

inherit rpm
