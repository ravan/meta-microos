SUMMARY = "Kernel firmware files for Nvidia Tegra and graphics drivers"
DESCRIPTION = "This package contains kernel firmware files for Nvidia Tegra and graphics drivers."
LICENSE = "GPL-2.0-or-later & SUSE-Firmware"

PV = "20260610"

RPM_NAME = "kernel-firmware-nvidia-20260610-2.1.noarch.rpm"
RPM_HASH = "26d4b2c578c5b773e03ad128348bcf83699fde79e79e41358684d47d7091740ef507eeb78d63c9d7b6acb8398ae09371e9ca1d840bbdea53e741937b1509e0bb"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "firmware-nvidia/ad102/gsp/booter-load-535.113.01.bin \
firmware-nvidia/ad102/gsp/booter-load-570.144.bin \
firmware-nvidia/ad102/gsp/booter-unload-535.113.01.bin \
firmware-nvidia/ad102/gsp/booter-unload-570.144.bin \
firmware-nvidia/ad102/gsp/bootloader-535.113.01.bin \
firmware-nvidia/ad102/gsp/bootloader-570.144.bin \
firmware-nvidia/ad102/gsp/gsp-535.113.01.bin \
firmware-nvidia/ad102/gsp/gsp-570.144.bin \
firmware-nvidia/ad102/gsp/scrubber-570.144.bin \
firmware-nvidia/ga100/acr/bl.bin \
firmware-nvidia/ga100/gsp/booter-load-535.113.01.bin \
firmware-nvidia/ga100/gsp/booter-load-570.144.bin \
firmware-nvidia/ga100/gsp/booter-unload-535.113.01.bin \
firmware-nvidia/ga100/gsp/booter-unload-570.144.bin \
firmware-nvidia/ga100/gsp/bootloader-535.113.01.bin \
firmware-nvidia/ga100/gsp/bootloader-570.144.bin \
firmware-nvidia/ga100/gsp/gen-bootloader-570.144.bin \
firmware-nvidia/ga100/gsp/gsp-535.113.01.bin \
firmware-nvidia/ga100/gsp/gsp-570.144.bin \
firmware-nvidia/ga102/acr/ucode-ahesasc.bin \
firmware-nvidia/ga102/acr/ucode-asb.bin \
firmware-nvidia/ga102/acr/ucode-unload.bin \
firmware-nvidia/ga102/gr/NET-img.bin \
firmware-nvidia/ga102/gr/fecs-bl.bin \
firmware-nvidia/ga102/gr/fecs-sig.bin \
firmware-nvidia/ga102/gr/gpccs-bl.bin \
firmware-nvidia/ga102/gr/gpccs-sig.bin \
firmware-nvidia/ga102/gsp/booter-load-535.113.01.bin \
firmware-nvidia/ga102/gsp/booter-load-570.144.bin \
firmware-nvidia/ga102/gsp/booter-unload-535.113.01.bin \
firmware-nvidia/ga102/gsp/booter-unload-570.144.bin \
firmware-nvidia/ga102/gsp/bootloader-535.113.01.bin \
firmware-nvidia/ga102/gsp/bootloader-570.144.bin \
firmware-nvidia/ga102/gsp/gsp-535.113.01.bin \
firmware-nvidia/ga102/gsp/gsp-570.144.bin \
firmware-nvidia/ga102/nvdec/scrubber.bin \
firmware-nvidia/ga102/sec2/desc.bin \
firmware-nvidia/ga102/sec2/hs-bl-sig.bin \
firmware-nvidia/ga102/sec2/image.bin \
firmware-nvidia/ga102/sec2/sig.bin \
firmware-nvidia/ga103/acr/ucode-ahesasc.bin \
firmware-nvidia/ga103/acr/ucode-asb.bin \
firmware-nvidia/ga103/acr/ucode-unload.bin \
firmware-nvidia/ga103/gr/NET-img.bin \
firmware-nvidia/ga103/gr/fecs-bl.bin \
firmware-nvidia/ga103/gr/fecs-sig.bin \
firmware-nvidia/ga103/gr/gpccs-bl.bin \
firmware-nvidia/ga103/gr/gpccs-sig.bin \
firmware-nvidia/ga103/nvdec/scrubber.bin \
firmware-nvidia/ga103/sec2/desc.bin \
firmware-nvidia/ga103/sec2/hs-bl-sig.bin \
firmware-nvidia/ga103/sec2/image.bin \
firmware-nvidia/ga103/sec2/sig.bin \
firmware-nvidia/ga104/acr/ucode-ahesasc.bin \
firmware-nvidia/ga104/acr/ucode-asb.bin \
firmware-nvidia/ga104/acr/ucode-unload.bin \
firmware-nvidia/ga104/gr/NET-img.bin \
firmware-nvidia/ga104/gr/fecs-bl.bin \
firmware-nvidia/ga104/gr/fecs-sig.bin \
firmware-nvidia/ga104/gr/gpccs-bl.bin \
firmware-nvidia/ga104/gr/gpccs-sig.bin \
firmware-nvidia/ga104/nvdec/scrubber.bin \
firmware-nvidia/ga104/sec2/desc.bin \
firmware-nvidia/ga104/sec2/hs-bl-sig.bin \
firmware-nvidia/ga104/sec2/image.bin \
firmware-nvidia/ga104/sec2/sig.bin \
firmware-nvidia/ga106/acr/ucode-ahesasc.bin \
firmware-nvidia/ga106/acr/ucode-asb.bin \
firmware-nvidia/ga106/acr/ucode-unload.bin \
firmware-nvidia/ga106/gr/NET-img.bin \
firmware-nvidia/ga106/gr/fecs-bl.bin \
firmware-nvidia/ga106/gr/fecs-sig.bin \
firmware-nvidia/ga106/gr/gpccs-bl.bin \
firmware-nvidia/ga106/gr/gpccs-sig.bin \
firmware-nvidia/ga106/nvdec/scrubber.bin \
firmware-nvidia/ga106/sec2/desc.bin \
firmware-nvidia/ga106/sec2/hs-bl-sig.bin \
firmware-nvidia/ga106/sec2/image.bin \
firmware-nvidia/ga106/sec2/sig.bin \
firmware-nvidia/ga107/acr/ucode-ahesasc.bin \
firmware-nvidia/ga107/acr/ucode-asb.bin \
firmware-nvidia/ga107/acr/ucode-unload.bin \
firmware-nvidia/ga107/gr/NET-img.bin \
firmware-nvidia/ga107/gr/fecs-bl.bin \
firmware-nvidia/ga107/gr/fecs-sig.bin \
firmware-nvidia/ga107/gr/gpccs-bl.bin \
firmware-nvidia/ga107/gr/gpccs-sig.bin \
firmware-nvidia/ga107/nvdec/scrubber.bin \
firmware-nvidia/ga107/sec2/desc.bin \
firmware-nvidia/ga107/sec2/hs-bl-sig.bin \
firmware-nvidia/ga107/sec2/image.bin \
firmware-nvidia/ga107/sec2/sig.bin \
firmware-nvidia/gb100/gsp/bootloader-570.144.bin \
firmware-nvidia/gb100/gsp/fmc-570.144.bin \
firmware-nvidia/gb100/gsp/gsp-570.144.bin \
firmware-nvidia/gb202/gsp/bootloader-570.144.bin \
firmware-nvidia/gb202/gsp/fmc-570.144.bin \
firmware-nvidia/gb202/gsp/gsp-570.144.bin \
firmware-nvidia/gh100/gsp/bootloader-570.144.bin \
firmware-nvidia/gh100/gsp/fmc-570.144.bin \
firmware-nvidia/gh100/gsp/gsp-570.144.bin \
firmware-nvidia/gk20a/fecs-data.bin \
firmware-nvidia/gk20a/fecs-inst.bin \
firmware-nvidia/gk20a/gpccs-data.bin \
firmware-nvidia/gk20a/gpccs-inst.bin \
firmware-nvidia/gk20a/sw-bundle-init.bin \
firmware-nvidia/gk20a/sw-ctx.bin \
firmware-nvidia/gk20a/sw-method-init.bin \
firmware-nvidia/gk20a/sw-nonctx.bin \
firmware-nvidia/gm200/acr/bl.bin \
firmware-nvidia/gm200/acr/ucode-load.bin \
firmware-nvidia/gm200/acr/ucode-unload.bin \
firmware-nvidia/gm200/gr/fecs-bl.bin \
firmware-nvidia/gm200/gr/fecs-data.bin \
firmware-nvidia/gm200/gr/fecs-inst.bin \
firmware-nvidia/gm200/gr/fecs-sig.bin \
firmware-nvidia/gm200/gr/gpccs-bl.bin \
firmware-nvidia/gm200/gr/gpccs-data.bin \
firmware-nvidia/gm200/gr/gpccs-inst.bin \
firmware-nvidia/gm200/gr/gpccs-sig.bin \
firmware-nvidia/gm200/gr/sw-bundle-init.bin \
firmware-nvidia/gm200/gr/sw-ctx.bin \
firmware-nvidia/gm200/gr/sw-method-init.bin \
firmware-nvidia/gm200/gr/sw-nonctx.bin \
firmware-nvidia/gm204/acr/bl.bin \
firmware-nvidia/gm204/acr/ucode-load.bin \
firmware-nvidia/gm204/acr/ucode-unload.bin \
firmware-nvidia/gm204/gr/fecs-bl.bin \
firmware-nvidia/gm204/gr/fecs-data.bin \
firmware-nvidia/gm204/gr/fecs-inst.bin \
firmware-nvidia/gm204/gr/fecs-sig.bin \
firmware-nvidia/gm204/gr/gpccs-bl.bin \
firmware-nvidia/gm204/gr/gpccs-data.bin \
firmware-nvidia/gm204/gr/gpccs-inst.bin \
firmware-nvidia/gm204/gr/gpccs-sig.bin \
firmware-nvidia/gm204/gr/sw-bundle-init.bin \
firmware-nvidia/gm204/gr/sw-ctx.bin \
firmware-nvidia/gm204/gr/sw-method-init.bin \
firmware-nvidia/gm204/gr/sw-nonctx.bin \
firmware-nvidia/gm206/acr/bl.bin \
firmware-nvidia/gm206/acr/ucode-load.bin \
firmware-nvidia/gm206/acr/ucode-unload.bin \
firmware-nvidia/gm206/gr/fecs-bl.bin \
firmware-nvidia/gm206/gr/fecs-data.bin \
firmware-nvidia/gm206/gr/fecs-inst.bin \
firmware-nvidia/gm206/gr/fecs-sig.bin \
firmware-nvidia/gm206/gr/gpccs-bl.bin \
firmware-nvidia/gm206/gr/gpccs-data.bin \
firmware-nvidia/gm206/gr/gpccs-inst.bin \
firmware-nvidia/gm206/gr/gpccs-sig.bin \
firmware-nvidia/gm206/gr/sw-bundle-init.bin \
firmware-nvidia/gm206/gr/sw-ctx.bin \
firmware-nvidia/gm206/gr/sw-method-init.bin \
firmware-nvidia/gm206/gr/sw-nonctx.bin \
firmware-nvidia/gm20b/acr/bl.bin \
firmware-nvidia/gm20b/acr/ucode-load.bin \
firmware-nvidia/gm20b/gr/fecs-bl.bin \
firmware-nvidia/gm20b/gr/fecs-data.bin \
firmware-nvidia/gm20b/gr/fecs-inst.bin \
firmware-nvidia/gm20b/gr/fecs-sig.bin \
firmware-nvidia/gm20b/gr/gpccs-data.bin \
firmware-nvidia/gm20b/gr/gpccs-inst.bin \
firmware-nvidia/gm20b/gr/sw-bundle-init.bin \
firmware-nvidia/gm20b/gr/sw-ctx.bin \
firmware-nvidia/gm20b/gr/sw-method-init.bin \
firmware-nvidia/gm20b/gr/sw-nonctx.bin \
firmware-nvidia/gm20b/pmu/desc.bin \
firmware-nvidia/gm20b/pmu/image.bin \
firmware-nvidia/gm20b/pmu/sig.bin \
firmware-nvidia/gp100/acr/bl.bin \
firmware-nvidia/gp100/acr/ucode-load.bin \
firmware-nvidia/gp100/acr/ucode-unload.bin \
firmware-nvidia/gp100/gr/fecs-bl.bin \
firmware-nvidia/gp100/gr/fecs-data.bin \
firmware-nvidia/gp100/gr/fecs-inst.bin \
firmware-nvidia/gp100/gr/fecs-sig.bin \
firmware-nvidia/gp100/gr/gpccs-bl.bin \
firmware-nvidia/gp100/gr/gpccs-data.bin \
firmware-nvidia/gp100/gr/gpccs-inst.bin \
firmware-nvidia/gp100/gr/gpccs-sig.bin \
firmware-nvidia/gp100/gr/sw-bundle-init.bin \
firmware-nvidia/gp100/gr/sw-ctx.bin \
firmware-nvidia/gp100/gr/sw-method-init.bin \
firmware-nvidia/gp100/gr/sw-nonctx.bin \
firmware-nvidia/gp102/acr/bl.bin \
firmware-nvidia/gp102/acr/ucode-load.bin \
firmware-nvidia/gp102/acr/ucode-unload.bin \
firmware-nvidia/gp102/acr/unload-bl.bin \
firmware-nvidia/gp102/gr/fecs-bl.bin \
firmware-nvidia/gp102/gr/fecs-data.bin \
firmware-nvidia/gp102/gr/fecs-inst.bin \
firmware-nvidia/gp102/gr/fecs-sig.bin \
firmware-nvidia/gp102/gr/gpccs-bl.bin \
firmware-nvidia/gp102/gr/gpccs-data.bin \
firmware-nvidia/gp102/gr/gpccs-inst.bin \
firmware-nvidia/gp102/gr/gpccs-sig.bin \
firmware-nvidia/gp102/gr/sw-bundle-init.bin \
firmware-nvidia/gp102/gr/sw-ctx.bin \
firmware-nvidia/gp102/gr/sw-method-init.bin \
firmware-nvidia/gp102/gr/sw-nonctx.bin \
firmware-nvidia/gp102/nvdec/scrubber.bin \
firmware-nvidia/gp102/sec2/desc-1.bin \
firmware-nvidia/gp102/sec2/desc.bin \
firmware-nvidia/gp102/sec2/image-1.bin \
firmware-nvidia/gp102/sec2/image.bin \
firmware-nvidia/gp102/sec2/sig-1.bin \
firmware-nvidia/gp102/sec2/sig.bin \
firmware-nvidia/gp104/acr/bl.bin \
firmware-nvidia/gp104/acr/ucode-load.bin \
firmware-nvidia/gp104/acr/ucode-unload.bin \
firmware-nvidia/gp104/acr/unload-bl.bin \
firmware-nvidia/gp104/gr/fecs-bl.bin \
firmware-nvidia/gp104/gr/fecs-data.bin \
firmware-nvidia/gp104/gr/fecs-inst.bin \
firmware-nvidia/gp104/gr/fecs-sig.bin \
firmware-nvidia/gp104/gr/gpccs-bl.bin \
firmware-nvidia/gp104/gr/gpccs-data.bin \
firmware-nvidia/gp104/gr/gpccs-inst.bin \
firmware-nvidia/gp104/gr/gpccs-sig.bin \
firmware-nvidia/gp104/gr/sw-bundle-init.bin \
firmware-nvidia/gp104/gr/sw-ctx.bin \
firmware-nvidia/gp104/gr/sw-method-init.bin \
firmware-nvidia/gp104/gr/sw-nonctx.bin \
firmware-nvidia/gp104/nvdec/scrubber.bin \
firmware-nvidia/gp104/sec2/desc-1.bin \
firmware-nvidia/gp104/sec2/desc.bin \
firmware-nvidia/gp104/sec2/image-1.bin \
firmware-nvidia/gp104/sec2/image.bin \
firmware-nvidia/gp104/sec2/sig-1.bin \
firmware-nvidia/gp104/sec2/sig.bin \
firmware-nvidia/gp106/acr/bl.bin \
firmware-nvidia/gp106/acr/ucode-load.bin \
firmware-nvidia/gp106/acr/ucode-unload.bin \
firmware-nvidia/gp106/acr/unload-bl.bin \
firmware-nvidia/gp106/gr/fecs-bl.bin \
firmware-nvidia/gp106/gr/fecs-data.bin \
firmware-nvidia/gp106/gr/fecs-inst.bin \
firmware-nvidia/gp106/gr/fecs-sig.bin \
firmware-nvidia/gp106/gr/gpccs-bl.bin \
firmware-nvidia/gp106/gr/gpccs-data.bin \
firmware-nvidia/gp106/gr/gpccs-inst.bin \
firmware-nvidia/gp106/gr/gpccs-sig.bin \
firmware-nvidia/gp106/gr/sw-bundle-init.bin \
firmware-nvidia/gp106/gr/sw-ctx.bin \
firmware-nvidia/gp106/gr/sw-method-init.bin \
firmware-nvidia/gp106/gr/sw-nonctx.bin \
firmware-nvidia/gp106/nvdec/scrubber.bin \
firmware-nvidia/gp106/sec2/desc-1.bin \
firmware-nvidia/gp106/sec2/desc.bin \
firmware-nvidia/gp106/sec2/image-1.bin \
firmware-nvidia/gp106/sec2/image.bin \
firmware-nvidia/gp106/sec2/sig-1.bin \
firmware-nvidia/gp106/sec2/sig.bin \
firmware-nvidia/gp107/acr/bl.bin \
firmware-nvidia/gp107/acr/ucode-load.bin \
firmware-nvidia/gp107/acr/ucode-unload.bin \
firmware-nvidia/gp107/acr/unload-bl.bin \
firmware-nvidia/gp107/gr/fecs-bl.bin \
firmware-nvidia/gp107/gr/fecs-data.bin \
firmware-nvidia/gp107/gr/fecs-inst.bin \
firmware-nvidia/gp107/gr/fecs-sig.bin \
firmware-nvidia/gp107/gr/gpccs-bl.bin \
firmware-nvidia/gp107/gr/gpccs-data.bin \
firmware-nvidia/gp107/gr/gpccs-inst.bin \
firmware-nvidia/gp107/gr/gpccs-sig.bin \
firmware-nvidia/gp107/gr/sw-bundle-init.bin \
firmware-nvidia/gp107/gr/sw-ctx.bin \
firmware-nvidia/gp107/gr/sw-method-init.bin \
firmware-nvidia/gp107/gr/sw-nonctx.bin \
firmware-nvidia/gp107/nvdec/scrubber.bin \
firmware-nvidia/gp107/sec2/desc-1.bin \
firmware-nvidia/gp107/sec2/desc.bin \
firmware-nvidia/gp107/sec2/image-1.bin \
firmware-nvidia/gp107/sec2/image.bin \
firmware-nvidia/gp107/sec2/sig-1.bin \
firmware-nvidia/gp107/sec2/sig.bin \
firmware-nvidia/gp108/acr/bl.bin \
firmware-nvidia/gp108/acr/ucode-load.bin \
firmware-nvidia/gp108/acr/ucode-unload.bin \
firmware-nvidia/gp108/acr/unload-bl.bin \
firmware-nvidia/gp108/gr/fecs-bl.bin \
firmware-nvidia/gp108/gr/fecs-data.bin \
firmware-nvidia/gp108/gr/fecs-inst.bin \
firmware-nvidia/gp108/gr/fecs-sig.bin \
firmware-nvidia/gp108/gr/gpccs-bl.bin \
firmware-nvidia/gp108/gr/gpccs-data.bin \
firmware-nvidia/gp108/gr/gpccs-inst.bin \
firmware-nvidia/gp108/gr/gpccs-sig.bin \
firmware-nvidia/gp108/gr/sw-bundle-init.bin \
firmware-nvidia/gp108/gr/sw-ctx.bin \
firmware-nvidia/gp108/gr/sw-method-init.bin \
firmware-nvidia/gp108/gr/sw-nonctx.bin \
firmware-nvidia/gp108/nvdec/scrubber.bin \
firmware-nvidia/gp108/sec2/desc.bin \
firmware-nvidia/gp108/sec2/image.bin \
firmware-nvidia/gp108/sec2/sig.bin \
firmware-nvidia/gp10b/acr/bl.bin \
firmware-nvidia/gp10b/acr/ucode-load.bin \
firmware-nvidia/gp10b/gr/fecs-bl.bin \
firmware-nvidia/gp10b/gr/fecs-data.bin \
firmware-nvidia/gp10b/gr/fecs-inst.bin \
firmware-nvidia/gp10b/gr/fecs-sig.bin \
firmware-nvidia/gp10b/gr/gpccs-bl.bin \
firmware-nvidia/gp10b/gr/gpccs-data.bin \
firmware-nvidia/gp10b/gr/gpccs-inst.bin \
firmware-nvidia/gp10b/gr/gpccs-sig.bin \
firmware-nvidia/gp10b/gr/sw-bundle-init.bin \
firmware-nvidia/gp10b/gr/sw-ctx.bin \
firmware-nvidia/gp10b/gr/sw-method-init.bin \
firmware-nvidia/gp10b/gr/sw-nonctx.bin \
firmware-nvidia/gp10b/pmu/desc.bin \
firmware-nvidia/gp10b/pmu/image.bin \
firmware-nvidia/gp10b/pmu/sig.bin \
firmware-nvidia/gv100/acr/bl.bin \
firmware-nvidia/gv100/acr/ucode-load.bin \
firmware-nvidia/gv100/acr/ucode-unload.bin \
firmware-nvidia/gv100/acr/unload-bl.bin \
firmware-nvidia/gv100/gr/fecs-bl.bin \
firmware-nvidia/gv100/gr/fecs-data.bin \
firmware-nvidia/gv100/gr/fecs-inst.bin \
firmware-nvidia/gv100/gr/fecs-sig.bin \
firmware-nvidia/gv100/gr/gpccs-bl.bin \
firmware-nvidia/gv100/gr/gpccs-data.bin \
firmware-nvidia/gv100/gr/gpccs-inst.bin \
firmware-nvidia/gv100/gr/gpccs-sig.bin \
firmware-nvidia/gv100/gr/sw-bundle-init.bin \
firmware-nvidia/gv100/gr/sw-ctx.bin \
firmware-nvidia/gv100/gr/sw-method-init.bin \
firmware-nvidia/gv100/gr/sw-nonctx.bin \
firmware-nvidia/gv100/nvdec/scrubber.bin \
firmware-nvidia/gv100/sec2/desc.bin \
firmware-nvidia/gv100/sec2/image.bin \
firmware-nvidia/gv100/sec2/sig.bin \
firmware-nvidia/tegra124/vic.bin \
firmware-nvidia/tegra124/vic03-ucode.bin \
firmware-nvidia/tegra124/xusb.bin \
firmware-nvidia/tegra186/vic.bin \
firmware-nvidia/tegra186/vic04-ucode.bin \
firmware-nvidia/tegra186/xusb.bin \
firmware-nvidia/tegra194/vic.bin \
firmware-nvidia/tegra194/xusb.bin \
firmware-nvidia/tegra210/vic.bin \
firmware-nvidia/tegra210/vic04-ucode.bin \
firmware-nvidia/tegra210/xusb.bin \
firmware-nvidia/tu102/acr/bl.bin \
firmware-nvidia/tu102/acr/ucode-ahesasc.bin \
firmware-nvidia/tu102/acr/ucode-asb.bin \
firmware-nvidia/tu102/acr/ucode-unload.bin \
firmware-nvidia/tu102/acr/unload-bl.bin \
firmware-nvidia/tu102/gr/fecs-bl.bin \
firmware-nvidia/tu102/gr/fecs-data.bin \
firmware-nvidia/tu102/gr/fecs-inst.bin \
firmware-nvidia/tu102/gr/fecs-sig.bin \
firmware-nvidia/tu102/gr/gpccs-bl.bin \
firmware-nvidia/tu102/gr/gpccs-data.bin \
firmware-nvidia/tu102/gr/gpccs-inst.bin \
firmware-nvidia/tu102/gr/gpccs-sig.bin \
firmware-nvidia/tu102/gr/sw-bundle-init.bin \
firmware-nvidia/tu102/gr/sw-ctx.bin \
firmware-nvidia/tu102/gr/sw-method-init.bin \
firmware-nvidia/tu102/gr/sw-nonctx.bin \
firmware-nvidia/tu102/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu102/gsp/booter-load-535.113.01.bin \
firmware-nvidia/tu102/gsp/booter-load-570.144.bin \
firmware-nvidia/tu102/gsp/booter-unload-535.113.01.bin \
firmware-nvidia/tu102/gsp/booter-unload-570.144.bin \
firmware-nvidia/tu102/gsp/bootloader-535.113.01.bin \
firmware-nvidia/tu102/gsp/bootloader-570.144.bin \
firmware-nvidia/tu102/gsp/gen-bootloader-570.144.bin \
firmware-nvidia/tu102/gsp/gsp-535.113.01.bin \
firmware-nvidia/tu102/gsp/gsp-570.144.bin \
firmware-nvidia/tu102/nvdec/scrubber.bin \
firmware-nvidia/tu102/sec2/desc.bin \
firmware-nvidia/tu102/sec2/image.bin \
firmware-nvidia/tu102/sec2/sig.bin \
firmware-nvidia/tu104/acr/bl.bin \
firmware-nvidia/tu104/acr/ucode-ahesasc.bin \
firmware-nvidia/tu104/acr/ucode-asb.bin \
firmware-nvidia/tu104/acr/ucode-unload.bin \
firmware-nvidia/tu104/acr/unload-bl.bin \
firmware-nvidia/tu104/gr/fecs-bl.bin \
firmware-nvidia/tu104/gr/fecs-data.bin \
firmware-nvidia/tu104/gr/fecs-inst.bin \
firmware-nvidia/tu104/gr/fecs-sig.bin \
firmware-nvidia/tu104/gr/gpccs-bl.bin \
firmware-nvidia/tu104/gr/gpccs-data.bin \
firmware-nvidia/tu104/gr/gpccs-inst.bin \
firmware-nvidia/tu104/gr/gpccs-sig.bin \
firmware-nvidia/tu104/gr/sw-bundle-init.bin \
firmware-nvidia/tu104/gr/sw-ctx.bin \
firmware-nvidia/tu104/gr/sw-method-init.bin \
firmware-nvidia/tu104/gr/sw-nonctx.bin \
firmware-nvidia/tu104/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu104/nvdec/scrubber.bin \
firmware-nvidia/tu104/sec2/desc.bin \
firmware-nvidia/tu104/sec2/image.bin \
firmware-nvidia/tu104/sec2/sig.bin \
firmware-nvidia/tu106/acr/bl.bin \
firmware-nvidia/tu106/acr/ucode-ahesasc.bin \
firmware-nvidia/tu106/acr/ucode-asb.bin \
firmware-nvidia/tu106/acr/ucode-unload.bin \
firmware-nvidia/tu106/acr/unload-bl.bin \
firmware-nvidia/tu106/gr/fecs-bl.bin \
firmware-nvidia/tu106/gr/fecs-data.bin \
firmware-nvidia/tu106/gr/fecs-inst.bin \
firmware-nvidia/tu106/gr/fecs-sig.bin \
firmware-nvidia/tu106/gr/gpccs-bl.bin \
firmware-nvidia/tu106/gr/gpccs-data.bin \
firmware-nvidia/tu106/gr/gpccs-inst.bin \
firmware-nvidia/tu106/gr/gpccs-sig.bin \
firmware-nvidia/tu106/gr/sw-bundle-init.bin \
firmware-nvidia/tu106/gr/sw-ctx.bin \
firmware-nvidia/tu106/gr/sw-method-init.bin \
firmware-nvidia/tu106/gr/sw-nonctx.bin \
firmware-nvidia/tu106/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu106/nvdec/scrubber.bin \
firmware-nvidia/tu106/sec2/desc.bin \
firmware-nvidia/tu106/sec2/image.bin \
firmware-nvidia/tu106/sec2/sig.bin \
firmware-nvidia/tu10x/typec/ccg-boot.cyacd \
firmware-nvidia/tu10x/typec/ccg-primary.cyacd \
firmware-nvidia/tu10x/typec/ccg-secondary.cyacd \
firmware-nvidia/tu116/acr/bl.bin \
firmware-nvidia/tu116/acr/ucode-ahesasc.bin \
firmware-nvidia/tu116/acr/ucode-asb.bin \
firmware-nvidia/tu116/acr/ucode-unload.bin \
firmware-nvidia/tu116/acr/unload-bl.bin \
firmware-nvidia/tu116/gr/fecs-bl.bin \
firmware-nvidia/tu116/gr/fecs-data.bin \
firmware-nvidia/tu116/gr/fecs-inst.bin \
firmware-nvidia/tu116/gr/fecs-sig.bin \
firmware-nvidia/tu116/gr/gpccs-bl.bin \
firmware-nvidia/tu116/gr/gpccs-data.bin \
firmware-nvidia/tu116/gr/gpccs-inst.bin \
firmware-nvidia/tu116/gr/gpccs-sig.bin \
firmware-nvidia/tu116/gr/sw-bundle-init.bin \
firmware-nvidia/tu116/gr/sw-ctx.bin \
firmware-nvidia/tu116/gr/sw-method-init.bin \
firmware-nvidia/tu116/gr/sw-nonctx.bin \
firmware-nvidia/tu116/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu116/gsp/booter-load-535.113.01.bin \
firmware-nvidia/tu116/gsp/booter-load-570.144.bin \
firmware-nvidia/tu116/gsp/booter-unload-535.113.01.bin \
firmware-nvidia/tu116/gsp/booter-unload-570.144.bin \
firmware-nvidia/tu116/gsp/bootloader-535.113.01.bin \
firmware-nvidia/tu116/gsp/bootloader-570.144.bin \
firmware-nvidia/tu116/gsp/gen-bootloader-570.144.bin \
firmware-nvidia/tu116/gsp/gsp-535.113.01.bin \
firmware-nvidia/tu116/gsp/gsp-570.144.bin \
firmware-nvidia/tu116/nvdec/scrubber.bin \
firmware-nvidia/tu116/sec2/desc.bin \
firmware-nvidia/tu116/sec2/image.bin \
firmware-nvidia/tu116/sec2/sig.bin \
firmware-nvidia/tu117/acr/bl.bin \
firmware-nvidia/tu117/acr/ucode-ahesasc.bin \
firmware-nvidia/tu117/acr/ucode-asb.bin \
firmware-nvidia/tu117/acr/ucode-unload.bin \
firmware-nvidia/tu117/acr/unload-bl.bin \
firmware-nvidia/tu117/gr/fecs-bl.bin \
firmware-nvidia/tu117/gr/fecs-data.bin \
firmware-nvidia/tu117/gr/fecs-inst.bin \
firmware-nvidia/tu117/gr/fecs-sig.bin \
firmware-nvidia/tu117/gr/gpccs-bl.bin \
firmware-nvidia/tu117/gr/gpccs-data.bin \
firmware-nvidia/tu117/gr/gpccs-inst.bin \
firmware-nvidia/tu117/gr/gpccs-sig.bin \
firmware-nvidia/tu117/gr/sw-bundle-init.bin \
firmware-nvidia/tu117/gr/sw-ctx.bin \
firmware-nvidia/tu117/gr/sw-method-init.bin \
firmware-nvidia/tu117/gr/sw-nonctx.bin \
firmware-nvidia/tu117/gr/sw-veid-bundle-init.bin \
firmware-nvidia/tu117/nvdec/scrubber.bin \
firmware-nvidia/tu117/sec2/desc.bin \
firmware-nvidia/tu117/sec2/image.bin \
firmware-nvidia/tu117/sec2/sig.bin \
kernel-firmware-nvidia"

RDEPENDS:${PN} += "/usr/bin/mkdir \
/usr/bin/sh \
/usr/bin/touch \
dracut"

inherit rpm
