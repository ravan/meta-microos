SUMMARY = "Microsoft EASM Data Plane Client Client Library for Python"
DESCRIPTION = "Microsoft Defender External Attack Surface Management (Defender EASM) continuously discovers \
and maps your digital attack surface to provide an external view of your online infrastructure. \
 \
This visibility enables security and IT teams to identify unknowns, prioritize risk, eliminate \
threats, and extend vulnerability and exposure control beyond the firewall. Defender EASM \
leverages Microsoft’s crawling technology to discover assets that are related to your known online \
infrastructure, and actively scans these assets to discover new connections over time. \
 \
Attack Surface Insights are generated by leveraging vulnerability and infrastructure data to \
showcase the key areas of concern for your organization."
LICENSE = "MIT"

PV = "1.0.0~b1"

RPM_NAME = "python313-azure-defender-easm-1.0.0~b1-2.8.noarch.rpm"
RPM_HASH = "53df277a5889ebe199bcffe3e963526a3e6ef0d2a9cc46f66bb6a6495e4ac8278b273bd697bfe620ddc93b8a4e612db47297d9ecbeb7f8d12e93209f71db17cf"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "python3-azure-defender-easm \
python3.13dist-azure-defender-easm \
python313-azure-defender-easm \
python3dist-azure-defender-easm"

RDEPENDS:${PN} += "python-abi \
python313-azure-core \
python313-azure-nspkg \
python313-isodate"

inherit rpm
