ksym-default-regmap-attach-dev \
ksym-default-regmap-bulk-read \
ksym-default-regmap-bulk-write \
ksym-default-regmap-can-raw-write \
ksym-default-regmap-check-range-table \
ksym-default-regmap-del-irq-chip \
ksym-default-regmap-encx24j600-spi-read \
ksym-default-regmap-encx24j600-spi-write \
ksym-default-regmap-exit \
ksym-default-regmap-field-alloc \
ksym-default-regmap-field-bulk-alloc \
ksym-default-regmap-field-bulk-free \
ksym-default-regmap-field-free \
ksym-default-regmap-field-read \
ksym-default-regmap-field-test-bits \
ksym-default-regmap-field-update-bits-base \
ksym-default-regmap-fields-read \
ksym-default-regmap-fields-update-bits-base \
ksym-default-regmap-get-device \
ksym-default-regmap-get-max-register \
ksym-default-regmap-get-raw-read-max \
ksym-default-regmap-get-raw-write-max \
ksym-default-regmap-get-reg-stride \
ksym-default-regmap-get-val-bytes \
ksym-default-regmap-get-val-endian \
ksym-default-regmap-irq-chip-get-base \
ksym-default-regmap-irq-get-domain \
ksym-default-regmap-irq-get-irq-reg-linear \
ksym-default-regmap-irq-get-virq \
ksym-default-regmap-irq-set-type-config-simple \
ksym-default-regmap-might-sleep \
ksym-default-regmap-mmio-attach-clk \
ksym-default-regmap-mmio-detach-clk \
ksym-default-regmap-multi-reg-read \
ksym-default-regmap-multi-reg-write \
ksym-default-regmap-multi-reg-write-bypassed \
ksym-default-regmap-noinc-read \
ksym-default-regmap-noinc-write \
ksym-default-regmap-parse-val \
ksym-default-regmap-raw-read \
ksym-default-regmap-raw-write \
ksym-default-regmap-raw-write-async \
ksym-default-regmap-read \
ksym-default-regmap-read-bypassed \
ksym-default-regmap-reg-in-ranges \
ksym-default-regmap-register-patch \
ksym-default-regmap-reinit-cache \
ksym-default-regmap-test-bits \
ksym-default-regmap-update-bits-base \
ksym-default-regmap-write \
ksym-default-regmap-write-async \
ksym-default-regset-get \
ksym-default-regset-get-alloc \
ksym-default-regulator-allow-bypass \
ksym-default-regulator-bulk-disable \
ksym-default-regulator-bulk-enable \
ksym-default-regulator-bulk-force-disable \
ksym-default-regulator-bulk-free \
ksym-default-regulator-bulk-get \
ksym-default-regulator-bulk-register-supply-alias \
ksym-default-regulator-bulk-set-supply-names \
ksym-default-regulator-bulk-unregister-supply-alias \
ksym-default-regulator-count-voltages \
ksym-default-regulator-desc-list-voltage-linear \
ksym-default-regulator-desc-list-voltage-linear-range \
ksym-default-regulator-disable \
ksym-default-regulator-disable-deferred \
ksym-default-regulator-disable-regmap \
ksym-default-regulator-enable \
ksym-default-regulator-enable-regmap \
ksym-default-regulator-find-closest-bigger \
ksym-default-regulator-force-disable \
ksym-default-regulator-free-power-budget \
ksym-default-regulator-get \
ksym-default-regulator-get-bypass-regmap \
ksym-default-regulator-get-current-limit \
ksym-default-regulator-get-current-limit-regmap \
ksym-default-regulator-get-drvdata \
ksym-default-regulator-get-error-flags \
ksym-default-regulator-get-exclusive \
ksym-default-regulator-get-hardware-vsel-register \
ksym-default-regulator-get-init-drvdata \
ksym-default-regulator-get-linear-step \
ksym-default-regulator-get-mode \
ksym-default-regulator-get-optional \
ksym-default-regulator-get-regmap \
ksym-default-regulator-get-unclaimed-power-budget \
ksym-default-regulator-get-voltage \
ksym-default-regulator-get-voltage-rdev \
ksym-default-regulator-get-voltage-sel-pickable-regmap \
ksym-default-regulator-get-voltage-sel-regmap \
ksym-default-regulator-hardware-enable \
ksym-default-regulator-has-full-constraints \
ksym-default-regulator-irq-helper \
ksym-default-regulator-irq-helper-cancel \
ksym-default-regulator-irq-map-event-simple \
ksym-default-regulator-is-enabled \
ksym-default-regulator-is-enabled-regmap \
ksym-default-regulator-is-equal \
ksym-default-regulator-is-supported-voltage \
ksym-default-regulator-list-hardware-vsel \
ksym-default-regulator-list-voltage \
ksym-default-regulator-list-voltage-linear \
ksym-default-regulator-list-voltage-linear-range \
ksym-default-regulator-list-voltage-pickable-linear-range \
ksym-default-regulator-list-voltage-table \
ksym-default-regulator-map-voltage-ascend \
ksym-default-regulator-map-voltage-iterate \
ksym-default-regulator-map-voltage-linear \
ksym-default-regulator-map-voltage-linear-range \
ksym-default-regulator-map-voltage-pickable-linear-range \
ksym-default-regulator-mode-to-status \
ksym-default-regulator-notifier-call-chain \
ksym-default-regulator-put \
ksym-default-regulator-register \
ksym-default-regulator-register-notifier \
ksym-default-regulator-register-supply-alias \
ksym-default-regulator-request-power-budget \
ksym-default-regulator-set-active-discharge-regmap \
ksym-default-regulator-set-bypass-regmap \
ksym-default-regulator-set-current-limit \
ksym-default-regulator-set-current-limit-regmap \
ksym-default-regulator-set-drvdata \
ksym-default-regulator-set-load \
ksym-default-regulator-set-mode \
ksym-default-regulator-set-pull-down-regmap \
ksym-default-regulator-set-ramp-delay-regmap \
ksym-default-regulator-set-soft-start-regmap \
ksym-default-regulator-set-suspend-voltage \
ksym-default-regulator-set-voltage \
ksym-default-regulator-set-voltage-rdev \
ksym-default-regulator-set-voltage-sel-pickable-regmap \
ksym-default-regulator-set-voltage-sel-regmap \
ksym-default-regulator-set-voltage-time \
ksym-default-regulator-set-voltage-time-sel \
ksym-default-regulator-suspend-disable \
ksym-default-regulator-suspend-enable \
ksym-default-regulator-sync-voltage \
ksym-default-regulator-unregister \
ksym-default-regulator-unregister-notifier \
ksym-default-regulator-unregister-supply-alias \
ksym-default-regulatory-hint \
ksym-default-regulatory-pre-cac-allowed \
ksym-default-regulatory-set-wiphy-regd \
ksym-default-regulatory-set-wiphy-regd-sync \
ksym-default-relay-buf-full \
ksym-default-relay-close \
ksym-default-relay-file-operations \
ksym-default-relay-flush \
ksym-default-relay-open \
ksym-default-relay-reset \
ksym-default-relay-subbufs-consumed \
ksym-default-relay-switch-subbuf \
ksym-default-release-and-free-resource \
ksym-default-release-dentry-name-snapshot \
ksym-default-release-firmware \
ksym-default-release-pages \
ksym-default-release-resource \
ksym-default-release-sock \
ksym-default-remap-pfn-range \
ksym-default-remap-verify-area \
ksym-default-remap-vmalloc-range \
ksym-default-remove-arg-zero \
ksym-default-remove-cpu \
ksym-default-remove-memory \
ksym-default-remove-proc-entry \
ksym-default-remove-proc-subtree \
ksym-default-remove-resource \
ksym-default-remove-wait-queue \
ksym-default-remove-watch-from-object \
ksym-default-rename-lock \
ksym-default-renesas-sdhi-probe \
ksym-default-renesas-sdhi-remove \
ksym-default-renesas-sdhi-resume \
ksym-default-renesas-sdhi-suspend \
ksym-default-replace-page-cache-folio \
ksym-default-report-iommu-fault \
ksym-default-request-any-context-irq \
ksym-default-request-firmware \
ksym-default-request-firmware-direct \
ksym-default-request-firmware-into-buf \
ksym-default-request-firmware-nowait \
ksym-default-request-firmware-nowait-cancel \
ksym-default-request-free-mem-region \
ksym-default-request-key-rcu \
ksym-default-request-key-tag \
ksym-default-request-key-with-auxdata \
ksym-default-request-partial-firmware-into-buf \
ksym-default-request-percpu-irq-affinity \
ksym-default-request-resource \
ksym-default-request-threaded-irq \
ksym-default-rescale-process-offset \
ksym-default-rescale-process-scale \
ksym-default-reservation-ww-class \
ksym-default-reserve-iova \
ksym-default-reserve-mem-find-by-name \
ksym-default-reset-control-acquire \
ksym-default-reset-control-assert \
ksym-default-reset-control-bulk-acquire \
ksym-default-reset-control-bulk-assert \
ksym-default-reset-control-bulk-deassert \
ksym-default-reset-control-bulk-put \
ksym-default-reset-control-bulk-release \
ksym-default-reset-control-bulk-reset \
ksym-default-reset-control-deassert \
ksym-default-reset-control-get-count \
ksym-default-reset-control-put \
ksym-default-reset-control-rearm \
ksym-default-reset-control-release \
ksym-default-reset-control-reset \
ksym-default-reset-control-status \
ksym-default-reset-controller-register \
ksym-default-reset-controller-unregister \
ksym-default-reset-devices \
ksym-default-reset-hung-task-detector \
ksym-default-reset-simple-ops \
ksym-default-resilient-queued-spin-lock-slowpath \
ksym-default-resilient-tas-spin-lock \
ksym-default-resource-list-create-entry \
ksym-default-resource-list-free \
ksym-default-restore-online-page-callback \
ksym-default-retire-super \
ksym-default-return-address \
ksym-default-reuseport-add-sock \
ksym-default-reuseport-alloc \
ksym-default-reuseport-attach-prog \
ksym-default-reuseport-detach-prog \
ksym-default-reuseport-detach-sock \
ksym-default-reuseport-has-conns-set \
ksym-default-reuseport-migrate-sock \
ksym-default-reuseport-select-sock \
ksym-default-reuseport-stop-listen-sock \
ksym-default-rfc1042-header \
ksym-default-rfkill-alloc \
ksym-default-rfkill-blocked \
ksym-default-rfkill-destroy \
ksym-default-rfkill-find-type \
ksym-default-rfkill-get-led-trigger-name \
ksym-default-rfkill-init-sw-state \
ksym-default-rfkill-pause-polling \
ksym-default-rfkill-register \
ksym-default-rfkill-resume-polling \
ksym-default-rfkill-set-hw-state-reason \
ksym-default-rfkill-set-led-trigger-name \
ksym-default-rfkill-set-states \
ksym-default-rfkill-set-sw-state \
ksym-default-rfkill-soft-blocked \
ksym-default-rfkill-unregister \
ksym-default-rfs-needed \
ksym-default-rhashtable-destroy \
ksym-default-rhashtable-free-and-destroy \
ksym-default-rhashtable-insert-slow \
ksym-default-rhashtable-next-key \
ksym-default-rhashtable-walk-enter \
ksym-default-rhashtable-walk-exit \
ksym-default-rhashtable-walk-next \
ksym-default-rhashtable-walk-peek \
ksym-default-rhashtable-walk-start-check \
ksym-default-rhashtable-walk-stop \
ksym-default-rht-bucket-nested \
ksym-default-rht-bucket-nested-insert \
ksym-default-ring-buffer-alloc-read-page \
ksym-default-ring-buffer-bytes-cpu \
ksym-default-ring-buffer-change-overwrite \
ksym-default-ring-buffer-commit-overrun-cpu \
ksym-default-ring-buffer-consume \
ksym-default-ring-buffer-discard-commit \
ksym-default-ring-buffer-dropped-events-cpu \
ksym-default-ring-buffer-empty \
ksym-default-ring-buffer-empty-cpu \
ksym-default-ring-buffer-entries \
ksym-default-ring-buffer-entries-cpu \
ksym-default-ring-buffer-event-data \
ksym-default-ring-buffer-event-length \
ksym-default-ring-buffer-free \
ksym-default-ring-buffer-free-read-page \
ksym-default-ring-buffer-iter-advance \
ksym-default-ring-buffer-iter-dropped \
ksym-default-ring-buffer-iter-empty \
ksym-default-ring-buffer-iter-peek \
ksym-default-ring-buffer-iter-reset \
ksym-default-ring-buffer-lock-reserve \
ksym-default-ring-buffer-max-event-size \
ksym-default-ring-buffer-normalize-time-stamp \
ksym-default-ring-buffer-oldest-event-ts \
ksym-default-ring-buffer-overrun-cpu \
ksym-default-ring-buffer-overruns \
ksym-default-ring-buffer-peek \
ksym-default-ring-buffer-read-events-cpu \
ksym-default-ring-buffer-read-finish \
ksym-default-ring-buffer-read-page \
ksym-default-ring-buffer-read-page-data \
ksym-default-ring-buffer-read-start \
ksym-default-ring-buffer-record-disable \
ksym-default-ring-buffer-record-disable-cpu \
ksym-default-ring-buffer-record-enable \
ksym-default-ring-buffer-record-enable-cpu \
ksym-default-ring-buffer-record-off \
ksym-default-ring-buffer-record-on \
ksym-default-ring-buffer-reset \
ksym-default-ring-buffer-reset-cpu \
ksym-default-ring-buffer-resize \
ksym-default-ring-buffer-size \
ksym-default-ring-buffer-subbuf-order-get \
ksym-default-ring-buffer-subbuf-order-set \
ksym-default-ring-buffer-subbuf-size-get \
ksym-default-ring-buffer-swap-cpu \
ksym-default-ring-buffer-time-stamp \
ksym-default-ring-buffer-unlock-commit \
ksym-default-ring-buffer-write \
ksym-default-rio-add-device \
ksym-default-rio-add-mport-pw-handler \
ksym-default-rio-add-net \
ksym-default-rio-alloc-net \
ksym-default-rio-attach-device \
ksym-default-rio-bus-type \
ksym-default-rio-del-device \
ksym-default-rio-del-mport-pw-handler \
ksym-default-rio-dev-get \
ksym-default-rio-dev-put \
ksym-default-rio-dma-prep-xfer \
ksym-default-rio-enable-rx-tx-port \
ksym-default-rio-free-net \
ksym-default-rio-get-comptag \
ksym-default-rio-inb-pwrite-handler \
ksym-default-rio-init-mports \
ksym-default-rio-local-get-device-id \
ksym-default-rio-local-set-device-id \
ksym-default-rio-lock-device \
ksym-default-rio-map-inb-region \
ksym-default-rio-map-outb-region \
ksym-default-rio-mport-chk-dev-access \
ksym-default-rio-mport-class \
ksym-default-rio-mport-get-efb \
ksym-default-rio-mport-get-feature \
ksym-default-rio-mport-get-physefb \
ksym-default-rio-mport-initialize \
ksym-default-rio-mport-read-config-16 \
ksym-default-rio-mport-read-config-32 \
ksym-default-rio-mport-read-config-8 \
ksym-default-rio-mport-send-doorbell \
ksym-default-rio-mport-write-config-16 \
ksym-default-rio-mport-write-config-32 \
ksym-default-rio-mport-write-config-8 \
ksym-default-rio-pw-enable \
ksym-default-rio-query-mport \
ksym-default-rio-register-driver \
ksym-default-rio-register-mport \
ksym-default-rio-register-scan \
ksym-default-rio-release-dma \
ksym-default-rio-release-inb-dbell \
ksym-default-rio-release-inb-mbox \
ksym-default-rio-release-inb-pwrite \
ksym-default-rio-release-outb-dbell \
ksym-default-rio-release-outb-mbox \
ksym-default-rio-request-inb-dbell \
ksym-default-rio-request-inb-mbox \
ksym-default-rio-request-inb-pwrite \
ksym-default-rio-request-mport-dma \
ksym-default-rio-request-outb-dbell \
ksym-default-rio-request-outb-mbox \
ksym-default-rio-route-add-entry \
ksym-default-rio-route-clr-table \
ksym-default-rio-route-get-entry \
ksym-default-rio-set-port-lockout \
ksym-default-rio-unlock-device \
ksym-default-rio-unmap-inb-region \
ksym-default-rio-unmap-outb-region \
ksym-default-rio-unregister-driver \
ksym-default-rio-unregister-mport \
ksym-default-rk8xx-probe \
ksym-default-rk8xx-resume \
ksym-default-rk8xx-shutdown \
ksym-default-rk8xx-suspend \
ksym-default-rl6231-calc-dmic-clk \
ksym-default-rl6231-get-clk-info \
ksym-default-rl6231-get-pre-div \
ksym-default-rl6231-pll-calc \
ksym-default-rm3100-common-probe \
ksym-default-rm3100-readable-table \
ksym-default-rm3100-volatile-table \
ksym-default-rm3100-writable-table \
ksym-default-rmi-2d-sensor-abs-process \
ksym-default-rmi-2d-sensor-abs-report \
ksym-default-rmi-2d-sensor-configure-input \
ksym-default-rmi-2d-sensor-of-probe \
ksym-default-rmi-2d-sensor-rel-report \
ksym-default-rmi-dbg \
ksym-default-rmi-driver-resume \
ksym-default-rmi-driver-suspend \
ksym-default-rmi-of-property-read-u32 \
ksym-default-rmi-register-transport-device \
ksym-default-rmi-set-attn-data \
ksym-default-rmi-unregister-function-handler \
ksym-default-rmi-unregister-transport-device \
ksym-default-rndis-add-hdr \
ksym-default-rndis-borrow-net \
ksym-default-rndis-command \
ksym-default-rndis-deregister \
ksym-default-rndis-free-response \
ksym-default-rndis-get-next-response \
ksym-default-rndis-msg-parser \
ksym-default-rndis-register \
ksym-default-rndis-rm-hdr \
ksym-default-rndis-rx-fixup \
ksym-default-rndis-set-host-mac \
ksym-default-rndis-set-param-dev \
ksym-default-rndis-set-param-medium \
ksym-default-rndis-set-param-vendor \
ksym-default-rndis-signal-connect \
ksym-default-rndis-signal-disconnect \
ksym-default-rndis-status \
ksym-default-rndis-tx-fixup \
ksym-default-rndis-unbind \
ksym-default-rndis-uninit \
ksym-default-rng-is-initialized \
ksym-default-roccat-common2-device-init-struct \
ksym-default-roccat-common2-receive \
ksym-default-roccat-common2-send \
ksym-default-roccat-common2-send-with-status \
ksym-default-roccat-common2-sysfs-read \
ksym-default-roccat-common2-sysfs-write \
ksym-default-roccat-connect \
ksym-default-roccat-disconnect \
ksym-default-roccat-report-event \
ksym-default-roce-del-all-netdev-gids \
ksym-default-roce-gid-type-mask-support \
ksym-default-rockchip-clk-add-grf \
ksym-default-rockchip-clk-finalize \
ksym-default-rockchip-clk-find-max-clk-id \
ksym-default-rockchip-clk-init \
ksym-default-rockchip-clk-init-early \
ksym-default-rockchip-clk-of-add-provider \
ksym-default-rockchip-clk-protect-critical \
ksym-default-rockchip-clk-register-armclk \
ksym-default-rockchip-clk-register-armclk-multi-pll \
ksym-default-rockchip-clk-register-branches \
ksym-default-rockchip-clk-register-ddrclk \
ksym-default-rockchip-clk-register-late-branches \
ksym-default-rockchip-clk-register-plls \
ksym-default-rockchip-drm-wait-vact-end \
ksym-default-rockchip-pcie-cfg-configuration-accesses \
ksym-default-rockchip-pcie-deinit-phys \
ksym-default-rockchip-pcie-disable-clocks \
ksym-default-rockchip-pcie-enable-clocks \
ksym-default-rockchip-pcie-get-phys \
ksym-default-rockchip-pcie-init-port \
ksym-default-rockchip-pcie-parse-dt \
ksym-default-rockchip-pmu-block \
ksym-default-rockchip-pmu-unblock \
ksym-default-rockchip-register-restart-notifier \
ksym-default-rockchip-register-softrst-lut \
ksym-default-rockchip-rgb-fini \
ksym-default-rockchip-rgb-init \
ksym-default-rocket-pm-ops \
ksym-default-rohm-regulator-set-dvs-levels \
ksym-default-rohm-regulator-set-voltage-sel-restricted \
ksym-default-root-device-unregister \
ksym-default-root-mem-cgroup \
ksym-default-round-jiffies \
ksym-default-round-jiffies-relative \
ksym-default-round-jiffies-up \
ksym-default-round-jiffies-up-relative \
ksym-default-rpc-add-pipe-dir-object \
ksym-default-rpc-alloc-iostats \
ksym-default-rpc-bind-new-program \
ksym-default-rpc-calc-rto \
ksym-default-rpc-call-async \
ksym-default-rpc-call-null \
ksym-default-rpc-call-start \
ksym-default-rpc-call-sync \
ksym-default-rpc-cancel-tasks \
ksym-default-rpc-clnt-add-xprt \
ksym-default-rpc-clnt-disconnect \
ksym-default-rpc-clnt-iterate-for-each-xprt \
ksym-default-rpc-clnt-manage-trunked-xprts \
ksym-default-rpc-clnt-probe-trunked-xprts \
ksym-default-rpc-clnt-setup-test-and-add-xprt \
ksym-default-rpc-clnt-show-stats \
ksym-default-rpc-clnt-swap-activate \
ksym-default-rpc-clnt-swap-deactivate \
ksym-default-rpc-clnt-test-and-add-xprt \
ksym-default-rpc-clnt-xprt-switch-add-xprt \
ksym-default-rpc-clnt-xprt-switch-has-addr \
ksym-default-rpc-clnt-xprt-switch-remove-xprt \
ksym-default-rpc-clone-client \
ksym-default-rpc-clone-client-set-auth \
ksym-default-rpc-count-iostats \
ksym-default-rpc-count-iostats-metrics \
ksym-default-rpc-create \
ksym-default-rpc-d-lookup-sb \
ksym-default-rpc-debug \
ksym-default-rpc-delay \
ksym-default-rpc-destroy-pipe-data \
ksym-default-rpc-destroy-wait-queue \
ksym-default-rpc-exit \
ksym-default-rpc-find-or-alloc-pipe-dir-object \
ksym-default-rpc-force-rebind \
ksym-default-rpc-free-iostats \
ksym-default-rpc-get-sb-net \
ksym-default-rpc-init-pipe-dir-head \
ksym-default-rpc-init-pipe-dir-object \
ksym-default-rpc-init-priority-wait-queue \
ksym-default-rpc-init-rtt \
ksym-default-rpc-init-wait-queue \
ksym-default-rpc-killall-tasks \
ksym-default-rpc-localaddr \
ksym-default-rpc-machine-cred \
ksym-default-rpc-max-bc-payload \
ksym-default-rpc-max-payload \
ksym-default-rpc-mkpipe-data \
ksym-default-rpc-mkpipe-dentry \
ksym-default-rpc-net-ns \
ksym-default-rpc-ntop \
ksym-default-rpc-num-bc-slots \
ksym-default-rpc-peeraddr \
ksym-default-rpc-peeraddr2str \
ksym-default-rpc-pipe-generic-upcall \
ksym-default-rpc-pipefs-notifier-register \
ksym-default-rpc-pipefs-notifier-unregister \
ksym-default-rpc-prepare-reply-pages \
ksym-default-rpc-proc-register \
ksym-default-rpc-proc-unregister \
ksym-default-rpc-pton \
ksym-default-rpc-put-sb-net \
ksym-default-rpc-put-task \
ksym-default-rpc-put-task-async \
ksym-default-rpc-queue-upcall \
ksym-default-rpc-release-client \
ksym-default-rpc-remove-pipe-dir-object \
ksym-default-rpc-restart-call \
ksym-default-rpc-restart-call-prepare \
ksym-default-rpc-run-task \
ksym-default-rpc-set-connect-timeout \
ksym-default-rpc-setbufsize \
ksym-default-rpc-shutdown-client \
ksym-default-rpc-sleep-on \
ksym-default-rpc-sleep-on-priority \
ksym-default-rpc-sleep-on-priority-timeout \
ksym-default-rpc-sleep-on-timeout \
ksym-default-rpc-switch-client-transport \
ksym-default-rpc-task-gfp-mask \
ksym-default-rpc-task-release-transport \
ksym-default-rpc-task-timeout \
ksym-default-rpc-uaddr2sockaddr \
ksym-default-rpc-unlink \
ksym-default-rpc-update-rtt \
ksym-default-rpc-wait-for-completion-task \
ksym-default-rpc-wake-up \
ksym-default-rpc-wake-up-first \
ksym-default-rpc-wake-up-next \
ksym-default-rpc-wake-up-queued-task \
ksym-default-rpc-wake-up-status \
ksym-default-rpcauth-create \
ksym-default-rpcauth-destroy-credcache \
ksym-default-rpcauth-get-gssinfo \
ksym-default-rpcauth-get-pseudoflavor \
ksym-default-rpcauth-init-cred \
ksym-default-rpcauth-init-credcache \
ksym-default-rpcauth-lookup-credcache \
ksym-default-rpcauth-lookupcred \
ksym-default-rpcauth-register \
ksym-default-rpcauth-stringify-acceptor \
ksym-default-rpcauth-unregister \
ksym-default-rpcauth-unwrap-resp-decode \
ksym-default-rpcauth-wrap-req-encode \
ksym-default-rpcb-getport-async \
ksym-default-rpcif-dirmap-read \
ksym-default-rpcif-hw-init \
ksym-default-rpcif-manual-xfer \
ksym-default-rpcif-prepare \
ksym-default-rpcif-sw-init \
ksym-default-rpi-firmware-clk-get-max-rate \
ksym-default-rpi-firmware-find-node \
ksym-default-rpi-firmware-get \
ksym-default-rpi-firmware-property \
ksym-default-rpi-firmware-property-list \
ksym-default-rpi-firmware-put \
ksym-default-rpmb-dev-find-device \
ksym-default-rpmb-dev-get \
ksym-default-rpmb-dev-put \
ksym-default-rpmb-dev-register \
ksym-default-rpmb-dev-unregister \
ksym-default-rpmb-interface-register \
ksym-default-rpmb-interface-unregister \
ksym-default-rpmb-route-frames \
ksym-default-rpmh-invalidate \
ksym-default-rpmh-write \
ksym-default-rpmh-write-async \
ksym-default-rpmh-write-batch \
ksym-default-rpmsg-chrdev-eptdev-create \
ksym-default-rpmsg-chrdev-eptdev-destroy \
ksym-default-rpmsg-class \
ksym-default-rpmsg-create-channel \
ksym-default-rpmsg-create-ept \
ksym-default-rpmsg-destroy-ept \
ksym-default-rpmsg-find-device \
ksym-default-rpmsg-get-mtu \
ksym-default-rpmsg-ns-register-device \
ksym-default-rpmsg-poll \
ksym-default-rpmsg-register-device \
ksym-default-rpmsg-register-device-override \
ksym-default-rpmsg-release-channel \
ksym-default-rpmsg-send \
ksym-default-rpmsg-sendto \
ksym-default-rpmsg-set-flow-control \
ksym-default-rpmsg-trysend \
ksym-default-rpmsg-trysendto \
ksym-default-rpmsg-unregister-device \
ksym-default-rproc-add \
ksym-default-rproc-add-carveout \
ksym-default-rproc-add-subdev \
ksym-default-rproc-alloc \
ksym-default-rproc-boot \
ksym-default-rproc-coredump \
ksym-default-rproc-coredump-add-custom-segment \
ksym-default-rproc-coredump-add-segment \
ksym-default-rproc-coredump-cleanup \
ksym-default-rproc-coredump-set-elf-info \
ksym-default-rproc-coredump-using-sections \
ksym-default-rproc-da-to-va \
ksym-default-rproc-del \
ksym-default-rproc-detach \
ksym-default-rproc-elf-find-loaded-rsc-table \
ksym-default-rproc-elf-get-boot-addr \
ksym-default-rproc-elf-load-rsc-table \
ksym-default-rproc-elf-load-segments \
ksym-default-rproc-elf-sanity-check \
ksym-default-rproc-free \
ksym-default-rproc-get-by-child \
ksym-default-rproc-get-by-phandle \
ksym-default-rproc-mem-entry-init \
ksym-default-rproc-of-parse-firmware \
ksym-default-rproc-of-resm-mem-entry-init \
ksym-default-rproc-put \
ksym-default-rproc-remove-subdev \
ksym-default-rproc-report-crash \
ksym-default-rproc-resource-cleanup \
ksym-default-rproc-set-firmware \
ksym-default-rproc-shutdown \
ksym-default-rproc-vq-interrupt \
ksym-default-rps-may-expire-flow \
ksym-default-rps-needed \
ksym-default-rqspinlock-held-locks \
ksym-default-rs-pretty-print-rate \
ksym-default-rsa-parse-priv-key \
ksym-default-rsa-parse-pub-key \
ksym-default-rsi-91x-deinit \
ksym-default-rsi-91x-init \
ksym-default-rsi-bt-ops \
ksym-default-rsi-config-wowlan \
ksym-default-rsi-dbg \
ksym-default-rsi-hal-device-init \
ksym-default-rsi-mac80211-detach \
ksym-default-rsi-mac80211-rfkill-exit \
ksym-default-rsi-present \
ksym-default-rsi-read-pkt \
ksym-default-rsi-zone-enabled \
ksym-default-rt-dst-alloc \
ksym-default-rt-mutex-base-init \
ksym-default-rt-mutex-lock \
ksym-default-rt-mutex-lock-interruptible \
ksym-default-rt-mutex-lock-killable \
ksym-default-rt-mutex-trylock \
ksym-default-rt-mutex-unlock \
ksym-default-rt2800-ampdu-action \
ksym-default-rt2800-check-firmware \
ksym-default-rt2800-clear-beacon \
ksym-default-rt2800-conf-tx \
ksym-default-rt2800-config \
ksym-default-rt2800-config-ant \
ksym-default-rt2800-config-erp \
ksym-default-rt2800-config-filter \
ksym-default-rt2800-config-intf \
ksym-default-rt2800-config-pairwise-key \
ksym-default-rt2800-config-shared-key \
ksym-default-rt2800-disable-radio \
ksym-default-rt2800-disable-wpdma \
ksym-default-rt2800-efuse-detect \
ksym-default-rt2800-enable-radio \
ksym-default-rt2800-gain-calibration \
ksym-default-rt2800-get-key-seq \
ksym-default-rt2800-get-survey \
ksym-default-rt2800-get-tsf \
ksym-default-rt2800-get-txwi-rxwi-size \
ksym-default-rt2800-link-stats \
ksym-default-rt2800-link-tuner \
ksym-default-rt2800-load-firmware \
ksym-default-rt2800-mcu-request \
ksym-default-rt2800-pre-reset-hw \
ksym-default-rt2800-probe-hw \
ksym-default-rt2800-process-rxwi \
ksym-default-rt2800-read-eeprom-efuse \
ksym-default-rt2800-read-eeprom-nvmem \
ksym-default-rt2800-reset-tuner \
ksym-default-rt2800-rfkill-poll \
ksym-default-rt2800-set-rts-threshold \
ksym-default-rt2800-sta-add \
ksym-default-rt2800-sta-remove \
ksym-default-rt2800-txdone \
ksym-default-rt2800-txdone-entry \
ksym-default-rt2800-txdone-nostatus \
ksym-default-rt2800-txstatus-pending \
ksym-default-rt2800-txstatus-timeout \
ksym-default-rt2800-vco-calibration \
ksym-default-rt2800-wait-csr-ready \
ksym-default-rt2800-wait-wpdma-ready \
ksym-default-rt2800-watchdog \
ksym-default-rt2800-write-beacon \
ksym-default-rt2800-write-tx-data \
ksym-default-rt2800mmio-autowake-tasklet \
ksym-default-rt2800mmio-clear-entry \
ksym-default-rt2800mmio-enable-radio \
ksym-default-rt2800mmio-fill-rxdone \
ksym-default-rt2800mmio-flush-queue \
ksym-default-rt2800mmio-get-dma-done \
ksym-default-rt2800mmio-get-entry-state \
ksym-default-rt2800mmio-get-txwi \
ksym-default-rt2800mmio-init-queues \
ksym-default-rt2800mmio-init-registers \
ksym-default-rt2800mmio-interrupt \
ksym-default-rt2800mmio-kick-queue \
ksym-default-rt2800mmio-pretbtt-tasklet \
ksym-default-rt2800mmio-probe-hw \
ksym-default-rt2800mmio-queue-init \
ksym-default-rt2800mmio-rxdone-tasklet \
ksym-default-rt2800mmio-start-queue \
ksym-default-rt2800mmio-stop-queue \
ksym-default-rt2800mmio-tbtt-tasklet \
ksym-default-rt2800mmio-toggle-irq \
ksym-default-rt2800mmio-txstatus-tasklet \
ksym-default-rt2800mmio-write-tx-desc \
ksym-default-rt2x00lib-beacondone \
ksym-default-rt2x00lib-dmadone \
ksym-default-rt2x00lib-dmastart \
ksym-default-rt2x00lib-get-bssidx \
ksym-default-rt2x00lib-pretbtt \
ksym-default-rt2x00lib-probe-dev \
ksym-default-rt2x00lib-remove-dev \
ksym-default-rt2x00lib-resume \
ksym-default-rt2x00lib-rxdone \
ksym-default-rt2x00lib-set-mac-address \
ksym-default-rt2x00lib-suspend \
ksym-default-rt2x00lib-txdone \
ksym-default-rt2x00lib-txdone-noinfo \
ksym-default-rt2x00lib-txdone-nomatch \
ksym-default-rt2x00mac-add-interface \
ksym-default-rt2x00mac-bss-info-changed \
ksym-default-rt2x00mac-conf-tx \
ksym-default-rt2x00mac-config \
ksym-default-rt2x00mac-configure-filter \
ksym-default-rt2x00mac-flush \
ksym-default-rt2x00mac-get-antenna \
ksym-default-rt2x00mac-get-ringparam \
ksym-default-rt2x00mac-get-stats \
ksym-default-rt2x00mac-reconfig-complete \
ksym-default-rt2x00mac-remove-interface \
ksym-default-rt2x00mac-rfkill-poll \
ksym-default-rt2x00mac-set-antenna \
ksym-default-rt2x00mac-set-key \
ksym-default-rt2x00mac-set-tim \
ksym-default-rt2x00mac-start \
ksym-default-rt2x00mac-stop \
ksym-default-rt2x00mac-sw-scan-complete \
ksym-default-rt2x00mac-sw-scan-start \
ksym-default-rt2x00mac-tx \
ksym-default-rt2x00mac-tx-frames-pending \
ksym-default-rt2x00mmio-flush-queue \
ksym-default-rt2x00mmio-initialize \
ksym-default-rt2x00mmio-regbusy-read \
ksym-default-rt2x00mmio-rxdone \
ksym-default-rt2x00mmio-uninitialize \
ksym-default-rt2x00pci-pm-ops \
ksym-default-rt2x00pci-probe \
ksym-default-rt2x00pci-remove \
ksym-default-rt2x00queue-flush-queue \
ksym-default-rt2x00queue-flush-queues \
ksym-default-rt2x00queue-for-each-entry \
ksym-default-rt2x00queue-get-entry \
ksym-default-rt2x00queue-map-txskb \
ksym-default-rt2x00queue-pause-queue \
ksym-default-rt2x00queue-start-queue \
ksym-default-rt2x00queue-start-queues \
ksym-default-rt2x00queue-stop-queue \
ksym-default-rt2x00queue-stop-queues \
ksym-default-rt2x00queue-unmap-skb \
ksym-default-rt2x00queue-unpause-queue \
ksym-default-rt2x00usb-clear-entry \
ksym-default-rt2x00usb-disable-radio \
ksym-default-rt2x00usb-disconnect \
ksym-default-rt2x00usb-flush-queue \
ksym-default-rt2x00usb-initialize \
ksym-default-rt2x00usb-kick-queue \
ksym-default-rt2x00usb-probe \
ksym-default-rt2x00usb-regbusy-read \
ksym-default-rt2x00usb-register-read-async \
ksym-default-rt2x00usb-resume \
ksym-default-rt2x00usb-suspend \
ksym-default-rt2x00usb-uninitialize \
ksym-default-rt2x00usb-vendor-req-buff-lock \
ksym-default-rt2x00usb-vendor-request \
ksym-default-rt2x00usb-vendor-request-buff \
ksym-default-rt2x00usb-watchdog \
ksym-default-rt5514-spi-burst-read \
ksym-default-rt5514-spi-burst-write \
ksym-default-rt5640-detect-headset \
ksym-default-rt5640-disable-micbias1-for-ovcd \
ksym-default-rt5640-dmic-enable \
ksym-default-rt5640-enable-micbias1-for-ovcd \
ksym-default-rt5640-sel-asrc-clk-src \
ksym-default-rt5640-set-ovcd-params \
ksym-default-rt5645-components \
ksym-default-rt5645-sel-asrc-clk-src \
ksym-default-rt5645-set-jack-detect \
ksym-default-rt5659-set-jack-detect \
ksym-default-rt5663-sel-asrc-clk-src \
ksym-default-rt5682-aif1-dai-ops \
ksym-default-rt5682-aif2-dai-ops \
ksym-default-rt5682-apply-patch-list \
ksym-default-rt5682-calibrate \
ksym-default-rt5682-get-ldo1 \
ksym-default-rt5682-jack-detect-handler \
ksym-default-rt5682-parse-dt \
ksym-default-rt5682-readable-register \
ksym-default-rt5682-reg \
ksym-default-rt5682-register-dai-clks \
ksym-default-rt5682-reset \
ksym-default-rt5682-sel-asrc-clk-src \
ksym-default-rt5682-soc-component-dev \
ksym-default-rt5682-supply-names \
ksym-default-rt5682-volatile-register \
ksym-default-rt5682s-sel-asrc-clk-src \
ksym-default-rt6-lookup \
ksym-default-rtc-add-group \
ksym-default-rtc-add-groups \
ksym-default-rtc-alarm-irq-enable \
ksym-default-rtc-class-close \
ksym-default-rtc-class-open \
ksym-default-rtc-initialize-alarm \
ksym-default-rtc-ktime-to-tm \
ksym-default-rtc-month-days \
ksym-default-rtc-read-alarm \
ksym-default-rtc-read-next-alarm \
ksym-default-rtc-read-time \
ksym-default-rtc-set-alarm \
ksym-default-rtc-set-time \
ksym-default-rtc-time64-to-tm \
ksym-default-rtc-tm-to-ktime \
ksym-default-rtc-tm-to-time64 \
ksym-default-rtc-update-irq \
ksym-default-rtc-update-irq-enable \
ksym-default-rtc-valid-tm \
ksym-default-rtc-year-days \
ksym-default-rtd-pinctrl-probe \
ksym-default-rtl-action-proc \
ksym-default-rtl-addr-delay \
ksym-default-rtl-beacon-statistic \
ksym-default-rtl-btc-get-ops-pointer \
ksym-default-rtl-btc-status-false \
ksym-default-rtl-c2hcmd-enqueue \
ksym-default-rtl-cam-add-one-entry \
ksym-default-rtl-cam-del-entry \
ksym-default-rtl-cam-delete-one-entry \
ksym-default-rtl-cam-empty-entry \
ksym-default-rtl-cam-get-free-entry \
ksym-default-rtl-cam-mark-invalid \
ksym-default-rtl-cam-reset-all-entry \
ksym-default-rtl-cmd-send-packet \
ksym-default-rtl-collect-scan-list \
ksym-default-rtl-debug-add-one \
ksym-default-rtl-debug-remove-one \
ksym-default-rtl-deinit-core \
ksym-default-rtl-deinit-deferred-work \
ksym-default-rtl-deinit-rfkill \
ksym-default-rtl-dm-diginit \
ksym-default-rtl-efuse-ops-init \
ksym-default-rtl-efuse-shadow-map-update \
ksym-default-rtl-evm-db-to-percentage \
ksym-default-rtl-fill-dummy \
ksym-default-rtl-fw-block-write \
ksym-default-rtl-fw-cb \
ksym-default-rtl-fw-page-write \
ksym-default-rtl-get-hal-edca-param \
ksym-default-rtl-get-hwinfo \
ksym-default-rtl-get-tcb-desc \
ksym-default-rtl-hal-pwrseqcmdparsing \
ksym-default-rtl-init-core \
ksym-default-rtl-init-rfkill \
ksym-default-rtl-init-rx-config \
ksym-default-rtl-init-sw-leds \
ksym-default-rtl-ips-nic-on \
ksym-default-rtl-is-special-data \
ksym-default-rtl-lps-change-work-callback \
ksym-default-rtl-lps-enter \
ksym-default-rtl-lps-leave \
ksym-default-rtl-mrate-idx-to-arfr-id \
ksym-default-rtl-ops \
ksym-default-rtl-p2p-info \
ksym-default-rtl-pci-disconnect \
ksym-default-rtl-pci-probe \
ksym-default-rtl-pci-resume \
ksym-default-rtl-pci-suspend \
ksym-default-rtl-phy-scan-operation-backup \
ksym-default-rtl-process-phyinfo \
ksym-default-rtl-ps-disable-nic \
ksym-default-rtl-ps-enable-nic \
ksym-default-rtl-query-rxpwrpercentage \
ksym-default-rtl-recognize-peer \
ksym-default-rtl-rfreg-delay \
ksym-default-rtl-rx-ampdu-apply \
ksym-default-rtl-send-smps-action \
ksym-default-rtl-set-tx-report \
ksym-default-rtl-signal-scale-mapping \
ksym-default-rtl-swlps-beacon \
ksym-default-rtl-tid-to-ac \
ksym-default-rtl-tx-ackqueue \
ksym-default-rtl-tx-mgmt-proc \
ksym-default-rtl-tx-report-handler \
ksym-default-rtl-update-beacon-work-callback \
ksym-default-rtl-usb-disconnect \
ksym-default-rtl-usb-probe \
ksym-default-rtl-wowlan-fw-cb \
ksym-default-rtl8152-get-version \
ksym-default-rtl8192-phy-check-is-legal-rfpath \
ksym-default-rtl8366-enable-vlan \
ksym-default-rtl8366-enable-vlan4k \
ksym-default-rtl8366-get-ethtool-stats \
ksym-default-rtl8366-get-sset-count \
ksym-default-rtl8366-get-strings \
ksym-default-rtl8366-mc-is-used \
ksym-default-rtl8366-reset-vlan \
ksym-default-rtl8366-set-pvid \
ksym-default-rtl8366-set-vlan \
ksym-default-rtl8366-vlan-add \
ksym-default-rtl8366-vlan-del \
ksym-default-rtl83xx-lock \
ksym-default-rtl83xx-port-bridge-flags \
ksym-default-rtl83xx-port-bridge-join \
ksym-default-rtl83xx-port-bridge-leave \
ksym-default-rtl83xx-port-fast-age \
ksym-default-rtl83xx-port-fdb-add \
ksym-default-rtl83xx-port-fdb-del \
ksym-default-rtl83xx-port-fdb-dump \
ksym-default-rtl83xx-port-mdb-add \
ksym-default-rtl83xx-port-mdb-del \
ksym-default-rtl83xx-probe \
ksym-default-rtl83xx-register-switch \
ksym-default-rtl83xx-remove \
ksym-default-rtl83xx-setup-port-flood-control \
ksym-default-rtl83xx-setup-user-mdio \
ksym-default-rtl83xx-shutdown \
ksym-default-rtl83xx-unlock \
ksym-default-rtl83xx-unregister-switch \
ksym-default-rtl8723-dm-init-dynamic-bb-powersaving \
ksym-default-rtl8723-dm-init-dynamic-txpower \
ksym-default-rtl8723-dm-init-edca-turbo \
ksym-default-rtl8723-download-fw \
ksym-default-rtl8723-enable-fw-download \
ksym-default-rtl8723-fw-free-to-go \
ksym-default-rtl8723-phy-init-bb-rf-reg-def \
ksym-default-rtl8723-phy-mac-setting-calibration \
ksym-default-rtl8723-phy-path-a-fill-iqk-matrix \
ksym-default-rtl8723-phy-path-a-standby \
ksym-default-rtl8723-phy-path-adda-on \
ksym-default-rtl8723-phy-pi-mode-switch \
ksym-default-rtl8723-phy-query-bb-reg \
ksym-default-rtl8723-phy-reload-adda-registers \
ksym-default-rtl8723-phy-reload-mac-registers \
ksym-default-rtl8723-phy-rf-serial-read \
ksym-default-rtl8723-phy-rf-serial-write \
ksym-default-rtl8723-phy-save-mac-registers \
ksym-default-rtl8723-phy-set-bb-reg \
ksym-default-rtl8723-phy-set-sw-chnl-cmdarray \
ksym-default-rtl8723-phy-txpwr-idx-to-dbm \
ksym-default-rtl8723-save-adda-registers \
ksym-default-rtl8723-write-fw \
ksym-default-rtl8723ae-firmware-selfreset \
ksym-default-rtl8723be-firmware-selfreset \
ksym-default-rtl92c-bt-rssi-state-change \
ksym-default-rtl92c-dm-bt-coexist \
ksym-default-rtl92c-dm-check-txpower-tracking \
ksym-default-rtl92c-dm-init \
ksym-default-rtl92c-dm-init-edca-turbo \
ksym-default-rtl92c-dm-init-rate-adaptive-mask \
ksym-default-rtl92c-dm-rf-saving \
ksym-default-rtl92c-dm-watchdog \
ksym-default-rtl92c-dm-write-dig \
ksym-default-rtl92c-download-fw \
ksym-default-rtl92c-fill-h2c-cmd \
ksym-default-rtl92c-firmware-selfreset \
ksym-default-rtl92c-phy-ap-calibrate \
ksym-default-rtl92c-phy-iq-calibrate \
ksym-default-rtl92c-phy-lc-calibrate \
ksym-default-rtl92c-phy-query-bb-reg \
ksym-default-rtl92c-phy-rf-config \
ksym-default-rtl92c-phy-set-bb-reg \
ksym-default-rtl92c-phy-set-bw-mode \
ksym-default-rtl92c-phy-set-io \
ksym-default-rtl92c-phy-set-io-cmd \
ksym-default-rtl92c-phy-set-rfpath-switch \
ksym-default-rtl92c-phy-set-txpower-level \
ksym-default-rtl92c-phy-sw-chnl \
ksym-default-rtl92c-phy-sw-chnl-callback \
ksym-default-rtl92c-phy-update-txpower-dbm \
ksym-default-rtl92c-set-fw-joinbss-report-cmd \
ksym-default-rtl92c-set-fw-pwrmode-cmd \
ksym-default-rtl92c-set-fw-rsvdpagepkt \
ksym-default-rtl92c-set-p2p-ps-offload-cmd \
ksym-default-rtl92ce-phy-set-rf-on \
ksym-default-rtl92d-dm-check-edca-turbo \
ksym-default-rtl92d-dm-check-txpower-tracking-thermal-meter \
ksym-default-rtl92d-dm-dig \
ksym-default-rtl92d-dm-false-alarm-counter-statistics \
ksym-default-rtl92d-dm-find-minimum-rssi \
ksym-default-rtl92d-dm-init-edca-turbo \
ksym-default-rtl92d-dm-init-rate-adaptive-mask \
ksym-default-rtl92d-dm-initialize-txpower-tracking \
ksym-default-rtl92d-dm-write-dig \
ksym-default-rtl92d-enable-fw-download \
ksym-default-rtl92d-enable-hw-security-config \
ksym-default-rtl92d-fill-h2c-cmd \
ksym-default-rtl92d-firmware-selfreset \
ksym-default-rtl92d-fw-free-to-go \
ksym-default-rtl92d-fw-init \
ksym-default-rtl92d-get-chnlgroup-fromarray \
ksym-default-rtl92d-get-desc \
ksym-default-rtl92d-get-hw-reg \
ksym-default-rtl92d-get-rightchnlplace-for-iqk \
ksym-default-rtl92d-gpio-radio-on-off-checking \
ksym-default-rtl92d-is-fw-downloaded \
ksym-default-rtl92d-llt-write \
ksym-default-rtl92d-phy-calc-curvindex \
ksym-default-rtl92d-phy-config-maccoexist-rfpage \
ksym-default-rtl92d-phy-config-macphymode \
ksym-default-rtl92d-phy-config-macphymode-info \
ksym-default-rtl92d-phy-enable-rf-env \
ksym-default-rtl92d-phy-get-hw-reg-originalvalue \
ksym-default-rtl92d-phy-init-bb-rf-register-definition \
ksym-default-rtl92d-phy-mac-setting-calibration \
ksym-default-rtl92d-phy-path-adda-on \
ksym-default-rtl92d-phy-query-rf-reg \
ksym-default-rtl92d-phy-reset-iqk-result \
ksym-default-rtl92d-phy-restore-rf-env \
ksym-default-rtl92d-phy-rf6052-set-bandwidth \
ksym-default-rtl92d-phy-rf6052-set-cck-txpower \
ksym-default-rtl92d-phy-rf6052-set-ofdm-txpower \
ksym-default-rtl92d-phy-save-adda-registers \
ksym-default-rtl92d-phy-save-mac-registers \
ksym-default-rtl92d-phy-set-io-cmd \
ksym-default-rtl92d-phy-set-rf-reg \
ksym-default-rtl92d-phy-set-txpower-level \
ksym-default-rtl92d-read-eeprom-info \
ksym-default-rtl92d-resume-tx-beacon \
ksym-default-rtl92d-rx-query-desc \
ksym-default-rtl92d-set-desc \
ksym-default-rtl92d-set-fw-joinbss-report-cmd \
ksym-default-rtl92d-set-hw-reg \
ksym-default-rtl92d-set-key \
ksym-default-rtl92d-set-qos \
ksym-default-rtl92d-stop-tx-beacon \
ksym-default-rtl92d-store-pwrindex-diffrate-offset \
ksym-default-rtl92d-update-channel-access-setting \
ksym-default-rtl92d-update-hal-rate-tbl \
ksym-default-rtl92d-write-fw \
ksym-default-rtlwifi-rate-mapping \
ksym-default-rtm-getroute-parse-ip-proto \
ksym-default-rtnetlink-put-metrics \
ksym-default-rtnl-af-register \
ksym-default-rtnl-af-unregister \
ksym-default-rtnl-configure-link \
ksym-default-rtnl-create-link \
ksym-default-rtnl-delete-link \
ksym-default-rtnl-dev-link-net-capable \
ksym-default-rtnl-get-net-ns-capable \
ksym-default-rtnl-is-locked \
ksym-default-rtnl-kfree-skbs \
ksym-default-rtnl-link-get-net \
ksym-default-rtnl-link-register \
ksym-default-rtnl-link-unregister \
ksym-default-rtnl-lock \
ksym-default-rtnl-nla-parse-ifinfomsg \
ksym-default-rtnl-notify \
ksym-default-rtnl-offload-xstats-notify \
ksym-default-rtnl-put-cacheinfo \
ksym-default-rtnl-set-sk-err \
ksym-default-rtnl-trylock \
ksym-default-rtnl-unicast \
ksym-default-rtnl-unlock \
ksym-default-rtnl-unregister-all \
ksym-default-rtrs-addr-to-sockaddr \
ksym-default-rtrs-addr-to-str \
ksym-default-rtrs-clt-close \
ksym-default-rtrs-clt-get-permit \
ksym-default-rtrs-clt-open \
ksym-default-rtrs-clt-put-permit \
ksym-default-rtrs-clt-query \
ksym-default-rtrs-clt-rdma-cq-direct \
ksym-default-rtrs-clt-request \
ksym-default-rtrs-cq-qp-create \
ksym-default-rtrs-cq-qp-destroy \
ksym-default-rtrs-ib-dev-find-or-add \
ksym-default-rtrs-ib-dev-put \
ksym-default-rtrs-init-hb \
ksym-default-rtrs-iu-alloc \
ksym-default-rtrs-iu-free \
ksym-default-rtrs-iu-post-rdma-write-imm \
ksym-default-rtrs-iu-post-recv \
ksym-default-rtrs-iu-post-send \
ksym-default-rtrs-post-recv-empty \
ksym-default-rtrs-rdma-dev-pd-deinit \
ksym-default-rtrs-rdma-dev-pd-init \
ksym-default-rtrs-send-hb-ack \
ksym-default-rtrs-srv-close \
ksym-default-rtrs-srv-get-path-name \
ksym-default-rtrs-srv-get-queue-depth \
ksym-default-rtrs-srv-open \
ksym-default-rtrs-srv-resp-rdma \
ksym-default-rtrs-srv-set-sess-priv \
ksym-default-rtrs-start-hb \
ksym-default-rtrs-stop-hb \
ksym-default-rtsx-pci-add-cmd \
ksym-default-rtsx-pci-card-exclusive-check \
ksym-default-rtsx-pci-card-exist \
ksym-default-rtsx-pci-card-power-off \
ksym-default-rtsx-pci-card-power-on \
ksym-default-rtsx-pci-card-pull-ctl-disable \
ksym-default-rtsx-pci-card-pull-ctl-enable \
ksym-default-rtsx-pci-complete-unfinished-transfer \
ksym-default-rtsx-pci-dma-map-sg \
ksym-default-rtsx-pci-dma-transfer \
ksym-default-rtsx-pci-dma-unmap-sg \
ksym-default-rtsx-pci-read-phy-register \
ksym-default-rtsx-pci-read-ppbuf \
ksym-default-rtsx-pci-read-register \
ksym-default-rtsx-pci-send-cmd \
ksym-default-rtsx-pci-send-cmd-no-wait \
ksym-default-rtsx-pci-start-run \
ksym-default-rtsx-pci-stop-cmd \
ksym-default-rtsx-pci-switch-clock \
ksym-default-rtsx-pci-switch-output-voltage \
ksym-default-rtsx-pci-write-phy-register \
ksym-default-rtsx-pci-write-ppbuf \
ksym-default-rtsx-pci-write-register \
ksym-default-rtsx-usb-add-cmd \
ksym-default-rtsx-usb-card-exclusive-check \
ksym-default-rtsx-usb-ep0-read-register \
ksym-default-rtsx-usb-ep0-write-register \
ksym-default-rtsx-usb-get-card-status \
ksym-default-rtsx-usb-get-rsp \
ksym-default-rtsx-usb-read-ppbuf \
ksym-default-rtsx-usb-read-register \
ksym-default-rtsx-usb-send-cmd \
ksym-default-rtsx-usb-switch-clock \
ksym-default-rtsx-usb-transfer-data \
ksym-default-rtsx-usb-write-ppbuf \
ksym-default-rtsx-usb-write-register \
ksym-default-rtw-bf-cfg-csi-rate \
ksym-default-rtw-bf-enable-bfee-mu \
ksym-default-rtw-bf-enable-bfee-su \
ksym-default-rtw-bf-phy-init \
ksym-default-rtw-bf-remove-bfee-mu \
ksym-default-rtw-bf-remove-bfee-su \
ksym-default-rtw-bf-set-gid-table \
ksym-default-rtw-chip-info-setup \
ksym-default-rtw-coex-init-hw-config \
ksym-default-rtw-coex-power-off-setting \
ksym-default-rtw-coex-power-on-setting \
ksym-default-rtw-coex-read-indirect-reg \
ksym-default-rtw-coex-write-indirect-reg \
ksym-default-rtw-coex-write-scbd \
ksym-default-rtw-core-deinit \
ksym-default-rtw-core-init \
ksym-default-rtw-debug-mask \
ksym-default-rtw-disable-lps-deep-mode \
ksym-default-rtw-download-firmware \
ksym-default-rtw-dump-fw \
ksym-default-rtw-dump-reg \
ksym-default-rtw-fw-c2h-cmd-isr \
ksym-default-rtw-fw-c2h-cmd-rx-irqsafe \
ksym-default-rtw-fw-do-iqk \
ksym-default-rtw-fw-inform-rfk-status \
ksym-default-rtw-fw-recovery \
ksym-default-rtw-ops \
ksym-default-rtw-parse-tbl-bb-pg \
ksym-default-rtw-parse-tbl-phy-cond \
ksym-default-rtw-parse-tbl-txpwr-lmt \
ksym-default-rtw-pci-err-handler \
ksym-default-rtw-pci-probe \
ksym-default-rtw-pci-remove \
ksym-default-rtw-pci-shutdown \
ksym-default-rtw-phy-cfg-agc \
ksym-default-rtw-phy-cfg-bb \
ksym-default-rtw-phy-cfg-mac \
ksym-default-rtw-phy-cfg-rf \
ksym-default-rtw-phy-config-swing-table \
ksym-default-rtw-phy-get-tx-power-index \
ksym-default-rtw-phy-init \
ksym-default-rtw-phy-load-tables \
ksym-default-rtw-phy-parsing-cfo \
ksym-default-rtw-phy-pwrtrack-avg \
ksym-default-rtw-phy-pwrtrack-get-delta \
ksym-default-rtw-phy-pwrtrack-get-pwridx \
ksym-default-rtw-phy-pwrtrack-need-iqk \
ksym-default-rtw-phy-pwrtrack-need-lck \
ksym-default-rtw-phy-pwrtrack-thermal-changed \
ksym-default-rtw-phy-read-rf \
ksym-default-rtw-phy-read-rf-sipi \
ksym-default-rtw-phy-rf-power-2-rssi \
ksym-default-rtw-phy-set-edcca-th \
ksym-default-rtw-phy-set-tx-power-level \
ksym-default-rtw-phy-write-rf-reg-mix \
ksym-default-rtw-phy-write-rf-reg-sipi \
ksym-default-rtw-pm-ops \
ksym-default-rtw-power-mode-change \
ksym-default-rtw-power-off \
ksym-default-rtw-power-on \
ksym-default-rtw-pwr-seq-parser \
ksym-default-rtw-rate-section \
ksym-default-rtw-rate-size \
ksym-default-rtw-read8-physical-efuse \
ksym-default-rtw-regd-get \
ksym-default-rtw-regd-srrc \
ksym-default-rtw-register-hw \
ksym-default-rtw-restore-reg \
ksym-default-rtw-rx-query-rx-desc \
ksym-default-rtw-rx-stats \
ksym-default-rtw-sdio-pm-ops \
ksym-default-rtw-sdio-probe \
ksym-default-rtw-sdio-remove \
ksym-default-rtw-sdio-shutdown \
ksym-default-rtw-set-channel-mac \
ksym-default-rtw-set-rx-freq-band \
ksym-default-rtw-set-trx-fifo-info \
ksym-default-rtw-tx-ac-to-hwq \
ksym-default-rtw-tx-fill-tx-desc \
ksym-default-rtw-tx-queue-mapping \
ksym-default-rtw-tx-report-enqueue \
ksym-default-rtw-tx-write-data-h2c-get \
ksym-default-rtw-tx-write-data-rsvd-page-get \
ksym-default-rtw-unregister-hw \
ksym-default-rtw-update-rx-freq-from-ie \
ksym-default-rtw-usb-disconnect \
ksym-default-rtw-usb-probe \
ksym-default-rtw-wait-firmware-completion \
ksym-default-rtw-write-firmware-page \
ksym-default-rtw8703b-hw-spec \
ksym-default-rtw8723d-hw-spec \
ksym-default-rtw8723x-common \
ksym-default-rtw8812a-hw-spec \
ksym-default-rtw8814a-hw-spec \
ksym-default-rtw8821a-hw-spec \
ksym-default-rtw8821c-hw-spec \
ksym-default-rtw8822b-hw-spec \
ksym-default-rtw8822c-hw-spec \
ksym-default-rtw8851b-chip-info \
ksym-default-rtw8852a-chip-info \
ksym-default-rtw8852b-chip-info \
ksym-default-rtw8852bt-chip-info \
ksym-default-rtw8852bx-info \
ksym-default-rtw8852c-chip-info \
ksym-default-rtw88xxa-efuse-grant \
ksym-default-rtw88xxa-false-alarm-statistics \
ksym-default-rtw88xxa-iqk-backup-afe \
ksym-default-rtw88xxa-iqk-backup-mac-bb \
ksym-default-rtw88xxa-iqk-configure-mac \
ksym-default-rtw88xxa-iqk-finish \
ksym-default-rtw88xxa-iqk-restore-mac-bb \
ksym-default-rtw88xxa-phy-cck-pd-set \
ksym-default-rtw88xxa-phy-pwrtrack \
ksym-default-rtw88xxa-phy-read-rf \
ksym-default-rtw88xxa-power-off \
ksym-default-rtw88xxa-power-on \
ksym-default-rtw88xxa-query-phy-status \
ksym-default-rtw88xxa-read-efuse \
ksym-default-rtw88xxa-set-channel \
ksym-default-rtw88xxa-set-tx-power-index \
ksym-default-rtw89-alloc-ieee80211-hw \
ksym-default-rtw89-bd-ram-table-dual \
ksym-default-rtw89-bd-ram-table-single \
ksym-default-rtw89-btc-ntfy-conn-rfk \
ksym-default-rtw89-btc-ntfy-preserve-bt-time \
ksym-default-rtw89-btc-ntfy-wl-rfk \
ksym-default-rtw89-btc-set-policy \
ksym-default-rtw89-btc-set-policy-v1 \
ksym-default-rtw89-check-quirks \
ksym-default-rtw89-chip-info-setup \
ksym-default-rtw89-core-deinit \
ksym-default-rtw89-core-fill-txdesc \
ksym-default-rtw89-core-fill-txdesc-fwcmd-v1 \
ksym-default-rtw89-core-fill-txdesc-fwcmd-v2 \
ksym-default-rtw89-core-fill-txdesc-v1 \
ksym-default-rtw89-core-fill-txdesc-v2 \
ksym-default-rtw89-core-fill-txdesc-v3 \
ksym-default-rtw89-core-get-ch-dma \
ksym-default-rtw89-core-get-ch-dma-v1 \
ksym-default-rtw89-core-get-ch-dma-v2 \
ksym-default-rtw89-core-init \
ksym-default-rtw89-core-napi-deinit \
ksym-default-rtw89-core-napi-init \
ksym-default-rtw89-core-napi-start \
ksym-default-rtw89-core-napi-stop \
ksym-default-rtw89-core-query-rxdesc \
ksym-default-rtw89-core-query-rxdesc-v2 \
ksym-default-rtw89-core-query-rxdesc-v3 \
ksym-default-rtw89-core-register \
ksym-default-rtw89-core-rx \
ksym-default-rtw89-core-unregister \
ksym-default-rtw89-db-quarter-to-linear \
ksym-default-rtw89-db-to-linear \
ksym-default-rtw89-decode-chan-idx \
ksym-default-rtw89-efuse-read-ecv-be \
ksym-default-rtw89-encode-chan-idx \
ksym-default-rtw89-entity-get-conf \
ksym-default-rtw89-free-ieee80211-hw \
ksym-default-rtw89-fw-blacklist-default \
ksym-default-rtw89-fw-h2c-ampdu-cmac-tbl-be \
ksym-default-rtw89-fw-h2c-ampdu-cmac-tbl-g7 \
ksym-default-rtw89-fw-h2c-assoc-cmac-tbl \
ksym-default-rtw89-fw-h2c-assoc-cmac-tbl-be \
ksym-default-rtw89-fw-h2c-assoc-cmac-tbl-g7 \
ksym-default-rtw89-fw-h2c-ba-cam \
ksym-default-rtw89-fw-h2c-ba-cam-v1 \
ksym-default-rtw89-fw-h2c-dctl-sec-cam-v1 \
ksym-default-rtw89-fw-h2c-dctl-sec-cam-v2 \
ksym-default-rtw89-fw-h2c-dctl-sec-cam-v3 \
ksym-default-rtw89-fw-h2c-default-cmac-tbl \
ksym-default-rtw89-fw-h2c-default-cmac-tbl-be \
ksym-default-rtw89-fw-h2c-default-cmac-tbl-g7 \
ksym-default-rtw89-fw-h2c-default-dmac-tbl-v2 \
ksym-default-rtw89-fw-h2c-default-dmac-tbl-v3 \
ksym-default-rtw89-fw-h2c-punctured-cmac-tbl-be \
ksym-default-rtw89-fw-h2c-punctured-cmac-tbl-g7 \
ksym-default-rtw89-fw-h2c-rf-ntfy-mcc \
ksym-default-rtw89-fw-h2c-rf-ps-info \
ksym-default-rtw89-fw-h2c-txtime-cmac-tbl \
ksym-default-rtw89-fw-h2c-txtime-cmac-tbl-be \
ksym-default-rtw89-fw-h2c-txtime-cmac-tbl-g7 \
ksym-default-rtw89-fw-h2c-update-beacon \
ksym-default-rtw89-fw-h2c-update-beacon-be \
ksym-default-rtw89-fw-h2c-wow-cam-update \
ksym-default-rtw89-fw-h2c-wow-cam-update-v1 \
ksym-default-rtw89-linear-to-db \
ksym-default-rtw89-linear-to-db-quarter \
ksym-default-rtw89-mac-cfg-ctrl-path \
ksym-default-rtw89-mac-cfg-ctrl-path-v1 \
ksym-default-rtw89-mac-cfg-ctrl-path-v2 \
ksym-default-rtw89-mac-cfg-gnt \
ksym-default-rtw89-mac-cfg-gnt-v1 \
ksym-default-rtw89-mac-cfg-gnt-v2 \
ksym-default-rtw89-mac-cfg-gnt-v3 \
ksym-default-rtw89-mac-cfg-phy-rpt-be \
ksym-default-rtw89-mac-coex-init \
ksym-default-rtw89-mac-coex-init-v1 \
ksym-default-rtw89-mac-disable-bb-rf \
ksym-default-rtw89-mac-enable-bb-rf \
ksym-default-rtw89-mac-gen-ax \
ksym-default-rtw89-mac-gen-be \
ksym-default-rtw89-mac-get-err-status \
ksym-default-rtw89-mac-resume-sch-tx \
ksym-default-rtw89-mac-resume-sch-tx-v1 \
ksym-default-rtw89-mac-resume-sch-tx-v2 \
ksym-default-rtw89-mac-set-err-status \
ksym-default-rtw89-mac-size \
ksym-default-rtw89-mac-stop-sch-tx \
ksym-default-rtw89-mac-stop-sch-tx-v1 \
ksym-default-rtw89-mac-stop-sch-tx-v2 \
ksym-default-rtw89-ops \
ksym-default-rtw89-pci-ch-dma-addr-set \
ksym-default-rtw89-pci-ch-dma-addr-set-be \
ksym-default-rtw89-pci-ch-dma-addr-set-be-v1 \
ksym-default-rtw89-pci-ch-dma-addr-set-v1 \
ksym-default-rtw89-pci-config-intr-mask \
ksym-default-rtw89-pci-config-intr-mask-v1 \
ksym-default-rtw89-pci-config-intr-mask-v2 \
ksym-default-rtw89-pci-config-intr-mask-v3 \
ksym-default-rtw89-pci-disable-intr \
ksym-default-rtw89-pci-disable-intr-v1 \
ksym-default-rtw89-pci-disable-intr-v2 \
ksym-default-rtw89-pci-disable-intr-v3 \
ksym-default-rtw89-pci-enable-intr \
ksym-default-rtw89-pci-enable-intr-v1 \
ksym-default-rtw89-pci-enable-intr-v2 \
ksym-default-rtw89-pci-enable-intr-v3 \
ksym-default-rtw89-pci-err-handler \
ksym-default-rtw89-pci-fill-txaddr-info \
ksym-default-rtw89-pci-fill-txaddr-info-v1 \
ksym-default-rtw89-pci-gen-ax \
ksym-default-rtw89-pci-gen-be \
ksym-default-rtw89-pci-isr-ax \
ksym-default-rtw89-pci-isr-be \
ksym-default-rtw89-pci-isr-be-v1 \
ksym-default-rtw89-pci-ltr-set \
ksym-default-rtw89-pci-ltr-set-v1 \
ksym-default-rtw89-pci-ltr-set-v2 \
ksym-default-rtw89-pci-parse-rpp \
ksym-default-rtw89-pci-parse-rpp-v1 \
ksym-default-rtw89-pci-probe \
ksym-default-rtw89-pci-recognize-intrs \
ksym-default-rtw89-pci-recognize-intrs-v1 \
ksym-default-rtw89-pci-recognize-intrs-v2 \
ksym-default-rtw89-pci-recognize-intrs-v3 \
ksym-default-rtw89-pci-remove \
ksym-default-rtw89-pci-shutdown \
ksym-default-rtw89-phy-ant-gain-pwr-offset \
ksym-default-rtw89-phy-bb-wrap-set-rfsi-bandedge-ch \
ksym-default-rtw89-phy-bb-wrap-set-rfsi-ct-opt \
ksym-default-rtw89-phy-config-rf-reg-v1 \
ksym-default-rtw89-phy-gen-ax \
ksym-default-rtw89-phy-gen-be \
ksym-default-rtw89-phy-gen-be-v1 \
ksym-default-rtw89-phy-get-kpath \
ksym-default-rtw89-phy-get-syn-sel \
ksym-default-rtw89-phy-get-txsb \
ksym-default-rtw89-phy-get-txsc \
ksym-default-rtw89-phy-load-txpwr-byrate \
ksym-default-rtw89-phy-read-rf \
ksym-default-rtw89-phy-read-rf-v1 \
ksym-default-rtw89-phy-read-rf-v2 \
ksym-default-rtw89-phy-read-rf-v3 \
ksym-default-rtw89-phy-read-txpwr-limit \
ksym-default-rtw89-phy-read32-idx \
ksym-default-rtw89-phy-rfk-cim3k-and-wait \
ksym-default-rtw89-phy-rfk-dack-and-wait \
ksym-default-rtw89-phy-rfk-dpk-and-wait \
ksym-default-rtw89-phy-rfk-iqk-and-wait \
ksym-default-rtw89-phy-rfk-pre-ntfy-and-wait \
ksym-default-rtw89-phy-rfk-rxdck-and-wait \
ksym-default-rtw89-phy-rfk-tssi-and-wait \
ksym-default-rtw89-phy-rfk-txgapk-and-wait \
ksym-default-rtw89-phy-rfk-txiqk-and-wait \
ksym-default-rtw89-phy-set-phy-regs \
ksym-default-rtw89-phy-tssi-ctrl-set-bandedge-cfg \
ksym-default-rtw89-phy-write-reg3-tbl \
ksym-default-rtw89-phy-write-rf \
ksym-default-rtw89-phy-write-rf-v1 \
ksym-default-rtw89-phy-write-rf-v2 \
ksym-default-rtw89-phy-write-rf-v3 \
ksym-default-rtw89-phy-write32-idx \
ksym-default-rtw89-phy-write32-idx-clr \
ksym-default-rtw89-phy-write32-idx-set \
ksym-default-rtw89-pm-ops \
ksym-default-rtw89-pm-ops-be \
ksym-default-rtw89-query-sar \
ksym-default-rtw89-read-efuse-ver \
ksym-default-rtw89-rfk-chan-lookup \
ksym-default-rtw89-rfk-parser \
ksym-default-rtw89-ser-notify \
ksym-default-rtw89-tas-chanctx-cb \
ksym-default-rtw89-usb-disconnect \
ksym-default-rtw89-usb-probe \
ksym-default-rtw8922a-chip-info \
ksym-default-rtw8922ae-vs-variant \
ksym-default-run-dax \
ksym-default-rvu-mbox-handler-npa-cn20k-aq-enq \
ksym-default-rw-verify-area \
ksym-default-rxgk-kernel-query-challenge \
ksym-default-rxgk-kernel-respond-to-challenge \
ksym-default-rxkad-kernel-respond-to-challenge \
ksym-default-rxrpc-debug-id \
ksym-default-rxrpc-get-null-key \
ksym-default-rxrpc-get-server-data-key \
ksym-default-rxrpc-kernel-abort-call \
ksym-default-rxrpc-kernel-begin-call \
ksym-default-rxrpc-kernel-charge-accept \
ksym-default-rxrpc-kernel-check-life \
ksym-default-rxrpc-kernel-dequeue-oob \
ksym-default-rxrpc-kernel-free-oob \
ksym-default-rxrpc-kernel-get-call-peer \
ksym-default-rxrpc-kernel-get-peer \
ksym-default-rxrpc-kernel-get-peer-data \
ksym-default-rxrpc-kernel-get-srtt \
ksym-default-rxrpc-kernel-lookup-peer \
ksym-default-rxrpc-kernel-put-call \
ksym-default-rxrpc-kernel-put-peer \
ksym-default-rxrpc-kernel-query-call-security \
ksym-default-rxrpc-kernel-query-challenge \
ksym-default-rxrpc-kernel-query-oob \
ksym-default-rxrpc-kernel-recv-data \
ksym-default-rxrpc-kernel-reject-challenge \
ksym-default-rxrpc-kernel-remote-addr \
ksym-default-rxrpc-kernel-remote-srx \
ksym-default-rxrpc-kernel-send-data \
ksym-default-rxrpc-kernel-set-notifications \
ksym-default-rxrpc-kernel-set-peer-data \
ksym-default-rxrpc-kernel-set-tx-length \
ksym-default-rxrpc-kernel-shutdown-call \
ksym-default-rxrpc-sock-set-manage-response \
ksym-default-rxrpc-sock-set-min-security-level \
ksym-default-rxrpc-sock-set-security-keyring \
ksym-default-rzg2l-cpg-dsi-div-set-divider \
ksym-default-rzt2h-icu-register-dma-req \
ksym-default-rzv2h-get-pll-divs-pars \
ksym-default-rzv2h-get-pll-pars \
ksym-default-rzv2h-icu-register-dma-ack \
ksym-default-rzv2h-icu-register-dma-req \
ksym-default-rzv2m-usb3drd-reset \
ksym-default-s2idle-wake \
ksym-default-s3fwrn5-phy-get-mode \
ksym-default-s3fwrn5-phy-power-ctrl \
ksym-default-s3fwrn5-phy-set-mode \
ksym-default-s3fwrn5-phy-set-wake \
ksym-default-s3fwrn5-probe \
ksym-default-s3fwrn5-recv-frame \
ksym-default-s3fwrn5-remove \
ksym-default-s5h1409-attach \
ksym-default-s5h1411-attach \
ksym-default-s5h1420-attach \
ksym-default-s5h1420-get-tuner-i2c-adapter \
ksym-default-s5h1432-attach \
ksym-default-s6e63m0-probe \
ksym-default-s6e63m0-remove \
ksym-default-s921-attach \
ksym-default-sa1100-rtc-init \
ksym-default-saa-dsp-writel \
ksym-default-saa7134-boards \
ksym-default-saa7134-devlist \
ksym-default-saa7134-devlist-lock \
ksym-default-saa7134-dmasound-exit \
ksym-default-saa7134-dmasound-init \
ksym-default-saa7134-enum-input \
ksym-default-saa7134-g-frequency \
ksym-default-saa7134-g-input \
ksym-default-saa7134-g-std \
ksym-default-saa7134-g-tuner \
ksym-default-saa7134-pgtable-alloc \
ksym-default-saa7134-pgtable-build \
ksym-default-saa7134-pgtable-free \
ksym-default-saa7134-querycap \
ksym-default-saa7134-querystd \
ksym-default-saa7134-s-frequency \
ksym-default-saa7134-s-input \
ksym-default-saa7134-s-std \
ksym-default-saa7134-s-tuner \
ksym-default-saa7134-set-dmabits \
ksym-default-saa7134-set-gpio \
ksym-default-saa7134-stop-streaming \
ksym-default-saa7134-ts-buffer-init \
ksym-default-saa7134-ts-buffer-prepare \
ksym-default-saa7134-ts-qops \
ksym-default-saa7134-ts-queue-setup \
ksym-default-saa7134-ts-register \
ksym-default-saa7134-ts-start-streaming \
ksym-default-saa7134-ts-stop-streaming \
ksym-default-saa7134-ts-unregister \
ksym-default-saa7134-tuner-callback \
ksym-default-saa7134-tvaudio-setmute \
ksym-default-saa7134-vb2-buffer-queue \
ksym-default-saa7146-debug \
ksym-default-saa7146-i2c-adapter-prepare \
ksym-default-saa7146-pgtable-alloc \
ksym-default-saa7146-pgtable-build-single \
ksym-default-saa7146-pgtable-free \
ksym-default-saa7146-register-device \
ksym-default-saa7146-register-extension \
ksym-default-saa7146-set-hps-source-and-sync \
ksym-default-saa7146-setgpio \
ksym-default-saa7146-unregister-device \
ksym-default-saa7146-unregister-extension \
ksym-default-saa7146-vfree-destroy-pgtable \
ksym-default-saa7146-vmalloc-build-pgtable \
ksym-default-saa7146-vv-init \
ksym-default-saa7146-vv-release \
ksym-default-saa7146-wait-for-debi-done \
ksym-default-safe-candev-priv \
ksym-default-sampling-rate-store \
ksym-default-samsung-asoc-dma-platform-register \
ksym-default-samsung-sdi-battery-get-info \
ksym-default-san-client-link \
ksym-default-san-dgpu-notifier-register \
ksym-default-san-dgpu-notifier-unregister \
ksym-default-sas-abort-task \
ksym-default-sas-abort-task-set \
ksym-default-sas-ata-device-link-abort \
ksym-default-sas-ata-ncq-prio-supported \
ksym-default-sas-ata-schedule-reset \
ksym-default-sas-ata-sdev-attr-group \
ksym-default-sas-attach-transport \
ksym-default-sas-bios-param \
ksym-default-sas-change-queue-depth \
ksym-default-sas-clear-task-set \
ksym-default-sas-disable-tlr \
ksym-default-sas-domain-attach-transport \
ksym-default-sas-drain-work \
ksym-default-sas-eh-abort-handler \
ksym-default-sas-eh-device-reset-handler \
ksym-default-sas-eh-target-reset-handler \
ksym-default-sas-eh-timed-out \
ksym-default-sas-enable-tlr \
ksym-default-sas-end-device-alloc \
ksym-default-sas-execute-ata-cmd \
ksym-default-sas-execute-internal-abort-dev \
ksym-default-sas-execute-internal-abort-single \
ksym-default-sas-expander-alloc \
ksym-default-sas-find-attached-phy-id \
ksym-default-sas-get-address \
ksym-default-sas-get-local-phy \
ksym-default-sas-ioctl \
ksym-default-sas-is-tlr-enabled \
ksym-default-sas-lu-reset \
ksym-default-sas-notify-phy-event \
ksym-default-sas-notify-port-event \
ksym-default-sas-phy-add \
ksym-default-sas-phy-alloc \
ksym-default-sas-phy-delete \
ksym-default-sas-phy-enable \
ksym-default-sas-phy-free \
ksym-default-sas-phy-reset \
ksym-default-sas-port-add \
ksym-default-sas-port-add-phy \
ksym-default-sas-port-alloc \
ksym-default-sas-port-alloc-num \
ksym-default-sas-port-delete \
ksym-default-sas-port-delete-phy \
ksym-default-sas-port-free \
ksym-default-sas-port-get-phy \
ksym-default-sas-port-mark-backlink \
ksym-default-sas-prep-resume-ha \
ksym-default-sas-query-task \
ksym-default-sas-queuecommand \
ksym-default-sas-read-port-mode-page \
ksym-default-sas-register-ha \
ksym-default-sas-release-transport \
ksym-default-sas-remove-children \
ksym-default-sas-remove-host \
ksym-default-sas-request-addr \
ksym-default-sas-resume-ha \
ksym-default-sas-rphy-add \
ksym-default-sas-rphy-delete \
ksym-default-sas-rphy-free \
ksym-default-sas-rphy-remove \
ksym-default-sas-rphy-unlink \
ksym-default-sas-sdev-configure \
ksym-default-sas-sdev-init \
ksym-default-sas-ssp-task-response \
ksym-default-sas-suspend-ha \
ksym-default-sas-target-alloc \
ksym-default-sas-target-destroy \
ksym-default-sas-task-abort \
ksym-default-sas-tlr-supported \
ksym-default-sas-unregister-ha \
ksym-default-sata-async-notification \
ksym-default-sata-deb-timing-hotplug \
ksym-default-sata-deb-timing-long \
ksym-default-sata-deb-timing-normal \
ksym-default-sata-link-debounce \
ksym-default-sata-link-hardreset \
ksym-default-sata-link-resume \
ksym-default-sata-link-scr-lpm \
ksym-default-sata-lpm-ignore-phy-events \
ksym-default-sata-pmp-error-handler \
ksym-default-sata-pmp-port-ops \
ksym-default-sata-pmp-qc-defer-cmd-switch \
ksym-default-sata-port-ops \
ksym-default-sata-scr-read \
ksym-default-sata-scr-valid \
ksym-default-sata-scr-write \
ksym-default-sata-scr-write-flush \
ksym-default-sata-set-spd \
ksym-default-sata-sff-hardreset \
ksym-default-sata-std-hardreset \
ksym-default-sb-init-dio-done-wq \
ksym-default-sb-min-blocksize \
ksym-default-sb-set-blocksize \
ksym-default-sb800-prefetch \
ksym-default-sbc-attrib-attrs \
ksym-default-sbc-dif-copy-prot \
ksym-default-sbc-dif-verify \
ksym-default-sbc-get-device-type \
ksym-default-sbc-get-write-same-sectors \
ksym-default-sbc-parse-cdb \
ksym-default-sbitmap-add-wait-queue \
ksym-default-sbitmap-any-bit-set \
ksym-default-sbitmap-bitmap-show \
ksym-default-sbitmap-del-wait-queue \
ksym-default-sbitmap-finish-wait \
ksym-default-sbitmap-get \
ksym-default-sbitmap-init-node \
ksym-default-sbitmap-prepare-to-wait \
ksym-default-sbitmap-queue-clear \
ksym-default-sbitmap-queue-get-shallow \
ksym-default-sbitmap-queue-init-node \
ksym-default-sbitmap-queue-min-shallow-depth \
ksym-default-sbitmap-queue-recalculate-wake-batch \
ksym-default-sbitmap-queue-resize \
ksym-default-sbitmap-queue-show \
ksym-default-sbitmap-queue-wake-all \
ksym-default-sbitmap-queue-wake-up \
ksym-default-sbitmap-resize \
ksym-default-sbitmap-show \
ksym-default-sbitmap-weight \
ksym-default-sc16is74x-devtype \
ksym-default-sc16is750-devtype \
ksym-default-sc16is752-devtype \
ksym-default-sc16is760-devtype \
ksym-default-sc16is762-devtype \
ksym-default-sc16is7xx-dt-ids \
ksym-default-sc16is7xx-probe \
ksym-default-sc16is7xx-regcfg \
ksym-default-sc16is7xx-regmap-name \
ksym-default-sc16is7xx-regmap-port-mask \
ksym-default-sc16is7xx-remove \
ksym-default-scatterwalk-ffwd \
ksym-default-scatterwalk-skip \
ksym-default-scd30-pm-ops \
ksym-default-scd30-probe \
ksym-default-sch-default-prio2band \
ksym-default-sch-frag-xmit-hook \
ksym-default-sch56xx-read-virtual-reg \
ksym-default-sch56xx-read-virtual-reg12 \
ksym-default-sch56xx-read-virtual-reg16 \
ksym-default-sch56xx-regmap-read16 \
ksym-default-sch56xx-regmap-write16 \
ksym-default-sch56xx-watchdog-register \
ksym-default-sch56xx-write-virtual-reg \
ksym-default-sched-clock \
ksym-default-sched-clock-register \
ksym-default-sched-numa-find-nth-cpu \
ksym-default-sched-numa-hop-mask \
ksym-default-sched-set-fifo \
ksym-default-sched-set-fifo-low \
ksym-default-sched-set-normal \
ksym-default-sched-setattr-nocheck \
ksym-default-sched-show-task \
ksym-default-sched-smt-present \
ksym-default-schedule \
ksym-default-schedule-cxl-memdev-detach \
ksym-default-schedule-hrtimeout \
ksym-default-schedule-hrtimeout-range \
ksym-default-schedule-hrtimeout-range-clock \
ksym-default-schedule-timeout \
ksym-default-schedule-timeout-idle \
ksym-default-schedule-timeout-interruptible \
ksym-default-schedule-timeout-killable \
ksym-default-schedule-timeout-uninterruptible \
ksym-default-sci-config-port \
ksym-default-sci-pm \
ksym-default-sci-port-disable \
ksym-default-sci-port-enable \
ksym-default-sci-release-port \
ksym-default-sci-request-port \
ksym-default-sci-scbrr-calc \
ksym-default-sci-shutdown \
ksym-default-sci-startup \
ksym-default-sci-verify-port \
ksym-default-scm-detach-fds \
ksym-default-scm-fp-dup \
ksym-default-scm-recv \
ksym-default-scmd-printk \
ksym-default-scmi-bus-type \
ksym-default-scmi-device-create \
ksym-default-scmi-device-destroy \
ksym-default-scmi-driver-register \
ksym-default-scmi-driver-unregister \
ksym-default-scmi-imx-cpu-reset-vector-set \
ksym-default-scmi-imx-cpu-start \
ksym-default-scmi-imx-cpu-started \
ksym-default-scmi-imx-lmm-info \
ksym-default-scmi-imx-lmm-operation \
ksym-default-scmi-imx-lmm-reset-vector-set \
ksym-default-scmi-imx-misc-ctrl-get \
ksym-default-scmi-imx-misc-ctrl-set \
ksym-default-scmi-protocol-register \
ksym-default-scmi-protocol-unregister \
ksym-default-scmi-requested-devices-nh \
ksym-default-scnprintf \
ksym-default-scp-get \
ksym-default-scp-get-device \
ksym-default-scp-get-rproc \
ksym-default-scp-get-vdec-hw-capa \
ksym-default-scp-get-venc-hw-capa \
ksym-default-scp-ipi-lock \
ksym-default-scp-ipi-register \
ksym-default-scp-ipi-send \
ksym-default-scp-ipi-unlock \
ksym-default-scp-ipi-unregister \
ksym-default-scp-mapping-dm-addr \
ksym-default-scp-memcpy-aligned \
ksym-default-scp-put \
ksym-default-screen-glyph \
ksym-default-screen-glyph-unicode \
ksym-default-screen-info-pci-dev \
ksym-default-screen-info-pixel-format \
ksym-default-screen-info-resources \
ksym-default-screen-pos \
ksym-default-scsi-add-device \
ksym-default-scsi-add-host-with-dma \
ksym-default-scsi-alloc-request \
ksym-default-scsi-alloc-sgtables \
ksym-default-scsi-autopm-get-device \
ksym-default-scsi-autopm-put-device \
ksym-default-scsi-bios-ptable \
ksym-default-scsi-block-requests \
ksym-default-scsi-block-targets \
ksym-default-scsi-block-when-processing-errors \
ksym-default-scsi-build-sense \
ksym-default-scsi-build-sense-buffer \
ksym-default-scsi-change-queue-depth \
ksym-default-scsi-check-sense \
ksym-default-scsi-cmd-allowed \
ksym-default-scsi-command-normalize-sense \
ksym-default-scsi-command-size-tbl \
ksym-default-scsi-dev-info-add-list \
ksym-default-scsi-dev-info-list-add-keyed \
ksym-default-scsi-dev-info-remove-list \
ksym-default-scsi-device-get \
ksym-default-scsi-device-lookup \
ksym-default-scsi-device-lookup-by-target \
ksym-default-scsi-device-put \
ksym-default-scsi-device-quiesce \
ksym-default-scsi-device-resume \
ksym-default-scsi-device-set-state \
ksym-default-scsi-device-type \
ksym-default-scsi-dh-activate \
ksym-default-scsi-dh-attach \
ksym-default-scsi-dh-attached-handler-name \
ksym-default-scsi-dh-set-params \
ksym-default-scsi-dma-map \
ksym-default-scsi-dma-unmap \
ksym-default-scsi-done \
ksym-default-scsi-done-direct \
ksym-default-scsi-eh-finish-cmd \
ksym-default-scsi-eh-flush-done-q \
ksym-default-scsi-eh-get-sense \
ksym-default-scsi-eh-prep-cmnd \
ksym-default-scsi-eh-ready-devs \
ksym-default-scsi-eh-restore-cmnd \
ksym-default-scsi-esp-cmd \
ksym-default-scsi-esp-intr \
ksym-default-scsi-esp-register \
ksym-default-scsi-esp-template \
ksym-default-scsi-esp-unregister \
ksym-default-scsi-execute-cmd \
ksym-default-scsi-extd-sense-format \
ksym-default-scsi-failures-reset-retries \
ksym-default-scsi-flush-work \
ksym-default-scsi-free-sgtables \
ksym-default-scsi-get-device-flags-keyed \
ksym-default-scsi-get-internal-cmd \
ksym-default-scsi-get-sense-info-fld \
ksym-default-scsi-get-vpd-page \
ksym-default-scsi-host-alloc \
ksym-default-scsi-host-block \
ksym-default-scsi-host-busy \
ksym-default-scsi-host-busy-iter \
ksym-default-scsi-host-complete-all-commands \
ksym-default-scsi-host-get \
ksym-default-scsi-host-lookup \
ksym-default-scsi-host-put \
ksym-default-scsi-host-unblock \
ksym-default-scsi-hostbyte-string \
ksym-default-scsi-init-limits \
ksym-default-scsi-internal-device-block-nowait \
ksym-default-scsi-internal-device-unblock-nowait \
ksym-default-scsi-ioctl \
ksym-default-scsi-ioctl-block-when-processing-errors \
ksym-default-scsi-is-fc-rport \
ksym-default-scsi-is-host-device \
ksym-default-scsi-is-sas-phy \
ksym-default-scsi-is-sas-port \
ksym-default-scsi-is-sas-rphy \
ksym-default-scsi-is-sdev-device \
ksym-default-scsi-is-target-device \
ksym-default-scsi-kmap-atomic-sg \
ksym-default-scsi-kunmap-atomic-sg \
ksym-default-scsi-logging-level \
ksym-default-scsi-mlreturn-string \
ksym-default-scsi-mode-select \
ksym-default-scsi-mode-sense \
ksym-default-scsi-nl-sock \
ksym-default-scsi-normalize-sense \
ksym-default-scsi-partsize \
ksym-default-scsi-pr-type-to-block \
ksym-default-scsi-print-command \
ksym-default-scsi-print-result \
ksym-default-scsi-print-sense \
ksym-default-scsi-print-sense-hdr \
ksym-default-scsi-put-internal-cmd \
ksym-default-scsi-queue-work \
ksym-default-scsi-register-device-handler \
ksym-default-scsi-register-interface \
ksym-default-scsi-remove-device \
ksym-default-scsi-remove-host \
ksym-default-scsi-remove-target \
ksym-default-scsi-report-bus-reset \
ksym-default-scsi-report-device-reset \
ksym-default-scsi-report-opcode \
ksym-default-scsi-rescan-device \
ksym-default-scsi-resume-device \
ksym-default-scsi-sanitize-inquiry-string \
ksym-default-scsi-scan-host \
ksym-default-scsi-scan-target \
ksym-default-scsi-schedule-eh \
ksym-default-scsi-sense-desc-find \
ksym-default-scsi-sense-key-string \
ksym-default-scsi-set-medium-removal \
ksym-default-scsi-set-sense-field-pointer \
ksym-default-scsi-set-sense-information \
ksym-default-scsi-target-quiesce \
ksym-default-scsi-target-resume \
ksym-default-scsi-target-unblock \
ksym-default-scsi-template-proc-dir \
ksym-default-scsi-test-unit-ready \
ksym-default-scsi-track-queue-full \
ksym-default-scsi-unblock-requests \
ksym-default-scsi-unregister-device-handler \
ksym-default-scsi-vpd-lun-id \
ksym-default-scsi-vpd-lun-serial \
ksym-default-scsi-vpd-tpg-id \
ksym-default-scsicam-bios-param \
ksym-default-scsilun-to-int \
ksym-default-sctp-for-each-endpoint \
ksym-default-sctp-get-sctp-info \
ksym-default-sctp-transport-lookup-process \
ksym-default-sctp-transport-traverse-process \
ksym-default-sdca-add-hid-device \
ksym-default-sdca-asoc-count-component \
ksym-default-sdca-asoc-free-constraints \
ksym-default-sdca-asoc-get-port \
ksym-default-sdca-asoc-hw-params \
ksym-default-sdca-asoc-pde-poll-actual-ps \
ksym-default-sdca-asoc-populate-component \
ksym-default-sdca-asoc-populate-controls \
ksym-default-sdca-asoc-populate-dais \
ksym-default-sdca-asoc-populate-dapm \
ksym-default-sdca-asoc-q78-get-volsw \
ksym-default-sdca-asoc-q78-put-volsw \
ksym-default-sdca-asoc-set-constraints \
ksym-default-sdca-control-find-range \
ksym-default-sdca-dev-register-functions \
ksym-default-sdca-dev-unregister-functions \
ksym-default-sdca-device-quirk-match \
ksym-default-sdca-fdl-alloc-state \
ksym-default-sdca-fdl-free-state \
ksym-default-sdca-fdl-process \
ksym-default-sdca-fdl-sync \
ksym-default-sdca-find-terminal-name \
ksym-default-sdca-hid-process-report \
ksym-default-sdca-id-find-cluster \
ksym-default-sdca-irq-cleanup \
ksym-default-sdca-irq-cleanup-late \
ksym-default-sdca-irq-data-populate \
ksym-default-sdca-irq-disable \
ksym-default-sdca-irq-enable \
ksym-default-sdca-irq-enable-early \
ksym-default-sdca-irq-free \
ksym-default-sdca-irq-populate \
ksym-default-sdca-irq-populate-early \
ksym-default-sdca-irq-request \
ksym-default-sdca-jack-alloc-state \
ksym-default-sdca-jack-free-state \
ksym-default-sdca-jack-init-state \
ksym-default-sdca-jack-process \
ksym-default-sdca-jack-report \
ksym-default-sdca-jack-set-jack \
ksym-default-sdca-lookup-functions \
ksym-default-sdca-lookup-interface-revision \
ksym-default-sdca-lookup-swft \
ksym-default-sdca-parse-function \
ksym-default-sdca-regmap-count-constants \
ksym-default-sdca-regmap-deferrable \
ksym-default-sdca-regmap-mbq-size \
ksym-default-sdca-regmap-populate-constants \
ksym-default-sdca-regmap-readable \
ksym-default-sdca-regmap-volatile \
ksym-default-sdca-regmap-write-defaults \
ksym-default-sdca-regmap-write-init \
ksym-default-sdca-regmap-writeable \
ksym-default-sdca-reset-function \
ksym-default-sdca-selector-find-control \
ksym-default-sdca-selector-find-range \
ksym-default-sdca-ump-cancel-timeout \
ksym-default-sdca-ump-get-owner-host \
ksym-default-sdca-ump-read-message \
ksym-default-sdca-ump-schedule-timeout \
ksym-default-sdca-ump-set-owner-device \
ksym-default-sdca-ump-write-message \
ksym-default-sdev-disable-disk-events \
ksym-default-sdev-enable-disk-events \
ksym-default-sdev-evt-alloc \
ksym-default-sdev-evt-send \
ksym-default-sdev-evt-send-simple \
ksym-default-sdev-prefix-printk \
ksym-default-sdhci-abort-tuning \
ksym-default-sdhci-add-host \
ksym-default-sdhci-adma-write-desc \
ksym-default-sdhci-alloc-host \
ksym-default-sdhci-calc-clk \
ksym-default-sdhci-cleanup-host \
ksym-default-sdhci-complete-work \
ksym-default-sdhci-cqe-disable \
ksym-default-sdhci-cqe-enable \
ksym-default-sdhci-cqe-irq \
ksym-default-sdhci-data-line-cmd \
ksym-default-sdhci-disable-irq-wakeups \
ksym-default-sdhci-do-reset \
ksym-default-sdhci-dumpregs \
ksym-default-sdhci-enable-clk \
ksym-default-sdhci-enable-irq-wakeups \
ksym-default-sdhci-enable-preset-value \
ksym-default-sdhci-enable-sdio-irq \
ksym-default-sdhci-enable-v4-mode \
ksym-default-sdhci-end-tuning \
ksym-default-sdhci-execute-tuning \
ksym-default-sdhci-finish-mrq \
ksym-default-sdhci-get-cd-nogpio \
ksym-default-sdhci-get-property \
ksym-default-sdhci-get-ro \
ksym-default-sdhci-get-vdd-value \
ksym-default-sdhci-initialize-data \
ksym-default-sdhci-mod-timer \
ksym-default-sdhci-needs-reset \
ksym-default-sdhci-pltfm-clk-get-max-clock \
ksym-default-sdhci-pltfm-init \
ksym-default-sdhci-pltfm-init-and-add-host \
ksym-default-sdhci-pltfm-pmops \
ksym-default-sdhci-pltfm-remove \
ksym-default-sdhci-pltfm-resume \
ksym-default-sdhci-pltfm-suspend \
ksym-default-sdhci-prepare-dma \
ksym-default-sdhci-present-error \
ksym-default-sdhci-remove-host \
ksym-default-sdhci-request \
ksym-default-sdhci-request-atomic \
ksym-default-sdhci-request-done-dma \
ksym-default-sdhci-reset \
ksym-default-sdhci-reset-tuning \
ksym-default-sdhci-resume-host \
ksym-default-sdhci-runtime-resume-host \
ksym-default-sdhci-runtime-suspend-host \
ksym-default-sdhci-send-tuning \
ksym-default-sdhci-set-bus-width \
ksym-default-sdhci-set-clock \
ksym-default-sdhci-set-data-timeout-irq \
ksym-default-sdhci-set-ios \
ksym-default-sdhci-set-ios-common \
ksym-default-sdhci-set-power \
ksym-default-sdhci-set-power-and-bus-voltage \
ksym-default-sdhci-set-power-noreg \
ksym-default-sdhci-set-uhs-signaling \
ksym-default-sdhci-setup-host \
ksym-default-sdhci-start-signal-voltage-switch \
ksym-default-sdhci-start-tuning \
ksym-default-sdhci-suspend-host \
ksym-default-sdhci-switch-external-dma \
ksym-default-sdhci-thread-irq \
ksym-default-sdhci-uhs2-add-host \
ksym-default-sdhci-uhs2-clear-set-irqs \
ksym-default-sdhci-uhs2-dump-regs \
ksym-default-sdhci-uhs2-irq \
ksym-default-sdhci-uhs2-remove-host \
ksym-default-sdhci-uhs2-reset \
ksym-default-sdhci-uhs2-set-power \
ksym-default-sdhci-uhs2-set-timeout \
ksym-default-sdio-align-size \
ksym-default-sdio-claim-host \
ksym-default-sdio-claim-irq \
ksym-default-sdio-disable-func \
ksym-default-sdio-enable-func \
ksym-default-sdio-f0-readb \
ksym-default-sdio-f0-writeb \
ksym-default-sdio-get-host-pm-caps \
ksym-default-sdio-memcpy-fromio \
ksym-default-sdio-memcpy-toio \
ksym-default-sdio-readb \
ksym-default-sdio-readl \
ksym-default-sdio-readsb \
ksym-default-sdio-readw \
ksym-default-sdio-release-host \
ksym-default-sdio-release-irq \
ksym-default-sdio-retune-crc-disable \
ksym-default-sdio-retune-crc-enable \
ksym-default-sdio-retune-hold-now \
ksym-default-sdio-retune-release \
ksym-default-sdio-set-block-size \
ksym-default-sdio-set-host-pm-flags \
ksym-default-sdio-signal-irq \
ksym-default-sdio-unregister-driver \
ksym-default-sdio-writeb \
ksym-default-sdio-writeb-readb \
ksym-default-sdio-writel \
ksym-default-sdio-writesb \
ksym-default-sdio-writew \
ksym-default-sdw-alloc-stream \
ksym-default-sdw-amd-exit \
ksym-default-sdw-amd-get-slave-info \
ksym-default-sdw-amd-probe \
ksym-default-sdw-bpt-send-async \
ksym-default-sdw-bpt-send-sync \
ksym-default-sdw-bpt-wait \
ksym-default-sdw-bread-no-pm-unlocked \
ksym-default-sdw-bus-clk-stop \
ksym-default-sdw-bus-exit-clk-stop \
ksym-default-sdw-bus-master-add \
ksym-default-sdw-bus-master-delete \
ksym-default-sdw-bus-prep-clk-stop \
ksym-default-sdw-bus-type \
ksym-default-sdw-bwrite-no-pm-unlocked \
ksym-default-sdw-clear-slave-status \
ksym-default-sdw-cols \
ksym-default-sdw-compare-devid \
ksym-default-sdw-compute-params \
ksym-default-sdw-compute-slave-ports \
ksym-default-sdw-deprepare-stream \
ksym-default-sdw-disable-stream \
ksym-default-sdw-enable-stream \
ksym-default-sdw-extract-slave-id \
ksym-default-sdw-find-col-index \
ksym-default-sdw-find-row-index \
ksym-default-sdw-handle-slave-status \
ksym-default-sdw-intel-acpi-scan \
ksym-default-sdw-master-read-prop \
ksym-default-sdw-nread \
ksym-default-sdw-nread-no-pm \
ksym-default-sdw-nwrite \
ksym-default-sdw-nwrite-no-pm \
ksym-default-sdw-prepare-stream \
ksym-default-sdw-read \
ksym-default-sdw-read-no-pm \
ksym-default-sdw-release-stream \
ksym-default-sdw-rows \
ksym-default-sdw-show-ping-status \
ksym-default-sdw-shutdown-stream \
ksym-default-sdw-slave-add \
ksym-default-sdw-slave-get-current-bank \
ksym-default-sdw-slave-get-scale-index \
ksym-default-sdw-slave-read-lane-mapping \
ksym-default-sdw-slave-read-prop \
ksym-default-sdw-slave-type \
ksym-default-sdw-startup-stream \
ksym-default-sdw-stream-add-master \
ksym-default-sdw-stream-add-slave \
ksym-default-sdw-stream-remove-master \
ksym-default-sdw-stream-remove-slave \
ksym-default-sdw-unregister-driver \
ksym-default-sdw-update \
ksym-default-sdw-update-no-pm \
ksym-default-sdw-write \
ksym-default-sdw-write-no-pm \
ksym-default-sec-pmic-pm-ops \
ksym-default-sec-pmic-probe \
ksym-default-sec-pmic-shutdown \
ksym-default-secpath-set \
ksym-default-sections-per-block \
ksym-default-secure-ipv4-port-ephemeral \
ksym-default-secure-ipv6-port-ephemeral \
ksym-default-secure-tcp-seq-and-ts-off \
ksym-default-secure-tcpv6-seq-and-ts-off \
ksym-default-security-bdev-alloc \
ksym-default-security-bdev-free \
ksym-default-security-bdev-setintegrity \
ksym-default-security-cred-getlsmprop \
ksym-default-security-cred-getsecid \
ksym-default-security-current-getlsmprop-subj \
ksym-default-security-d-instantiate \
ksym-default-security-dentry-create-files-as \
ksym-default-security-dentry-init-security \
ksym-default-security-file-ioctl \
ksym-default-security-file-ioctl-compat \
ksym-default-security-file-post-open \
ksym-default-security-free-mnt-opts \
ksym-default-security-ib-alloc-security \
ksym-default-security-ib-endport-manage-subnet \
ksym-default-security-ib-free-security \
ksym-default-security-ib-pkey-access \
ksym-default-security-inet-conn-established \
ksym-default-security-inet-conn-request \
ksym-default-security-inode-copy-up \
ksym-default-security-inode-copy-up-xattr \
ksym-default-security-inode-create \
ksym-default-security-inode-getsecctx \
ksym-default-security-inode-init-security \
ksym-default-security-inode-invalidate-secctx \
ksym-default-security-inode-listsecurity \
ksym-default-security-inode-mkdir \
ksym-default-security-inode-notifysecctx \
ksym-default-security-inode-setattr \
ksym-default-security-inode-setintegrity \
ksym-default-security-inode-setsecctx \
ksym-default-security-ismaclabel \
ksym-default-security-kernel-load-data \
ksym-default-security-kernel-post-load-data \
ksym-default-security-kernel-post-read-file \
ksym-default-security-kernel-read-file \
ksym-default-security-lock-kernel-down \
ksym-default-security-locked-down \
ksym-default-security-lsmprop-to-secctx \
ksym-default-security-mmap-backing-file \
ksym-default-security-path-mkdir \
ksym-default-security-path-mknod \
ksym-default-security-path-rename \
ksym-default-security-path-unlink \
ksym-default-security-release-secctx \
ksym-default-security-req-classify-flow \
ksym-default-security-sb-clone-mnt-opts \
ksym-default-security-sb-eat-lsm-opts \
ksym-default-security-sb-mnt-opts-compat \
ksym-default-security-sb-remount \
ksym-default-security-sb-set-mnt-opts \
ksym-default-security-sctp-assoc-established \
ksym-default-security-sctp-assoc-request \
ksym-default-security-sctp-bind-connect \
ksym-default-security-sctp-sk-clone \
ksym-default-security-secctx-to-secid \
ksym-default-security-secid-to-secctx \
ksym-default-security-secmark-refcount-dec \
ksym-default-security-secmark-refcount-inc \
ksym-default-security-secmark-relabel-packet \
ksym-default-security-sk-classify-flow \
ksym-default-security-sk-clone \
ksym-default-security-skb-classify-flow \
ksym-default-security-sock-graft \
ksym-default-security-sock-rcv-skb \
ksym-default-security-socket-getpeersec-dgram \
ksym-default-security-socket-socketpair \
ksym-default-security-task-getlsmprop-obj \
ksym-default-security-tun-dev-alloc-security \
ksym-default-security-tun-dev-attach \
ksym-default-security-tun-dev-attach-queue \
ksym-default-security-tun-dev-create \
ksym-default-security-tun-dev-free-security \
ksym-default-security-tun-dev-open \
ksym-default-security-unix-find \
ksym-default-security-unix-may-send \
ksym-default-security-unix-stream-connect \
ksym-default-security-xfrm-policy-alloc \
ksym-default-security-xfrm-policy-free \
ksym-default-security-xfrm-state-alloc \
ksym-default-security-xfrm-state-delete \
ksym-default-securityfs-create-dir \
ksym-default-securityfs-create-file \
ksym-default-securityfs-create-symlink \
ksym-default-securityfs-remove \
ksym-default-sed-ioctl \
ksym-default-seg6-do-srh-encap \
ksym-default-seg6-do-srh-inline \
ksym-default-seg6-hmac-compute \
ksym-default-seg6-hmac-info-add \
ksym-default-seg6-hmac-info-del \
ksym-default-seg6-hmac-info-lookup \
ksym-default-seg6-hmac-net-exit \
ksym-default-seg6-hmac-validate-skb \
ksym-default-seg6-push-hmac \
ksym-default-send-implementation-id \
ksym-default-send-sig \
ksym-default-send-sig-info \
ksym-default-send-sig-mceerr \
ksym-default-sensor-hub-device-close \
ksym-default-sensor-hub-device-open \
ksym-default-sensor-hub-get-feature \
ksym-default-sensor-hub-input-attr-get-raw-value \
ksym-default-sensor-hub-input-attr-read-values \
ksym-default-sensor-hub-input-get-attribute-info \
ksym-default-sensor-hub-register-callback \
ksym-default-sensor-hub-remove-callback \
ksym-default-sensor-hub-set-feature \
ksym-default-seq-bprintf \
ksym-default-seq-buf-do-printk \
ksym-default-seq-buf-printf \
ksym-default-seq-buf-putc \
ksym-default-seq-buf-putmem-hex \
ksym-default-seq-buf-puts \
ksym-default-seq-dentry \
ksym-default-seq-escape-mem \
ksym-default-seq-file-path \
ksym-default-seq-hex-dump \
ksym-default-seq-hlist-next \
ksym-default-seq-hlist-next-percpu \
ksym-default-seq-hlist-next-rcu \
ksym-default-seq-hlist-start \
ksym-default-seq-hlist-start-head \
ksym-default-seq-hlist-start-head-rcu \
ksym-default-seq-hlist-start-percpu \
ksym-default-seq-hlist-start-rcu \
ksym-default-seq-list-next \
ksym-default-seq-list-next-rcu \
ksym-default-seq-list-start \
ksym-default-seq-list-start-head \
ksym-default-seq-list-start-head-rcu \
ksym-default-seq-list-start-rcu \
ksym-default-seq-lseek \
ksym-default-seq-open \
ksym-default-seq-open-private \
ksym-default-seq-pad \
ksym-default-seq-path \
ksym-default-seq-printf \
ksym-default-seq-put-decimal-ll \
ksym-default-seq-put-decimal-ull \
ksym-default-seq-putc \
ksym-default-seq-read \
ksym-default-seq-read-iter \
ksym-default-seq-release \
ksym-default-seq-release-private \
ksym-default-seq-vprintf \
ksym-default-seq-write \
ksym-default-serdev-acpi-get-uart-resource \
ksym-default-serdev-controller-add \
ksym-default-serdev-controller-alloc \
ksym-default-serdev-controller-remove \
ksym-default-serdev-device-add \
ksym-default-serdev-device-alloc \
ksym-default-serdev-device-break-ctl \
ksym-default-serdev-device-close \
ksym-default-serdev-device-get-tiocm \
ksym-default-serdev-device-open \
ksym-default-serdev-device-remove \
ksym-default-serdev-device-set-baudrate \
ksym-default-serdev-device-set-flow-control \
ksym-default-serdev-device-set-parity \
ksym-default-serdev-device-set-tiocm \
ksym-default-serdev-device-wait-until-sent \
ksym-default-serdev-device-write \
ksym-default-serdev-device-write-buf \
ksym-default-serdev-device-write-flush \
ksym-default-serdev-device-write-wakeup \
ksym-default-serial-8250-warn-need-ioport \
ksym-default-serial8250-clear-and-reinit-fifos \
ksym-default-serial8250-clear-fifos \
ksym-default-serial8250-do-get-mctrl \
ksym-default-serial8250-do-pm \
ksym-default-serial8250-do-set-divisor \
ksym-default-serial8250-do-set-ldisc \
ksym-default-serial8250-do-set-mctrl \
ksym-default-serial8250-do-set-termios \
ksym-default-serial8250-do-shutdown \
ksym-default-serial8250-do-startup \
ksym-default-serial8250-em485-config \
ksym-default-serial8250-em485-destroy \
ksym-default-serial8250-em485-start-tx \
ksym-default-serial8250-em485-stop-tx \
ksym-default-serial8250-em485-supported \
ksym-default-serial8250-fifo-wait-for-lsr-thre \
ksym-default-serial8250-get-port \
ksym-default-serial8250-handle-irq \
ksym-default-serial8250-handle-irq-locked \
ksym-default-serial8250-init-port \
ksym-default-serial8250-modem-status \
ksym-default-serial8250-pci-setup-port \
ksym-default-serial8250-read-char \
ksym-default-serial8250-register-8250-port \
ksym-default-serial8250-release-dma \
ksym-default-serial8250-request-dma \
ksym-default-serial8250-resume-port \
ksym-default-serial8250-rpm-get \
ksym-default-serial8250-rpm-put \
ksym-default-serial8250-rx-chars \
ksym-default-serial8250-rx-dma-flush \
ksym-default-serial8250-set-defaults \
ksym-default-serial8250-set-isa-configurator \
ksym-default-serial8250-suspend-port \
ksym-default-serial8250-tx-chars \
ksym-default-serial8250-unregister-port \
ksym-default-serial8250-update-uartclk \
ksym-default-serio-bus \
ksym-default-serio-close \
ksym-default-serio-interrupt \
ksym-default-serio-open \
ksym-default-serio-reconnect \
ksym-default-serio-rescan \
ksym-default-serio-unregister-child-port \
ksym-default-serio-unregister-driver \
ksym-default-serio-unregister-port \
ksym-default-serpent-setkey \
ksym-default-servreg-get-domain-list-req-ei \
ksym-default-servreg-get-domain-list-resp-ei \
ksym-default-servreg-loc-pfr-req-ei \
ksym-default-servreg-loc-pfr-resp-ei \
ksym-default-servreg-register-listener-req-ei \
ksym-default-servreg-register-listener-resp-ei \
ksym-default-servreg-restart-pd-req-ei \
ksym-default-servreg-restart-pd-resp-ei \
ksym-default-servreg-set-ack-req-ei \
ksym-default-servreg-set-ack-resp-ei \
ksym-default-servreg-state-updated-ind-ei \
ksym-default-set-and-calc-slave-port-state \
ksym-default-set-anon-super \
ksym-default-set-anon-super-fc \
ksym-default-set-binfmt \
ksym-default-set-blocksize \
ksym-default-set-cached-acl \
ksym-default-set-capacity \
ksym-default-set-capacity-and-notify \
ksym-default-set-cpus-allowed-ptr \
ksym-default-set-create-files-as \
ksym-default-set-current-groups \
ksym-default-set-dax-nocache \
ksym-default-set-dax-nomc \
ksym-default-set-dax-synchronous \
ksym-default-set-default-d-op \
ksym-default-set-disk-ro \
ksym-default-set-exclusive-cxl-commands \
ksym-default-set-freezable \
ksym-default-set-groups \
ksym-default-set-memory-decrypted \
ksym-default-set-memory-encrypted \
ksym-default-set-movable-ops \
ksym-default-set-nlink \
ksym-default-set-normalized-timespec64 \
ksym-default-set-online-page-callback \
ksym-default-set-page-dirty \
ksym-default-set-page-dirty-lock \
ksym-default-set-page-writeback \
ksym-default-set-phv-bit \
ksym-default-set-posix-acl \
ksym-default-set-primary-fwnode \
ksym-default-set-secondary-fwnode \
ksym-default-set-security-override \
ksym-default-set-selection-kernel \
ksym-default-set-task-ioprio \
ksym-default-set-user-nice \
ksym-default-set-worker-desc \
ksym-default-setattr-copy \
ksym-default-setattr-prepare \
ksym-default-setattr-should-drop-sgid \
ksym-default-setattr-should-drop-suidgid \
ksym-default-setup-arg-pages \
ksym-default-setup-bdev-super \
ksym-default-setup-cn23xx-octeon-pf-device \
ksym-default-setup-fault-attr \
ksym-default-setup-max-cpus \
ksym-default-setup-new-exec \
ksym-default-setup-rx-oom-poll-fn \
ksym-default-setup-udp-tunnel-sock \
ksym-default-setup-ufile-idr-uobject \
ksym-default-sfp-add-phy \
ksym-default-sfp-bus-add-upstream \
ksym-default-sfp-bus-del-upstream \
ksym-default-sfp-bus-find-fwnode \
ksym-default-sfp-bus-put \
ksym-default-sfp-get-module-caps \
ksym-default-sfp-get-module-eeprom \
ksym-default-sfp-get-module-eeprom-by-page \
ksym-default-sfp-get-module-info \
ksym-default-sfp-get-name \
ksym-default-sfp-link-down \
ksym-default-sfp-link-up \
ksym-default-sfp-module-insert \
ksym-default-sfp-module-remove \
ksym-default-sfp-module-start \
ksym-default-sfp-module-stop \
ksym-default-sfp-register-socket \
ksym-default-sfp-remove-phy \
ksym-default-sfp-select-interface \
ksym-default-sfp-unregister-socket \
ksym-default-sfp-upstream-set-signal-rate \
ksym-default-sfp-upstream-start \
ksym-default-sfp-upstream-stop \
ksym-default-sg-alloc-append-table-from-pages \
ksym-default-sg-alloc-table \
ksym-default-sg-alloc-table-chained \
ksym-default-sg-alloc-table-from-pages-segment \
ksym-default-sg-copy-buffer \
ksym-default-sg-copy-from-buffer \
ksym-default-sg-copy-to-buffer \
ksym-default-sg-free-append-table \
ksym-default-sg-free-table \
ksym-default-sg-free-table-chained \
ksym-default-sg-init-one \
ksym-default-sg-init-table \
ksym-default-sg-last \
ksym-default-sg-miter-next \
ksym-default-sg-miter-skip \
ksym-default-sg-miter-start \
ksym-default-sg-miter-stop \
ksym-default-sg-nents \
ksym-default-sg-nents-for-dma \
ksym-default-sg-nents-for-len \
ksym-default-sg-pcopy-from-buffer \
ksym-default-sg-pcopy-to-buffer \
ksym-default-sg-split \
ksym-default-sg-zero-buffer \
ksym-default-sg2042-cfg-ops \
ksym-default-sg2042-pconf-ops \
ksym-default-sg2042-pctrl-ops \
ksym-default-sg2042-pmx-ops \
ksym-default-sget-dev \
ksym-default-sget-fc \
ksym-default-sgl-alloc \
ksym-default-sgl-alloc-order \
ksym-default-sgl-free \
ksym-default-sgl-free-n-order \
ksym-default-sgl-free-order \
ksym-default-sha1 \
ksym-default-sha1-final \
ksym-default-sha1-init \
ksym-default-sha1-update \
ksym-default-sha1-zero-message-hash \
ksym-default-sha224 \
ksym-default-sha224-final \
ksym-default-sha224-init \
ksym-default-sha224-zero-message-hash \
ksym-default-sha256 \
ksym-default-sha256-final \
ksym-default-sha256-finup-2x \
ksym-default-sha256-finup-2x-is-optimized \
ksym-default-sha256-init \
ksym-default-sha256-zero-message-hash \
ksym-default-sha3-224 \
ksym-default-sha3-256 \
ksym-default-sha3-384 \
ksym-default-sha3-512 \
ksym-default-sha3-final \
ksym-default-sha384 \
ksym-default-sha384-final \
ksym-default-sha384-init \
ksym-default-sha384-zero-message-hash \
ksym-default-sha512 \
ksym-default-sha512-final \
ksym-default-sha512-init \
ksym-default-sha512-zero-message-hash \
ksym-default-shake-folio \
ksym-default-shake-squeeze \
ksym-default-shake128 \
ksym-default-shake256 \
ksym-default-shash-ahash-digest \
ksym-default-shash-ahash-finup \
ksym-default-shash-ahash-update \
ksym-default-shash-free-singlespawn-instance \
ksym-default-shash-no-setkey \
ksym-default-shash-register-instance \
ksym-default-shmem-file-setup \
ksym-default-shmem-file-setup-with-mnt \
ksym-default-shmem-get-folio \
ksym-default-shmem-kernel-file-setup \
ksym-default-shmem-mapping \
ksym-default-shmem-read-folio-gfp \
ksym-default-shmem-read-mapping-page-gfp \
ksym-default-shmem-truncate-range \
ksym-default-shmem-writeout \
ksym-default-should-fail \
ksym-default-show-class-attr-string \
ksym-default-show-rcu-gp-kthreads \
ksym-default-show-rcu-tasks-classic-gp-kthread \
ksym-default-show-rcu-tasks-rude-gp-kthread \
ksym-default-shrink-dcache-parent \
ksym-default-shrink-dcache-sb \
ksym-default-shrink-dentry-list \
ksym-default-shrinker-alloc \
ksym-default-shrinker-free \
ksym-default-shrinker-register \
ksym-default-si-mem-available \
ksym-default-si-meminfo \
ksym-default-si21xx-attach \
ksym-default-si470x-ctrl-ops \
ksym-default-si470x-set-freq \
ksym-default-si470x-start \
ksym-default-si470x-stop \
ksym-default-si470x-viddev-template \
ksym-default-sig-register-instance \
ksym-default-sigmadsp-attach \
ksym-default-sigmadsp-reset \
ksym-default-sigmadsp-restrict-params \
ksym-default-sigmadsp-setup \
ksym-default-sigprocmask \
ksym-default-simple-attr-open \
ksym-default-simple-attr-read \
ksym-default-simple-attr-release \
ksym-default-simple-attr-write \
ksym-default-simple-attr-write-signed \
ksym-default-simple-dir-inode-operations \
ksym-default-simple-dir-operations \
ksym-default-simple-done-creating \
ksym-default-simple-empty \
ksym-default-simple-fill-super \
ksym-default-simple-fsync \
ksym-default-simple-fsync-noflush \
ksym-default-simple-get-link \
ksym-default-simple-getattr \
ksym-default-simple-inode-init-ts \
ksym-default-simple-link \
ksym-default-simple-lookup \
ksym-default-simple-map-init \
ksym-default-simple-open \
ksym-default-simple-pin-fs \
ksym-default-simple-read-from-buffer \
ksym-default-simple-recursive-removal \
ksym-default-simple-release-fs \
ksym-default-simple-remove-by-name \
ksym-default-simple-rename \
ksym-default-simple-rename-exchange \
ksym-default-simple-rename-timestamp \
ksym-default-simple-rmdir \
ksym-default-simple-setattr \
ksym-default-simple-start-creating \
ksym-default-simple-statfs \
ksym-default-simple-strtol \
ksym-default-simple-strtoll \
ksym-default-simple-strtoul \
ksym-default-simple-strtoull \
ksym-default-simple-symlink-inode-operations \
ksym-default-simple-transaction-get \
ksym-default-simple-transaction-read \
ksym-default-simple-transaction-release \
ksym-default-simple-transaction-set \
ksym-default-simple-tuner-attach \
ksym-default-simple-unlink \
ksym-default-simple-util-be-hw-params-fixup \
ksym-default-simple-util-canonicalize-cpu \
ksym-default-simple-util-canonicalize-platform \
ksym-default-simple-util-clean-reference \
ksym-default-simple-util-dai-init \
ksym-default-simple-util-get-sample-fmt \
ksym-default-simple-util-hw-params \
ksym-default-simple-util-init-aux-jacks \
ksym-default-simple-util-init-jack \
ksym-default-simple-util-init-priv \
ksym-default-simple-util-is-convert-required \
ksym-default-simple-util-parse-card-name \
ksym-default-simple-util-parse-clk \
ksym-default-simple-util-parse-convert \
ksym-default-simple-util-parse-daifmt \
ksym-default-simple-util-parse-pin-switches \
ksym-default-simple-util-parse-routing \
ksym-default-simple-util-parse-tdm-width-map \
ksym-default-simple-util-parse-widgets \
ksym-default-simple-util-remove \
ksym-default-simple-util-set-dailink-name \
ksym-default-simple-util-shutdown \
ksym-default-simple-util-startup \
ksym-default-simple-write-begin \
ksym-default-simple-write-to-buffer \
ksym-default-single-open \
ksym-default-single-open-size \
ksym-default-single-release \
ksym-default-single-task-running \
ksym-default-siphash-1u32 \
ksym-default-siphash-1u64 \
ksym-default-siphash-2u64 \
ksym-default-siphash-3u32 \
ksym-default-siphash-3u64 \
ksym-default-siphash-4u64 \
ksym-default-sis-info133-for-sata \
ksym-default-sized-strscpy \
ksym-default-sja1000-interrupt \
ksym-default-sk-alloc \
ksym-default-sk-attach-filter \
ksym-default-sk-busy-loop-end \
ksym-default-sk-capable \
ksym-default-sk-clear-memalloc \
ksym-default-sk-clone \
ksym-default-sk-common-release \
ksym-default-sk-detach-filter \
ksym-default-sk-dst-check \
ksym-default-sk-error-report \
ksym-default-sk-filter-trim-cap \
ksym-default-sk-free \
ksym-default-sk-ioctl \
ksym-default-sk-mc-loop \
ksym-default-sk-msg-alloc \
ksym-default-sk-msg-clone \
ksym-default-sk-msg-free \
ksym-default-sk-msg-free-nocharge \
ksym-default-sk-msg-free-partial \
ksym-default-sk-msg-is-readable \
ksym-default-sk-msg-memcopy-from-iter \
ksym-default-sk-msg-recvmsg \
ksym-default-sk-msg-return \
ksym-default-sk-msg-return-zero \
ksym-default-sk-msg-trim \
ksym-default-sk-msg-zerocopy-from-iter \
ksym-default-sk-net-capable \
ksym-default-sk-net-refcnt-upgrade \
ksym-default-sk-ns-capable \
ksym-default-sk-page-frag-refill \
ksym-default-sk-psock-drop \
ksym-default-sk-psock-init \
ksym-default-sk-psock-msg-verdict \
ksym-default-sk-reset-timer \
ksym-default-sk-send-sigurg \
ksym-default-sk-set-memalloc \
ksym-default-sk-set-peek-off \
ksym-default-sk-setup-caps \
ksym-default-sk-skb-reason-drop \
ksym-default-sk-stop-timer \
ksym-default-sk-stop-timer-sync \
ksym-default-sk-stream-error \
ksym-default-sk-stream-kill-queues \
ksym-default-sk-stream-wait-connect \
ksym-default-sk-stream-wait-memory \
ksym-default-sk-tx-queue-get \
ksym-default-sk-wait-data \
ksym-default-skb-abort-seq-read \
ksym-default-skb-append \
ksym-default-skb-append-pagefrags \
ksym-default-skb-checksum \
ksym-default-skb-checksum-help \
ksym-default-skb-checksum-setup \
ksym-default-skb-checksum-trimmed \
ksym-default-skb-clone \
ksym-default-skb-clone-sk \
ksym-default-skb-coalesce-rx-frag \
ksym-default-skb-complete-tx-timestamp \
ksym-default-skb-complete-wifi-ack \
ksym-default-skb-condense \
ksym-default-skb-copy \
ksym-default-skb-copy-and-crc32c-datagram-iter \
ksym-default-skb-copy-and-csum-bits \
ksym-default-skb-copy-and-csum-datagram-msg \
ksym-default-skb-copy-and-csum-dev \
ksym-default-skb-copy-bits \
ksym-default-skb-copy-datagram-from-iter \
ksym-default-skb-copy-datagram-from-iter-full \
ksym-default-skb-copy-datagram-iter \
ksym-default-skb-copy-expand \
ksym-default-skb-copy-header \
ksym-default-skb-copy-seq-read \
ksym-default-skb-copy-ubufs \
ksym-default-skb-cow-data \
ksym-default-skb-cow-data-for-xdp \
ksym-default-skb-crc32c \
ksym-default-skb-crc32c-csum-help \
ksym-default-skb-csum-hwoffload-help \
ksym-default-skb-dequeue \
ksym-default-skb-dequeue-tail \
ksym-default-skb-dump \
ksym-default-skb-ensure-writable \
ksym-default-skb-ensure-writable-head-tail \
ksym-default-skb-errqueue-purge \
ksym-default-skb-eth-gso-segment \
ksym-default-skb-eth-pop \
ksym-default-skb-eth-push \
ksym-default-skb-expand-head \
ksym-default-skb-ext-add \
ksym-default-skb-find-text \
ksym-default-skb-flow-dissect-ct \
ksym-default-skb-flow-dissect-hash \
ksym-default-skb-flow-dissect-meta \
ksym-default-skb-flow-dissect-tunnel-info \
ksym-default-skb-flow-dissector-init \
ksym-default-skb-flow-get-icmp-tci \
ksym-default-skb-flow-get-ports \
ksym-default-skb-free-datagram \
ksym-default-skb-get-hash-perturb \
ksym-default-skb-gso-validate-mac-len \
ksym-default-skb-gso-validate-network-len \
ksym-default-skb-headers-offset-update \
ksym-default-skb-kill-datagram \
ksym-default-skb-mac-gso-segment \
ksym-default-skb-morph \
ksym-default-skb-mpls-dec-ttl \
ksym-default-skb-mpls-pop \
ksym-default-skb-mpls-push \
ksym-default-skb-mpls-update-lse \
ksym-default-skb-orphan-partial \
ksym-default-skb-page-frag-refill \
ksym-default-skb-partial-csum-set \
ksym-default-skb-pp-cow-data \
ksym-default-skb-prepare-seq-read \
ksym-default-skb-pull \
ksym-default-skb-pull-data \
ksym-default-skb-pull-rcsum \
ksym-default-skb-push \
ksym-default-skb-put \
ksym-default-skb-queue-head \
ksym-default-skb-queue-purge-reason \
ksym-default-skb-queue-tail \
ksym-default-skb-realloc-headroom \
ksym-default-skb-recv-datagram \
ksym-default-skb-scrub-packet \
ksym-default-skb-segment \
ksym-default-skb-segment-list \
ksym-default-skb-send-sock-locked \
ksym-default-skb-send-sock-locked-with-flags \
ksym-default-skb-seq-read \
ksym-default-skb-set-owner-w \
ksym-default-skb-splice-bits \
ksym-default-skb-splice-from-iter \
ksym-default-skb-split \
ksym-default-skb-store-bits \
ksym-default-skb-to-sgvec \
ksym-default-skb-to-sgvec-nomark \
ksym-default-skb-trim \
ksym-default-skb-try-coalesce \
ksym-default-skb-tstamp-tx \
ksym-default-skb-tunnel-check-pmtu \
ksym-default-skb-tx-error \
ksym-default-skb-unlink \
ksym-default-skb-vlan-pop \
ksym-default-skb-vlan-push \
ksym-default-skb-vlan-untag \
ksym-default-skb-zerocopy \
ksym-default-skb-zerocopy-headlen \
ksym-default-skb-zerocopy-iter-stream \
ksym-default-skcipher-alloc-instance-simple \
ksym-default-skcipher-register-instance \
ksym-default-skcipher-walk-aead-decrypt \
ksym-default-skcipher-walk-aead-encrypt \
ksym-default-skcipher-walk-done \
ksym-default-skcipher-walk-virt \
ksym-default-skip-spaces \
ksym-default-sky1-base-pinctrl-probe \
ksym-default-sl811h-driver \
ksym-default-slab-build-skb \
ksym-default-slash-name \
ksym-default-slhc-compress \
ksym-default-slhc-free \
ksym-default-slhc-init \
ksym-default-slhc-remember \
ksym-default-slhc-toss \
ksym-default-slhc-uncompress \
ksym-default-slim-alloc-txn-tid \
ksym-default-slim-ctrl-clk-pause \
ksym-default-slim-device-report-present \
ksym-default-slim-do-transfer \
ksym-default-slim-driver-unregister \
ksym-default-slim-free-txn-tid \
ksym-default-slim-get-device \
ksym-default-slim-get-logical-addr \
ksym-default-slim-msg-response \
ksym-default-slim-read \
ksym-default-slim-readb \
ksym-default-slim-register-controller \
ksym-default-slim-report-absent \
ksym-default-slim-stream-allocate \
ksym-default-slim-stream-disable \
ksym-default-slim-stream-enable \
ksym-default-slim-stream-free \
ksym-default-slim-stream-prepare \
ksym-default-slim-stream-unprepare \
ksym-default-slim-unregister-controller \
ksym-default-slim-write \
ksym-default-slim-writeb \
ksym-default-slim-xfer-msg \
ksym-default-slimbus-bus \
ksym-default-sm-register-device \
ksym-default-sm3 \
ksym-default-sm3-final \
ksym-default-sm3-init \
ksym-default-sm3-update \
ksym-default-sm4-ce-cbc-enc \
ksym-default-sm4-ce-crypt-block \
ksym-default-sm4-ce-expand-key \
ksym-default-sm4-crypt-block \
ksym-default-sm4-expandkey \
ksym-default-smb-compression-compress-chained \
ksym-default-smb-compression-decompress \
ksym-default-smb-lz77-compress \
ksym-default-smb-lz77-decompress \
ksym-default-smc-proto \
ksym-default-smc-proto6 \
ksym-default-smp-ata-check-ready-type \
ksym-default-smp-call-function \
ksym-default-smp-call-function-any \
ksym-default-smp-call-function-many \
ksym-default-smp-call-function-single \
ksym-default-smp-call-function-single-async \
ksym-default-smp-call-on-cpu \
ksym-default-smpboot-register-percpu-thread \
ksym-default-smpboot-unregister-percpu-thread \
ksym-default-sms-board-event \
ksym-default-sms-board-led-feedback \
ksym-default-sms-board-lna-control \
ksym-default-sms-board-load-modules \
ksym-default-sms-board-power \
ksym-default-sms-board-setup \
ksym-default-sms-get-board \
ksym-default-smsc-phy-config-init \
ksym-default-smsc-phy-config-intr \
ksym-default-smsc-phy-get-tunable \
ksym-default-smsc-phy-handle-interrupt \
ksym-default-smsc-phy-probe \
ksym-default-smsc-phy-set-tunable \
ksym-default-smsclient-sendrequest \
ksym-default-smscore-get-board-id \
ksym-default-smscore-get-device-mode \
ksym-default-smscore-getbuffer \
ksym-default-smscore-onresponse \
ksym-default-smscore-putbuffer \
ksym-default-smscore-register-client \
ksym-default-smscore-register-device \
ksym-default-smscore-register-hotplug \
ksym-default-smscore-registry-getmode \
ksym-default-smscore-set-board-id \
ksym-default-smscore-start-device \
ksym-default-smscore-translate-msg \
ksym-default-smscore-unregister-client \
ksym-default-smscore-unregister-device \
ksym-default-smscore-unregister-hotplug \
ksym-default-smsendian-handle-message-header \
ksym-default-smsendian-handle-rx-message \
ksym-default-smsendian-handle-tx-message \
ksym-default-snd-ac97-bus \
ksym-default-snd-ac97-get-short-name \
ksym-default-snd-ac97-mixer \
ksym-default-snd-ac97-pcm-assign \
ksym-default-snd-ac97-pcm-close \
ksym-default-snd-ac97-pcm-double-rate-rules \
ksym-default-snd-ac97-pcm-open \
ksym-default-snd-ac97-read \
ksym-default-snd-ac97-reset \
ksym-default-snd-ac97-resume \
ksym-default-snd-ac97-set-rate \
ksym-default-snd-ac97-suspend \
ksym-default-snd-ac97-tune-hardware \
ksym-default-snd-ac97-update \
ksym-default-snd-ac97-update-bits \
ksym-default-snd-ac97-update-power \
ksym-default-snd-ac97-write \
ksym-default-snd-ac97-write-cache \
ksym-default-snd-ak4113-build \
ksym-default-snd-ak4113-check-rate-and-errors \
ksym-default-snd-ak4113-create \
ksym-default-snd-ak4113-external-rate \
ksym-default-snd-ak4113-reg-write \
ksym-default-snd-ak4113-reinit \
ksym-default-snd-ak4113-resume \
ksym-default-snd-ak4113-suspend \
ksym-default-snd-ak4114-build \
ksym-default-snd-ak4114-check-rate-and-errors \
ksym-default-snd-ak4114-create \
ksym-default-snd-ak4114-external-rate \
ksym-default-snd-ak4114-reg-write \
ksym-default-snd-ak4114-reinit \
ksym-default-snd-ak4114-resume \
ksym-default-snd-ak4114-suspend \
ksym-default-snd-akm4xxx-build-controls \
ksym-default-snd-akm4xxx-init \
ksym-default-snd-akm4xxx-reset \
ksym-default-snd-akm4xxx-write \
ksym-default-snd-amd-acp-find-config \
ksym-default-snd-array-free \
ksym-default-snd-array-new \
ksym-default-snd-card-add-dev-attr \
ksym-default-snd-card-disconnect \
ksym-default-snd-card-disconnect-sync \
ksym-default-snd-card-file-add \
ksym-default-snd-card-file-remove \
ksym-default-snd-card-free \
ksym-default-snd-card-free-on-error \
ksym-default-snd-card-free-when-closed \
ksym-default-snd-card-new \
ksym-default-snd-card-ref \
ksym-default-snd-card-register \
ksym-default-snd-card-rw-proc-new \
ksym-default-snd-card-set-id \
ksym-default-snd-component-add \
ksym-default-snd-compr-free-pages \
ksym-default-snd-compr-malloc-pages \
ksym-default-snd-compr-stop-error \
ksym-default-snd-compr-task-finished \
ksym-default-snd-compress-new \
ksym-default-snd-ctl-activate-id \
ksym-default-snd-ctl-add \
ksym-default-snd-ctl-add-followers \
ksym-default-snd-ctl-add-vmaster-hook \
ksym-default-snd-ctl-apply-vmaster-followers \
ksym-default-snd-ctl-boolean-mono-info \
ksym-default-snd-ctl-boolean-stereo-info \
ksym-default-snd-ctl-disconnect-layer \
ksym-default-snd-ctl-enum-info \
ksym-default-snd-ctl-find-id \
ksym-default-snd-ctl-find-numid \
ksym-default-snd-ctl-free-one \
ksym-default-snd-ctl-get-preferred-subdevice \
ksym-default-snd-ctl-make-virtual-master \
ksym-default-snd-ctl-new1 \
ksym-default-snd-ctl-notify \
ksym-default-snd-ctl-notify-one \
ksym-default-snd-ctl-register-ioctl \
ksym-default-snd-ctl-register-ioctl-compat \
ksym-default-snd-ctl-register-layer \
ksym-default-snd-ctl-remove \
ksym-default-snd-ctl-remove-id \
ksym-default-snd-ctl-rename \
ksym-default-snd-ctl-rename-id \
ksym-default-snd-ctl-replace \
ksym-default-snd-ctl-request-layer \
ksym-default-snd-ctl-sync-vmaster \
ksym-default-snd-ctl-unregister-ioctl \
ksym-default-snd-ctl-unregister-ioctl-compat \
ksym-default-snd-device-alloc \
ksym-default-snd-device-disconnect \
ksym-default-snd-device-free \
ksym-default-snd-device-new \
ksym-default-snd-device-register \
ksym-default-snd-devm-alloc-dir-pages \
ksym-default-snd-devm-card-new \
ksym-default-snd-dma-alloc-dir-pages \
ksym-default-snd-dma-alloc-pages-fallback \
ksym-default-snd-dma-buffer-mmap \
ksym-default-snd-dma-buffer-sync \
ksym-default-snd-dma-free-pages \
ksym-default-snd-dmaengine-pcm-close \
ksym-default-snd-dmaengine-pcm-close-release-chan \
ksym-default-snd-dmaengine-pcm-get-chan \
ksym-default-snd-dmaengine-pcm-open \
ksym-default-snd-dmaengine-pcm-pointer \
ksym-default-snd-dmaengine-pcm-pointer-no-residue \
ksym-default-snd-dmaengine-pcm-prepare-slave-config \
ksym-default-snd-dmaengine-pcm-refine-runtime-hwparams \
ksym-default-snd-dmaengine-pcm-register \
ksym-default-snd-dmaengine-pcm-request-channel \
ksym-default-snd-dmaengine-pcm-set-config-from-dai-data \
ksym-default-snd-dmaengine-pcm-sync-stop \
ksym-default-snd-dmaengine-pcm-trigger \
ksym-default-snd-dmaengine-pcm-unregister \
ksym-default-snd-ecards-limit \
ksym-default-snd-fasync-free \
ksym-default-snd-fasync-helper \
ksym-default-snd-fw-transaction \
ksym-default-snd-hda-activate-path \
ksym-default-snd-hda-add-imux-item \
ksym-default-snd-hda-add-new-ctls \
ksym-default-snd-hda-add-new-path \
ksym-default-snd-hda-add-verbs \
ksym-default-snd-hda-add-vmaster-hook \
ksym-default-snd-hda-apply-fixup \
ksym-default-snd-hda-apply-pincfgs \
ksym-default-snd-hda-apply-verbs \
ksym-default-snd-hda-attach-beep-device \
ksym-default-snd-hda-bus-type \
ksym-default-snd-hda-check-amp-caps \
ksym-default-snd-hda-check-amp-list-power \
ksym-default-snd-hda-codec-amp-init \
ksym-default-snd-hda-codec-amp-init-stereo \
ksym-default-snd-hda-codec-amp-stereo \
ksym-default-snd-hda-codec-amp-update \
ksym-default-snd-hda-codec-build-controls \
ksym-default-snd-hda-codec-cleanup \
ksym-default-snd-hda-codec-cleanup-for-unbind \
ksym-default-snd-hda-codec-configure \
ksym-default-snd-hda-codec-device-init \
ksym-default-snd-hda-codec-device-new \
ksym-default-snd-hda-codec-eapd-power-filter \
ksym-default-snd-hda-codec-get-pin-target \
ksym-default-snd-hda-codec-get-pincfg \
ksym-default-snd-hda-codec-load-dsp-cleanup \
ksym-default-snd-hda-codec-load-dsp-prepare \
ksym-default-snd-hda-codec-load-dsp-trigger \
ksym-default-snd-hda-codec-new \
ksym-default-snd-hda-codec-parse-pcms \
ksym-default-snd-hda-codec-pcm-new \
ksym-default-snd-hda-codec-prepare \
ksym-default-snd-hda-codec-register \
ksym-default-snd-hda-codec-set-gpio \
ksym-default-snd-hda-codec-set-name \
ksym-default-snd-hda-codec-set-pin-target \
ksym-default-snd-hda-codec-set-pincfg \
ksym-default-snd-hda-codec-set-power-save \
ksym-default-snd-hda-codec-set-power-to-all \
ksym-default-snd-hda-codec-setup-stream \
ksym-default-snd-hda-codec-unregister \
ksym-default-snd-hda-codec-update-widgets \
ksym-default-snd-hda-correct-pin-ctl \
ksym-default-snd-hda-create-dig-out-ctls \
ksym-default-snd-hda-create-spdif-in-ctls \
ksym-default-snd-hda-create-spdif-share-sw \
ksym-default-snd-hda-ctl-add \
ksym-default-snd-hda-detach-beep-device \
ksym-default-snd-hda-enable-beep-device \
ksym-default-snd-hda-enum-helper-info \
ksym-default-snd-hda-ext-driver-register \
ksym-default-snd-hda-ext-driver-unregister \
ksym-default-snd-hda-find-mixer-ctl \
ksym-default-snd-hda-gen-add-kctl \
ksym-default-snd-hda-gen-add-micmute-led-cdev \
ksym-default-snd-hda-gen-add-mute-led-cdev \
ksym-default-snd-hda-gen-build-controls \
ksym-default-snd-hda-gen-build-pcms \
ksym-default-snd-hda-gen-check-power-status \
ksym-default-snd-hda-gen-fix-pin-power \
ksym-default-snd-hda-gen-hp-automute \
ksym-default-snd-hda-gen-init \
ksym-default-snd-hda-gen-line-automute \
ksym-default-snd-hda-gen-mic-autoswitch \
ksym-default-snd-hda-gen-parse-auto-config \
ksym-default-snd-hda-gen-path-power-filter \
ksym-default-snd-hda-gen-remove \
ksym-default-snd-hda-gen-shutup-speakers \
ksym-default-snd-hda-gen-spec-init \
ksym-default-snd-hda-gen-stream-pm \
ksym-default-snd-hda-gen-update-outputs \
ksym-default-snd-hda-get-bool-hint \
ksym-default-snd-hda-get-conn-index \
ksym-default-snd-hda-get-conn-list \
ksym-default-snd-hda-get-connections \
ksym-default-snd-hda-get-default-vref \
ksym-default-snd-hda-get-dev-select \
ksym-default-snd-hda-get-hint \
ksym-default-snd-hda-get-input-pin-attr \
ksym-default-snd-hda-get-int-hint \
ksym-default-snd-hda-get-num-devices \
ksym-default-snd-hda-get-path-from-idx \
ksym-default-snd-hda-get-path-idx \
ksym-default-snd-hda-get-pin-label \
ksym-default-snd-hda-hdmi-acomp-init \
ksym-default-snd-hda-hdmi-acomp-master-bind \
ksym-default-snd-hda-hdmi-acomp-master-unbind \
ksym-default-snd-hda-hdmi-acomp-pin-eld-notify \
ksym-default-snd-hda-hdmi-check-presence-and-report \
ksym-default-snd-hda-hdmi-generic-alloc \
ksym-default-snd-hda-hdmi-generic-build-controls \
ksym-default-snd-hda-hdmi-generic-build-pcms \
ksym-default-snd-hda-hdmi-generic-init \
ksym-default-snd-hda-hdmi-generic-init-per-pins \
ksym-default-snd-hda-hdmi-generic-pcm-cleanup \
ksym-default-snd-hda-hdmi-generic-pcm-prepare \
ksym-default-snd-hda-hdmi-generic-probe \
ksym-default-snd-hda-hdmi-generic-remove \
ksym-default-snd-hda-hdmi-generic-resume \
ksym-default-snd-hda-hdmi-generic-spec-free \
ksym-default-snd-hda-hdmi-generic-suspend \
ksym-default-snd-hda-hdmi-generic-unsol-event \
ksym-default-snd-hda-hdmi-parse-codec \
ksym-default-snd-hda-hdmi-pin-id-to-pin-index \
ksym-default-snd-hda-hdmi-setup-audio-infoframe \
ksym-default-snd-hda-hdmi-setup-drm-audio-ops \
ksym-default-snd-hda-hdmi-setup-stream \
ksym-default-snd-hda-hdmi-simple-build-controls \
ksym-default-snd-hda-hdmi-simple-build-pcms \
ksym-default-snd-hda-hdmi-simple-init \
ksym-default-snd-hda-hdmi-simple-pcm-open \
ksym-default-snd-hda-hdmi-simple-probe \
ksym-default-snd-hda-hdmi-simple-remove \
ksym-default-snd-hda-hdmi-simple-unsol-event \
ksym-default-snd-hda-input-mux-info \
ksym-default-snd-hda-input-mux-put \
ksym-default-snd-hda-jack-add-kctl-mst \
ksym-default-snd-hda-jack-add-kctls \
ksym-default-snd-hda-jack-bind-keymap \
ksym-default-snd-hda-jack-detect-enable \
ksym-default-snd-hda-jack-detect-enable-callback-mst \
ksym-default-snd-hda-jack-detect-state-mst \
ksym-default-snd-hda-jack-pin-sense \
ksym-default-snd-hda-jack-poll-all \
ksym-default-snd-hda-jack-report-sync \
ksym-default-snd-hda-jack-set-button-state \
ksym-default-snd-hda-jack-set-dirty-all \
ksym-default-snd-hda-jack-set-gating-jack \
ksym-default-snd-hda-jack-tbl-get-from-tag \
ksym-default-snd-hda-jack-tbl-get-mst \
ksym-default-snd-hda-jack-unsol-event \
ksym-default-snd-hda-load-patch \
ksym-default-snd-hda-lock-devices \
ksym-default-snd-hda-mixer-amp-switch-get \
ksym-default-snd-hda-mixer-amp-switch-get-beep \
ksym-default-snd-hda-mixer-amp-switch-info \
ksym-default-snd-hda-mixer-amp-switch-put \
ksym-default-snd-hda-mixer-amp-switch-put-beep \
ksym-default-snd-hda-mixer-amp-tlv \
ksym-default-snd-hda-mixer-amp-volume-get \
ksym-default-snd-hda-mixer-amp-volume-info \
ksym-default-snd-hda-mixer-amp-volume-put \
ksym-default-snd-hda-multi-out-analog-cleanup \
ksym-default-snd-hda-multi-out-analog-open \
ksym-default-snd-hda-multi-out-analog-prepare \
ksym-default-snd-hda-multi-out-dig-cleanup \
ksym-default-snd-hda-multi-out-dig-close \
ksym-default-snd-hda-multi-out-dig-open \
ksym-default-snd-hda-multi-out-dig-prepare \
ksym-default-snd-hda-override-amp-caps \
ksym-default-snd-hda-override-conn-list \
ksym-default-snd-hda-parse-pin-defcfg \
ksym-default-snd-hda-pick-fixup \
ksym-default-snd-hda-pick-pin-fixup \
ksym-default-snd-hda-sequence-write \
ksym-default-snd-hda-set-dev-select \
ksym-default-snd-hda-set-power-save \
ksym-default-snd-hda-set-vmaster-tlv \
ksym-default-snd-hda-shutup-pins \
ksym-default-snd-hda-spdif-ctls-assign \
ksym-default-snd-hda-spdif-ctls-unassign \
ksym-default-snd-hda-spdif-out-of-nid \
ksym-default-snd-hda-sync-vmaster-hook \
ksym-default-snd-hda-unlock-devices \
ksym-default-snd-hdac-acomp-exit \
ksym-default-snd-hdac-acomp-get-eld \
ksym-default-snd-hdac-acomp-init \
ksym-default-snd-hdac-acomp-register-notifier \
ksym-default-snd-hdac-add-chmap-ctls \
ksym-default-snd-hdac-aligned-read \
ksym-default-snd-hdac-aligned-write \
ksym-default-snd-hdac-bus-alloc-stream-pages \
ksym-default-snd-hdac-bus-enter-link-reset \
ksym-default-snd-hdac-bus-exec-verb-unlocked \
ksym-default-snd-hdac-bus-exit \
ksym-default-snd-hdac-bus-exit-link-reset \
ksym-default-snd-hdac-bus-free-stream-pages \
ksym-default-snd-hdac-bus-get-response \
ksym-default-snd-hdac-bus-handle-stream-irq \
ksym-default-snd-hdac-bus-init \
ksym-default-snd-hdac-bus-init-chip \
ksym-default-snd-hdac-bus-init-cmd-io \
ksym-default-snd-hdac-bus-link-power \
ksym-default-snd-hdac-bus-parse-capabilities \
ksym-default-snd-hdac-bus-reset-link \
ksym-default-snd-hdac-bus-send-cmd \
ksym-default-snd-hdac-bus-stop-chip \
ksym-default-snd-hdac-bus-stop-cmd-io \
ksym-default-snd-hdac-bus-update-rirb \
ksym-default-snd-hdac-channel-allocation \
ksym-default-snd-hdac-check-power-state \
ksym-default-snd-hdac-chmap-to-spk-mask \
ksym-default-snd-hdac-codec-link-down \
ksym-default-snd-hdac-codec-link-up \
ksym-default-snd-hdac-codec-modalias \
ksym-default-snd-hdac-codec-read \
ksym-default-snd-hdac-codec-write \
ksym-default-snd-hdac-device-exit \
ksym-default-snd-hdac-device-init \
ksym-default-snd-hdac-device-register \
ksym-default-snd-hdac-device-set-chip-name \
ksym-default-snd-hdac-device-unregister \
ksym-default-snd-hdac-display-power \
ksym-default-snd-hdac-dsp-cleanup \
ksym-default-snd-hdac-dsp-prepare \
ksym-default-snd-hdac-dsp-trigger \
ksym-default-snd-hdac-ext-bus-device-remove \
ksym-default-snd-hdac-ext-bus-exit \
ksym-default-snd-hdac-ext-bus-get-hlink-by-addr \
ksym-default-snd-hdac-ext-bus-get-hlink-by-id \
ksym-default-snd-hdac-ext-bus-get-hlink-by-name \
ksym-default-snd-hdac-ext-bus-get-ml-capabilities \
ksym-default-snd-hdac-ext-bus-init \
ksym-default-snd-hdac-ext-bus-link-clear-stream-id \
ksym-default-snd-hdac-ext-bus-link-get \
ksym-default-snd-hdac-ext-bus-link-power \
ksym-default-snd-hdac-ext-bus-link-power-down \
ksym-default-snd-hdac-ext-bus-link-power-down-all \
ksym-default-snd-hdac-ext-bus-link-power-up \
ksym-default-snd-hdac-ext-bus-link-power-up-all \
ksym-default-snd-hdac-ext-bus-link-put \
ksym-default-snd-hdac-ext-bus-link-set-stream-id \
ksym-default-snd-hdac-ext-bus-ppcap-enable \
ksym-default-snd-hdac-ext-bus-ppcap-int-enable \
ksym-default-snd-hdac-ext-cstream-assign \
ksym-default-snd-hdac-ext-host-stream-setup \
ksym-default-snd-hdac-ext-link-free-all \
ksym-default-snd-hdac-ext-stream-assign \
ksym-default-snd-hdac-ext-stream-clear \
ksym-default-snd-hdac-ext-stream-decouple \
ksym-default-snd-hdac-ext-stream-decouple-locked \
ksym-default-snd-hdac-ext-stream-free-all \
ksym-default-snd-hdac-ext-stream-init-all \
ksym-default-snd-hdac-ext-stream-release \
ksym-default-snd-hdac-ext-stream-reset \
ksym-default-snd-hdac-ext-stream-setup \
ksym-default-snd-hdac-ext-stream-start \
ksym-default-snd-hdac-get-active-channels \
ksym-default-snd-hdac-get-ch-alloc-from-ca \
ksym-default-snd-hdac-get-connections \
ksym-default-snd-hdac-get-stream \
ksym-default-snd-hdac-get-stream-stripe-ctl \
ksym-default-snd-hdac-get-sub-nodes \
ksym-default-snd-hdac-i915-init \
ksym-default-snd-hdac-i915-set-bclk \
ksym-default-snd-hdac-is-supported-format \
ksym-default-snd-hdac-override-parm \
ksym-default-snd-hdac-power-down \
ksym-default-snd-hdac-power-down-pm \
ksym-default-snd-hdac-power-up \
ksym-default-snd-hdac-power-up-pm \
ksym-default-snd-hdac-print-channel-allocation \
ksym-default-snd-hdac-query-supported-pcm \
ksym-default-snd-hdac-read \
ksym-default-snd-hdac-read-parm-uncached \
ksym-default-snd-hdac-refresh-widgets \
ksym-default-snd-hdac-register-chmap-ops \
ksym-default-snd-hdac-regmap-add-vendor-verb \
ksym-default-snd-hdac-regmap-exit \
ksym-default-snd-hdac-regmap-init \
ksym-default-snd-hdac-regmap-read-raw \
ksym-default-snd-hdac-regmap-sync \
ksym-default-snd-hdac-regmap-update-raw \
ksym-default-snd-hdac-regmap-update-raw-once \
ksym-default-snd-hdac-regmap-write-raw \
ksym-default-snd-hdac-set-codec-wakeup \
ksym-default-snd-hdac-setup-channel-mapping \
ksym-default-snd-hdac-spdif-stream-format \
ksym-default-snd-hdac-spk-to-chmap \
ksym-default-snd-hdac-stop-streams \
ksym-default-snd-hdac-stop-streams-and-chip \
ksym-default-snd-hdac-stream-assign \
ksym-default-snd-hdac-stream-cleanup \
ksym-default-snd-hdac-stream-drsm-enable \
ksym-default-snd-hdac-stream-format \
ksym-default-snd-hdac-stream-format-bits \
ksym-default-snd-hdac-stream-init \
ksym-default-snd-hdac-stream-release \
ksym-default-snd-hdac-stream-release-locked \
ksym-default-snd-hdac-stream-reset \
ksym-default-snd-hdac-stream-set-dpibr \
ksym-default-snd-hdac-stream-set-lpib \
ksym-default-snd-hdac-stream-set-params \
ksym-default-snd-hdac-stream-set-spib \
ksym-default-snd-hdac-stream-setup \
ksym-default-snd-hdac-stream-setup-periods \
ksym-default-snd-hdac-stream-spbcap-enable \
ksym-default-snd-hdac-stream-start \
ksym-default-snd-hdac-stream-stop \
ksym-default-snd-hdac-stream-sync \
ksym-default-snd-hdac-stream-sync-trigger \
ksym-default-snd-hdac-stream-timecounter-init \
ksym-default-snd-hdac-stream-wait-drsm \
ksym-default-snd-hdac-sync-audio-rate \
ksym-default-snd-hdac-sync-power-state \
ksym-default-snd-hwdep-new \
ksym-default-snd-hwparams-to-dma-slave-config \
ksym-default-snd-i2c-bus-create \
ksym-default-snd-i2c-device-create \
ksym-default-snd-i2c-device-free \
ksym-default-snd-i2c-probeaddr \
ksym-default-snd-i2c-readbytes \
ksym-default-snd-i2c-sendbytes \
ksym-default-snd-ice1712-akm4xxx-build-controls \
ksym-default-snd-ice1712-akm4xxx-free \
ksym-default-snd-ice1712-akm4xxx-init \
ksym-default-snd-info-create-card-entry \
ksym-default-snd-info-create-module-entry \
ksym-default-snd-info-free-entry \
ksym-default-snd-info-get-line \
ksym-default-snd-info-get-str \
ksym-default-snd-info-register \
ksym-default-snd-intel-acpi-dsp-driver-probe \
ksym-default-snd-intel-dsp-driver-probe \
ksym-default-snd-interval-list \
ksym-default-snd-interval-ranges \
ksym-default-snd-interval-ratnum \
ksym-default-snd-interval-refine \
ksym-default-snd-jack-add-new-kctl \
ksym-default-snd-jack-new \
ksym-default-snd-jack-report \
ksym-default-snd-jack-set-key \
ksym-default-snd-kill-fasync \
ksym-default-snd-lookup-minor-data \
ksym-default-snd-lookup-oss-minor-data \
ksym-default-snd-major \
ksym-default-snd-midi-channel-alloc-set \
ksym-default-snd-midi-channel-free-set \
ksym-default-snd-midi-channel-set-clear \
ksym-default-snd-midi-event-decode \
ksym-default-snd-midi-event-encode-byte \
ksym-default-snd-midi-event-free \
ksym-default-snd-midi-event-new \
ksym-default-snd-midi-event-no-status \
ksym-default-snd-midi-event-reset-decode \
ksym-default-snd-midi-event-reset-encode \
ksym-default-snd-midi-process-event \
ksym-default-snd-mixer-oss-ioctl-card \
ksym-default-snd-mixer-oss-notify-callback \
ksym-default-snd-mpu401-uart-interrupt \
ksym-default-snd-mpu401-uart-interrupt-tx \
ksym-default-snd-mpu401-uart-new \
ksym-default-snd-opl3-create \
ksym-default-snd-opl3-find-patch \
ksym-default-snd-opl3-hwdep-new \
ksym-default-snd-opl3-init \
ksym-default-snd-opl3-interrupt \
ksym-default-snd-opl3-load-patch \
ksym-default-snd-opl3-new \
ksym-default-snd-opl3-regmap \
ksym-default-snd-opl3-reset \
ksym-default-snd-opl3-timer-new \
ksym-default-snd-oss-info-register \
ksym-default-snd-parse-eld \
ksym-default-snd-pci-quirk-lookup \
ksym-default-snd-pci-quirk-lookup-id \
ksym-default-snd-pcm-2-1-chmaps \
ksym-default-snd-pcm-add-chmap-ctls \
ksym-default-snd-pcm-alt-chmaps \
ksym-default-snd-pcm-create-iec958-consumer \
ksym-default-snd-pcm-create-iec958-consumer-default \
ksym-default-snd-pcm-create-iec958-consumer-hw-params \
ksym-default-snd-pcm-debug-name \
ksym-default-snd-pcm-fill-iec958-consumer \
ksym-default-snd-pcm-fill-iec958-consumer-hw-params \
ksym-default-snd-pcm-format-big-endian \
ksym-default-snd-pcm-format-linear \
ksym-default-snd-pcm-format-little-endian \
ksym-default-snd-pcm-format-name \
ksym-default-snd-pcm-format-physical-width \
ksym-default-snd-pcm-format-set-silence \
ksym-default-snd-pcm-format-signed \
ksym-default-snd-pcm-format-silence-64 \
ksym-default-snd-pcm-format-size \
ksym-default-snd-pcm-format-unsigned \
ksym-default-snd-pcm-format-width \
ksym-default-snd-pcm-get-state \
ksym-default-snd-pcm-hw-constraint-eld \
ksym-default-snd-pcm-hw-constraint-integer \
ksym-default-snd-pcm-hw-constraint-list \
ksym-default-snd-pcm-hw-constraint-mask64 \
ksym-default-snd-pcm-hw-constraint-minmax \
ksym-default-snd-pcm-hw-constraint-msbits \
ksym-default-snd-pcm-hw-constraint-pow2 \
ksym-default-snd-pcm-hw-constraint-ranges \
ksym-default-snd-pcm-hw-constraint-ratdens \
ksym-default-snd-pcm-hw-constraint-ratnums \
ksym-default-snd-pcm-hw-constraint-step \
ksym-default-snd-pcm-hw-limit-rates \
ksym-default-snd-pcm-hw-param-first \
ksym-default-snd-pcm-hw-param-last \
ksym-default-snd-pcm-hw-param-value \
ksym-default-snd-pcm-hw-params-bits \
ksym-default-snd-pcm-hw-refine \
ksym-default-snd-pcm-hw-rule-add \
ksym-default-snd-pcm-hw-rule-noresample \
ksym-default-snd-pcm-kernel-ioctl \
ksym-default-snd-pcm-lib-default-mmap \
ksym-default-snd-pcm-lib-free-pages \
ksym-default-snd-pcm-lib-ioctl \
ksym-default-snd-pcm-lib-malloc-pages \
ksym-default-snd-pcm-lib-preallocate-free-for-all \
ksym-default-snd-pcm-lib-preallocate-pages \
ksym-default-snd-pcm-lib-preallocate-pages-for-all \
ksym-default-snd-pcm-mmap-data \
ksym-default-snd-pcm-new \
ksym-default-snd-pcm-new-internal \
ksym-default-snd-pcm-new-stream \
ksym-default-snd-pcm-notify \
ksym-default-snd-pcm-open-substream \
ksym-default-snd-pcm-period-elapsed \
ksym-default-snd-pcm-period-elapsed-under-stream-lock \
ksym-default-snd-pcm-rate-bit-to-rate \
ksym-default-snd-pcm-rate-mask-intersect \
ksym-default-snd-pcm-rate-to-rate-bit \
ksym-default-snd-pcm-release-substream \
ksym-default-snd-pcm-runtime-buffer-set-silence \
ksym-default-snd-pcm-set-managed-buffer \
ksym-default-snd-pcm-set-managed-buffer-all \
ksym-default-snd-pcm-set-ops \
ksym-default-snd-pcm-set-state \
ksym-default-snd-pcm-set-sync-per-card \
ksym-default-snd-pcm-std-chmaps \
ksym-default-snd-pcm-stop \
ksym-default-snd-pcm-stop-xrun \
ksym-default-snd-pcm-stream-lock \
ksym-default-snd-pcm-stream-lock-irq \
ksym-default-snd-pcm-stream-unlock \
ksym-default-snd-pcm-stream-unlock-irq \
ksym-default-snd-pcm-stream-unlock-irqrestore \
ksym-default-snd-pcm-suspend-all \
ksym-default-snd-power-ref-and-wait \
ksym-default-snd-power-wait \
ksym-default-snd-print-eld-info \
ksym-default-snd-print-pcm-bits \
ksym-default-snd-pt2258-build-controls \
ksym-default-snd-pt2258-reset \
ksym-default-snd-rawmidi-drain-input \
ksym-default-snd-rawmidi-drain-output \
ksym-default-snd-rawmidi-drop-output \
ksym-default-snd-rawmidi-free \
ksym-default-snd-rawmidi-info-select \
ksym-default-snd-rawmidi-init \
ksym-default-snd-rawmidi-input-params \
ksym-default-snd-rawmidi-kernel-open \
ksym-default-snd-rawmidi-kernel-read \
ksym-default-snd-rawmidi-kernel-release \
ksym-default-snd-rawmidi-kernel-write \
ksym-default-snd-rawmidi-new \
ksym-default-snd-rawmidi-output-params \
ksym-default-snd-rawmidi-proceed \
ksym-default-snd-rawmidi-receive \
ksym-default-snd-rawmidi-set-ops \
ksym-default-snd-rawmidi-transmit \
ksym-default-snd-rawmidi-transmit-ack \
ksym-default-snd-rawmidi-transmit-empty \
ksym-default-snd-rawmidi-transmit-peek \
ksym-default-snd-refcount-init \
ksym-default-snd-refcount-put \
ksym-default-snd-refcount-sync \
ksym-default-snd-register-device \
ksym-default-snd-register-oss-device \
ksym-default-snd-request-card \
ksym-default-snd-seq-autoload-exit \
ksym-default-snd-seq-autoload-init \
ksym-default-snd-seq-create-kernel-client \
ksym-default-snd-seq-delete-kernel-client \
ksym-default-snd-seq-device-load-drivers \
ksym-default-snd-seq-device-new \
ksym-default-snd-seq-driver-unregister \
ksym-default-snd-seq-dump-var-event \
ksym-default-snd-seq-event-port-attach \
ksym-default-snd-seq-event-port-detach \
ksym-default-snd-seq-expand-var-event \
ksym-default-snd-seq-expand-var-event-at \
ksym-default-snd-seq-kernel-client-ctl \
ksym-default-snd-seq-kernel-client-dispatch \
ksym-default-snd-seq-kernel-client-enqueue \
ksym-default-snd-seq-kernel-client-get \
ksym-default-snd-seq-kernel-client-ioctl \
ksym-default-snd-seq-kernel-client-put \
ksym-default-snd-seq-kernel-client-write-poll \
ksym-default-snd-seq-root \
ksym-default-snd-seq-set-queue-tempo \
ksym-default-snd-seq-system-broadcast \
ksym-default-snd-sgbuf-get-addr \
ksym-default-snd-sgbuf-get-chunk-size \
ksym-default-snd-sgbuf-get-page \
ksym-default-snd-show-eld \
ksym-default-snd-soc-acpi-amd-acp63-sof-machines \
ksym-default-snd-soc-acpi-amd-acp70-sof-machines \
ksym-default-snd-soc-acpi-amd-rmb-sof-machines \
ksym-default-snd-soc-acpi-amd-sof-machines \
ksym-default-snd-soc-acpi-amd-vangogh-sof-machines \
ksym-default-snd-soc-acpi-codec-list \
ksym-default-snd-soc-acpi-find-machine \
ksym-default-snd-soc-acpi-find-package-from-hid \
ksym-default-snd-soc-acpi-sdw-link-slaves-found \
ksym-default-snd-soc-add-card-controls \
ksym-default-snd-soc-add-component \
ksym-default-snd-soc-add-component-controls \
ksym-default-snd-soc-add-dai-controls \
ksym-default-snd-soc-add-pcm-runtimes \
ksym-default-snd-soc-alloc-ac97-component \
ksym-default-snd-soc-bytes-get \
ksym-default-snd-soc-bytes-info \
ksym-default-snd-soc-bytes-info-ext \
ksym-default-snd-soc-bytes-put \
ksym-default-snd-soc-bytes-tlv-callback \
ksym-default-snd-soc-calc-bclk \
ksym-default-snd-soc-calc-frame-size \
ksym-default-snd-soc-card-add-dai-link \
ksym-default-snd-soc-card-get-kcontrol \
ksym-default-snd-soc-card-jack-new \
ksym-default-snd-soc-card-jack-new-pins \
ksym-default-snd-soc-card-remove-dai-link \
ksym-default-snd-soc-card-set-topology-name \
ksym-default-snd-soc-close-delayed-work \
ksym-default-snd-soc-cnew \
ksym-default-snd-soc-component-async-complete \
ksym-default-snd-soc-component-compr-ack \
ksym-default-snd-soc-component-compr-copy \
ksym-default-snd-soc-component-compr-free \
ksym-default-snd-soc-component-compr-get-caps \
ksym-default-snd-soc-component-compr-get-codec-caps \
ksym-default-snd-soc-component-compr-get-metadata \
ksym-default-snd-soc-component-compr-get-params \
ksym-default-snd-soc-component-compr-open \
ksym-default-snd-soc-component-compr-pointer \
ksym-default-snd-soc-component-compr-set-metadata \
ksym-default-snd-soc-component-compr-set-params \
ksym-default-snd-soc-component-compr-trigger \
ksym-default-snd-soc-component-exit-regmap \
ksym-default-snd-soc-component-get-jack-type \
ksym-default-snd-soc-component-get-kcontrol \
ksym-default-snd-soc-component-init-regmap \
ksym-default-snd-soc-component-initialize \
ksym-default-snd-soc-component-notify-control \
ksym-default-snd-soc-component-read \
ksym-default-snd-soc-component-read-field \
ksym-default-snd-soc-component-regmap-val-bytes \
ksym-default-snd-soc-component-set-jack \
ksym-default-snd-soc-component-set-pll \
ksym-default-snd-soc-component-set-sysclk \
ksym-default-snd-soc-component-test-bits \
ksym-default-snd-soc-component-update-bits \
ksym-default-snd-soc-component-update-bits-async \
ksym-default-snd-soc-component-write \
ksym-default-snd-soc-component-write-field \
ksym-default-snd-soc-copy-dai-args \
ksym-default-snd-soc-dai-action \
ksym-default-snd-soc-dai-active \
ksym-default-snd-soc-dai-compr-ack \
ksym-default-snd-soc-dai-compr-get-metadata \
ksym-default-snd-soc-dai-compr-get-params \
ksym-default-snd-soc-dai-compr-pointer \
ksym-default-snd-soc-dai-compr-set-metadata \
ksym-default-snd-soc-dai-compr-set-params \
ksym-default-snd-soc-dai-compr-shutdown \
ksym-default-snd-soc-dai-compr-startup \
ksym-default-snd-soc-dai-compr-trigger \
ksym-default-snd-soc-dai-digital-mute \
ksym-default-snd-soc-dai-get-channel-map \
ksym-default-snd-soc-dai-is-dummy \
ksym-default-snd-soc-dai-name-get \
ksym-default-snd-soc-dai-prepare \
ksym-default-snd-soc-dai-set-bclk-clk \
ksym-default-snd-soc-dai-set-bclk-ratio \
ksym-default-snd-soc-dai-set-channel-map \
ksym-default-snd-soc-dai-set-clkdiv \
ksym-default-snd-soc-dai-set-fmt \
ksym-default-snd-soc-dai-set-pll \
ksym-default-snd-soc-dai-set-sysclk \
ksym-default-snd-soc-dai-set-tdm-idle \
ksym-default-snd-soc-dai-set-tdm-slot \
ksym-default-snd-soc-dai-set-tristate \
ksym-default-snd-soc-daifmt-clock-provider-flipped \
ksym-default-snd-soc-daifmt-clock-provider-from-bitmap \
ksym-default-snd-soc-daifmt-parse-clock-provider-raw \
ksym-default-snd-soc-daifmt-parse-format \
ksym-default-snd-soc-dapm-add-routes \
ksym-default-snd-soc-dapm-clock-event \
ksym-default-snd-soc-dapm-dai-free-widgets \
ksym-default-snd-soc-dapm-dai-get-connected-widgets \
ksym-default-snd-soc-dapm-del-routes \
ksym-default-snd-soc-dapm-disable-pin \
ksym-default-snd-soc-dapm-disable-pin-unlocked \
ksym-default-snd-soc-dapm-enable-pin \
ksym-default-snd-soc-dapm-enable-pin-unlocked \
ksym-default-snd-soc-dapm-force-bias-level \
ksym-default-snd-soc-dapm-force-enable-pin \
ksym-default-snd-soc-dapm-force-enable-pin-unlocked \
ksym-default-snd-soc-dapm-free-widget \
ksym-default-snd-soc-dapm-get-bias-level \
ksym-default-snd-soc-dapm-get-component-pin-switch \
ksym-default-snd-soc-dapm-get-enum-double \
ksym-default-snd-soc-dapm-get-idle-bias \
ksym-default-snd-soc-dapm-get-pin-status \
ksym-default-snd-soc-dapm-get-pin-switch \
ksym-default-snd-soc-dapm-get-volsw \
ksym-default-snd-soc-dapm-ignore-suspend \
ksym-default-snd-soc-dapm-info-pin-switch \
ksym-default-snd-soc-dapm-init-bias-level \
ksym-default-snd-soc-dapm-kcontrol-get-value \
ksym-default-snd-soc-dapm-kcontrol-to-component \
ksym-default-snd-soc-dapm-kcontrol-to-dapm \
ksym-default-snd-soc-dapm-kcontrol-to-widget \
ksym-default-snd-soc-dapm-mixer-update-power \
ksym-default-snd-soc-dapm-mux-update-power \
ksym-default-snd-soc-dapm-new-control \
ksym-default-snd-soc-dapm-new-controls \
ksym-default-snd-soc-dapm-new-dai-widgets \
ksym-default-snd-soc-dapm-new-widgets \
ksym-default-snd-soc-dapm-pin-has-prefix \
ksym-default-snd-soc-dapm-pinctrl-event \
ksym-default-snd-soc-dapm-put-component-pin-switch \
ksym-default-snd-soc-dapm-put-enum-double \
ksym-default-snd-soc-dapm-put-pin-switch \
ksym-default-snd-soc-dapm-put-volsw \
ksym-default-snd-soc-dapm-regulator-event \
ksym-default-snd-soc-dapm-set-idle-bias \
ksym-default-snd-soc-dapm-stream-stop \
ksym-default-snd-soc-dapm-sync \
ksym-default-snd-soc-dapm-sync-unlocked \
ksym-default-snd-soc-dapm-to-card \
ksym-default-snd-soc-dapm-to-component \
ksym-default-snd-soc-dapm-to-dev \
ksym-default-snd-soc-dapm-widget-name-cmp \
ksym-default-snd-soc-debugfs-root \
ksym-default-snd-soc-dlc-is-dummy \
ksym-default-snd-soc-dlc-use-cpu-as-platform \
ksym-default-snd-soc-dpcm-get-substream \
ksym-default-snd-soc-dpcm-runtime-update \
ksym-default-snd-soc-dummy-dlc \
ksym-default-snd-soc-find-dai \
ksym-default-snd-soc-find-dai-with-mutex \
ksym-default-snd-soc-free-ac97-component \
ksym-default-snd-soc-get-dai-id \
ksym-default-snd-soc-get-dai-name \
ksym-default-snd-soc-get-dai-via-args \
ksym-default-snd-soc-get-dlc \
ksym-default-snd-soc-get-enum-double \
ksym-default-snd-soc-get-pcm-runtime \
ksym-default-snd-soc-get-stream-cpu \
ksym-default-snd-soc-get-strobe \
ksym-default-snd-soc-get-volsw \
ksym-default-snd-soc-get-volsw-sx \
ksym-default-snd-soc-get-xr-sx \
ksym-default-snd-soc-hda-codec-dai-ops \
ksym-default-snd-soc-info-enum-double \
ksym-default-snd-soc-info-volsw \
ksym-default-snd-soc-info-volsw-sx \
ksym-default-snd-soc-info-xr-sx \
ksym-default-snd-soc-jack-add-gpiods \
ksym-default-snd-soc-jack-add-gpios \
ksym-default-snd-soc-jack-add-pins \
ksym-default-snd-soc-jack-add-zones \
ksym-default-snd-soc-jack-free-gpios \
ksym-default-snd-soc-jack-get-type \
ksym-default-snd-soc-jack-notifier-register \
ksym-default-snd-soc-jack-notifier-unregister \
ksym-default-snd-soc-jack-report \
ksym-default-snd-soc-limit-volume \
ksym-default-snd-soc-link-compr-set-params \
ksym-default-snd-soc-link-compr-shutdown \
ksym-default-snd-soc-link-compr-startup \
ksym-default-snd-soc-lookup-component \
ksym-default-snd-soc-lookup-component-by-name \
ksym-default-snd-soc-lookup-component-nolocked \
ksym-default-snd-soc-new-ac97-component \
ksym-default-snd-soc-new-compress \
ksym-default-snd-soc-of-get-dai-link-codecs \
ksym-default-snd-soc-of-get-dai-link-cpus \
ksym-default-snd-soc-of-get-dai-name \
ksym-default-snd-soc-of-get-dlc \
ksym-default-snd-soc-of-get-slot-mask \
ksym-default-snd-soc-of-parse-audio-routing \
ksym-default-snd-soc-of-parse-audio-simple-widgets \
ksym-default-snd-soc-of-parse-aux-devs \
ksym-default-snd-soc-of-parse-card-name \
ksym-default-snd-soc-of-parse-ignore-suspend-widgets \
ksym-default-snd-soc-of-parse-node-prefix \
ksym-default-snd-soc-of-parse-pin-switches \
ksym-default-snd-soc-of-parse-tdm-slot \
ksym-default-snd-soc-of-put-dai-link-codecs \
ksym-default-snd-soc-of-put-dai-link-cpus \
ksym-default-snd-soc-params-to-bclk \
ksym-default-snd-soc-params-to-frame-size \
ksym-default-snd-soc-pm-ops \
ksym-default-snd-soc-poweroff \
ksym-default-snd-soc-put-enum-double \
ksym-default-snd-soc-put-strobe \
ksym-default-snd-soc-put-volsw \
ksym-default-snd-soc-put-volsw-sx \
ksym-default-snd-soc-put-xr-sx \
ksym-default-snd-soc-register-card \
ksym-default-snd-soc-register-component \
ksym-default-snd-soc-register-dai \
ksym-default-snd-soc-remove-pcm-runtime \
ksym-default-snd-soc-resume \
ksym-default-snd-soc-ret \
ksym-default-snd-soc-rtdcom-lookup \
ksym-default-snd-soc-runtime-action \
ksym-default-snd-soc-runtime-calc-hw \
ksym-default-snd-soc-runtime-set-dai-fmt \
ksym-default-snd-soc-set-ac97-ops \
ksym-default-snd-soc-set-ac97-ops-of-reset \
ksym-default-snd-soc-suspend \
ksym-default-snd-soc-tdm-params-to-bclk \
ksym-default-snd-soc-tplg-component-load \
ksym-default-snd-soc-tplg-component-remove \
ksym-default-snd-soc-tplg-widget-bind-event \
ksym-default-snd-soc-unregister-card \
ksym-default-snd-soc-unregister-component-by-driver \
ksym-default-snd-soc-unregister-dai \
ksym-default-snd-soc-usb-add-port \
ksym-default-snd-soc-usb-allocate-port \
ksym-default-snd-soc-usb-connect \
ksym-default-snd-soc-usb-disconnect \
ksym-default-snd-soc-usb-find-priv-data \
ksym-default-snd-soc-usb-find-supported-format \
ksym-default-snd-soc-usb-free-port \
ksym-default-snd-soc-usb-remove-port \
ksym-default-snd-soc-usb-setup-offload-jack \
ksym-default-snd-soc-usb-update-offload-route \
ksym-default-snd-sof-boot-dsp-firmware \
ksym-default-snd-sof-complete \
ksym-default-snd-sof-create-page-table \
ksym-default-snd-sof-dbg-init \
ksym-default-snd-sof-dbg-memory-info-init \
ksym-default-snd-sof-debugfs-add-region-item-iomem \
ksym-default-snd-sof-debugfs-buf-item \
ksym-default-snd-sof-device-probe \
ksym-default-snd-sof-device-probe-completed \
ksym-default-snd-sof-device-remove \
ksym-default-snd-sof-device-shutdown \
ksym-default-snd-sof-dsp-dbg-dump \
ksym-default-snd-sof-dsp-only-d0i3-compatible-stream-active \
ksym-default-snd-sof-dsp-panic \
ksym-default-snd-sof-dsp-update-bits \
ksym-default-snd-sof-dsp-update-bits-forced \
ksym-default-snd-sof-dsp-update-bits-unlocked \
ksym-default-snd-sof-dsp-update-bits64 \
ksym-default-snd-sof-dsp-update-bits64-unlocked \
ksym-default-snd-sof-free-debug \
ksym-default-snd-sof-fw-unload \
ksym-default-snd-sof-handle-fw-exception \
ksym-default-snd-sof-ipc-free \
ksym-default-snd-sof-ipc-get-reply \
ksym-default-snd-sof-ipc-init \
ksym-default-snd-sof-ipc-reply \
ksym-default-snd-sof-load-firmware-memcpy \
ksym-default-snd-sof-load-firmware-raw \
ksym-default-snd-sof-load-topology \
ksym-default-snd-sof-pci-update-bits \
ksym-default-snd-sof-pcm-period-elapsed \
ksym-default-snd-sof-prepare \
ksym-default-snd-sof-resume \
ksym-default-snd-sof-run-firmware \
ksym-default-snd-sof-runtime-idle \
ksym-default-snd-sof-runtime-resume \
ksym-default-snd-sof-runtime-suspend \
ksym-default-snd-sof-suspend \
ksym-default-snd-tea575x-enum-freq-bands \
ksym-default-snd-tea575x-exit \
ksym-default-snd-tea575x-g-tuner \
ksym-default-snd-tea575x-hw-init \
ksym-default-snd-tea575x-init \
ksym-default-snd-tea575x-s-hw-freq-seek \
ksym-default-snd-tea575x-set-freq \
ksym-default-snd-timer-close \
ksym-default-snd-timer-continue \
ksym-default-snd-timer-global-free \
ksym-default-snd-timer-global-new \
ksym-default-snd-timer-global-register \
ksym-default-snd-timer-instance-free \
ksym-default-snd-timer-instance-new \
ksym-default-snd-timer-interrupt \
ksym-default-snd-timer-new \
ksym-default-snd-timer-notify \
ksym-default-snd-timer-open \
ksym-default-snd-timer-pause \
ksym-default-snd-timer-resolution \
ksym-default-snd-timer-start \
ksym-default-snd-timer-stop \
ksym-default-snd-timeri-timer-get \
ksym-default-snd-timeri-timer-put \
ksym-default-snd-ump-attach-legacy-rawmidi \
ksym-default-snd-ump-block-new \
ksym-default-snd-ump-convert-from-ump \
ksym-default-snd-ump-convert-to-ump \
ksym-default-snd-ump-endpoint-new \
ksym-default-snd-ump-parse-endpoint \
ksym-default-snd-ump-receive \
ksym-default-snd-ump-receive-ump-val \
ksym-default-snd-ump-switch-protocol \
ksym-default-snd-ump-transmit \
ksym-default-snd-ump-update-group-attrs \
ksym-default-snd-unregister-device \
ksym-default-snd-unregister-oss-device \
ksym-default-snd-usb-autoresume \
ksym-default-snd-usb-autosuspend \
ksym-default-snd-usb-endpoint-prepare \
ksym-default-snd-usb-find-csint-desc \
ksym-default-snd-usb-find-format \
ksym-default-snd-usb-find-substream-format \
ksym-default-snd-usb-find-suppported-substream \
ksym-default-snd-usb-hw-free \
ksym-default-snd-usb-hw-params \
ksym-default-snd-usb-lock-shutdown \
ksym-default-snd-usb-rediscover-devices \
ksym-default-snd-usb-register-platform-ops \
ksym-default-snd-usb-unlock-shutdown \
ksym-default-snd-usb-unregister-platform-ops \
ksym-default-snd-usbmidi-disconnect \
ksym-default-snd-usbmidi-input-start \
ksym-default-snd-usbmidi-input-stop \
ksym-default-snd-usbmidi-resume \
ksym-default-snd-usbmidi-suspend \
ksym-default-snd-use-lock-sync-helper \
ksym-default-snd-virmidi-new \
ksym-default-snd-vx-check-reg-bit \
ksym-default-snd-vx-create \
ksym-default-snd-vx-dsp-boot \
ksym-default-snd-vx-dsp-load \
ksym-default-snd-vx-free-firmware \
ksym-default-snd-vx-irq-handler \
ksym-default-snd-vx-load-boot-image \
ksym-default-snd-vx-resume \
ksym-default-snd-vx-setup-firmware \
ksym-default-snd-vx-suspend \
ksym-default-snd-vx-threaded-irq-handler \
ksym-default-snprintf \
ksym-default-soc-ac97-ops \
ksym-default-soc-attr-read-machine \
ksym-default-soc-codec-dev-max98373 \
ksym-default-soc-codec-dev-max98373-sdw \
ksym-default-soc-device-match \
ksym-default-soc-device-register \
ksym-default-soc-device-unregister \
ksym-default-soc-hda-ext-bus-ops \
ksym-default-sock-alloc \
ksym-default-sock-alloc-file \
ksym-default-sock-alloc-send-pskb \
ksym-default-sock-bind-add \
ksym-default-sock-bindtoindex \
ksym-default-sock-cmsg-send \
ksym-default-sock-common-getsockopt \
ksym-default-sock-common-recvmsg \
ksym-default-sock-common-setsockopt \
ksym-default-sock-copy-user-timeval \
ksym-default-sock-create \
ksym-default-sock-create-kern \
ksym-default-sock-create-lite \
ksym-default-sock-dequeue-err-skb \
ksym-default-sock-diag-check-cookie \
ksym-default-sock-diag-destroy \
ksym-default-sock-diag-put-filterinfo \
ksym-default-sock-diag-put-meminfo \
ksym-default-sock-diag-register \
ksym-default-sock-diag-register-inet-compat \
ksym-default-sock-diag-save-cookie \
ksym-default-sock-diag-unregister \
ksym-default-sock-diag-unregister-inet-compat \
ksym-default-sock-edemux \
ksym-default-sock-efree \
ksym-default-sock-from-file \
ksym-default-sock-gen-put \
ksym-default-sock-get-timeout \
ksym-default-sock-gettstamp \
ksym-default-sock-init-data \
ksym-default-sock-init-data-uid \
ksym-default-sock-inuse-get \
ksym-default-sock-ioctl-inout \
ksym-default-sock-kfree-s \
ksym-default-sock-kmalloc \
ksym-default-sock-kmemdup \
ksym-default-sock-kzfree-s \
ksym-default-sock-load-diag-module \
ksym-default-sock-map-close \
ksym-default-sock-map-destroy \
ksym-default-sock-map-unhash \
ksym-default-sock-no-accept \
ksym-default-sock-no-bind \
ksym-default-sock-no-connect \
ksym-default-sock-no-getname \
ksym-default-sock-no-ioctl \
ksym-default-sock-no-linger \
ksym-default-sock-no-listen \
ksym-default-sock-no-mmap \
ksym-default-sock-no-recvmsg \
ksym-default-sock-no-sendmsg \
ksym-default-sock-no-sendmsg-locked \
ksym-default-sock-no-shutdown \
ksym-default-sock-no-socketpair \
ksym-default-sock-pfree \
ksym-default-sock-prot-inuse-get \
ksym-default-sock-queue-err-skb \
ksym-default-sock-queue-rcv-skb-reason \
ksym-default-sock-recv-errqueue \
ksym-default-sock-recvmsg \
ksym-default-sock-register \
ksym-default-sock-release \
ksym-default-sock-rfree \
ksym-default-sock-sendmsg \
ksym-default-sock-set-keepalive \
ksym-default-sock-set-mark \
ksym-default-sock-set-priority \
ksym-default-sock-set-rcvbuf \
ksym-default-sock-set-reuseaddr \
ksym-default-sock-set-reuseport \
ksym-default-sock-set-sndtimeo \
ksym-default-sock-setsockopt \
ksym-default-sock-unregister \
ksym-default-sock-wake-async \
ksym-default-sock-wfree \
ksym-default-sock-wmalloc \
ksym-default-sockaddr-to-str \
ksym-default-sockfd-lookup \
ksym-default-sockopt-capable \
ksym-default-sockopt-lock-sock \
ksym-default-sockopt-ns-capable \
ksym-default-sockopt-release-sock \
ksym-default-sof-block-read \
ksym-default-sof-block-write \
ksym-default-sof-compressed-ops \
ksym-default-sof-create-ipc-file-profile \
ksym-default-sof-dai-get-bclk \
ksym-default-sof-dai-get-mclk \
ksym-default-sof-dai-get-tdm-slots \
ksym-default-sof-debug-check-flag \
ksym-default-sof-imx-ops \
ksym-default-sof-io-read \
ksym-default-sof-io-read64 \
ksym-default-sof-io-write \
ksym-default-sof-io-write64 \
ksym-default-sof-ipc-msg-data \
ksym-default-sof-ipc-set-get-data \
ksym-default-sof-ipc-tx-message \
ksym-default-sof-ipc-tx-message-no-pm \
ksym-default-sof-ipc3-do-rx-work \
ksym-default-sof-machine-register \
ksym-default-sof-machine-unregister \
ksym-default-sof-mailbox-read \
ksym-default-sof-mailbox-write \
ksym-default-sof-of-pm \
ksym-default-sof-of-probe \
ksym-default-sof-of-remove \
ksym-default-sof-of-shutdown \
ksym-default-sof-pcm-dai-link-fixup \
ksym-default-sof-print-oops-and-stack \
ksym-default-sof-set-fw-state \
ksym-default-sof-set-stream-data-offset \
ksym-default-sof-stream-pcm-close \
ksym-default-sof-stream-pcm-open \
ksym-default-sof-widget-free \
ksym-default-sof-widget-setup \
ksym-default-sof-xtensa-arch-ops \
ksym-default-softnet-data \
ksym-default-software-node-find-by-name \
ksym-default-software-node-fwnode \
ksym-default-software-node-register \
ksym-default-software-node-register-node-group \
ksym-default-software-node-unregister \
ksym-default-software-node-unregister-node-group \
ksym-default-sonet-copy-stats \
ksym-default-sonet-subtract-stats \
ksym-default-sophgo-pinctrl-probe \
ksym-default-sort \
ksym-default-sort-nonatomic \
ksym-default-sort-r \
ksym-default-sort-r-nonatomic \
ksym-default-sound-class \
ksym-default-sound-debugfs-root \
ksym-default-sp8870-attach \
ksym-default-sp887x-attach \
ksym-default-sparse-keymap-entry-from-keycode \
ksym-default-sparse-keymap-entry-from-scancode \
ksym-default-sparse-keymap-report-entry \
ksym-default-sparse-keymap-report-event \
ksym-default-sparse-keymap-setup \
ksym-default-spc-emulate-evpd-83 \
ksym-default-spc-emulate-inquiry-std \
ksym-default-spc-emulate-report-luns \
ksym-default-spc-parse-cdb \
ksym-default-spi-add-device \
ksym-default-spi-alloc-device \
ksym-default-spi-async \
ksym-default-spi-attach-transport \
ksym-default-spi-bitbang-cleanup \
ksym-default-spi-bitbang-init \
ksym-default-spi-bitbang-setup \
ksym-default-spi-bitbang-setup-transfer \
ksym-default-spi-bitbang-start \
ksym-default-spi-bitbang-stop \
ksym-default-spi-bus-lock \
ksym-default-spi-bus-type \
ksym-default-spi-bus-unlock \
ksym-default-spi-controller-dma-map-mem-op-data \
ksym-default-spi-controller-dma-unmap-mem-op-data \
ksym-default-spi-controller-resume \
ksym-default-spi-controller-suspend \
ksym-default-spi-delay-exec \
ksym-default-spi-delay-to-ns \
ksym-default-spi-display-xfer-agreement \
ksym-default-spi-dv-device \
ksym-default-spi-finalize-current-message \
ksym-default-spi-finalize-current-transfer \
ksym-default-spi-get-device-id \
ksym-default-spi-get-device-match-data \
ksym-default-spi-get-next-queued-message \
ksym-default-spi-mem-adjust-op-freq \
ksym-default-spi-mem-adjust-op-size \
ksym-default-spi-mem-calc-op-duration \
ksym-default-spi-mem-default-supports-op \
ksym-default-spi-mem-dirmap-create \
ksym-default-spi-mem-dirmap-destroy \
ksym-default-spi-mem-dirmap-read \
ksym-default-spi-mem-dirmap-write \
ksym-default-spi-mem-driver-register-with-owner \
ksym-default-spi-mem-driver-unregister \
ksym-default-spi-mem-exec-op \
ksym-default-spi-mem-get-name \
ksym-default-spi-mem-poll-status \
ksym-default-spi-mem-supports-op \
ksym-default-spi-new-ancillary-device \
ksym-default-spi-new-device \
ksym-default-spi-nor-scan \
ksym-default-spi-offload-trigger-disable \
ksym-default-spi-offload-trigger-enable \
ksym-default-spi-offload-trigger-get-priv \
ksym-default-spi-offload-trigger-validate \
ksym-default-spi-optimize-message \
ksym-default-spi-populate-ppr-msg \
ksym-default-spi-populate-sync-msg \
ksym-default-spi-populate-tag-msg \
ksym-default-spi-populate-width-msg \
ksym-default-spi-print-msg \
ksym-default-spi-register-controller \
ksym-default-spi-release-transport \
ksym-default-spi-schedule-dv-device \
ksym-default-spi-setup \
ksym-default-spi-split-transfers-maxsize \
ksym-default-spi-split-transfers-maxwords \
ksym-default-spi-sync \
ksym-default-spi-sync-locked \
ksym-default-spi-take-timestamp-post \
ksym-default-spi-take-timestamp-pre \
ksym-default-spi-target-abort \
ksym-default-spi-test-execute-msg \
ksym-default-spi-test-run-test \
ksym-default-spi-test-run-tests \
ksym-default-spi-transfer-cs-change-delay-exec \
ksym-default-spi-unoptimize-message \
ksym-default-spi-unregister-controller \
ksym-default-spi-unregister-device \
ksym-default-spi-write-then-read \
ksym-default-splice-direct-to-actor \
ksym-default-splice-file-range \
ksym-default-splice-to-pipe \
ksym-default-split-key-done \
ksym-default-split-page \
ksym-default-spmi-command-reset \
ksym-default-spmi-command-shutdown \
ksym-default-spmi-command-sleep \
ksym-default-spmi-command-wakeup \
ksym-default-spmi-controller-add \
ksym-default-spmi-controller-alloc \
ksym-default-spmi-controller-remove \
ksym-default-spmi-device-add \
ksym-default-spmi-device-alloc \
ksym-default-spmi-device-remove \
ksym-default-spmi-ext-register-read \
ksym-default-spmi-ext-register-readl \
ksym-default-spmi-ext-register-write \
ksym-default-spmi-ext-register-writel \
ksym-default-spmi-find-device-by-of-node \
ksym-default-spmi-register-read \
ksym-default-spmi-register-write \
ksym-default-spmi-register-zero-write \
ksym-default-sprd-clk-probe \
ksym-default-sprd-clk-regmap-init \
ksym-default-sprd-comp-ops \
ksym-default-sprd-div-helper-recalc-rate \
ksym-default-sprd-div-helper-set-rate \
ksym-default-sprd-div-ops \
ksym-default-sprd-gate-ops \
ksym-default-sprd-mcdt-chan-dma-disable \
ksym-default-sprd-mcdt-chan-dma-enable \
ksym-default-sprd-mcdt-chan-int-disable \
ksym-default-sprd-mcdt-chan-int-enable \
ksym-default-sprd-mcdt-chan-read \
ksym-default-sprd-mcdt-chan-write \
ksym-default-sprd-mcdt-free-chan \
ksym-default-sprd-mcdt-request-chan \
ksym-default-sprd-mux-helper-get-parent \
ksym-default-sprd-mux-helper-set-parent \
ksym-default-sprd-mux-ops \
ksym-default-sprd-pinctrl-core-probe \
ksym-default-sprd-pinctrl-remove \
ksym-default-sprd-pinctrl-shutdown \
ksym-default-sprd-pll-ops \
ksym-default-sprd-pll-sc-gate-ops \
ksym-default-sprd-pmic-detect-charger-type \
ksym-default-sprd-sc-gate-ops \
ksym-default-sprint-oid \
ksym-default-sprint-symbol \
ksym-default-sprint-symbol-build-id \
ksym-default-sprint-symbol-no-offset \
ksym-default-sprintf \
ksym-default-sps30-probe \
ksym-default-srcu-barrier \
ksym-default-srcu-batches-completed \
ksym-default-srcu-expedite-current \
ksym-default-srcu-init-notifier-head \
ksym-default-srcu-notifier-call-chain \
ksym-default-srcu-notifier-chain-register \
ksym-default-srcu-notifier-chain-unregister \
ksym-default-srcu-torture-stats-print \
ksym-default-srcutorture-get-gp-data \
ksym-default-srgb-eotf \
ksym-default-srgb-inv-eotf \
ksym-default-srp-attach-transport \
ksym-default-srp-parse-tmo \
ksym-default-srp-reconnect-rport \
ksym-default-srp-release-transport \
ksym-default-srp-remove-host \
ksym-default-srp-rport-add \
ksym-default-srp-rport-del \
ksym-default-srp-rport-get \
ksym-default-srp-rport-put \
ksym-default-srp-start-tl-fail-timers \
ksym-default-srp-stop-rport-timers \
ksym-default-srp-timed-out \
ksym-default-srp-tmo-valid \
ksym-default-ssam-client-bind \
ksym-default-ssam-client-link \
ksym-default-ssam-controller-device \
ksym-default-ssam-controller-event-disable \
ksym-default-ssam-controller-event-enable \
ksym-default-ssam-controller-get \
ksym-default-ssam-controller-put \
ksym-default-ssam-controller-statelock \
ksym-default-ssam-controller-stateunlock \
ksym-default-ssam-device-add \
ksym-default-ssam-device-alloc \
ksym-default-ssam-device-driver-unregister \
ksym-default-ssam-device-get-match \
ksym-default-ssam-device-get-match-data \
ksym-default-ssam-device-id-match \
ksym-default-ssam-device-remove \
ksym-default-ssam-device-type \
ksym-default-ssam-get-controller \
ksym-default-ssam-notifier-register \
ksym-default-ssam-remove-clients \
ksym-default-ssam-request-do-sync \
ksym-default-ssam-request-do-sync-with-buffer \
ksym-default-ssam-request-sync-alloc \
ksym-default-ssam-request-sync-free \
ksym-default-ssam-request-sync-init \
ksym-default-ssam-request-sync-submit \
ksym-default-ssam-request-write-data \
ksym-default-ssb-admatch-base \
ksym-default-ssb-admatch-size \
ksym-default-ssb-bus-may-powerdown \
ksym-default-ssb-bus-powerup \
ksym-default-ssb-bus-resume \
ksym-default-ssb-bus-sdiobus-register \
ksym-default-ssb-bus-suspend \
ksym-default-ssb-bus-unregister \
ksym-default-ssb-chipco-gpio-control \
ksym-default-ssb-clockspeed \
ksym-default-ssb-commit-settings \
ksym-default-ssb-device-disable \
ksym-default-ssb-device-enable \
ksym-default-ssb-device-is-enabled \
ksym-default-ssb-dma-translation \
ksym-default-ssb-driver-unregister \
ksym-default-ssb-pcicore-dev-irqvecs-enable \
ksym-default-ssb-pcihost-register \
ksym-default-ssb-pmu-set-ldo-paref \
ksym-default-ssb-pmu-set-ldo-voltage \
ksym-default-ssb-pmu-spuravoid-pllupdate \
ksym-default-ssb-set-devtypedata \
ksym-default-sscanf \
ksym-default-ssd130x-probe \
ksym-default-ssd130x-remove \
ksym-default-ssd130x-shutdown \
ksym-default-ssd130x-variants \
ksym-default-ssh-packet-get \
ksym-default-ssh-packet-put \
ksym-default-ssm2602-probe \
ksym-default-ssm2602-regmap-config \
ksym-default-st-accel-common-probe \
ksym-default-st-accel-get-settings \
ksym-default-st-lsm6dsx-pm-ops \
ksym-default-st-lsm6dsx-probe \
ksym-default-st-lsm9ds0-probe \
ksym-default-st-magn-common-probe \
ksym-default-st-magn-get-settings \
ksym-default-st-nci-disable-se \
ksym-default-st-nci-discover-se \
ksym-default-st-nci-enable-se \
ksym-default-st-nci-hci-cmd-received \
ksym-default-st-nci-hci-event-received \
ksym-default-st-nci-hci-load-session \
ksym-default-st-nci-probe \
ksym-default-st-nci-remove \
ksym-default-st-nci-se-deinit \
ksym-default-st-nci-se-init \
ksym-default-st-nci-se-io \
ksym-default-st-nci-vendor-cmds-init \
ksym-default-st-press-common-probe \
ksym-default-st-press-get-settings \
ksym-default-st-sensors-allocate-trigger \
ksym-default-st-sensors-debugfs-reg-access \
ksym-default-st-sensors-dev-name-probe \
ksym-default-st-sensors-get-settings-index \
ksym-default-st-sensors-i2c-configure \
ksym-default-st-sensors-init-sensor \
ksym-default-st-sensors-power-enable \
ksym-default-st-sensors-read-info-raw \
ksym-default-st-sensors-set-axis-enable \
ksym-default-st-sensors-set-dataready-irq \
ksym-default-st-sensors-set-enable \
ksym-default-st-sensors-set-fullscale-by-gain \
ksym-default-st-sensors-set-odr \
ksym-default-st-sensors-spi-configure \
ksym-default-st-sensors-sysfs-sampling-frequency-avail \
ksym-default-st-sensors-sysfs-scale-avail \
ksym-default-st-sensors-trigger-handler \
ksym-default-st-sensors-validate-device \
ksym-default-st-sensors-verify-id \
ksym-default-st-thermal-pm-ops \
ksym-default-st-thermal-register \
ksym-default-st-thermal-unregister \
ksym-default-st-uvis25-pm-ops \
ksym-default-st-uvis25-probe \
ksym-default-st21nfca-apdu-reader-event-received \
ksym-default-st21nfca-connectivity-event-received \
ksym-default-st21nfca-dep-deinit \
ksym-default-st21nfca-dep-event-received \
ksym-default-st21nfca-dep-init \
ksym-default-st21nfca-hci-disable-se \
ksym-default-st21nfca-hci-discover-se \
ksym-default-st21nfca-hci-enable-se \
ksym-default-st21nfca-hci-loopback-event-received \
ksym-default-st21nfca-hci-probe \
ksym-default-st21nfca-hci-remove \
ksym-default-st21nfca-hci-se-io \
ksym-default-st21nfca-im-send-atr-req \
ksym-default-st21nfca-im-send-dep-req \
ksym-default-st21nfca-se-deinit \
ksym-default-st21nfca-se-init \
ksym-default-st21nfca-tm-send-dep-res \
ksym-default-st21nfca-vendor-cmds-init \
ksym-default-st33zp24-pm-resume \
ksym-default-st33zp24-pm-suspend \
ksym-default-st33zp24-probe \
ksym-default-st33zp24-remove \
ksym-default-st7567-config \
ksym-default-st7571-config \
ksym-default-st7571-probe \
ksym-default-st7571-remove \
ksym-default-st95hf-spi-recv-echo-res \
ksym-default-st95hf-spi-recv-response \
ksym-default-st95hf-spi-send \
ksym-default-stable-page-flags \
ksym-default-stack-depot-fetch \
ksym-default-stack-depot-get-extra-bits \
ksym-default-stack-depot-init \
ksym-default-stack-depot-print \
ksym-default-stack-depot-put \
ksym-default-stack-depot-save \
ksym-default-stack-depot-save-flags \
ksym-default-stack-depot-set-extra-bits \
ksym-default-stack-depot-snprint \
ksym-default-stack-trace-print \
ksym-default-stack-trace-save \
ksym-default-stack-trace-save-tsk \
ksym-default-stack-trace-snprint \
ksym-default-starget-for-each-device \
ksym-default-start-creating \
ksym-default-start-creating-dentry \
ksym-default-start-creating-killable \
ksym-default-start-creating-noperm \
ksym-default-start-creating-path \
ksym-default-start-creating-user-path \
ksym-default-start-poll-synchronize-rcu \
ksym-default-start-poll-synchronize-rcu-expedited \
ksym-default-start-poll-synchronize-rcu-expedited-full \
ksym-default-start-poll-synchronize-rcu-full \
ksym-default-start-poll-synchronize-srcu \
ksym-default-start-removing \
ksym-default-start-removing-dentry \
ksym-default-start-removing-killable \
ksym-default-start-removing-noperm \
ksym-default-start-renaming \
ksym-default-start-renaming-dentry \
ksym-default-start-renaming-two-dentries \
ksym-default-start-tty \
ksym-default-static-dev-dax \
ksym-default-static-key-count \
ksym-default-static-key-disable \
ksym-default-static-key-disable-cpuslocked \
ksym-default-static-key-enable \
ksym-default-static-key-enable-cpuslocked \
ksym-default-static-key-fast-inc-not-disabled \
ksym-default-static-key-initialized \
ksym-default-static-key-slow-dec \
ksym-default-static-key-slow-inc \
ksym-default-stb0899-attach \
ksym-default-stb6000-attach \
ksym-default-stb6100-attach \
ksym-default-stm-data-write \
ksym-default-stm-register-device \
ksym-default-stm-register-protocol \
ksym-default-stm-source-register-device \
ksym-default-stm-source-unregister-device \
ksym-default-stm-source-write \
ksym-default-stm-unregister-device \
ksym-default-stm-unregister-protocol \
ksym-default-stm32-dfsdm-get-buff-cb \
ksym-default-stm32-dfsdm-release-buff-cb \
ksym-default-stm32-dfsdm-start-dfsdm \
ksym-default-stm32-dfsdm-stop-dfsdm \
ksym-default-stm32-firewall-controller-register \
ksym-default-stm32-firewall-controller-unregister \
ksym-default-stm32-firewall-get-firewall \
ksym-default-stm32-firewall-get-grant-all-access \
ksym-default-stm32-firewall-grant-access \
ksym-default-stm32-firewall-grant-access-by-id \
ksym-default-stm32-firewall-populate-bus \
ksym-default-stm32-firewall-release-access \
ksym-default-stm32-firewall-release-access-by-id \
ksym-default-stm32-pctl-probe \
ksym-default-stm32-pinctrl-resume \
ksym-default-stm32-pinctrl-suspend \
ksym-default-stm32-timers-dma-burst-read \
ksym-default-stmfx-function-disable \
ksym-default-stmfx-function-enable \
ksym-default-stmmac-axi-blen-to-mask \
ksym-default-stmmac-dvr-probe \
ksym-default-stmmac-dvr-remove \
ksym-default-stmmac-get-mac-addr \
ksym-default-stmmac-get-phy-intf-sel \
ksym-default-stmmac-get-platform-resources \
ksym-default-stmmac-mdio-lock \
ksym-default-stmmac-mdio-unlock \
ksym-default-stmmac-pci-plat-resume \
ksym-default-stmmac-pci-plat-suspend \
ksym-default-stmmac-plat-dat-alloc \
ksym-default-stmmac-pltfr-find-clk \
ksym-default-stmmac-pltfr-pm-ops \
ksym-default-stmmac-pltfr-probe \
ksym-default-stmmac-pltfr-remove \
ksym-default-stmmac-resume \
ksym-default-stmmac-set-clk-tx-rate \
ksym-default-stmmac-set-mac-addr \
ksym-default-stmmac-simple-pm-ops \
ksym-default-stmmac-suspend \
ksym-default-stmp-reset-block \
ksym-default-stop-core-cpuslocked \
ksym-default-stop-machine \
ksym-default-stop-tty \
ksym-default-store-cdrom-address \
ksym-default-stp-proto-register \
ksym-default-stp-proto-unregister \
ksym-default-stpcpy \
ksym-default-stratix10-svc-add-async-client \
ksym-default-stratix10-svc-allocate-memory \
ksym-default-stratix10-svc-async-done \
ksym-default-stratix10-svc-async-poll \
ksym-default-stratix10-svc-async-send \
ksym-default-stratix10-svc-done \
ksym-default-stratix10-svc-free-channel \
ksym-default-stratix10-svc-free-memory \
ksym-default-stratix10-svc-remove-async-client \
ksym-default-stratix10-svc-request-channel-byname \
ksym-default-stratix10-svc-send \
ksym-default-strcasecmp \
ksym-default-strcat \
ksym-default-strchr \
ksym-default-strchrnul \
ksym-default-strcmp \
ksym-default-strcpy \
ksym-default-strcspn \
ksym-default-stream-open \
ksym-default-strim \
ksym-default-string-escape-mem \
ksym-default-string-get-size \
ksym-default-string-unescape \
ksym-default-strlcat \
ksym-default-strlen \
ksym-default-strncasecmp \
ksym-default-strncat \
ksym-default-strnchr \
ksym-default-strncmp \
ksym-default-strncpy-from-user \
ksym-default-strndup-user \
ksym-default-strnlen \
ksym-default-strnlen-user \
ksym-default-strnstr \
ksym-default-strp-check-rcv \
ksym-default-strp-data-ready \
ksym-default-strp-done \
ksym-default-strp-init \
ksym-default-strp-process \
ksym-default-strp-stop \
ksym-default-strp-unpause \
ksym-default-strpbrk \
ksym-default-strrchr \
ksym-default-strreplace \
ksym-default-strsep \
ksym-default-strspn \
ksym-default-strstr \
ksym-default-stutter-wait \
ksym-default-stv0288-attach \
ksym-default-stv0297-attach \
ksym-default-stv0299-attach \
ksym-default-stv0367cab-attach \
ksym-default-stv0367ddb-attach \
ksym-default-stv0367ter-attach \
ksym-default-stv0900-attach \
ksym-default-stv090x-attach \
ksym-default-stv0910-attach \
ksym-default-stv6110-attach \
ksym-default-stv6110x-attach \
ksym-default-stv6111-attach \
ksym-default-subdev-8255-cb-init \
ksym-default-subdev-8255-io-init \
ksym-default-subdev-8255-mm-init \
ksym-default-subdev-8255-regbase \
ksym-default-submit-bio \
ksym-default-submit-bio-noacct \
ksym-default-submit-bio-wait \
ksym-default-subsys-interface-register \
ksym-default-subsys-interface-unregister \
ksym-default-subsys-system-register \
ksym-default-subsys-virtual-register \
ksym-default-sun4i-dclk-create \
ksym-default-sun4i-dclk-free \
ksym-default-sun4i-lvds-init \
ksym-default-sun4i-rgb-init \
ksym-default-sun4i-tcon-enable-vblank \
ksym-default-sun4i-tcon-mode-set \
ksym-default-sun4i-tcon-of-table \
ksym-default-sun4i-usb-phy-set-squelch-detect \
ksym-default-sun8i-adda-pr-regmap-init \
ksym-default-sun8i-tcon-top-de-config \
ksym-default-sun8i-tcon-top-of-table \
ksym-default-sun8i-tcon-top-set-hdmi-src \
ksym-default-sungem-phy-probe \
ksym-default-sunrpc-cache-lookup-rcu \
ksym-default-sunrpc-cache-notify \
ksym-default-sunrpc-cache-register-pipefs \
ksym-default-sunrpc-cache-requests-count \
ksym-default-sunrpc-cache-requests-snapshot \
ksym-default-sunrpc-cache-unhash \
ksym-default-sunrpc-cache-unregister-pipefs \
ksym-default-sunrpc-cache-upcall \
ksym-default-sunrpc-cache-upcall-warn \
ksym-default-sunrpc-cache-update \
ksym-default-sunrpc-destroy-cache-detail \
ksym-default-sunrpc-get-pool-mode \
ksym-default-sunrpc-init-cache-detail \
ksym-default-sunrpc-net-id \
ksym-default-sunrpc-set-pool-mode \
ksym-default-sunxi-ccu-get-mmc-timing-mode \
ksym-default-sunxi-ccu-set-mmc-timing-mode \
ksym-default-sunxi-rsb-driver-register \
ksym-default-sunxi-sram-claim \
ksym-default-sunxi-sram-release \
ksym-default-super-setup-bdi \
ksym-default-super-setup-bdi-name \
ksym-default-surface-hid-device-add \
ksym-default-surface-hid-device-destroy \
ksym-default-surface-hid-pm-ops \
ksym-default-suspend-set-ops \
ksym-default-suspend-valid-only-mem \
ksym-default-svc-addsock \
ksym-default-svc-age-temp-xprts-now \
ksym-default-svc-auth-flavor \
ksym-default-svc-auth-register \
ksym-default-svc-auth-unregister \
ksym-default-svc-bind \
ksym-default-svc-create \
ksym-default-svc-create-pooled \
ksym-default-svc-destroy \
ksym-default-svc-encode-result-payload \
ksym-default-svc-exit-thread \
ksym-default-svc-fill-symlink-pathname \
ksym-default-svc-find-listener \
ksym-default-svc-find-xprt \
ksym-default-svc-generic-init-request \
ksym-default-svc-generic-rpcbind-set \
ksym-default-svc-max-payload \
ksym-default-svc-new-thread \
ksym-default-svc-pool-stats-open \
ksym-default-svc-pool-wake-idle-thread \
ksym-default-svc-print-addr \
ksym-default-svc-proc-register \
ksym-default-svc-proc-unregister \
ksym-default-svc-recv \
ksym-default-svc-reg-xprt-class \
ksym-default-svc-reserve \
ksym-default-svc-rqst-replace-page \
ksym-default-svc-seq-show \
ksym-default-svc-set-client \
ksym-default-svc-set-num-threads \
ksym-default-svc-set-pool-threads \
ksym-default-svc-unreg-xprt-class \
ksym-default-svc-wake-up \
ksym-default-svc-xprt-close \
ksym-default-svc-xprt-copy-addrs \
ksym-default-svc-xprt-create \
ksym-default-svc-xprt-create-from-sa \
ksym-default-svc-xprt-deferred-close \
ksym-default-svc-xprt-destroy-all \
ksym-default-svc-xprt-enqueue \
ksym-default-svc-xprt-init \
ksym-default-svc-xprt-names \
ksym-default-svc-xprt-put \
ksym-default-svc-xprt-received \
ksym-default-svcauth-gss-flavor \
ksym-default-svcauth-gss-register-pseudoflavor \
ksym-default-svcauth-map-clnt-to-svc-cred-local \
ksym-default-svcauth-unix-purge \
ksym-default-svcauth-unix-set-client \
ksym-default-sw842-compress \
ksym-default-sw842-decompress \
ksym-default-swake-up-all \
ksym-default-swake-up-locked \
ksym-default-swake-up-one \
ksym-default-switchdev-bridge-port-offload \
ksym-default-switchdev-bridge-port-replay \
ksym-default-switchdev-bridge-port-unoffload \
ksym-default-switchdev-deferred-process \
ksym-default-switchdev-handle-fdb-event-to-device \
ksym-default-switchdev-handle-port-attr-set \
ksym-default-switchdev-handle-port-obj-add \
ksym-default-switchdev-handle-port-obj-add-foreign \
ksym-default-switchdev-handle-port-obj-del \
ksym-default-switchdev-handle-port-obj-del-foreign \
ksym-default-switchdev-port-attr-set \
ksym-default-switchdev-port-obj-act-is-deferred \
ksym-default-switchdev-port-obj-add \
ksym-default-switchdev-port-obj-del \
ksym-default-switchtec-class \
ksym-default-swnode-gpio-undefined \
ksym-default-swphy-read-reg \
ksym-default-swphy-validate-state \
ksym-default-sx-common-events \
ksym-default-sx-common-probe \
ksym-default-sx-common-read-event-config \
ksym-default-sx-common-read-proximity \
ksym-default-sx-common-write-event-config \
ksym-default-symbol-put-addr \
ksym-default-sync-blockdev \
ksym-default-sync-blockdev-nowait \
ksym-default-sync-blockdev-range \
ksym-default-sync-dirty-buffer \
ksym-default-sync-file-create \
ksym-default-sync-file-get-fence \
ksym-default-sync-filesystem \
ksym-default-sync-inode-metadata \
ksym-default-sync-inodes-sb \
ksym-default-sync-page-io \
ksym-default-synchronize-hardirq \
ksym-default-synchronize-irq \
ksym-default-synchronize-net \
ksym-default-synchronize-rcu \
ksym-default-synchronize-rcu-expedited \
ksym-default-synchronize-rcu-tasks \
ksym-default-synchronize-rcu-tasks-rude \
ksym-default-synchronize-srcu \
ksym-default-synchronize-srcu-expedited \
ksym-default-synproxy-init-timestamp-cookie \
ksym-default-synproxy-net-id \
ksym-default-synproxy-parse-options \
ksym-default-synproxy-recv-client-ack \
ksym-default-synproxy-recv-client-ack-ipv6 \
ksym-default-synproxy-send-client-synack \
ksym-default-synproxy-send-client-synack-ipv6 \
ksym-default-synth-event-add-field \
ksym-default-synth-event-add-field-str \
ksym-default-synth-event-add-fields \
ksym-default-synth-event-add-next-val \
ksym-default-synth-event-add-val \
ksym-default-synth-event-cmd-init \
ksym-default-synth-event-create \
ksym-default-synth-event-delete \
ksym-default-synth-event-gen-cmd-array-start \
ksym-default-synth-event-trace \
ksym-default-synth-event-trace-array \
ksym-default-synth-event-trace-end \
ksym-default-synth-event-trace-start \
ksym-default-sys-copyarea \
ksym-default-sys-fillrect \
ksym-default-sys-imageblit \
ksym-default-sys-tz \
ksym-default-syscon-node-to-regmap \
ksym-default-syscon-regmap-lookup-by-compatible \
ksym-default-syscon-regmap-lookup-by-phandle \
ksym-default-syscon-regmap-lookup-by-phandle-args \
ksym-default-syscon-regmap-lookup-by-phandle-optional \
ksym-default-sysconfig-probe \
ksym-default-syscore-resume \
ksym-default-syscore-suspend \
ksym-default-sysctl-devconf-inherit-init-net \
ksym-default-sysctl-fb-tunnels-only-for-init-net \
ksym-default-sysctl-long-vals \
ksym-default-sysctl-nf-log-all-netns \
ksym-default-sysctl-rmem-max \
ksym-default-sysctl-vals \
ksym-default-sysctl-wmem-max \
ksym-default-sysfb-disable \
ksym-default-sysfb-handles-screen-info \
ksym-default-sysfb-primary-display \
ksym-default-sysfs-add-file-to-group \
ksym-default-sysfs-add-link-to-group \
ksym-default-sysfs-bin-attr-simple-read \
ksym-default-sysfs-break-active-protection \
ksym-default-sysfs-chmod-file \
ksym-default-sysfs-create-bin-file \
ksym-default-sysfs-create-file-ns \
ksym-default-sysfs-create-files \
ksym-default-sysfs-create-group \
ksym-default-sysfs-create-groups \
ksym-default-sysfs-create-link \
ksym-default-sysfs-create-link-nowarn \
ksym-default-sysfs-create-mount-point \
ksym-default-sysfs-emit \
ksym-default-sysfs-emit-at \
ksym-default-sysfs-format-mac \
ksym-default-sysfs-group-change-owner \
ksym-default-sysfs-groups-change-owner \
ksym-default-sysfs-merge-group \
ksym-default-sysfs-notify \
ksym-default-sysfs-remove-bin-file \
ksym-default-sysfs-remove-file-from-group \
ksym-default-sysfs-remove-file-ns \
ksym-default-sysfs-remove-file-self \
ksym-default-sysfs-remove-files \
ksym-default-sysfs-remove-group \
ksym-default-sysfs-remove-groups \
ksym-default-sysfs-remove-link \
ksym-default-sysfs-remove-link-from-group \
ksym-default-sysfs-remove-mount-point \
ksym-default-sysfs-rename-link-ns \
ksym-default-sysfs-streq \
ksym-default-sysfs-unbreak-active-protection \
ksym-default-sysfs-unmerge-group \
ksym-default-sysfs-update-group \
ksym-default-sysfs-update-groups \
ksym-default-sysrq-mask \
ksym-default-sysrq-toggle-support \
ksym-default-system-bh-highpri-wq \
ksym-default-system-bh-wq \
ksym-default-system-cpucaps \
ksym-default-system-dfl-long-wq \
ksym-default-system-dfl-wq \
ksym-default-system-entering-hibernation \
ksym-default-system-freezable-power-efficient-wq \
ksym-default-system-freezable-wq \
ksym-default-system-highpri-wq \
ksym-default-system-long-wq \
ksym-default-system-percpu-wq \
ksym-default-system-power-efficient-wq \
ksym-default-system-state \
ksym-default-system-unbound-wq \
ksym-default-system-wq \
ksym-default-t3-l2e-free \
ksym-default-t3-l2t-get \
ksym-default-t3-l2t-send-slow \
ksym-default-t3-register-cpl-handler \
ksym-default-t4-cleanup-clip-tbl \
ksym-default-tag-pages-for-writeback \
ksym-default-take-dentry-name-snapshot \
ksym-default-tap-create-cdev \
ksym-default-tap-del-queues \
ksym-default-tap-destroy-cdev \
ksym-default-tap-free-minor \
ksym-default-tap-get-minor \
ksym-default-tap-get-ptr-ring \
ksym-default-tap-get-socket \
ksym-default-tap-handle-frame \
ksym-default-tap-queue-resize \
ksym-default-taprio-offload-free \
ksym-default-taprio-offload-get \
ksym-default-target-alloc-cmd-counter \
ksym-default-target-alloc-sgl \
ksym-default-target-backend-unregister \
ksym-default-target-cmd-init-cdb \
ksym-default-target-cmd-parse-cdb \
ksym-default-target-complete-cmd \
ksym-default-target-complete-cmd-with-length \
ksym-default-target-complete-cmd-with-sense \
ksym-default-target-configure-unmap-from-bdev \
ksym-default-target-configure-write-atomic-from-bdev \
ksym-default-target-depend-item \
ksym-default-target-execute-cmd \
ksym-default-target-free-cmd-counter \
ksym-default-target-free-sgl \
ksym-default-target-get-sess-cmd \
ksym-default-target-init-cmd \
ksym-default-target-lun-is-rdonly \
ksym-default-target-nacl-find-deve \
ksym-default-target-put-nacl \
ksym-default-target-put-sess-cmd \
ksym-default-target-register-template \
ksym-default-target-remove-session \
ksym-default-target-send-busy \
ksym-default-target-set-cmd-data-length \
ksym-default-target-setup-session \
ksym-default-target-show-cmd \
ksym-default-target-show-dynamic-sessions \
ksym-default-target-stop-cmd-counter \
ksym-default-target-stop-session \
ksym-default-target-submit \
ksym-default-target-submit-cmd \
ksym-default-target-submit-prep \
ksym-default-target-submit-tmr \
ksym-default-target-to-linux-sector \
ksym-default-target-tpg-has-node-acl \
ksym-default-target-undepend-item \
ksym-default-target-unregister-template \
ksym-default-target-wait-for-cmds \
ksym-default-target-wait-for-sess-cmds \
ksym-default-tas2781-hda-remove \
ksym-default-tas2781-load-calibration \
ksym-default-tas2781-save-calibration \
ksym-default-tascodec-init \
ksym-default-tasdev-chn-switch \
ksym-default-tasdev-fct-efi-guid \
ksym-default-tasdevice-amp-getvol \
ksym-default-tasdevice-amp-putvol \
ksym-default-tasdevice-calbin-remove \
ksym-default-tasdevice-config-get \
ksym-default-tasdevice-config-info-remove \
ksym-default-tasdevice-config-put \
ksym-default-tasdevice-dev-bulk-read \
ksym-default-tasdevice-dev-bulk-write \
ksym-default-tasdevice-dev-read \
ksym-default-tasdevice-dev-update-bits \
ksym-default-tasdevice-dev-write \
ksym-default-tasdevice-digital-getvol \
ksym-default-tasdevice-digital-putvol \
ksym-default-tasdevice-dsp-parser \
ksym-default-tasdevice-dsp-remove \
ksym-default-tasdevice-get-profile-id \
ksym-default-tasdevice-info-config \
ksym-default-tasdevice-info-profile \
ksym-default-tasdevice-info-programs \
ksym-default-tasdevice-init \
ksym-default-tasdevice-kzalloc \
ksym-default-tasdevice-prmg-load \
ksym-default-tasdevice-program-get \
ksym-default-tasdevice-program-put \
ksym-default-tasdevice-rca-parser \
ksym-default-tasdevice-remove \
ksym-default-tasdevice-reset \
ksym-default-tasdevice-select-cfg-blk \
ksym-default-tasdevice-select-tuningprm-cfg \
ksym-default-tasdevice-set-profile-id \
ksym-default-tasdevice-tuning-switch \
ksym-default-task-active-pid-ns \
ksym-default-task-cls-state \
ksym-default-task-cputime-adjusted \
ksym-default-task-user-regset-view \
ksym-default-tasklet-init \
ksym-default-tasklet-kill \
ksym-default-tasklet-setup \
ksym-default-tasklet-unlock \
ksym-default-tasklet-unlock-spin-wait \
ksym-default-tasklet-unlock-wait \
ksym-default-tb-configfs-register-group \
ksym-default-tb-configfs-unregister-group \
ksym-default-tb-property-add-data \
ksym-default-tb-property-add-dir \
ksym-default-tb-property-add-immediate \
ksym-default-tb-property-add-text \
ksym-default-tb-property-copy-dir \
ksym-default-tb-property-create-dir \
ksym-default-tb-property-find \
ksym-default-tb-property-free-dir \
ksym-default-tb-property-get-next \
ksym-default-tb-property-merge-dir \
ksym-default-tb-property-remove \
ksym-default-tb-register-property-dir \
ksym-default-tb-register-protocol-handler \
ksym-default-tb-register-service-driver \
ksym-default-tb-ring-alloc-rx \
ksym-default-tb-ring-alloc-tx \
ksym-default-tb-ring-flush \
ksym-default-tb-ring-free \
ksym-default-tb-ring-poll \
ksym-default-tb-ring-poll-complete \
ksym-default-tb-ring-start \
ksym-default-tb-ring-stop \
ksym-default-tb-ring-throttling \
ksym-default-tb-service-properties-changed \
ksym-default-tb-service-type \
ksym-default-tb-unregister-property-dir \
ksym-default-tb-unregister-protocol-handler \
ksym-default-tb-unregister-service-driver \
ksym-default-tb-xdomain-alloc-in-hopid \
ksym-default-tb-xdomain-alloc-out-hopid \
ksym-default-tb-xdomain-disable-paths \
ksym-default-tb-xdomain-enable-paths \
ksym-default-tb-xdomain-find-by-route \
ksym-default-tb-xdomain-find-by-uuid \
ksym-default-tb-xdomain-lane-bonding-disable \
ksym-default-tb-xdomain-lane-bonding-enable \
ksym-default-tb-xdomain-release-in-hopid \
ksym-default-tb-xdomain-release-out-hopid \
ksym-default-tb-xdomain-request \
ksym-default-tb-xdomain-response \
ksym-default-tb-xdomain-type \
ksym-default-tc-cleanup-offload-action \
ksym-default-tc-setup-cb-add \
ksym-default-tc-setup-cb-call \
ksym-default-tc-setup-cb-destroy \
ksym-default-tc-setup-cb-reoffload \
ksym-default-tc-setup-cb-replace \
ksym-default-tc-setup-offload-action \
ksym-default-tc-skb-ext-tc \
ksym-default-tc-skb-ext-tc-disable \
ksym-default-tc-skb-ext-tc-enable \
ksym-default-tcf-action-check-ctrlact \
ksym-default-tcf-action-exec \
ksym-default-tcf-action-set-ctrlact \
ksym-default-tcf-action-update-hw-stats \
ksym-default-tcf-action-update-stats \
ksym-default-tcf-block-get \
ksym-default-tcf-block-get-ext \
ksym-default-tcf-block-lookup \
ksym-default-tcf-block-netif-keep-dst \
ksym-default-tcf-block-put \
ksym-default-tcf-block-put-ext \
ksym-default-tcf-chain-get-by-act \
ksym-default-tcf-chain-put-by-act \
ksym-default-tcf-classify \
ksym-default-tcf-dev-queue-xmit \
ksym-default-tcf-em-register \
ksym-default-tcf-em-tree-destroy \
ksym-default-tcf-em-tree-dump \
ksym-default-tcf-em-tree-validate \
ksym-default-tcf-em-unregister \
ksym-default-tcf-exts-change \
ksym-default-tcf-exts-destroy \
ksym-default-tcf-exts-dump \
ksym-default-tcf-exts-dump-stats \
ksym-default-tcf-exts-init-ex \
ksym-default-tcf-exts-num-actions \
ksym-default-tcf-exts-terse-dump \
ksym-default-tcf-exts-validate \
ksym-default-tcf-exts-validate-ex \
ksym-default-tcf-frag-xmit-count \
ksym-default-tcf-generic-walker \
ksym-default-tcf-get-next-chain \
ksym-default-tcf-get-next-proto \
ksym-default-tcf-idr-check-alloc \
ksym-default-tcf-idr-cleanup \
ksym-default-tcf-idr-create \
ksym-default-tcf-idr-create-from-flags \
ksym-default-tcf-idr-release \
ksym-default-tcf-idr-search \
ksym-default-tcf-idrinfo-destroy \
ksym-default-tcf-qevent-destroy \
ksym-default-tcf-qevent-dump \
ksym-default-tcf-qevent-handle \
ksym-default-tcf-qevent-init \
ksym-default-tcf-qevent-validate-change \
ksym-default-tcf-queue-work \
ksym-default-tcf-register-action \
ksym-default-tcf-sw-enabled-key \
ksym-default-tcf-unregister-action \
ksym-default-tcp-abort \
ksym-default-tcp-bpf-sendmsg-redir \
ksym-default-tcp-bpf-update-proto \
ksym-default-tcp-close \
ksym-default-tcp-cong-avoid-ai \
ksym-default-tcp-connect \
ksym-default-tcp-enter-cwr \
ksym-default-tcp-get-info \
ksym-default-tcp-gro-complete \
ksym-default-tcp-have-smc \
ksym-default-tcp-is-ulp-esp \
ksym-default-tcp-memory-per-cpu-fw-alloc \
ksym-default-tcp-memory-pressure \
ksym-default-tcp-mss-to-mtu \
ksym-default-tcp-parse-options \
ksym-default-tcp-plb-check-rehash \
ksym-default-tcp-plb-update-state \
ksym-default-tcp-plb-update-state-upon-rto \
ksym-default-tcp-poll \
ksym-default-tcp-prot \
ksym-default-tcp-rate-check-app-limited \
ksym-default-tcp-read-done \
ksym-default-tcp-read-sock \
ksym-default-tcp-recv-skb \
ksym-default-tcp-register-congestion-control \
ksym-default-tcp-register-ulp \
ksym-default-tcp-reno-cong-avoid \
ksym-default-tcp-reno-ssthresh \
ksym-default-tcp-reno-undo-cwnd \
ksym-default-tcp-sendmsg \
ksym-default-tcp-sendmsg-locked \
ksym-default-tcp-slow-start \
ksym-default-tcp-sock-set-cork \
ksym-default-tcp-sock-set-keepcnt \
ksym-default-tcp-sock-set-keepidle \
ksym-default-tcp-sock-set-keepintvl \
ksym-default-tcp-sock-set-nodelay \
ksym-default-tcp-sock-set-quickack \
ksym-default-tcp-sock-set-syncnt \
ksym-default-tcp-sock-set-user-timeout \
ksym-default-tcp-stream-memory-free \
ksym-default-tcp-unregister-congestion-control \
ksym-default-tcp-unregister-ulp \
ksym-default-tcp-vegas-cwnd-event \
ksym-default-tcp-vegas-cwnd-event-tx-start \
ksym-default-tcp-vegas-get-info \
ksym-default-tcp-vegas-init \
ksym-default-tcp-vegas-pkts-acked \
ksym-default-tcp-vegas-state \
ksym-default-tcp-wfree \
ksym-default-tcpci-get-tcpm-port \
ksym-default-tcpci-irq \
ksym-default-tcpci-register-port \
ksym-default-tcpci-unregister-port \
ksym-default-tcpm-cc-change \
ksym-default-tcpm-pd-hard-reset \
ksym-default-tcpm-pd-receive \
ksym-default-tcpm-pd-transmit-complete \
ksym-default-tcpm-port-clean \
ksym-default-tcpm-port-error-recovery \
ksym-default-tcpm-port-is-toggling \
ksym-default-tcpm-register-port \
ksym-default-tcpm-sink-frs \
ksym-default-tcpm-sourcing-vbus \
ksym-default-tcpm-tcpc-reset \
ksym-default-tcpm-unregister-port \
ksym-default-tcpm-vbus-change \
ksym-default-tcpv6-prot \
ksym-default-tda10021-attach \
ksym-default-tda10023-attach \
ksym-default-tda10045-attach \
ksym-default-tda10046-attach \
ksym-default-tda10048-attach \
ksym-default-tda10086-attach \
ksym-default-tda18218-attach \
ksym-default-tda18271-attach \
ksym-default-tda18271c2dd-attach \
ksym-default-tda665x-attach \
ksym-default-tda8083-attach \
ksym-default-tda8261-attach \
ksym-default-tda826x-attach \
ksym-default-tda827x-attach \
ksym-default-tda829x-attach \
ksym-default-tda829x-probe \
ksym-default-tda9887-attach \
ksym-default-tea5761-attach \
ksym-default-tea5761-autodetection \
ksym-default-tea5767-attach \
ksym-default-tea5767-autodetection \
ksym-default-team-mode-register \
ksym-default-team-mode-unregister \
ksym-default-team-modeop-port-change-dev-addr \
ksym-default-team-modeop-port-enter \
ksym-default-team-option-inst-set-change \
ksym-default-team-options-change-check \
ksym-default-team-options-register \
ksym-default-team-options-unregister \
ksym-default-tee-bnxt-copy-coredump \
ksym-default-tee-bnxt-fw-load \
ksym-default-tee-bus-type \
ksym-default-tee-client-close-context \
ksym-default-tee-client-close-session \
ksym-default-tee-client-driver-unregister \
ksym-default-tee-client-get-version \
ksym-default-tee-client-invoke-func \
ksym-default-tee-client-open-context \
ksym-default-tee-client-open-session \
ksym-default-tee-client-system-session \
ksym-default-tee-device-alloc \
ksym-default-tee-device-get \
ksym-default-tee-device-put \
ksym-default-tee-device-put-all-dma-heaps \
ksym-default-tee-device-register \
ksym-default-tee-device-register-dma-heap \
ksym-default-tee-device-set-dev-groups \
ksym-default-tee-device-unregister \
ksym-default-tee-dyn-shm-alloc-helper \
ksym-default-tee-dyn-shm-free-helper \
ksym-default-tee-get-drvdata \
ksym-default-tee-protmem-static-pool-alloc \
ksym-default-tee-session-calc-client-uuid \
ksym-default-tee-shm-alloc-dma-mem \
ksym-default-tee-shm-alloc-kernel-buf \
ksym-default-tee-shm-alloc-priv-buf \
ksym-default-tee-shm-free \
ksym-default-tee-shm-get-from-id \
ksym-default-tee-shm-get-pa \
ksym-default-tee-shm-get-va \
ksym-default-tee-shm-pool-alloc-res-mem \
ksym-default-tee-shm-put \
ksym-default-tee-shm-register-fd \
ksym-default-tee-shm-register-kernel-buf \
ksym-default-teedev-close-context \
ksym-default-teedev-ctx-get \
ksym-default-teedev-ctx-put \
ksym-default-teedev-open \
ksym-default-tegra-ahb-enable-smmu \
ksym-default-tegra-asoc-machine-init \
ksym-default-tegra-asoc-machine-probe \
ksym-default-tegra-bpmp-free-mrq \
ksym-default-tegra-bpmp-get \
ksym-default-tegra-bpmp-get-with-id \
ksym-default-tegra-bpmp-mrq-is-supported \
ksym-default-tegra-bpmp-mrq-return \
ksym-default-tegra-bpmp-put \
ksym-default-tegra-bpmp-request-mrq \
ksym-default-tegra-bpmp-transfer \
ksym-default-tegra-bpmp-transfer-atomic \
ksym-default-tegra-dfll-register \
ksym-default-tegra-dfll-resume \
ksym-default-tegra-dfll-runtime-resume \
ksym-default-tegra-dfll-runtime-suspend \
ksym-default-tegra-dfll-suspend \
ksym-default-tegra-dfll-unregister \
ksym-default-tegra-fuse-readl \
ksym-default-tegra-ivc-align \
ksym-default-tegra-ivc-cleanup \
ksym-default-tegra-ivc-init \
ksym-default-tegra-ivc-notified \
ksym-default-tegra-ivc-read-advance \
ksym-default-tegra-ivc-read-get-next-frame \
ksym-default-tegra-ivc-reset \
ksym-default-tegra-ivc-total-queue-size \
ksym-default-tegra-ivc-write-advance \
ksym-default-tegra-ivc-write-get-next-frame \
ksym-default-tegra-mc-get-carveout-info \
ksym-default-tegra-mc-get-emem-device-count \
ksym-default-tegra-mc-probe-device \
ksym-default-tegra-mc-write-emem-configuration \
ksym-default-tegra-mipi-disable \
ksym-default-tegra-mipi-enable \
ksym-default-tegra-mipi-finish-calibration \
ksym-default-tegra-mipi-free \
ksym-default-tegra-mipi-request \
ksym-default-tegra-mipi-start-calibration \
ksym-default-tegra-pcm-close \
ksym-default-tegra-pcm-hw-params \
ksym-default-tegra-pcm-new \
ksym-default-tegra-pcm-open \
ksym-default-tegra-pcm-platform-register \
ksym-default-tegra-pcm-platform-register-with-chan-names \
ksym-default-tegra-pcm-platform-unregister \
ksym-default-tegra-pcm-pointer \
ksym-default-tegra-phy-xusb-utmi-pad-power-down \
ksym-default-tegra-phy-xusb-utmi-pad-power-on \
ksym-default-tegra-phy-xusb-utmi-port-reset \
ksym-default-tegra-pinctrl-probe \
ksym-default-tegra-pmc-io-pad-power-disable \
ksym-default-tegra-pmc-io-pad-power-enable \
ksym-default-tegra-pmc-powergate-power-off \
ksym-default-tegra-pmc-powergate-power-on \
ksym-default-tegra-pmc-powergate-remove-clamping \
ksym-default-tegra-pmc-powergate-sequence-power-up \
ksym-default-tegra-read-ram-code \
ksym-default-tegra-sku-info \
ksym-default-tegra-xusb-padctl-disable-phy-sleepwalk \
ksym-default-tegra-xusb-padctl-disable-phy-wake \
ksym-default-tegra-xusb-padctl-enable-phy-sleepwalk \
ksym-default-tegra-xusb-padctl-enable-phy-wake \
ksym-default-tegra-xusb-padctl-get \
ksym-default-tegra-xusb-padctl-get-port-number \
ksym-default-tegra-xusb-padctl-get-usb3-companion \
ksym-default-tegra-xusb-padctl-hsic-set-idle \
ksym-default-tegra-xusb-padctl-legacy-probe \
ksym-default-tegra-xusb-padctl-legacy-remove \
ksym-default-tegra-xusb-padctl-put \
ksym-default-tegra-xusb-padctl-remote-wake-detected \
ksym-default-tegra-xusb-padctl-set-vbus-override \
ksym-default-tegra-xusb-padctl-usb3-save-context \
ksym-default-tegra-xusb-padctl-usb3-set-lfps-detect \
ksym-default-tegra124-xusb-padctl-soc \
ksym-default-tegra186-xusb-padctl-soc \
ksym-default-tegra194-miscreg-mask-serror \
ksym-default-tegra194-xusb-padctl-soc \
ksym-default-tegra210-clk-emc-attach \
ksym-default-tegra210-clk-emc-detach \
ksym-default-tegra210-clk-emc-dll-enable \
ksym-default-tegra210-clk-emc-dll-update-setting \
ksym-default-tegra210-clk-emc-update-setting \
ksym-default-tegra210-plle-hw-sequence-is-enabled \
ksym-default-tegra210-plle-hw-sequence-start \
ksym-default-tegra210-put-utmipll-in-iddq \
ksym-default-tegra210-put-utmipll-out-iddq \
ksym-default-tegra210-sata-pll-hw-control-enable \
ksym-default-tegra210-sata-pll-hw-sequence-start \
ksym-default-tegra210-set-sata-pll-seq-sw \
ksym-default-tegra210-xusb-padctl-soc \
ksym-default-tegra210-xusb-pll-hw-control-enable \
ksym-default-tegra210-xusb-pll-hw-sequence-start \
ksym-default-tegra234-xusb-padctl-soc \
ksym-default-test-taint \
ksym-default-textsearch-destroy \
ksym-default-textsearch-find-continuous \
ksym-default-textsearch-prepare \
ksym-default-textsearch-register \
ksym-default-textsearch-unregister \
ksym-default-thaw-super \
ksym-default-thermal-acpi-active-trip-temp \
ksym-default-thermal-acpi-critical-trip-temp \
ksym-default-thermal-acpi-hot-trip-temp \
ksym-default-thermal-acpi-passive-trip-temp \
ksym-default-thermal-add-hwmon-sysfs \
ksym-default-thermal-cooling-device-register \
ksym-default-thermal-cooling-device-unregister \
ksym-default-thermal-cooling-device-update \
ksym-default-thermal-genl-cpu-capability-event \
ksym-default-thermal-of-cooling-device-register \
ksym-default-thermal-remove-hwmon-sysfs \
ksym-default-thermal-trip-is-bound-to-cdev \
ksym-default-thermal-tripless-zone-device-register \
ksym-default-thermal-zone-device \
ksym-default-thermal-zone-device-critical \
ksym-default-thermal-zone-device-disable \
ksym-default-thermal-zone-device-enable \
ksym-default-thermal-zone-device-id \
ksym-default-thermal-zone-device-priv \
ksym-default-thermal-zone-device-register-with-trips \
ksym-default-thermal-zone-device-type \
ksym-default-thermal-zone-device-unregister \
ksym-default-thermal-zone-device-update \
ksym-default-thermal-zone-for-each-trip \
ksym-default-thermal-zone-get-crit-temp \
ksym-default-thermal-zone-get-offset \
ksym-default-thermal-zone-get-slope \
ksym-default-thermal-zone-get-temp \
ksym-default-thermal-zone-get-zone-by-name \
ksym-default-thermal-zone-set-trip-temp \
ksym-default-this-cpu-has-cap \
ksym-default-thp-get-unmapped-area \
ksym-default-ti-lmu-common-get-brt-res \
ksym-default-ti-lmu-common-get-ramp-params \
ksym-default-ti-lmu-common-set-brightness \
ksym-default-ti-lmu-common-set-ramp \
ksym-default-tick-broadcast-control \
ksym-default-tick-broadcast-oneshot-control \
ksym-default-tick-nohz-dep-clear-cpu \
ksym-default-tick-nohz-dep-clear-task \
ksym-default-tick-nohz-dep-set-cpu \
ksym-default-tick-nohz-dep-set-task \
ksym-default-tick-nohz-full-mask \
ksym-default-tick-nohz-full-running \
ksym-default-tick-nohz-is-active \
ksym-default-tifm-add-adapter \
ksym-default-tifm-alloc-adapter \
ksym-default-tifm-alloc-device \
ksym-default-tifm-eject \
ksym-default-tifm-free-adapter \
ksym-default-tifm-free-device \
ksym-default-tifm-has-ms-pif \
ksym-default-tifm-map-sg \
ksym-default-tifm-queue-work \
ksym-default-tifm-register-driver \
ksym-default-tifm-remove-adapter \
ksym-default-tifm-unmap-sg \
ksym-default-tifm-unregister-driver \
ksym-default-time64-to-tm \
ksym-default-timecounter-init \
ksym-default-timecounter-read \
ksym-default-timekeeping-clocksource-has-base \
ksym-default-timer-delete \
ksym-default-timer-delete-sync \
ksym-default-timer-delete-sync-try \
ksym-default-timer-init-key \
ksym-default-timer-of-cleanup \
ksym-default-timer-of-init \
ksym-default-timer-reduce \
ksym-default-timer-shutdown \
ksym-default-timer-shutdown-sync \
ksym-default-timer-unstable-counter-workaround \
ksym-default-timerqueue-add \
ksym-default-timerqueue-del \
ksym-default-timerqueue-iterate-next \
ksym-default-timerqueue-linked-add \
ksym-default-timespec64-add-safe \
ksym-default-timespec64-to-jiffies \
ksym-default-timestamp-truncate \
ksym-default-tipc-dump-done \
ksym-default-tipc-dump-start \
ksym-default-tipc-nl-sk-walk \
ksym-default-tipc-sk-fill-sock-diag \
ksym-default-tls-alert-recv \
ksym-default-tls-client-hello-anon \
ksym-default-tls-client-hello-psk \
ksym-default-tls-client-hello-x509 \
ksym-default-tls-device-sk-destruct \
ksym-default-tls-encrypt-skb \
ksym-default-tls-get-record \
ksym-default-tls-get-record-type \
ksym-default-tls-handshake-cancel \
ksym-default-tls-handshake-close \
ksym-default-tls-offload-tx-resync-request \
ksym-default-tls-server-hello-psk \
ksym-default-tls-server-hello-x509 \
ksym-default-tls-validate-xmit-skb \
ksym-default-tlv320aic23-probe \
ksym-default-tlv320aic23-regmap \
ksym-default-tmc-alloc-sg-table \
ksym-default-tmc-etr-get-buffer \
ksym-default-tmc-etr-get-catu-device \
ksym-default-tmc-etr-remove-catu-ops \
ksym-default-tmc-etr-set-catu-ops \
ksym-default-tmc-free-sg-table \
ksym-default-tmc-sg-table-get-data \
ksym-default-tmc-sg-table-sync-data-range \
ksym-default-tmc-sg-table-sync-table \
ksym-default-tmio-mmc-disable-mmc-irqs \
ksym-default-tmio-mmc-do-data-irq \
ksym-default-tmio-mmc-enable-mmc-irqs \
ksym-default-tmio-mmc-host-alloc \
ksym-default-tmio-mmc-host-probe \
ksym-default-tmio-mmc-host-remove \
ksym-default-tmio-mmc-host-runtime-resume \
ksym-default-tmio-mmc-host-runtime-suspend \
ksym-default-tmio-mmc-irq \
ksym-default-tnum-strn \
ksym-default-to-cxl-dax-region \
ksym-default-to-cxl-decoder \
ksym-default-to-cxl-endpoint-decoder \
ksym-default-to-cxl-nvdimm \
ksym-default-to-cxl-nvdimm-bridge \
ksym-default-to-cxl-pmem-region \
ksym-default-to-cxl-port \
ksym-default-to-cxl-root-decoder \
ksym-default-to-cxl-switch-decoder \
ksym-default-to-cxlfs \
ksym-default-to-drm-sched-fence \
ksym-default-to-hisi-sas-port \
ksym-default-to-nd-btt \
ksym-default-to-nd-dax \
ksym-default-to-nd-desc \
ksym-default-to-nd-pfn \
ksym-default-to-nd-region \
ksym-default-to-ndd \
ksym-default-to-nfit-uuid \
ksym-default-to-nvdimm \
ksym-default-to-nvdimm-bus \
ksym-default-to-nvdimm-bus-dev \
ksym-default-to-of-pinfo \
ksym-default-to-pdrv-policy-node \
ksym-default-to-software-node \
ksym-default-topology-clear-scale-freq-source \
ksym-default-topology-set-scale-freq-source \
ksym-default-topology-update-hw-pressure \
ksym-default-torture-cleanup-begin \
ksym-default-torture-cleanup-end \
ksym-default-torture-hrtimeout-jiffies \
ksym-default-torture-hrtimeout-ms \
ksym-default-torture-hrtimeout-ns \
ksym-default-torture-hrtimeout-s \
ksym-default-torture-hrtimeout-us \
ksym-default-torture-init-begin \
ksym-default-torture-init-end \
ksym-default-torture-kthread-stopping \
ksym-default-torture-must-stop \
ksym-default-torture-must-stop-irq \
ksym-default-torture-num-online-cpus \
ksym-default-torture-offline \
ksym-default-torture-online \
ksym-default-torture-onoff-failures \
ksym-default-torture-onoff-init \
ksym-default-torture-onoff-stats \
ksym-default-torture-random \
ksym-default-torture-sched-set-normal \
ksym-default-torture-sched-setaffinity \
ksym-default-torture-shuffle-init \
ksym-default-torture-shuffle-task-register \
ksym-default-torture-shutdown-absorb \
ksym-default-torture-shutdown-init \
ksym-default-torture-stutter-init \
ksym-default-touch-atime \
ksym-default-touch-buffer \
ksym-default-touch-overlay-get-touchscreen-abs \
ksym-default-touch-overlay-map \
ksym-default-touch-overlay-mapped-touchscreen \
ksym-default-touch-overlay-process-contact \
ksym-default-touch-overlay-sync-frame \
ksym-default-touch-softlockup-watchdog \
ksym-default-touchscreen-parse-properties \
ksym-default-touchscreen-report-pos \
ksym-default-touchscreen-set-mt-pos \
ksym-default-tpm-buf-append \
ksym-default-tpm-buf-append-hmac-session \
ksym-default-tpm-buf-append-name \
ksym-default-tpm-buf-append-u16 \
ksym-default-tpm-buf-append-u32 \
ksym-default-tpm-buf-append-u8 \
ksym-default-tpm-buf-destroy \
ksym-default-tpm-buf-init \
ksym-default-tpm-buf-init-sized \
ksym-default-tpm-buf-length \
ksym-default-tpm-buf-read-u16 \
ksym-default-tpm-buf-read-u32 \
ksym-default-tpm-buf-read-u8 \
ksym-default-tpm-buf-reset \
ksym-default-tpm-buf-reset-sized \
ksym-default-tpm-calc-ordinal-duration \
ksym-default-tpm-chip-alloc \
ksym-default-tpm-chip-bootstrap \
ksym-default-tpm-chip-register \
ksym-default-tpm-chip-start \
ksym-default-tpm-chip-stop \
ksym-default-tpm-chip-unregister \
ksym-default-tpm-crb-ffa-init \
ksym-default-tpm-crb-ffa-start \
ksym-default-tpm-default-chip \
ksym-default-tpm-get-random \
ksym-default-tpm-get-timeouts \
ksym-default-tpm-is-tpm2 \
ksym-default-tpm-pcr-extend \
ksym-default-tpm-pcr-read \
ksym-default-tpm-pm-resume \
ksym-default-tpm-pm-suspend \
ksym-default-tpm-put-ops \
ksym-default-tpm-tis-core-init \
ksym-default-tpm-tis-remove \
ksym-default-tpm-tis-resume \
ksym-default-tpm-transmit-cmd \
ksym-default-tpm-try-get-ops \
ksym-default-tpm1-do-selftest \
ksym-default-tpm1-getcap \
ksym-default-tpm2-find-hash-alg \
ksym-default-tpm2-flush-context \
ksym-default-tpm2-get-cc-attrs-tbl \
ksym-default-tpm2-get-tpm-pt \
ksym-default-tpm2-probe \
ksym-default-tpmm-chip-alloc \
ksym-default-tps65010-config-vdcdc2 \
ksym-default-tps65010-config-vregs1 \
ksym-default-tps65010-set-gpio-out-value \
ksym-default-tps65010-set-led \
ksym-default-tps65010-set-low-pwr \
ksym-default-tps65010-set-vbus-draw \
ksym-default-tps65010-set-vib \
ksym-default-tps65013-set-low-pwr \
ksym-default-tps65224-volatile-table \
ksym-default-tps6594-device-init \
ksym-default-tps6594-volatile-table \
ksym-default-trace-add-event-call \
ksym-default-trace-array-destroy \
ksym-default-trace-array-get-by-name \
ksym-default-trace-array-init-printk \
ksym-default-trace-array-printk \
ksym-default-trace-array-put \
ksym-default-trace-array-set-clr-event \
ksym-default-trace-clock \
ksym-default-trace-clock-global \
ksym-default-trace-clock-jiffies \
ksym-default-trace-clock-local \
ksym-default-trace-define-field \
ksym-default-trace-dump-stack \
ksym-default-trace-event-buffer-commit \
ksym-default-trace-event-buffer-lock-reserve \
ksym-default-trace-event-buffer-reserve \
ksym-default-trace-event-ignore-this-pid \
ksym-default-trace-event-printf \
ksym-default-trace-event-raw-init \
ksym-default-trace-event-reg \
ksym-default-trace-get-event-file \
ksym-default-trace-handle-return \
ksym-default-trace-output-call \
ksym-default-trace-print-array-seq \
ksym-default-trace-print-bitmask-seq \
ksym-default-trace-print-flags-seq \
ksym-default-trace-print-hex-dump-seq \
ksym-default-trace-print-hex-seq \
ksym-default-trace-print-symbols-seq \
ksym-default-trace-printk-init-buffers \
ksym-default-trace-put-event-file \
ksym-default-trace-raw-output-prep \
ksym-default-trace-remove-event-call \
ksym-default-trace-seq-acquire \
ksym-default-trace-seq-bitmask \
ksym-default-trace-seq-bitmask-list \
ksym-default-trace-seq-bprintf \
ksym-default-trace-seq-hex-dump \
ksym-default-trace-seq-path \
ksym-default-trace-seq-printf \
ksym-default-trace-seq-putc \
ksym-default-trace-seq-putmem \
ksym-default-trace-seq-putmem-hex \
ksym-default-trace-seq-puts \
ksym-default-trace-seq-to-user \
ksym-default-trace-seq-vprintf \
ksym-default-trace-set-clr-event \
ksym-default-trace-vbprintk \
ksym-default-trace-vprintk \
ksym-default-tracefs-create-file \
ksym-default-tracepoint-probe-register \
ksym-default-tracepoint-probe-register-prio \
ksym-default-tracepoint-probe-register-prio-may-exist \
ksym-default-tracepoint-probe-unregister \
ksym-default-tracepoint-srcu \
ksym-default-tracing-cond-snapshot-data \
ksym-default-tracing-is-on \
ksym-default-tracing-off \
ksym-default-tracing-on \
ksym-default-tracing-snapshot \
ksym-default-tracing-snapshot-alloc \
ksym-default-tracing-snapshot-cond \
ksym-default-tracing-snapshot-cond-disable \
ksym-default-tracing-snapshot-cond-enable \
ksym-default-transport-add-device \
ksym-default-transport-alloc-session \
ksym-default-transport-alloc-session-tags \
ksym-default-transport-backend-register \
ksym-default-transport-class-register \
ksym-default-transport-class-unregister \
ksym-default-transport-configure-device \
ksym-default-transport-copy-sense-to-cmd \
ksym-default-transport-deregister-session \
ksym-default-transport-deregister-session-configfs \
ksym-default-transport-destroy-device \
ksym-default-transport-free-session \
ksym-default-transport-generic-free-cmd \
ksym-default-transport-generic-handle-tmr \
ksym-default-transport-generic-new-cmd \
ksym-default-transport-generic-request-failure \
ksym-default-transport-init-session \
ksym-default-transport-kmap-data-sg \
ksym-default-transport-kunmap-data-sg \
ksym-default-transport-lookup-cmd-lun \
ksym-default-transport-lookup-tmr-lun \
ksym-default-transport-register-session \
ksym-default-transport-remove-device \
ksym-default-transport-send-check-condition-and-sense \
ksym-default-transport-set-vpd-assoc \
ksym-default-transport-set-vpd-ident \
ksym-default-transport-set-vpd-ident-type \
ksym-default-transport-set-vpd-proto-id \
ksym-default-transport-setup-device \
ksym-default-transport-wait-for-tasks \
ksym-default-truncate-inode-pages \
ksym-default-truncate-inode-pages-final \
ksym-default-truncate-inode-pages-range \
ksym-default-truncate-pagecache \
ksym-default-truncate-pagecache-range \
ksym-default-truncate-setsize \
ksym-default-try-lookup-noperm \
ksym-default-try-module-get \
ksym-default-try-offline-node \
ksym-default-try-test-sas-gpio-gp-bit \
ksym-default-try-to-free-buffers \
ksym-default-try-to-writeback-inodes-sb \
ksym-default-try-wait-for-completion \
ksym-default-ts2020-attach \
ksym-default-ts3a227e-enable-jack-detect \
ksym-default-tsa-serial-connect \
ksym-default-tsa-serial-disconnect \
ksym-default-tsa-serial-get-byphandle \
ksym-default-tsa-serial-get-info \
ksym-default-tsa-serial-get-num \
ksym-default-tsa-serial-put \
ksym-default-tsc200x-groups \
ksym-default-tsc200x-pm-ops \
ksym-default-tsc200x-probe \
ksym-default-tsc200x-regmap-config \
ksym-default-tsm-register \
ksym-default-tsm-report-register \
ksym-default-tsm-report-unregister \
ksym-default-tsm-unregister \
ksym-default-tso-build-data \
ksym-default-tso-build-hdr \
ksym-default-tso-dma-map-cleanup \
ksym-default-tso-dma-map-count \
ksym-default-tso-dma-map-init \
ksym-default-tso-dma-map-next \
ksym-default-tso-start \
ksym-default-ttm-backup-bytes-avail \
ksym-default-ttm-bo-access \
ksym-default-ttm-bo-eviction-valuable \
ksym-default-ttm-bo-fini \
ksym-default-ttm-bo-init-reserved \
ksym-default-ttm-bo-init-validate \
ksym-default-ttm-bo-kmap \
ksym-default-ttm-bo-kmap-try-from-panic \
ksym-default-ttm-bo-kunmap \
ksym-default-ttm-bo-lru-cursor-fini \
ksym-default-ttm-bo-lru-cursor-first \
ksym-default-ttm-bo-lru-cursor-init \
ksym-default-ttm-bo-lru-cursor-next \
ksym-default-ttm-bo-mem-space \
ksym-default-ttm-bo-mmap-obj \
ksym-default-ttm-bo-move-accel-cleanup \
ksym-default-ttm-bo-move-memcpy \
ksym-default-ttm-bo-move-sync-cleanup \
ksym-default-ttm-bo-move-to-lru-tail \
ksym-default-ttm-bo-pin \
ksym-default-ttm-bo-populate \
ksym-default-ttm-bo-set-bulk-move \
ksym-default-ttm-bo-setup-export \
ksym-default-ttm-bo-shrink \
ksym-default-ttm-bo-shrink-avoid-wait \
ksym-default-ttm-bo-shrink-suitable \
ksym-default-ttm-bo-unmap-virtual \
ksym-default-ttm-bo-unpin \
ksym-default-ttm-bo-validate \
ksym-default-ttm-bo-vm-access \
ksym-default-ttm-bo-vm-close \
ksym-default-ttm-bo-vm-dummy-page \
ksym-default-ttm-bo-vm-fault \
ksym-default-ttm-bo-vm-fault-reserved \
ksym-default-ttm-bo-vm-open \
ksym-default-ttm-bo-vm-reserve \
ksym-default-ttm-bo-vmap \
ksym-default-ttm-bo-vunmap \
ksym-default-ttm-bo-wait-ctx \
ksym-default-ttm-device-clear-dma-mappings \
ksym-default-ttm-device-fini \
ksym-default-ttm-device-init \
ksym-default-ttm-device-prepare-hibernation \
ksym-default-ttm-device-swapout \
ksym-default-ttm-eu-backoff-reservation \
ksym-default-ttm-eu-fence-buffer-objects \
ksym-default-ttm-eu-reserve-buffers \
ksym-default-ttm-glob \
ksym-default-ttm-io-prot \
ksym-default-ttm-kmap-iter-iomap-init \
ksym-default-ttm-kmap-iter-tt-init \
ksym-default-ttm-lru-bulk-move-fini \
ksym-default-ttm-lru-bulk-move-init \
ksym-default-ttm-lru-bulk-move-tail \
ksym-default-ttm-lru-walk-for-evict \
ksym-default-ttm-move-memcpy \
ksym-default-ttm-pool-alloc \
ksym-default-ttm-pool-debugfs \
ksym-default-ttm-pool-fini \
ksym-default-ttm-pool-free \
ksym-default-ttm-pool-init \
ksym-default-ttm-range-man-fini-nocheck \
ksym-default-ttm-range-man-init-nocheck \
ksym-default-ttm-resource-fini \
ksym-default-ttm-resource-free \
ksym-default-ttm-resource-init \
ksym-default-ttm-resource-manager-create-debugfs \
ksym-default-ttm-resource-manager-debug \
ksym-default-ttm-resource-manager-evict-all \
ksym-default-ttm-resource-manager-init \
ksym-default-ttm-resource-manager-usage \
ksym-default-ttm-sg-tt-init \
ksym-default-ttm-tt-fini \
ksym-default-ttm-tt-init \
ksym-default-ttm-tt-pages-limit \
ksym-default-ttm-tt-restore \
ksym-default-ttm-tt-setup-backup \
ksym-default-ttpci-budget-debiread \
ksym-default-ttpci-budget-debiwrite \
ksym-default-ttpci-budget-deinit \
ksym-default-ttpci-budget-init \
ksym-default-ttpci-budget-init-hooks \
ksym-default-ttpci-budget-irq10-handler \
ksym-default-ttpci-budget-set-video-port \
ksym-default-ttpci-eeprom-decode-mac \
ksym-default-ttpci-eeprom-parse-mac \
ksym-default-ttusbdecfe-dvbs-attach \
ksym-default-ttusbdecfe-dvbt-attach \
ksym-default-tty-buffer-lock-exclusive \
ksym-default-tty-buffer-request-room \
ksym-default-tty-buffer-set-limit \
ksym-default-tty-buffer-space-avail \
ksym-default-tty-buffer-unlock-exclusive \
ksym-default-tty-chars-in-buffer \
ksym-default-tty-check-change \
ksym-default-tty-dev-name-to-number \
ksym-default-tty-devnum \
ksym-default-tty-do-resize \
ksym-default-tty-driver-flush-buffer \
ksym-default-tty-driver-kref-put \
ksym-default-tty-encode-baud-rate \
ksym-default-tty-find-polling-driver \
ksym-default-tty-flip-buffer-push \
ksym-default-tty-get-char-size \
ksym-default-tty-get-frame-size \
ksym-default-tty-get-icount \
ksym-default-tty-get-pgrp \
ksym-default-tty-get-tiocm \
ksym-default-tty-hangup \
ksym-default-tty-hung-up-p \
ksym-default-tty-init-termios \
ksym-default-tty-kclose \
ksym-default-tty-kopen-exclusive \
ksym-default-tty-kopen-shared \
ksym-default-tty-kref-put \
ksym-default-tty-ldisc-deref \
ksym-default-tty-ldisc-flush \
ksym-default-tty-ldisc-receive-buf \
ksym-default-tty-ldisc-ref \
ksym-default-tty-ldisc-ref-wait \
ksym-default-tty-lock \
ksym-default-tty-mode-ioctl \
ksym-default-tty-name \
ksym-default-tty-perform-flush \
ksym-default-tty-port-alloc-xmit-buf \
ksym-default-tty-port-block-til-ready \
ksym-default-tty-port-carrier-raised \
ksym-default-tty-port-close \
ksym-default-tty-port-close-end \
ksym-default-tty-port-close-start \
ksym-default-tty-port-default-client-ops \
ksym-default-tty-port-destroy \
ksym-default-tty-port-free-xmit-buf \
ksym-default-tty-port-hangup \
ksym-default-tty-port-init \
ksym-default-tty-port-install \
ksym-default-tty-port-link-device \
ksym-default-tty-port-link-wq \
ksym-default-tty-port-lower-dtr-rts \
ksym-default-tty-port-open \
ksym-default-tty-port-put \
ksym-default-tty-port-raise-dtr-rts \
ksym-default-tty-port-register-device \
ksym-default-tty-port-register-device-attr \
ksym-default-tty-port-register-device-attr-serdev \
ksym-default-tty-port-tty-get \
ksym-default-tty-port-tty-set \
ksym-default-tty-port-tty-wakeup \
ksym-default-tty-port-unregister-device \
ksym-default-tty-prepare-flip-string \
ksym-default-tty-put-char \
ksym-default-tty-register-device \
ksym-default-tty-register-device-attr \
ksym-default-tty-register-driver \
ksym-default-tty-register-ldisc \
ksym-default-tty-release-struct \
ksym-default-tty-save-termios \
ksym-default-tty-set-ldisc \
ksym-default-tty-set-termios \
ksym-default-tty-standard-install \
ksym-default-tty-std-termios \
ksym-default-tty-termios-baud-rate \
ksym-default-tty-termios-copy-hw \
ksym-default-tty-termios-encode-baud-rate \
ksym-default-tty-termios-hw-change \
ksym-default-tty-termios-input-baud-rate \
ksym-default-tty-unlock \
ksym-default-tty-unregister-device \
ksym-default-tty-unregister-driver \
ksym-default-tty-unregister-ldisc \
ksym-default-tty-unthrottle \
ksym-default-tty-vhangup \
ksym-default-tty-wait-until-sent \
ksym-default-tty-wakeup \
ksym-default-tty-write-room \
ksym-default-tua6100-attach \
ksym-default-tun-get-socket \
ksym-default-tun-get-tx-ring \
ksym-default-tun-ptr-free \
ksym-default-tuner-count \
ksym-default-tuners \
ksym-default-tveeprom-hauppauge-analog \
ksym-default-tveeprom-read \
ksym-default-twofish-setkey \
ksym-default-typec-altmode-attention \
ksym-default-typec-altmode-enter \
ksym-default-typec-altmode-exit \
ksym-default-typec-altmode-get-partner \
ksym-default-typec-altmode-get-plug \
ksym-default-typec-altmode-notify \
ksym-default-typec-altmode-put-plug \
ksym-default-typec-altmode-set-ops \
ksym-default-typec-altmode-state-update \
ksym-default-typec-altmode-unregister-driver \
ksym-default-typec-altmode-update-active \
ksym-default-typec-altmode-vdm \
ksym-default-typec-altmode2port \
ksym-default-typec-bus \
ksym-default-typec-cable-altmode-enter \
ksym-default-typec-cable-altmode-exit \
ksym-default-typec-cable-altmode-vdm \
ksym-default-typec-cable-get \
ksym-default-typec-cable-is-active \
ksym-default-typec-cable-put \
ksym-default-typec-cable-set-identity \
ksym-default-typec-cable-set-svdm-version \
ksym-default-typec-find-orientation \
ksym-default-typec-find-port-data-role \
ksym-default-typec-find-port-power-role \
ksym-default-typec-find-power-role \
ksym-default-typec-find-pwr-opmode \
ksym-default-typec-get-cable-svdm-version \
ksym-default-typec-get-data-role \
ksym-default-typec-get-drvdata \
ksym-default-typec-get-fw-cap \
ksym-default-typec-get-negotiated-svdm-version \
ksym-default-typec-get-orientation \
ksym-default-typec-match-altmode \
ksym-default-typec-mode-selection-delete \
ksym-default-typec-mode-selection-start \
ksym-default-typec-mux-get-drvdata \
ksym-default-typec-mux-put \
ksym-default-typec-mux-register \
ksym-default-typec-mux-set \
ksym-default-typec-mux-set-drvdata \
ksym-default-typec-mux-unregister \
ksym-default-typec-partner-altmode-dev-type \
ksym-default-typec-partner-register-altmode \
ksym-default-typec-partner-set-identity \
ksym-default-typec-partner-set-num-altmodes \
ksym-default-typec-partner-set-pd-revision \
ksym-default-typec-partner-set-svdm-version \
ksym-default-typec-partner-set-usb-mode \
ksym-default-typec-partner-set-usb-power-delivery \
ksym-default-typec-partner-usb-power-delivery-register \
ksym-default-typec-plug-altmode-dev-type \
ksym-default-typec-plug-register-altmode \
ksym-default-typec-plug-set-num-altmodes \
ksym-default-typec-port-altmode-dev-type \
ksym-default-typec-port-register-altmode \
ksym-default-typec-port-register-altmodes \
ksym-default-typec-port-register-cable-ops \
ksym-default-typec-port-set-usb-mode \
ksym-default-typec-port-set-usb-power-delivery \
ksym-default-typec-register-cable \
ksym-default-typec-register-partner \
ksym-default-typec-register-plug \
ksym-default-typec-register-port \
ksym-default-typec-retimer-get-drvdata \
ksym-default-typec-retimer-put \
ksym-default-typec-retimer-register \
ksym-default-typec-retimer-set \
ksym-default-typec-retimer-unregister \
ksym-default-typec-set-data-role \
ksym-default-typec-set-mode \
ksym-default-typec-set-orientation \
ksym-default-typec-set-pwr-opmode \
ksym-default-typec-set-pwr-role \
ksym-default-typec-set-vconn-role \
ksym-default-typec-switch-get-drvdata \
ksym-default-typec-switch-put \
ksym-default-typec-switch-register \
ksym-default-typec-switch-set \
ksym-default-typec-switch-set-drvdata \
ksym-default-typec-switch-unregister \
ksym-default-typec-unregister-altmode \
ksym-default-typec-unregister-cable \
ksym-default-typec-unregister-partner \
ksym-default-typec-unregister-plug \
ksym-default-typec-unregister-port \
ksym-default-u-audio-get-capture-srate \
ksym-default-u-audio-get-mute \
ksym-default-u-audio-get-playback-srate \
ksym-default-u-audio-get-volume \
ksym-default-u-audio-set-capture-srate \
ksym-default-u-audio-set-mute \
ksym-default-u-audio-set-playback-srate \
ksym-default-u-audio-set-volume \
ksym-default-u-audio-start-capture \
ksym-default-u-audio-start-playback \
ksym-default-u-audio-stop-capture \
ksym-default-u-audio-stop-playback \
ksym-default-u-audio-suspend \
ksym-default-u-boot-env-parse \
ksym-default-uacce-alloc \
ksym-default-uacce-register \
ksym-default-uacce-remove \
ksym-default-uart-add-one-port \
ksym-default-uart-console-device \
ksym-default-uart-console-write \
ksym-default-uart-get-baud-rate \
ksym-default-uart-get-divisor \
ksym-default-uart-get-rs485-mode \
ksym-default-uart-handle-cts-change \
ksym-default-uart-handle-dcd-change \
ksym-default-uart-insert-char \
ksym-default-uart-match-port \
ksym-default-uart-parse-earlycon \
ksym-default-uart-parse-options \
ksym-default-uart-read-and-validate-port-properties \
ksym-default-uart-read-port-properties \
ksym-default-uart-register-driver \
ksym-default-uart-remove-one-port \
ksym-default-uart-resume-port \
ksym-default-uart-set-options \
ksym-default-uart-suspend-port \
ksym-default-uart-try-toggle-sysrq \
ksym-default-uart-unregister-driver \
ksym-default-uart-update-timeout \
ksym-default-uart-write-wakeup \
ksym-default-uart-xchar-out \
ksym-default-ubi-close-volume \
ksym-default-ubi-do-get-device-info \
ksym-default-ubi-get-device-info \
ksym-default-ubi-get-volume-info \
ksym-default-ubi-is-mapped \
ksym-default-ubi-leb-change \
ksym-default-ubi-leb-erase \
ksym-default-ubi-leb-map \
ksym-default-ubi-leb-read \
ksym-default-ubi-leb-read-sg \
ksym-default-ubi-leb-unmap \
ksym-default-ubi-leb-write \
ksym-default-ubi-open-volume \
ksym-default-ubi-open-volume-nm \
ksym-default-ubi-open-volume-path \
ksym-default-ubi-register-volume-notifier \
ksym-default-ubi-sync \
ksym-default-ubi-unregister-volume-notifier \
ksym-default-ucc-fast-disable \
ksym-default-ucc-fast-dump-regs \
ksym-default-ucc-fast-enable \
ksym-default-ucc-fast-free \
ksym-default-ucc-fast-get-qe-cr-subblock \
ksym-default-ucc-fast-init \
ksym-default-ucc-fast-transmit-on-demand \
ksym-default-ucc-mux-set-grant-tsa-bkpt \
ksym-default-ucc-of-parse-tdm \
ksym-default-ucc-set-qe-mux-mii-mng \
ksym-default-ucc-tdm-init \
ksym-default-ucs2-as-utf8 \
ksym-default-ucs2-strlen \
ksym-default-ucs2-strncmp \
ksym-default-ucs2-strnlen \
ksym-default-ucs2-strscpy \
ksym-default-ucs2-strsize \
ksym-default-ucs2-utf8size \
ksym-default-ucsi-connector-change \
ksym-default-ucsi-create \
ksym-default-ucsi-destroy \
ksym-default-ucsi-get-drvdata \
ksym-default-ucsi-notify-common \
ksym-default-ucsi-register \
ksym-default-ucsi-resume \
ksym-default-ucsi-send-command \
ksym-default-ucsi-set-drvdata \
ksym-default-ucsi-suspend \
ksym-default-ucsi-sync-control-common \
ksym-default-ucsi-unregister \
ksym-default-ucsi-write-message-out-command \
ksym-default-udc-basic-init \
ksym-default-udc-enable-dev-setup-interrupts \
ksym-default-udc-irq \
ksym-default-udc-mask-unused-interrupts \
ksym-default-udc-probe \
ksym-default-udc-remove \
ksym-default-udp-bpf-update-proto \
ksym-default-udp-encap-disable \
ksym-default-udp-encap-enable \
ksym-default-udp-flow-hashrnd \
ksym-default-udp-memory-per-cpu-fw-alloc \
ksym-default-udp-prot \
ksym-default-udp-sendmsg \
ksym-default-udp-set-csum \
ksym-default-udp-sock-create4 \
ksym-default-udp-sock-create6 \
ksym-default-udp-tun-rx-dst \
ksym-default-udp-tunnel-drop-rx-port \
ksym-default-udp-tunnel-dst-lookup \
ksym-default-udp-tunnel-nic-ops \
ksym-default-udp-tunnel-notify-add-rx-port \
ksym-default-udp-tunnel-notify-del-rx-port \
ksym-default-udp-tunnel-push-rx-port \
ksym-default-udp-tunnel-sock-release \
ksym-default-udp-tunnel-update-gro-lookup \
ksym-default-udp-tunnel-update-gro-rcv \
ksym-default-udp-tunnel-xmit-skb \
ksym-default-udp-tunnel6-dst-lookup \
ksym-default-udp-tunnel6-xmit-skb \
ksym-default-udp4-hwcsum \
ksym-default-udp4-lib-lookup \
ksym-default-udp6-lib-lookup \
ksym-default-udp6-set-csum \
ksym-default-udpv6-encap-enable \
ksym-default-udpv6-sendmsg \
ksym-default-ufshcd-alloc-host \
ksym-default-ufshcd-apply-tx-eq-settings \
ksym-default-ufshcd-auto-hibern8-update \
ksym-default-ufshcd-change-power-mode \
ksym-default-ufshcd-clkgate-delay-set \
ksym-default-ufshcd-config-pwr-mode \
ksym-default-ufshcd-delay-us \
ksym-default-ufshcd-disable-irq \
ksym-default-ufshcd-dme-configure-adapt \
ksym-default-ufshcd-dme-enable \
ksym-default-ufshcd-dme-get-attr \
ksym-default-ufshcd-dme-reset \
ksym-default-ufshcd-dme-rmw \
ksym-default-ufshcd-dme-set-attr \
ksym-default-ufshcd-dump-regs \
ksym-default-ufshcd-dwc-dme-set-attrs \
ksym-default-ufshcd-dwc-link-startup-notify \
ksym-default-ufshcd-enable-irq \
ksym-default-ufshcd-fixup-dev-quirks \
ksym-default-ufshcd-force-error-recovery \
ksym-default-ufshcd-get-vreg \
ksym-default-ufshcd-hba-enable \
ksym-default-ufshcd-hba-stop \
ksym-default-ufshcd-hold \
ksym-default-ufshcd-init \
ksym-default-ufshcd-init-host-params \
ksym-default-ufshcd-is-hba-active \
ksym-default-ufshcd-link-recovery \
ksym-default-ufshcd-make-hba-operational \
ksym-default-ufshcd-mcq-config-esi \
ksym-default-ufshcd-mcq-config-mac \
ksym-default-ufshcd-mcq-enable \
ksym-default-ufshcd-mcq-enable-esi \
ksym-default-ufshcd-mcq-make-queues-operational \
ksym-default-ufshcd-mcq-poll-cqe-lock \
ksym-default-ufshcd-mcq-queue-cfg-addr \
ksym-default-ufshcd-mcq-read-cqis \
ksym-default-ufshcd-mcq-write-cqis \
ksym-default-ufshcd-negotiate-pwr-params \
ksym-default-ufshcd-opp-config-clks \
ksym-default-ufshcd-parse-gear-limits \
ksym-default-ufshcd-pltfrm-init \
ksym-default-ufshcd-pltfrm-remove \
ksym-default-ufshcd-pm-qos-update \
ksym-default-ufshcd-populate-vreg \
ksym-default-ufshcd-release \
ksym-default-ufshcd-remove \
ksym-default-ufshcd-resume-complete \
ksym-default-ufshcd-runtime-resume \
ksym-default-ufshcd-runtime-suspend \
ksym-default-ufshcd-suspend-prepare \
ksym-default-ufshcd-system-freeze \
ksym-default-ufshcd-system-restore \
ksym-default-ufshcd-system-resume \
ksym-default-ufshcd-system-suspend \
ksym-default-ufshcd-system-thaw \
ksym-default-ufshcd-uic-change-pwr-mode \
ksym-default-ufshcd-uic-hibern8-enter \
ksym-default-ufshcd-uic-hibern8-exit \
ksym-default-ufshcd-update-evt-hist \
ksym-default-ufshcd-us-to-ahit \
ksym-default-uhci-check-and-reset-hc \
ksym-default-uhci-reset-hc \
ksym-default-uio-event-notify \
ksym-default-uio-unregister-device \
ksym-default-ulpi-read \
ksym-default-ulpi-register-interface \
ksym-default-ulpi-unregister-driver \
ksym-default-ulpi-unregister-interface \
ksym-default-ulpi-viewport-access-ops \
ksym-default-ulpi-write \
ksym-default-unix-domain-find \
ksym-default-unix-inq-len \
ksym-default-unix-outq-len \
ksym-default-unix-peer-get \
ksym-default-unload-nls \
ksym-default-unlock-buffer \
ksym-default-unlock-new-inode \
ksym-default-unlock-page \
ksym-default-unlock-system-sleep \
ksym-default-unlock-two-nondirectories \
ksym-default-unmap-mapping-pages \
ksym-default-unmap-mapping-range \
ksym-default-unpack \
ksym-default-unpack-fields-u16 \
ksym-default-unpack-fields-u8 \
ksym-default-unpin-folio \
ksym-default-unpin-folios \
ksym-default-unpin-user-folio \
ksym-default-unpin-user-page \
ksym-default-unpin-user-page-range-dirty-lock \
ksym-default-unpin-user-pages \
ksym-default-unpin-user-pages-dirty-lock \
ksym-default-unpoison-memory \
ksym-default-unregister-acpi-bus-type \
ksym-default-unregister-acpi-hed-notifier \
ksym-default-unregister-acpi-notifier \
ksym-default-unregister-asymmetric-key-parser \
ksym-default-unregister-atmdevice-notifier \
ksym-default-unregister-binfmt \
ksym-default-unregister-blkdev \
ksym-default-unregister-blocking-lsm-notifier \
ksym-default-unregister-c-can-dev \
ksym-default-unregister-candev \
ksym-default-unregister-cdrom \
ksym-default-unregister-chrdev-region \
ksym-default-unregister-console \
ksym-default-unregister-dcbevent-notifier \
ksym-default-unregister-die-notifier \
ksym-default-unregister-dpll-notifier \
ksym-default-unregister-fib-notifier \
ksym-default-unregister-filesystem \
ksym-default-unregister-firmware-config-sysctl \
ksym-default-unregister-framebuffer \
ksym-default-unregister-ftrace-direct \
ksym-default-unregister-ftrace-export \
ksym-default-unregister-ftrace-function \
ksym-default-unregister-gadget-item \
ksym-default-unregister-hdlc-device \
ksym-default-unregister-hdlc-protocol \
ksym-default-unregister-hw-breakpoint \
ksym-default-unregister-ife-op \
ksym-default-unregister-inet6addr-notifier \
ksym-default-unregister-inet6addr-validator-notifier \
ksym-default-unregister-inetaddr-notifier \
ksym-default-unregister-inetaddr-validator-notifier \
ksym-default-unregister-ip-vs-app \
ksym-default-unregister-ip-vs-pe \
ksym-default-unregister-ip-vs-scheduler \
ksym-default-unregister-key-type \
ksym-default-unregister-keyboard-notifier \
ksym-default-unregister-kprobe \
ksym-default-unregister-kprobes \
ksym-default-unregister-kretprobe \
ksym-default-unregister-kretprobes \
ksym-default-unregister-md-submodule \
ksym-default-unregister-memory-notifier \
ksym-default-unregister-module-notifier \
ksym-default-unregister-mt-adistance-algorithm \
ksym-default-unregister-mtd-chip-driver \
ksym-default-unregister-mtd-user \
ksym-default-unregister-net-sysctl-table \
ksym-default-unregister-netdev \
ksym-default-unregister-netdevice-many \
ksym-default-unregister-netdevice-notifier \
ksym-default-unregister-netdevice-notifier-dev-net \
ksym-default-unregister-netdevice-notifier-net \
ksym-default-unregister-netdevice-queue \
ksym-default-unregister-netevent-notifier \
ksym-default-unregister-nexthop-notifier \
ksym-default-unregister-nfs-version \
ksym-default-unregister-nls \
ksym-default-unregister-node-notifier \
ksym-default-unregister-nvdimm-pmu \
ksym-default-unregister-oom-notifier \
ksym-default-unregister-pernet-device \
ksym-default-unregister-pernet-subsys \
ksym-default-unregister-pfn-address-space \
ksym-default-unregister-platform-power-off \
ksym-default-unregister-pm-notifier \
ksym-default-unregister-pppox-proto \
ksym-default-unregister-pstore-device \
ksym-default-unregister-pstore-zone \
ksym-default-unregister-qdisc \
ksym-default-unregister-quota-format \
ksym-default-unregister-random-vmfork-notifier \
ksym-default-unregister-reboot-notifier \
ksym-default-unregister-restart-handler \
ksym-default-unregister-rpmsg-driver \
ksym-default-unregister-sja1000dev \
ksym-default-unregister-snap-client \
ksym-default-unregister-sound-dsp \
ksym-default-unregister-sound-mixer \
ksym-default-unregister-sound-special \
ksym-default-unregister-switchdev-blocking-notifier \
ksym-default-unregister-switchdev-notifier \
ksym-default-unregister-sys-off-handler \
ksym-default-unregister-syscore \
ksym-default-unregister-sysctl-table \
ksym-default-unregister-sysrq-key \
ksym-default-unregister-tcf-proto-ops \
ksym-default-unregister-trace-event \
ksym-default-unregister-tracepoint-module-notifier \
ksym-default-unregister-virtio-device \
ksym-default-unregister-virtio-driver \
ksym-default-unregister-vmap-purge-notifier \
ksym-default-unregister-vmcore-cb \
ksym-default-unregister-vt-notifier \
ksym-default-unregister-wide-hw-breakpoint \
ksym-default-unshare-fs-struct \
ksym-default-uobj-destroy \
ksym-default-up \
ksym-default-up-read \
ksym-default-up-write \
ksym-default-update-devfreq \
ksym-default-update-region \
ksym-default-uprobe-register \
ksym-default-uprobe-unregister-nosync \
ksym-default-uprobe-unregister-sync \
ksym-default-usb-acpi-port-lpm-incapable \
ksym-default-usb-acpi-power-manageable \
ksym-default-usb-acpi-set-power-state \
ksym-default-usb-add-config \
ksym-default-usb-add-config-only \
ksym-default-usb-add-function \
ksym-default-usb-add-gadget \
ksym-default-usb-add-gadget-udc \
ksym-default-usb-add-gadget-udc-release \
ksym-default-usb-add-hcd \
ksym-default-usb-add-phy \
ksym-default-usb-add-phy-dev \
ksym-default-usb-alloc-coherent \
ksym-default-usb-alloc-dev \
ksym-default-usb-alloc-noncoherent \
ksym-default-usb-alloc-streams \
ksym-default-usb-alloc-urb \
ksym-default-usb-altnum-to-altsetting \
ksym-default-usb-amd-dev-put \
ksym-default-usb-amd-hang-symptom-quirk \
ksym-default-usb-amd-prefetch-quirk \
ksym-default-usb-amd-pt-check-port \
ksym-default-usb-amd-quirk-pll-check \
ksym-default-usb-amd-quirk-pll-disable \
ksym-default-usb-amd-quirk-pll-enable \
ksym-default-usb-anchor-empty \
ksym-default-usb-anchor-resume-wakeups \
ksym-default-usb-anchor-suspend-wakeups \
ksym-default-usb-anchor-urb \
ksym-default-usb-asmedia-modifyflowcontrol \
ksym-default-usb-assign-descriptors \
ksym-default-usb-autopm-get-interface \
ksym-default-usb-autopm-get-interface-async \
ksym-default-usb-autopm-get-interface-no-resume \
ksym-default-usb-autopm-put-interface \
ksym-default-usb-autopm-put-interface-async \
ksym-default-usb-autopm-put-interface-no-suspend \
ksym-default-usb-block-urb \
ksym-default-usb-bulk-msg \
ksym-default-usb-bulk-msg-killable \
ksym-default-usb-bus-idr \
ksym-default-usb-bus-idr-lock \
ksym-default-usb-bus-start-enum \
ksym-default-usb-cache-string \
ksym-default-usb-calc-bus-time \
ksym-default-usb-cdc-wdm-register \
ksym-default-usb-check-bulk-endpoints \
ksym-default-usb-check-int-endpoints \
ksym-default-usb-choose-configuration \
ksym-default-usb-clear-halt \
ksym-default-usb-composite-overwrite-options \
ksym-default-usb-composite-probe \
ksym-default-usb-composite-setup-continue \
ksym-default-usb-composite-unregister \
ksym-default-usb-control-msg \
ksym-default-usb-control-msg-recv \
ksym-default-usb-control-msg-send \
ksym-default-usb-copy-descriptors \
ksym-default-usb-create-hcd \
ksym-default-usb-create-shared-hcd \
ksym-default-usb-cypress-load-firmware \
ksym-default-usb-debug-root \
ksym-default-usb-decode-ctrl \
ksym-default-usb-decode-interval \
ksym-default-usb-del-gadget \
ksym-default-usb-del-gadget-udc \
ksym-default-usb-deregister \
ksym-default-usb-deregister-dev \
ksym-default-usb-deregister-device-driver \
ksym-default-usb-descriptor-fillbuf \
ksym-default-usb-device-match-id \
ksym-default-usb-disable-autosuspend \
ksym-default-usb-disable-lpm \
ksym-default-usb-disable-ltm \
ksym-default-usb-disable-xhci-ports \
ksym-default-usb-disabled \
ksym-default-usb-driver-claim-interface \
ksym-default-usb-driver-release-interface \
ksym-default-usb-driver-set-configuration \
ksym-default-usb-dynids-lock \
ksym-default-usb-enable-autosuspend \
ksym-default-usb-enable-intel-xhci-ports \
ksym-default-usb-enable-lpm \
ksym-default-usb-enable-ltm \
ksym-default-usb-endpoint-is-hs-isoc-double \
ksym-default-usb-endpoint-max-periodic-payload \
ksym-default-usb-ep-alloc-request \
ksym-default-usb-ep-autoconfig \
ksym-default-usb-ep-autoconfig-release \
ksym-default-usb-ep-autoconfig-reset \
ksym-default-usb-ep-autoconfig-ss \
ksym-default-usb-ep-clear-halt \
ksym-default-usb-ep-dequeue \
ksym-default-usb-ep-disable \
ksym-default-usb-ep-enable \
ksym-default-usb-ep-fifo-flush \
ksym-default-usb-ep-fifo-status \
ksym-default-usb-ep-free-request \
ksym-default-usb-ep-queue \
ksym-default-usb-ep-set-halt \
ksym-default-usb-ep-set-maxpacket-limit \
ksym-default-usb-ep-set-wedge \
ksym-default-usb-ep-type-string \
ksym-default-usb-ep0-reinit \
ksym-default-usb-find-alt-setting \
ksym-default-usb-find-common-endpoints \
ksym-default-usb-find-common-endpoints-reverse \
ksym-default-usb-find-interface \
ksym-default-usb-for-each-dev \
ksym-default-usb-free-all-descriptors \
ksym-default-usb-free-coherent \
ksym-default-usb-free-noncoherent \
ksym-default-usb-free-streams \
ksym-default-usb-free-urb \
ksym-default-usb-func-wakeup \
ksym-default-usb-function-activate \
ksym-default-usb-function-deactivate \
ksym-default-usb-function-register \
ksym-default-usb-function-unregister \
ksym-default-usb-gadget-activate \
ksym-default-usb-gadget-check-config \
ksym-default-usb-gadget-clear-selfpowered \
ksym-default-usb-gadget-connect \
ksym-default-usb-gadget-deactivate \
ksym-default-usb-gadget-disconnect \
ksym-default-usb-gadget-ep-match-desc \
ksym-default-usb-gadget-frame-number \
ksym-default-usb-gadget-get-string \
ksym-default-usb-gadget-giveback-request \
ksym-default-usb-gadget-map-request \
ksym-default-usb-gadget-map-request-by-dev \
ksym-default-usb-gadget-register-driver-owner \
ksym-default-usb-gadget-set-remote-wakeup \
ksym-default-usb-gadget-set-selfpowered \
ksym-default-usb-gadget-set-state \
ksym-default-usb-gadget-udc-reset \
ksym-default-usb-gadget-unmap-request \
ksym-default-usb-gadget-unmap-request-by-dev \
ksym-default-usb-gadget-unregister-driver \
ksym-default-usb-gadget-vbus-connect \
ksym-default-usb-gadget-vbus-disconnect \
ksym-default-usb-gadget-vbus-draw \
ksym-default-usb-gadget-wakeup \
ksym-default-usb-gen-phy-init \
ksym-default-usb-gen-phy-shutdown \
ksym-default-usb-get-current-frame-number \
ksym-default-usb-get-descriptor \
ksym-default-usb-get-dev \
ksym-default-usb-get-dr-mode \
ksym-default-usb-get-from-anchor \
ksym-default-usb-get-function \
ksym-default-usb-get-function-instance \
ksym-default-usb-get-gadget-udc-name \
ksym-default-usb-get-hcd \
ksym-default-usb-get-intf \
ksym-default-usb-get-maximum-speed \
ksym-default-usb-get-maximum-ssp-rate \
ksym-default-usb-get-phy \
ksym-default-usb-get-role-switch-default-mode \
ksym-default-usb-get-status \
ksym-default-usb-get-urb \
ksym-default-usb-gstrings-attach \
ksym-default-usb-hc-died \
ksym-default-usb-hcd-amd-remote-wakeup-quirk \
ksym-default-usb-hcd-check-unlink-urb \
ksym-default-usb-hcd-end-port-resume \
ksym-default-usb-hcd-giveback-urb \
ksym-default-usb-hcd-irq \
ksym-default-usb-hcd-is-primary-hcd \
ksym-default-usb-hcd-link-urb-to-ep \
ksym-default-usb-hcd-map-urb-for-dma \
ksym-default-usb-hcd-pci-pm-ops \
ksym-default-usb-hcd-pci-probe \
ksym-default-usb-hcd-pci-remove \
ksym-default-usb-hcd-pci-shutdown \
ksym-default-usb-hcd-platform-shutdown \
ksym-default-usb-hcd-poll-rh-status \
ksym-default-usb-hcd-resume-root-hub \
ksym-default-usb-hcd-setup-local-mem \
ksym-default-usb-hcd-start-port-resume \
ksym-default-usb-hcd-unlink-urb-from-ep \
ksym-default-usb-hcd-unmap-urb-for-dma \
ksym-default-usb-hcd-unmap-urb-setup-for-dma \
ksym-default-usb-hub-claim-port \
ksym-default-usb-hub-clear-tt-buffer \
ksym-default-usb-hub-find-child \
ksym-default-usb-hub-release-port \
ksym-default-usb-ifnum-to-if \
ksym-default-usb-init-urb \
ksym-default-usb-initialize-gadget \
ksym-default-usb-interface-id \
ksym-default-usb-interrupt-msg \
ksym-default-usb-intf-get-dma-device \
ksym-default-usb-kill-anchored-urbs \
ksym-default-usb-kill-urb \
ksym-default-usb-led-activity \
ksym-default-usb-lock-device-for-reset \
ksym-default-usb-match-id \
ksym-default-usb-match-one-id \
ksym-default-usb-mon-deregister \
ksym-default-usb-mon-register \
ksym-default-usb-of-get-companion-dev \
ksym-default-usb-of-get-connect-type \
ksym-default-usb-of-get-device-node \
ksym-default-usb-of-get-interface-node \
ksym-default-usb-of-has-combined-node \
ksym-default-usb-offload-check \
ksym-default-usb-offload-get \
ksym-default-usb-offload-put \
ksym-default-usb-offload-set-pm-locked \
ksym-default-usb-os-desc-prepare-interf-dir \
ksym-default-usb-otg-descriptor-alloc \
ksym-default-usb-otg-descriptor-init \
ksym-default-usb-otg-state-string \
ksym-default-usb-phy-gen-create-phy \
ksym-default-usb-phy-generic-register \
ksym-default-usb-phy-generic-unregister \
ksym-default-usb-phy-get-charger-current \
ksym-default-usb-phy-roothub-alloc \
ksym-default-usb-phy-roothub-alloc-usb3-phy \
ksym-default-usb-phy-roothub-calibrate \
ksym-default-usb-phy-roothub-exit \
ksym-default-usb-phy-roothub-init \
ksym-default-usb-phy-roothub-notify-connect \
ksym-default-usb-phy-roothub-notify-disconnect \
ksym-default-usb-phy-roothub-power-off \
ksym-default-usb-phy-roothub-power-on \
ksym-default-usb-phy-roothub-resume \
ksym-default-usb-phy-roothub-set-mode \
ksym-default-usb-phy-roothub-suspend \
ksym-default-usb-phy-set-charger-current \
ksym-default-usb-phy-set-charger-state \
ksym-default-usb-phy-set-event \
ksym-default-usb-pipe-type-check \
ksym-default-usb-poison-anchored-urbs \
ksym-default-usb-poison-urb \
ksym-default-usb-power-delivery-link-device \
ksym-default-usb-power-delivery-register \
ksym-default-usb-power-delivery-register-capabilities \
ksym-default-usb-power-delivery-unlink-device \
ksym-default-usb-power-delivery-unregister \
ksym-default-usb-power-delivery-unregister-capabilities \
ksym-default-usb-put-dev \
ksym-default-usb-put-function \
ksym-default-usb-put-function-instance \
ksym-default-usb-put-hcd \
ksym-default-usb-put-intf \
ksym-default-usb-put-phy \
ksym-default-usb-queue-reset-device \
ksym-default-usb-register-dev \
ksym-default-usb-register-device-driver \
ksym-default-usb-register-driver \
ksym-default-usb-register-notify \
ksym-default-usb-remove-function \
ksym-default-usb-remove-hcd \
ksym-default-usb-remove-phy \
ksym-default-usb-reset-configuration \
ksym-default-usb-reset-device \
ksym-default-usb-reset-endpoint \
ksym-default-usb-role-string \
ksym-default-usb-role-switch-find-by-fwnode \
ksym-default-usb-role-switch-get \
ksym-default-usb-role-switch-get-drvdata \
ksym-default-usb-role-switch-get-role \
ksym-default-usb-role-switch-put \
ksym-default-usb-role-switch-register \
ksym-default-usb-role-switch-set-drvdata \
ksym-default-usb-role-switch-set-role \
ksym-default-usb-role-switch-unregister \
ksym-default-usb-root-hub-lost-power \
ksym-default-usb-scuttle-anchored-urbs \
ksym-default-usb-serial-claim-interface \
ksym-default-usb-serial-deregister-drivers \
ksym-default-usb-serial-generic-chars-in-buffer \
ksym-default-usb-serial-generic-close \
ksym-default-usb-serial-generic-get-icount \
ksym-default-usb-serial-generic-open \
ksym-default-usb-serial-generic-process-read-urb \
ksym-default-usb-serial-generic-read-bulk-callback \
ksym-default-usb-serial-generic-resume \
ksym-default-usb-serial-generic-submit-read-urbs \
ksym-default-usb-serial-generic-throttle \
ksym-default-usb-serial-generic-tiocmiwait \
ksym-default-usb-serial-generic-unthrottle \
ksym-default-usb-serial-generic-wait-until-sent \
ksym-default-usb-serial-generic-write \
ksym-default-usb-serial-generic-write-bulk-callback \
ksym-default-usb-serial-generic-write-start \
ksym-default-usb-serial-handle-dcd-change \
ksym-default-usb-serial-port-softint \
ksym-default-usb-serial-resume \
ksym-default-usb-serial-suspend \
ksym-default-usb-set-configuration \
ksym-default-usb-set-device-state \
ksym-default-usb-set-interface \
ksym-default-usb-set-wireless-status \
ksym-default-usb-sg-cancel \
ksym-default-usb-sg-init \
ksym-default-usb-sg-wait \
ksym-default-usb-show-dynids \
ksym-default-usb-speed-string \
ksym-default-usb-state-string \
ksym-default-usb-stor-Bulk-reset \
ksym-default-usb-stor-Bulk-transport \
ksym-default-usb-stor-CB-reset \
ksym-default-usb-stor-CB-transport \
ksym-default-usb-stor-access-xfer-buf \
ksym-default-usb-stor-adjust-quirks \
ksym-default-usb-stor-bulk-srb \
ksym-default-usb-stor-bulk-transfer-buf \
ksym-default-usb-stor-bulk-transfer-sg \
ksym-default-usb-stor-clear-halt \
ksym-default-usb-stor-control-msg \
ksym-default-usb-stor-ctrl-transfer \
ksym-default-usb-stor-disconnect \
ksym-default-usb-stor-host-template-init \
ksym-default-usb-stor-post-reset \
ksym-default-usb-stor-pre-reset \
ksym-default-usb-stor-probe1 \
ksym-default-usb-stor-probe2 \
ksym-default-usb-stor-reset-resume \
ksym-default-usb-stor-resume \
ksym-default-usb-stor-sense-invalidCDB \
ksym-default-usb-stor-set-xfer-buf \
ksym-default-usb-stor-suspend \
ksym-default-usb-stor-transparent-scsi-command \
ksym-default-usb-store-new-id \
ksym-default-usb-string \
ksym-default-usb-string-id \
ksym-default-usb-string-ids-n \
ksym-default-usb-string-ids-tab \
ksym-default-usb-submit-urb \
ksym-default-usb-udc-vbus-handler \
ksym-default-usb-unanchor-urb \
ksym-default-usb-unlink-urb \
ksym-default-usb-unlocked-disable-lpm \
ksym-default-usb-unlocked-enable-lpm \
ksym-default-usb-unpoison-anchored-urbs \
ksym-default-usb-unpoison-urb \
ksym-default-usb-unregister-notify \
ksym-default-usb-urb-ep-type-check \
ksym-default-usb-validate-langid \
ksym-default-usb-wait-anchor-empty-timeout \
ksym-default-usb-wakeup-enabled-descendants \
ksym-default-usb-wakeup-notification \
ksym-default-usb-wwan-chars-in-buffer \
ksym-default-usb-wwan-close \
ksym-default-usb-wwan-dtr-rts \
ksym-default-usb-wwan-open \
ksym-default-usb-wwan-port-probe \
ksym-default-usb-wwan-port-remove \
ksym-default-usb-wwan-resume \
ksym-default-usb-wwan-suspend \
ksym-default-usb-wwan-tiocmget \
ksym-default-usb-wwan-tiocmset \
ksym-default-usb-wwan-write \
ksym-default-usb-wwan-write-room \
ksym-default-usb4-usb3-port-match \
ksym-default-usbatm-usb-disconnect \
ksym-default-usbatm-usb-probe \
ksym-default-usbip-alloc-iso-desc-pdu \
ksym-default-usbip-debug-flag \
ksym-default-usbip-dump-header \
ksym-default-usbip-dump-urb \
ksym-default-usbip-event-add \
ksym-default-usbip-event-happened \
ksym-default-usbip-header-correct-endian \
ksym-default-usbip-in-eh \
ksym-default-usbip-pack-pdu \
ksym-default-usbip-pad-iso \
ksym-default-usbip-recv \
ksym-default-usbip-recv-iso \
ksym-default-usbip-recv-xbuff \
ksym-default-usbip-start-eh \
ksym-default-usbip-stop-eh \
ksym-default-usbnet-cdc-bind \
ksym-default-usbnet-cdc-status \
ksym-default-usbnet-cdc-unbind \
ksym-default-usbnet-cdc-update-filter \
ksym-default-usbnet-cdc-zte-rx-fixup \
ksym-default-usbnet-change-mtu \
ksym-default-usbnet-defer-kevent \
ksym-default-usbnet-device-suggests-idle \
ksym-default-usbnet-disconnect \
ksym-default-usbnet-ether-cdc-bind \
ksym-default-usbnet-generic-cdc-bind \
ksym-default-usbnet-get-drvinfo \
ksym-default-usbnet-get-endpoints \
ksym-default-usbnet-get-ethernet-addr \
ksym-default-usbnet-get-link \
ksym-default-usbnet-get-link-ksettings-internal \
ksym-default-usbnet-get-link-ksettings-mii \
ksym-default-usbnet-get-msglevel \
ksym-default-usbnet-link-change \
ksym-default-usbnet-manage-power \
ksym-default-usbnet-mii-ioctl \
ksym-default-usbnet-nway-reset \
ksym-default-usbnet-open \
ksym-default-usbnet-pause-rx \
ksym-default-usbnet-probe \
ksym-default-usbnet-purge-paused-rxq \
ksym-default-usbnet-read-cmd \
ksym-default-usbnet-read-cmd-nopm \
ksym-default-usbnet-resume \
ksym-default-usbnet-resume-rx \
ksym-default-usbnet-set-link-ksettings-mii \
ksym-default-usbnet-set-msglevel \
ksym-default-usbnet-set-rx-mode \
ksym-default-usbnet-skb-return \
ksym-default-usbnet-start-xmit \
ksym-default-usbnet-status-start \
ksym-default-usbnet-status-stop \
ksym-default-usbnet-stop \
ksym-default-usbnet-suspend \
ksym-default-usbnet-tx-timeout \
ksym-default-usbnet-unlink-rx-urbs \
ksym-default-usbnet-update-max-qlen \
ksym-default-usbnet-write-cmd \
ksym-default-usbnet-write-cmd-async \
ksym-default-usbnet-write-cmd-nopm \
ksym-default-user-describe \
ksym-default-user-destroy \
ksym-default-user-free-preparse \
ksym-default-user-path-at \
ksym-default-user-preparse \
ksym-default-user-read \
ksym-default-user-revoke \
ksym-default-user-update \
ksym-default-usermodehelper-read-lock-wait \
ksym-default-usermodehelper-read-trylock \
ksym-default-usermodehelper-read-unlock \
ksym-default-usleep-range-state \
ksym-default-utf16s-to-utf8s \
ksym-default-utf32-to-utf8 \
ksym-default-utf8-casefold \
ksym-default-utf8-casefold-hash \
ksym-default-utf8-data-table \
ksym-default-utf8-load \
ksym-default-utf8-normalize \
ksym-default-utf8-parse-version \
ksym-default-utf8-strncasecmp \
ksym-default-utf8-strncasecmp-folded \
ksym-default-utf8-strncmp \
ksym-default-utf8-to-utf32 \
ksym-default-utf8-unload \
ksym-default-utf8-validate \
ksym-default-utf8s-to-utf16s \
ksym-default-uuid-gen \
ksym-default-uuid-is-valid \
ksym-default-uuid-null \
ksym-default-uuid-parse \
ksym-default-uvc-format-by-guid \
ksym-default-uverbs-copy-to \
ksym-default-uverbs-copy-to-struct-or-zero \
ksym-default-uverbs-destroy-def-handler \
ksym-default-uverbs-fd-class \
ksym-default-uverbs-finalize-object \
ksym-default-uverbs-finalize-uobj-create \
ksym-default-uverbs-get-buffer-desc \
ksym-default-uverbs-get-cleared-udata \
ksym-default-uverbs-get-flags32 \
ksym-default-uverbs-get-flags64 \
ksym-default-uverbs-get-uobject-from-file \
ksym-default-uverbs-idr-class \
ksym-default-uverbs-try-lock-object \
ksym-default-uverbs-uobject-fd-release \
ksym-default-uverbs-uobject-put \
ksym-default-uverbs-uobject-release \
ksym-default-v4l-bound-align-image \
ksym-default-v4l-disable-media-source \
ksym-default-v4l-enable-media-source \
ksym-default-v4l-printk-ioctl \
ksym-default-v4l-vb2q-enable-media-source \
ksym-default-v4l2-apply-frmsize-constraints \
ksym-default-v4l2-async-connection-unique \
ksym-default-v4l2-async-nf-cleanup \
ksym-default-v4l2-async-nf-init \
ksym-default-v4l2-async-nf-register \
ksym-default-v4l2-async-nf-unregister \
ksym-default-v4l2-async-subdev-endpoint-add \
ksym-default-v4l2-async-subdev-nf-init \
ksym-default-v4l2-async-unregister-subdev \
ksym-default-v4l2-calc-aspect-ratio \
ksym-default-v4l2-calc-timeperframe \
ksym-default-v4l2-compat-ioctl32 \
ksym-default-v4l2-create-fwnode-links \
ksym-default-v4l2-create-fwnode-links-to-pad \
ksym-default-v4l2-ctrl-activate \
ksym-default-v4l2-ctrl-add-handler \
ksym-default-v4l2-ctrl-auto-cluster \
ksym-default-v4l2-ctrl-cluster \
ksym-default-v4l2-ctrl-fill \
ksym-default-v4l2-ctrl-find \
ksym-default-v4l2-ctrl-g-ctrl \
ksym-default-v4l2-ctrl-g-ctrl-int64 \
ksym-default-v4l2-ctrl-get-int-menu \
ksym-default-v4l2-ctrl-get-menu \
ksym-default-v4l2-ctrl-get-name \
ksym-default-v4l2-ctrl-handler-free \
ksym-default-v4l2-ctrl-handler-init-class \
ksym-default-v4l2-ctrl-handler-log-status \
ksym-default-v4l2-ctrl-handler-setup \
ksym-default-v4l2-ctrl-log-status \
ksym-default-v4l2-ctrl-merge \
ksym-default-v4l2-ctrl-new-custom \
ksym-default-v4l2-ctrl-new-fwnode-properties \
ksym-default-v4l2-ctrl-new-int-menu \
ksym-default-v4l2-ctrl-new-std \
ksym-default-v4l2-ctrl-new-std-compound \
ksym-default-v4l2-ctrl-new-std-menu \
ksym-default-v4l2-ctrl-new-std-menu-items \
ksym-default-v4l2-ctrl-notify \
ksym-default-v4l2-ctrl-poll \
ksym-default-v4l2-ctrl-query-fill \
ksym-default-v4l2-ctrl-radio-filter \
ksym-default-v4l2-ctrl-replace \
ksym-default-v4l2-ctrl-request-complete \
ksym-default-v4l2-ctrl-request-hdl-ctrl-find \
ksym-default-v4l2-ctrl-request-hdl-find \
ksym-default-v4l2-ctrl-request-setup \
ksym-default-v4l2-ctrl-sub-ev-ops \
ksym-default-v4l2-ctrl-subdev-log-status \
ksym-default-v4l2-ctrl-subdev-subscribe-event \
ksym-default-v4l2-ctrl-subscribe-event \
ksym-default-v4l2-ctrl-type-op-equal \
ksym-default-v4l2-ctrl-type-op-init \
ksym-default-v4l2-ctrl-type-op-log \
ksym-default-v4l2-ctrl-type-op-validate \
ksym-default-v4l2-debugfs-if-alloc \
ksym-default-v4l2-debugfs-if-free \
ksym-default-v4l2-debugfs-root \
ksym-default-v4l2-detect-cvt \
ksym-default-v4l2-detect-gtf \
ksym-default-v4l2-device-disconnect \
ksym-default-v4l2-device-put \
ksym-default-v4l2-device-register \
ksym-default-v4l2-device-set-name \
ksym-default-v4l2-device-unregister \
ksym-default-v4l2-device-unregister-subdev \
ksym-default-v4l2-dv-timings-aspect-ratio \
ksym-default-v4l2-dv-timings-presets \
ksym-default-v4l2-enum-dv-timings-cap \
ksym-default-v4l2-event-dequeue \
ksym-default-v4l2-event-pending \
ksym-default-v4l2-event-queue \
ksym-default-v4l2-event-queue-fh \
ksym-default-v4l2-event-subdev-unsubscribe \
ksym-default-v4l2-event-subscribe \
ksym-default-v4l2-event-unsubscribe \
ksym-default-v4l2-event-unsubscribe-all \
ksym-default-v4l2-event-wake-all \
ksym-default-v4l2-fh-add \
ksym-default-v4l2-fh-del \
ksym-default-v4l2-fh-exit \
ksym-default-v4l2-fh-init \
ksym-default-v4l2-fh-is-singular \
ksym-default-v4l2-fh-open \
ksym-default-v4l2-fh-release \
ksym-default-v4l2-field-names \
ksym-default-v4l2-fill-pixfmt \
ksym-default-v4l2-fill-pixfmt-mp \
ksym-default-v4l2-fill-pixfmt-mp-aligned \
ksym-default-v4l2-find-dv-timings-cap \
ksym-default-v4l2-find-dv-timings-cea861-vic \
ksym-default-v4l2-format-info \
ksym-default-v4l2-fraction-to-interval \
ksym-default-v4l2-fwnode-connector-add-link \
ksym-default-v4l2-fwnode-connector-free \
ksym-default-v4l2-fwnode-connector-parse \
ksym-default-v4l2-fwnode-device-parse \
ksym-default-v4l2-fwnode-endpoint-alloc-parse \
ksym-default-v4l2-fwnode-endpoint-free \
ksym-default-v4l2-fwnode-endpoint-parse \
ksym-default-v4l2-fwnode-parse-link \
ksym-default-v4l2-fwnode-put-link \
ksym-default-v4l2-g-ctrl \
ksym-default-v4l2-g-ext-ctrls \
ksym-default-v4l2-g-parm-cap \
ksym-default-v4l2-get-active-data-lanes \
ksym-default-v4l2-get-edid-phys-addr \
ksym-default-v4l2-get-link-freq \
ksym-default-v4l2-h264-build-b-ref-lists \
ksym-default-v4l2-h264-build-p-ref-list \
ksym-default-v4l2-h264-init-reflist-builder \
ksym-default-v4l2-hdmi-rx-colorimetry \
ksym-default-v4l2-i2c-new-subdev \
ksym-default-v4l2-i2c-new-subdev-board \
ksym-default-v4l2-i2c-subdev-addr \
ksym-default-v4l2-i2c-subdev-init \
ksym-default-v4l2-i2c-subdev-set-name \
ksym-default-v4l2-i2c-tuner-addrs \
ksym-default-v4l2-isp-params-validate-buffer \
ksym-default-v4l2-isp-params-validate-buffer-size \
ksym-default-v4l2-jpeg-parse-header \
ksym-default-v4l2-jpeg-ref-table-chroma-ac-ht \
ksym-default-v4l2-jpeg-ref-table-chroma-dc-ht \
ksym-default-v4l2-jpeg-ref-table-chroma-qt \
ksym-default-v4l2-jpeg-ref-table-luma-ac-ht \
ksym-default-v4l2-jpeg-ref-table-luma-dc-ht \
ksym-default-v4l2-jpeg-ref-table-luma-qt \
ksym-default-v4l2-jpeg-zigzag-scan-index \
ksym-default-v4l2-link-freq-to-bitmap \
ksym-default-v4l2-m2m-buf-copy-metadata \
ksym-default-v4l2-m2m-buf-done-and-job-finish \
ksym-default-v4l2-m2m-buf-queue \
ksym-default-v4l2-m2m-buf-remove \
ksym-default-v4l2-m2m-buf-remove-by-buf \
ksym-default-v4l2-m2m-buf-remove-by-idx \
ksym-default-v4l2-m2m-create-bufs \
ksym-default-v4l2-m2m-ctx-init \
ksym-default-v4l2-m2m-ctx-release \
ksym-default-v4l2-m2m-decoder-cmd \
ksym-default-v4l2-m2m-dqbuf \
ksym-default-v4l2-m2m-encoder-cmd \
ksym-default-v4l2-m2m-expbuf \
ksym-default-v4l2-m2m-fop-mmap \
ksym-default-v4l2-m2m-fop-poll \
ksym-default-v4l2-m2m-get \
ksym-default-v4l2-m2m-get-curr-priv \
ksym-default-v4l2-m2m-get-vq \
ksym-default-v4l2-m2m-init \
ksym-default-v4l2-m2m-ioctl-create-bufs \
ksym-default-v4l2-m2m-ioctl-decoder-cmd \
ksym-default-v4l2-m2m-ioctl-dqbuf \
ksym-default-v4l2-m2m-ioctl-encoder-cmd \
ksym-default-v4l2-m2m-ioctl-expbuf \
ksym-default-v4l2-m2m-ioctl-prepare-buf \
ksym-default-v4l2-m2m-ioctl-qbuf \
ksym-default-v4l2-m2m-ioctl-querybuf \
ksym-default-v4l2-m2m-ioctl-remove-bufs \
ksym-default-v4l2-m2m-ioctl-reqbufs \
ksym-default-v4l2-m2m-ioctl-stateless-decoder-cmd \
ksym-default-v4l2-m2m-ioctl-stateless-try-decoder-cmd \
ksym-default-v4l2-m2m-ioctl-streamoff \
ksym-default-v4l2-m2m-ioctl-streamon \
ksym-default-v4l2-m2m-ioctl-try-decoder-cmd \
ksym-default-v4l2-m2m-ioctl-try-encoder-cmd \
ksym-default-v4l2-m2m-job-finish \
ksym-default-v4l2-m2m-last-buf \
ksym-default-v4l2-m2m-last-buffer-done \
ksym-default-v4l2-m2m-mmap \
ksym-default-v4l2-m2m-next-buf \
ksym-default-v4l2-m2m-poll \
ksym-default-v4l2-m2m-prepare-buf \
ksym-default-v4l2-m2m-put \
ksym-default-v4l2-m2m-qbuf \
ksym-default-v4l2-m2m-querybuf \
ksym-default-v4l2-m2m-register-media-controller \
ksym-default-v4l2-m2m-release \
ksym-default-v4l2-m2m-reqbufs \
ksym-default-v4l2-m2m-request-queue \
ksym-default-v4l2-m2m-resume \
ksym-default-v4l2-m2m-streamoff \
ksym-default-v4l2-m2m-streamon \
ksym-default-v4l2-m2m-suspend \
ksym-default-v4l2-m2m-try-schedule \
ksym-default-v4l2-m2m-unregister-media-controller \
ksym-default-v4l2-m2m-update-start-streaming-state \
ksym-default-v4l2-m2m-update-stop-streaming-state \
ksym-default-v4l2-match-dv-timings \
ksym-default-v4l2-mc-create-media-graph \
ksym-default-v4l2-norm-to-name \
ksym-default-v4l2-num-edid-blocks \
ksym-default-v4l2-phys-addr-for-input \
ksym-default-v4l2-phys-addr-validate \
ksym-default-v4l2-pipeline-link-notify \
ksym-default-v4l2-pipeline-pm-get \
ksym-default-v4l2-pipeline-pm-put \
ksym-default-v4l2-print-dv-timings \
ksym-default-v4l2-prio-change \
ksym-default-v4l2-prio-check \
ksym-default-v4l2-prio-close \
ksym-default-v4l2-prio-init \
ksym-default-v4l2-prio-max \
ksym-default-v4l2-prio-open \
ksym-default-v4l2-query-ext-ctrl \
ksym-default-v4l2-query-ext-ctrl-to-v4l2-queryctrl \
ksym-default-v4l2-queryctrl \
ksym-default-v4l2-querymenu \
ksym-default-v4l2-s-ctrl \
ksym-default-v4l2-s-ext-ctrls \
ksym-default-v4l2-s-parm-cap \
ksym-default-v4l2-set-edid-phys-addr \
ksym-default-v4l2-simplify-fraction \
ksym-default-v4l2-spi-new-subdev \
ksym-default-v4l2-spi-subdev-init \
ksym-default-v4l2-src-change-event-subdev-subscribe \
ksym-default-v4l2-src-change-event-subscribe \
ksym-default-v4l2-subdev-call-wrappers \
ksym-default-v4l2-subdev-cleanup \
ksym-default-v4l2-subdev-disable-streams \
ksym-default-v4l2-subdev-enable-streams \
ksym-default-v4l2-subdev-get-fmt \
ksym-default-v4l2-subdev-get-frame-desc-passthrough \
ksym-default-v4l2-subdev-get-frame-interval \
ksym-default-v4l2-subdev-get-fwnode-pad-1-to-1 \
ksym-default-v4l2-subdev-get-privacy-led \
ksym-default-v4l2-subdev-has-pad-interdep \
ksym-default-v4l2-subdev-init \
ksym-default-v4l2-subdev-is-streaming \
ksym-default-v4l2-subdev-link-validate \
ksym-default-v4l2-subdev-link-validate-default \
ksym-default-v4l2-subdev-notify-event \
ksym-default-v4l2-subdev-put-privacy-led \
ksym-default-v4l2-subdev-routing-find-opposite-end \
ksym-default-v4l2-subdev-routing-validate \
ksym-default-v4l2-subdev-s-stream-helper \
ksym-default-v4l2-subdev-set-routing \
ksym-default-v4l2-subdev-set-routing-with-fmt \
ksym-default-v4l2-subdev-state-get-opposite-stream-format \
ksym-default-v4l2-subdev-state-xlate-streams \
ksym-default-v4l2-translate-cmd \
ksym-default-v4l2-try-ext-ctrls \
ksym-default-v4l2-type-names \
ksym-default-v4l2-valid-dv-timings \
ksym-default-v4l2-video-std-construct \
ksym-default-v4l2-video-std-frame-period \
ksym-default-v4l2-vp9-adapt-coef-probs \
ksym-default-v4l2-vp9-adapt-noncoef-probs \
ksym-default-v4l2-vp9-default-probs \
ksym-default-v4l2-vp9-fw-update-probs \
ksym-default-v4l2-vp9-kf-partition-probs \
ksym-default-v4l2-vp9-kf-uv-mode-prob \
ksym-default-v4l2-vp9-kf-y-mode-prob \
ksym-default-v4l2-vp9-reset-frame-ctx \
ksym-default-v4l2-vp9-seg-feat-enabled \
ksym-default-v9fs-get-default-trans \
ksym-default-v9fs-get-trans-by-name \
ksym-default-v9fs-put-trans \
ksym-default-v9fs-register-trans \
ksym-default-v9fs-unregister-trans \
ksym-default-validate-slab-cache \
ksym-default-validate-usercopy-range \
ksym-default-validate-xmit-skb-list \
ksym-default-validate-xmit-xfrm \
ksym-default-vb2-buffer-done \
ksym-default-vb2-buffer-in-use \
ksym-default-vb2-common-vm-ops \
ksym-default-vb2-core-create-bufs \
ksym-default-vb2-core-dqbuf \
ksym-default-vb2-core-expbuf \
ksym-default-vb2-core-poll \
ksym-default-vb2-core-prepare-buf \
ksym-default-vb2-core-qbuf \
ksym-default-vb2-core-querybuf \
ksym-default-vb2-core-queue-init \
ksym-default-vb2-core-queue-release \
ksym-default-vb2-core-remove-bufs \
ksym-default-vb2-core-reqbufs \
ksym-default-vb2-core-streamoff \
ksym-default-vb2-core-streamon \
ksym-default-vb2-create-bufs \
ksym-default-vb2-create-framevec \
ksym-default-vb2-destroy-framevec \
ksym-default-vb2-discard-done \
ksym-default-vb2-dma-contig-memops \
ksym-default-vb2-dma-contig-set-max-seg-size \
ksym-default-vb2-dma-sg-memops \
ksym-default-vb2-dqbuf \
ksym-default-vb2-dvb-alloc-frontend \
ksym-default-vb2-dvb-dealloc-frontends \
ksym-default-vb2-dvb-find-frontend \
ksym-default-vb2-dvb-get-frontend \
ksym-default-vb2-dvb-register-bus \
ksym-default-vb2-dvb-unregister-bus \
ksym-default-vb2-expbuf \
ksym-default-vb2-find-buffer \
ksym-default-vb2-fop-mmap \
ksym-default-vb2-fop-poll \
ksym-default-vb2-fop-read \
ksym-default-vb2-fop-release \
ksym-default-vb2-fop-write \
ksym-default-vb2-ioctl-create-bufs \
ksym-default-vb2-ioctl-dqbuf \
ksym-default-vb2-ioctl-expbuf \
ksym-default-vb2-ioctl-prepare-buf \
ksym-default-vb2-ioctl-qbuf \
ksym-default-vb2-ioctl-querybuf \
ksym-default-vb2-ioctl-remove-bufs \
ksym-default-vb2-ioctl-reqbufs \
ksym-default-vb2-ioctl-streamoff \
ksym-default-vb2-ioctl-streamon \
ksym-default-vb2-mmap \
ksym-default-vb2-plane-cookie \
ksym-default-vb2-plane-vaddr \
ksym-default-vb2-poll \
ksym-default-vb2-prepare-buf \
ksym-default-vb2-qbuf \
ksym-default-vb2-querybuf \
ksym-default-vb2-queue-change-type \
ksym-default-vb2-queue-error \
ksym-default-vb2-queue-init \
ksym-default-vb2-queue-init-name \
ksym-default-vb2-queue-release \
ksym-default-vb2-read \
ksym-default-vb2-reqbufs \
ksym-default-vb2-request-buffer-cnt \
ksym-default-vb2-request-object-is-buffer \
ksym-default-vb2-request-queue \
ksym-default-vb2-request-validate \
ksym-default-vb2-streamoff \
ksym-default-vb2-streamon \
ksym-default-vb2-thread-start \
ksym-default-vb2-thread-stop \
ksym-default-vb2-verify-memory-type \
ksym-default-vb2-video-unregister-device \
ksym-default-vb2-vmalloc-memops \
ksym-default-vb2-wait-for-all-buffers \
ksym-default-vb2-write \
ksym-default-vbg-err \
ksym-default-vbg-err-ratelimited \
ksym-default-vbg-get-gdev \
ksym-default-vbg-hgcm-call \
ksym-default-vbg-hgcm-connect \
ksym-default-vbg-hgcm-disconnect \
ksym-default-vbg-info \
ksym-default-vbg-put-gdev \
ksym-default-vbg-status-code-to-errno \
ksym-default-vbg-warn \
ksym-default-vbin-printf \
ksym-default-vc-cons \
ksym-default-vc-font-pitch \
ksym-default-vc-font-size \
ksym-default-vcalloc-noprof \
ksym-default-vcap-add-rule \
ksym-default-vcap-addr-keysets \
ksym-default-vcap-admin-rule-count \
ksym-default-vcap-alloc-rule \
ksym-default-vcap-chain-id-to-lookup \
ksym-default-vcap-chain-offset \
ksym-default-vcap-copy-rule \
ksym-default-vcap-debugfs \
ksym-default-vcap-del-rule \
ksym-default-vcap-del-rules \
ksym-default-vcap-enable-lookups \
ksym-default-vcap-filter-rule-keys \
ksym-default-vcap-find-actionfield \
ksym-default-vcap-find-admin \
ksym-default-vcap-find-keystream-keysets \
ksym-default-vcap-free-rule \
ksym-default-vcap-get-rule \
ksym-default-vcap-get-rule-count-by-cookie \
ksym-default-vcap-is-last-chain \
ksym-default-vcap-is-next-lookup \
ksym-default-vcap-keyfield-name \
ksym-default-vcap-keyfieldset \
ksym-default-vcap-keyset-list-add \
ksym-default-vcap-keyset-name \
ksym-default-vcap-lookup-keyfield \
ksym-default-vcap-lookup-rule-by-cookie \
ksym-default-vcap-mod-rule \
ksym-default-vcap-netbytes-copy \
ksym-default-vcap-port-debugfs \
ksym-default-vcap-rule-add-action-bit \
ksym-default-vcap-rule-add-action-u32 \
ksym-default-vcap-rule-add-action-u72 \
ksym-default-vcap-rule-add-key-bit \
ksym-default-vcap-rule-add-key-u128 \
ksym-default-vcap-rule-add-key-u32 \
ksym-default-vcap-rule-add-key-u48 \
ksym-default-vcap-rule-add-key-u72 \
ksym-default-vcap-rule-find-keysets \
ksym-default-vcap-rule-get-counter \
ksym-default-vcap-rule-get-key-u32 \
ksym-default-vcap-rule-mod-action-u32 \
ksym-default-vcap-rule-mod-key-u32 \
ksym-default-vcap-rule-rem-key \
ksym-default-vcap-rule-set-counter \
ksym-default-vcap-rule-set-counter-id \
ksym-default-vcap-select-min-rule-keyset \
ksym-default-vcap-set-rule-set-actionset \
ksym-default-vcap-set-rule-set-keyset \
ksym-default-vcap-set-tc-exterr \
ksym-default-vcap-tc-flower-handler-arp-usage \
ksym-default-vcap-tc-flower-handler-cvlan-usage \
ksym-default-vcap-tc-flower-handler-ethaddr-usage \
ksym-default-vcap-tc-flower-handler-ip-usage \
ksym-default-vcap-tc-flower-handler-ipv4-usage \
ksym-default-vcap-tc-flower-handler-ipv6-usage \
ksym-default-vcap-tc-flower-handler-portnum-usage \
ksym-default-vcap-tc-flower-handler-tcp-usage \
ksym-default-vcap-tc-flower-handler-vlan-usage \
ksym-default-vcap-val-rule \
ksym-default-vcc-hash \
ksym-default-vcc-insert-socket \
ksym-default-vcc-process-recv-queue \
ksym-default-vcc-release-async \
ksym-default-vcc-sklist-lock \
ksym-default-vchan-dma-desc-free-list \
ksym-default-vchan-find-desc \
ksym-default-vchan-init \
ksym-default-vchan-tx-desc-free \
ksym-default-vchan-tx-submit \
ksym-default-vchiq-add-connected-callback \
ksym-default-vchiq-bulk-receive \
ksym-default-vchiq-bulk-transmit \
ksym-default-vchiq-close-service \
ksym-default-vchiq-connect \
ksym-default-vchiq-driver-register \
ksym-default-vchiq-driver-unregister \
ksym-default-vchiq-get-peer-version \
ksym-default-vchiq-get-service-userdata \
ksym-default-vchiq-initialise \
ksym-default-vchiq-mmal-component-disable \
ksym-default-vchiq-mmal-component-enable \
ksym-default-vchiq-mmal-component-finalise \
ksym-default-vchiq-mmal-component-init \
ksym-default-vchiq-mmal-finalise \
ksym-default-vchiq-mmal-init \
ksym-default-vchiq-mmal-port-connect-tunnel \
ksym-default-vchiq-mmal-port-disable \
ksym-default-vchiq-mmal-port-enable \
ksym-default-vchiq-mmal-port-parameter-get \
ksym-default-vchiq-mmal-port-parameter-set \
ksym-default-vchiq-mmal-port-set-format \
ksym-default-vchiq-mmal-submit-buffer \
ksym-default-vchiq-mmal-version \
ksym-default-vchiq-msg-hold \
ksym-default-vchiq-msg-queue-push \
ksym-default-vchiq-open-service \
ksym-default-vchiq-queue-kernel-message \
ksym-default-vchiq-release-message \
ksym-default-vchiq-release-service \
ksym-default-vchiq-shutdown \
ksym-default-vchiq-use-service \
ksym-default-vdpa-get-config \
ksym-default-vdpa-mgmtdev-register \
ksym-default-vdpa-mgmtdev-unregister \
ksym-default-vdpa-register-device \
ksym-default-vdpa-set-config \
ksym-default-vdpa-set-status \
ksym-default-vdpa-unregister-device \
ksym-default-vdpa-unregister-driver \
ksym-default-vdpasim-create \
ksym-default-vdpasim-schedule-work \
ksym-default-venus-close-common \
ksym-default-venus-helper-acquire-buf-ref \
ksym-default-venus-helper-alloc-dpb-bufs \
ksym-default-venus-helper-buffers-done \
ksym-default-venus-helper-change-dpb-owner \
ksym-default-venus-helper-check-codec \
ksym-default-venus-helper-check-format \
ksym-default-venus-helper-find-buf \
ksym-default-venus-helper-free-dpb-bufs \
ksym-default-venus-helper-get-bufreq \
ksym-default-venus-helper-get-framesz \
ksym-default-venus-helper-get-framesz-raw \
ksym-default-venus-helper-get-opb-size \
ksym-default-venus-helper-get-out-fmts \
ksym-default-venus-helper-get-profile-level \
ksym-default-venus-helper-get-ts-metadata \
ksym-default-venus-helper-init-instance \
ksym-default-venus-helper-intbufs-alloc \
ksym-default-venus-helper-intbufs-free \
ksym-default-venus-helper-intbufs-realloc \
ksym-default-venus-helper-m2m-device-run \
ksym-default-venus-helper-m2m-job-abort \
ksym-default-venus-helper-process-initial-cap-bufs \
ksym-default-venus-helper-process-initial-out-bufs \
ksym-default-venus-helper-queue-dpb-bufs \
ksym-default-venus-helper-release-buf-ref \
ksym-default-venus-helper-session-init \
ksym-default-venus-helper-set-bufsize \
ksym-default-venus-helper-set-color-format \
ksym-default-venus-helper-set-dyn-bufmode \
ksym-default-venus-helper-set-format-constraints \
ksym-default-venus-helper-set-input-resolution \
ksym-default-venus-helper-set-multistream \
ksym-default-venus-helper-set-num-bufs \
ksym-default-venus-helper-set-output-resolution \
ksym-default-venus-helper-set-profile-level \
ksym-default-venus-helper-set-raw-format \
ksym-default-venus-helper-set-stride \
ksym-default-venus-helper-set-work-mode \
ksym-default-venus-helper-unregister-bufs \
ksym-default-venus-helper-vb2-buf-init \
ksym-default-venus-helper-vb2-buf-prepare \
ksym-default-venus-helper-vb2-buf-queue \
ksym-default-venus-helper-vb2-queue-error \
ksym-default-venus-helper-vb2-start-streaming \
ksym-default-venus-helper-vb2-stop-streaming \
ksym-default-verbose-torout-sleep \
ksym-default-verify-pkcs7-signature \
ksym-default-verify-signature \
ksym-default-verify-spi-info \
ksym-default-versal-pm-aes-dec-final \
ksym-default-versal-pm-aes-dec-update \
ksym-default-versal-pm-aes-enc-final \
ksym-default-versal-pm-aes-enc-update \
ksym-default-versal-pm-aes-init \
ksym-default-versal-pm-aes-key-write \
ksym-default-versal-pm-aes-key-zero \
ksym-default-versal-pm-aes-op-init \
ksym-default-versal-pm-aes-update-aad \
ksym-default-ves1820-attach \
ksym-default-ves1x93-attach \
ksym-default-vesa-modes \
ksym-default-vfio-assign-device-set \
ksym-default-vfio-combine-iova-ranges \
ksym-default-vfio-device-put-registration \
ksym-default-vfio-device-set-open-count \
ksym-default-vfio-device-try-get-registration \
ksym-default-vfio-dma-rw \
ksym-default-vfio-file-enforced-coherent \
ksym-default-vfio-file-has-dev \
ksym-default-vfio-file-iommu-group \
ksym-default-vfio-file-is-group \
ksym-default-vfio-file-is-valid \
ksym-default-vfio-file-set-kvm \
ksym-default-vfio-find-device-in-devset \
ksym-default-vfio-info-add-capability \
ksym-default-vfio-info-cap-add \
ksym-default-vfio-info-cap-shift \
ksym-default-vfio-mig-get-next-state \
ksym-default-vfio-pci-config-rw-single \
ksym-default-vfio-pci-core-aer-err-detected \
ksym-default-vfio-pci-core-close-device \
ksym-default-vfio-pci-core-disable \
ksym-default-vfio-pci-core-do-io-rw \
ksym-default-vfio-pci-core-enable \
ksym-default-vfio-pci-core-err-handlers \
ksym-default-vfio-pci-core-fill-phys-vec \
ksym-default-vfio-pci-core-finish-enable \
ksym-default-vfio-pci-core-get-dmabuf-phys \
ksym-default-vfio-pci-core-init-dev \
ksym-default-vfio-pci-core-ioctl \
ksym-default-vfio-pci-core-ioctl-feature \
ksym-default-vfio-pci-core-ioread16 \
ksym-default-vfio-pci-core-ioread32 \
ksym-default-vfio-pci-core-ioread64 \
ksym-default-vfio-pci-core-ioread8 \
ksym-default-vfio-pci-core-iowrite16 \
ksym-default-vfio-pci-core-iowrite32 \
ksym-default-vfio-pci-core-iowrite64 \
ksym-default-vfio-pci-core-iowrite8 \
ksym-default-vfio-pci-core-match \
ksym-default-vfio-pci-core-match-token-uuid \
ksym-default-vfio-pci-core-mmap \
ksym-default-vfio-pci-core-range-intersect-range \
ksym-default-vfio-pci-core-read \
ksym-default-vfio-pci-core-register-dev-region \
ksym-default-vfio-pci-core-register-device \
ksym-default-vfio-pci-core-release-dev \
ksym-default-vfio-pci-core-request \
ksym-default-vfio-pci-core-sriov-configure \
ksym-default-vfio-pci-core-unregister-device \
ksym-default-vfio-pci-core-write \
ksym-default-vfio-pci-dma-buf-iommufd-map \
ksym-default-vfio-pci-ioctl-get-region-info \
ksym-default-vfio-pci-vmf-insert-pfn \
ksym-default-vfio-pin-pages \
ksym-default-vfio-platform-close-device \
ksym-default-vfio-platform-init-common \
ksym-default-vfio-platform-ioctl \
ksym-default-vfio-platform-ioctl-get-region-info \
ksym-default-vfio-platform-mmap \
ksym-default-vfio-platform-open-device \
ksym-default-vfio-platform-read \
ksym-default-vfio-platform-release-common \
ksym-default-vfio-platform-unregister-reset \
ksym-default-vfio-platform-write \
ksym-default-vfio-register-emulated-iommu-dev \
ksym-default-vfio-register-group-dev \
ksym-default-vfio-register-iommu-driver \
ksym-default-vfio-set-irqs-validate-and-prepare \
ksym-default-vfio-unpin-pages \
ksym-default-vfio-unregister-group-dev \
ksym-default-vfio-unregister-iommu-driver \
ksym-default-vfio-virqfd-disable \
ksym-default-vfio-virqfd-enable \
ksym-default-vfio-virqfd-flush-thread \
ksym-default-vfree \
ksym-default-vfs-cancel-lock \
ksym-default-vfs-clone-file-range \
ksym-default-vfs-copy-file-range \
ksym-default-vfs-create \
ksym-default-vfs-create-mount \
ksym-default-vfs-dedupe-file-range \
ksym-default-vfs-dedupe-file-range-one \
ksym-default-vfs-dup-fs-context \
ksym-default-vfs-fadvise \
ksym-default-vfs-fallocate \
ksym-default-vfs-fileattr-get \
ksym-default-vfs-fileattr-set \
ksym-default-vfs-fsync \
ksym-default-vfs-fsync-range \
ksym-default-vfs-get-acl \
ksym-default-vfs-get-fsid \
ksym-default-vfs-get-link \
ksym-default-vfs-get-tree \
ksym-default-vfs-getattr \
ksym-default-vfs-getattr-nosec \
ksym-default-vfs-getxattr \
ksym-default-vfs-inode-has-locks \
ksym-default-vfs-iocb-iter-read \
ksym-default-vfs-iocb-iter-write \
ksym-default-vfs-iter-read \
ksym-default-vfs-iter-write \
ksym-default-vfs-kern-mount \
ksym-default-vfs-link \
ksym-default-vfs-listxattr \
ksym-default-vfs-llseek \
ksym-default-vfs-lock-file \
ksym-default-vfs-mkdir \
ksym-default-vfs-mknod \
ksym-default-vfs-mkobj \
ksym-default-vfs-parse-fs-param \
ksym-default-vfs-parse-fs-param-source \
ksym-default-vfs-parse-fs-qstr \
ksym-default-vfs-parse-monolithic-sep \
ksym-default-vfs-path-lookup \
ksym-default-vfs-path-parent-lookup \
ksym-default-vfs-pressure-ratio \
ksym-default-vfs-readlink \
ksym-default-vfs-remove-acl \
ksym-default-vfs-removexattr \
ksym-default-vfs-rename \
ksym-default-vfs-rmdir \
ksym-default-vfs-set-acl \
ksym-default-vfs-setlease \
ksym-default-vfs-setpos \
ksym-default-vfs-setxattr \
ksym-default-vfs-splice-read \
ksym-default-vfs-statfs \
ksym-default-vfs-symlink \
ksym-default-vfs-test-lock \
ksym-default-vfs-truncate \
ksym-default-vfs-unlink \
ksym-default-vfs-utimes \
ksym-default-vfsgid-in-group-p \
ksym-default-vfsmount-to-propagation-flags \
ksym-default-vga-client-register \
ksym-default-vga-default-device \
ksym-default-vga-get \
ksym-default-vga-put \
ksym-default-vga-remove-vgacon \
ksym-default-vga-set-legacy-decoding \
ksym-default-vhost-add-used \
ksym-default-vhost-add-used-and-signal \
ksym-default-vhost-add-used-and-signal-n \
ksym-default-vhost-add-used-n \
ksym-default-vhost-chr-poll \
ksym-default-vhost-chr-read-iter \
ksym-default-vhost-chr-write-iter \
ksym-default-vhost-clear-msg \
ksym-default-vhost-dequeue-msg \
ksym-default-vhost-dev-check-owner \
ksym-default-vhost-dev-cleanup \
ksym-default-vhost-dev-flush \
ksym-default-vhost-dev-has-owner \
ksym-default-vhost-dev-init \
ksym-default-vhost-dev-ioctl \
ksym-default-vhost-dev-reset-owner \
ksym-default-vhost-dev-reset-owner-prepare \
ksym-default-vhost-dev-set-owner \
ksym-default-vhost-dev-stop \
ksym-default-vhost-disable-notify \
ksym-default-vhost-discard-vq-desc \
ksym-default-vhost-enable-notify \
ksym-default-vhost-enqueue-msg \
ksym-default-vhost-exceeds-weight \
ksym-default-vhost-get-vq-desc \
ksym-default-vhost-get-vq-desc-n \
ksym-default-vhost-init-device-iotlb \
ksym-default-vhost-iotlb-add-range \
ksym-default-vhost-iotlb-add-range-ctx \
ksym-default-vhost-iotlb-alloc \
ksym-default-vhost-iotlb-del-range \
ksym-default-vhost-iotlb-free \
ksym-default-vhost-iotlb-init \
ksym-default-vhost-iotlb-itree-first \
ksym-default-vhost-iotlb-itree-next \
ksym-default-vhost-iotlb-map-free \
ksym-default-vhost-iotlb-reset \
ksym-default-vhost-log-access-ok \
ksym-default-vhost-log-write \
ksym-default-vhost-new-msg \
ksym-default-vhost-poll-init \
ksym-default-vhost-poll-queue \
ksym-default-vhost-poll-start \
ksym-default-vhost-poll-stop \
ksym-default-vhost-set-backend-features \
ksym-default-vhost-signal \
ksym-default-vhost-task-create \
ksym-default-vhost-task-start \
ksym-default-vhost-task-stop \
ksym-default-vhost-task-wake \
ksym-default-vhost-vq-access-ok \
ksym-default-vhost-vq-avail-empty \
ksym-default-vhost-vq-has-work \
ksym-default-vhost-vq-init-access \
ksym-default-vhost-vq-is-setup \
ksym-default-vhost-vq-work-queue \
ksym-default-vhost-vring-ioctl \
ksym-default-vhost-work-init \
ksym-default-vhost-worker-ioctl \
ksym-default-viai2c-init \
ksym-default-viai2c-irq-xfer \
ksym-default-viai2c-wait-bus-not-busy \
ksym-default-viai2c-xfer \
ksym-default-vid-from-reg \
ksym-default-vid-is-dsa-8021q \
ksym-default-vid-which-vrm \
ksym-default-video-devdata \
ksym-default-video-device-alloc \
ksym-default-video-device-pipeline \
ksym-default-video-device-pipeline-alloc-start \
ksym-default-video-device-pipeline-start \
ksym-default-video-device-pipeline-stop \
ksym-default-video-device-release \
ksym-default-video-device-release-empty \
ksym-default-video-firmware-drivers-only \
ksym-default-video-get-options \
ksym-default-video-ioctl2 \
ksym-default-video-unregister-device \
ksym-default-videomode-from-timing \
ksym-default-videomode-from-timings \
ksym-default-virtio-add-status \
ksym-default-virtio-break-device \
ksym-default-virtio-check-driver-offered-feature \
ksym-default-virtio-check-mem-acc-cb \
ksym-default-virtio-config-changed \
ksym-default-virtio-config-driver-disable \
ksym-default-virtio-config-driver-enable \
ksym-default-virtio-device-freeze \
ksym-default-virtio-device-reset-done \
ksym-default-virtio-device-reset-prepare \
ksym-default-virtio-device-restore \
ksym-default-virtio-dma-buf-attach \
ksym-default-virtio-dma-buf-export \
ksym-default-virtio-dma-buf-get-uuid \
ksym-default-virtio-max-dma-size \
ksym-default-virtio-pci-admin-dev-parts-get \
ksym-default-virtio-pci-admin-dev-parts-metadata-get \
ksym-default-virtio-pci-admin-dev-parts-set \
ksym-default-virtio-pci-admin-has-dev-parts \
ksym-default-virtio-pci-admin-mode-set \
ksym-default-virtio-pci-admin-obj-create \
ksym-default-virtio-pci-admin-obj-destroy \
ksym-default-virtio-pmem-host-ack \
ksym-default-virtio-require-restricted-mem-acc \
ksym-default-virtio-reset-device \
ksym-default-virtio-transport-connect \
ksym-default-virtio-transport-consume-skb-sent \
ksym-default-virtio-transport-deliver-tap-pkt \
ksym-default-virtio-transport-destruct \
ksym-default-virtio-transport-dgram-allow \
ksym-default-virtio-transport-dgram-bind \
ksym-default-virtio-transport-dgram-dequeue \
ksym-default-virtio-transport-dgram-enqueue \
ksym-default-virtio-transport-do-socket-init \
ksym-default-virtio-transport-get-credit \
ksym-default-virtio-transport-inc-tx-pkt \
ksym-default-virtio-transport-notify-buffer-size \
ksym-default-virtio-transport-notify-poll-in \
ksym-default-virtio-transport-notify-poll-out \
ksym-default-virtio-transport-notify-recv-init \
ksym-default-virtio-transport-notify-recv-post-dequeue \
ksym-default-virtio-transport-notify-recv-pre-block \
ksym-default-virtio-transport-notify-recv-pre-dequeue \
ksym-default-virtio-transport-notify-send-init \
ksym-default-virtio-transport-notify-send-post-enqueue \
ksym-default-virtio-transport-notify-send-pre-block \
ksym-default-virtio-transport-notify-send-pre-enqueue \
ksym-default-virtio-transport-notify-set-rcvlowat \
ksym-default-virtio-transport-purge-skbs \
ksym-default-virtio-transport-put-credit \
ksym-default-virtio-transport-read-skb \
ksym-default-virtio-transport-recv-pkt \
ksym-default-virtio-transport-release \
ksym-default-virtio-transport-seqpacket-dequeue \
ksym-default-virtio-transport-seqpacket-enqueue \
ksym-default-virtio-transport-seqpacket-has-data \
ksym-default-virtio-transport-shutdown \
ksym-default-virtio-transport-stream-dequeue \
ksym-default-virtio-transport-stream-enqueue \
ksym-default-virtio-transport-stream-has-data \
ksym-default-virtio-transport-stream-has-space \
ksym-default-virtio-transport-stream-is-active \
ksym-default-virtio-transport-stream-rcvhiwat \
ksym-default-virtio-transport-unsent-bytes \
ksym-default-virtqueue-add-inbuf \
ksym-default-virtqueue-add-inbuf-cache-clean \
ksym-default-virtqueue-add-inbuf-ctx \
ksym-default-virtqueue-add-inbuf-premapped \
ksym-default-virtqueue-add-outbuf \
ksym-default-virtqueue-add-outbuf-premapped \
ksym-default-virtqueue-add-sgs \
ksym-default-virtqueue-detach-unused-buf \
ksym-default-virtqueue-disable-cb \
ksym-default-virtqueue-dma-dev \
ksym-default-virtqueue-enable-cb \
ksym-default-virtqueue-enable-cb-delayed \
ksym-default-virtqueue-enable-cb-prepare \
ksym-default-virtqueue-get-avail-addr \
ksym-default-virtqueue-get-buf \
ksym-default-virtqueue-get-buf-ctx \
ksym-default-virtqueue-get-desc-addr \
ksym-default-virtqueue-get-used-addr \
ksym-default-virtqueue-get-vring \
ksym-default-virtqueue-get-vring-size \
ksym-default-virtqueue-is-broken \
ksym-default-virtqueue-kick \
ksym-default-virtqueue-kick-prepare \
ksym-default-virtqueue-map-alloc-coherent \
ksym-default-virtqueue-map-free-coherent \
ksym-default-virtqueue-map-mapping-error \
ksym-default-virtqueue-map-need-sync \
ksym-default-virtqueue-map-page-attrs \
ksym-default-virtqueue-map-single-attrs \
ksym-default-virtqueue-map-sync-single-range-for-cpu \
ksym-default-virtqueue-map-sync-single-range-for-device \
ksym-default-virtqueue-notify \
ksym-default-virtqueue-poll \
ksym-default-virtqueue-reset \
ksym-default-virtqueue-resize \
ksym-default-virtqueue-unmap-page-attrs \
ksym-default-virtqueue-unmap-single-attrs \
ksym-default-visitor128 \
ksym-default-visitor32 \
ksym-default-visitor64 \
ksym-default-visitorl \
ksym-default-vivaldi-attribute-groups \
ksym-default-vivaldi-feature-mapping \
ksym-default-vivaldi-function-row-physmap-show \
ksym-default-vlan-dev-real-dev \
ksym-default-vlan-dev-vlan-id \
ksym-default-vlan-dev-vlan-proto \
ksym-default-vlan-filter-drop-vids \
ksym-default-vlan-filter-push-vids \
ksym-default-vlan-for-each \
ksym-default-vlan-ioctl-set \
ksym-default-vlan-uses-dev \
ksym-default-vlan-vid-add \
ksym-default-vlan-vid-del \
ksym-default-vlan-vids-add-by-dev \
ksym-default-vlan-vids-del-by-dev \
ksym-default-vli-cmp \
ksym-default-vli-from-be64 \
ksym-default-vli-from-le64 \
ksym-default-vli-is-zero \
ksym-default-vli-mod-inv \
ksym-default-vli-mod-mult-slow \
ksym-default-vli-num-bits \
ksym-default-vli-sub \
ksym-default-vm-event-states \
ksym-default-vm-get-page-prot \
ksym-default-vm-insert-page \
ksym-default-vm-insert-pages \
ksym-default-vm-iomap-memory \
ksym-default-vm-map-pages \
ksym-default-vm-map-pages-zero \
ksym-default-vm-map-ram \
ksym-default-vm-memory-committed \
ksym-default-vm-mmap \
ksym-default-vm-munmap \
ksym-default-vm-node-stat \
ksym-default-vm-unmap-aliases \
ksym-default-vm-unmap-ram \
ksym-default-vm-zone-stat \
ksym-default-vma-alloc-folio-noprof \
ksym-default-vma-set-file \
ksym-default-vmalloc-32-noprof \
ksym-default-vmalloc-32-user-noprof \
ksym-default-vmalloc-array-noprof \
ksym-default-vmalloc-huge-node-noprof \
ksym-default-vmalloc-node-noprof \
ksym-default-vmalloc-noprof \
ksym-default-vmalloc-to-page \
ksym-default-vmalloc-to-pfn \
ksym-default-vmalloc-user-noprof \
ksym-default-vmap \
ksym-default-vmap-pfn \
ksym-default-vmbus-alloc-ring \
ksym-default-vmbus-allocate-mmio \
ksym-default-vmbus-close \
ksym-default-vmbus-connect-ring \
ksym-default-vmbus-connection \
ksym-default-vmbus-device-unregister \
ksym-default-vmbus-devs \
ksym-default-vmbus-disconnect-ring \
ksym-default-vmbus-driver-unregister \
ksym-default-vmbus-establish-gpadl \
ksym-default-vmbus-free-mmio \
ksym-default-vmbus-free-ring \
ksym-default-vmbus-hvsock-device-unregister \
ksym-default-vmbus-initiate-unload \
ksym-default-vmbus-is-confidential \
ksym-default-vmbus-isr \
ksym-default-vmbus-next-request-id \
ksym-default-vmbus-open \
ksym-default-vmbus-prep-negotiate-resp \
ksym-default-vmbus-proto-version \
ksym-default-vmbus-recvpacket \
ksym-default-vmbus-recvpacket-raw \
ksym-default-vmbus-request-addr \
ksym-default-vmbus-request-addr-match \
ksym-default-vmbus-send-modifychannel \
ksym-default-vmbus-send-tl-connect-request \
ksym-default-vmbus-sendpacket \
ksym-default-vmbus-sendpacket-getid \
ksym-default-vmbus-sendpacket-mpb-desc \
ksym-default-vmbus-set-chn-rescind-callback \
ksym-default-vmbus-set-event \
ksym-default-vmbus-set-sc-create-callback \
ksym-default-vmbus-set-skip-unload \
ksym-default-vmbus-setevent \
ksym-default-vmbus-teardown-gpadl \
ksym-default-vmci-context-get-priv-flags \
ksym-default-vmci-datagram-create-handle \
ksym-default-vmci-datagram-create-handle-priv \
ksym-default-vmci-datagram-destroy-handle \
ksym-default-vmci-datagram-send \
ksym-default-vmci-doorbell-create \
ksym-default-vmci-doorbell-destroy \
ksym-default-vmci-event-subscribe \
ksym-default-vmci-event-unsubscribe \
ksym-default-vmci-get-context-id \
ksym-default-vmci-is-context-owner \
ksym-default-vmci-qpair-alloc \
ksym-default-vmci-qpair-consume-buf-ready \
ksym-default-vmci-qpair-consume-free-space \
ksym-default-vmci-qpair-dequev \
ksym-default-vmci-qpair-detach \
ksym-default-vmci-qpair-enquev \
ksym-default-vmci-qpair-get-consume-indexes \
ksym-default-vmci-qpair-get-produce-indexes \
ksym-default-vmci-qpair-peekv \
ksym-default-vmci-qpair-produce-buf-ready \
ksym-default-vmci-qpair-produce-free-space \
ksym-default-vmci-register-vsock-callback \
ksym-default-vmci-send-datagram \
ksym-default-vmcore-add-device-dump \
ksym-default-vmemdup-user \
ksym-default-vmf-insert-folio-pmd \
ksym-default-vmf-insert-mixed \
ksym-default-vmf-insert-page-mkwrite \
ksym-default-vmf-insert-pfn \
ksym-default-vmf-insert-pfn-pmd \
ksym-default-vmf-insert-pfn-prot \
ksym-default-vnic-dev-get-pdev \
ksym-default-vnic-dev-get-res \
ksym-default-vnic-dev-get-res-count \
ksym-default-vnic-dev-register \
ksym-default-vnic-dev-unregister \
ksym-default-vop-component-ops \
ksym-default-vop2-component-ops \
ksym-default-vp-legacy-config-vector \
ksym-default-vp-legacy-get-driver-features \
ksym-default-vp-legacy-get-features \
ksym-default-vp-legacy-get-queue-enable \
ksym-default-vp-legacy-get-queue-size \
ksym-default-vp-legacy-get-status \
ksym-default-vp-legacy-probe \
ksym-default-vp-legacy-queue-vector \
ksym-default-vp-legacy-remove \
ksym-default-vp-legacy-set-features \
ksym-default-vp-legacy-set-queue-address \
ksym-default-vp-legacy-set-status \
ksym-default-vp-modern-avq-index \
ksym-default-vp-modern-avq-num \
ksym-default-vp-modern-config-vector \
ksym-default-vp-modern-generation \
ksym-default-vp-modern-get-driver-extended-features \
ksym-default-vp-modern-get-extended-features \
ksym-default-vp-modern-get-num-queues \
ksym-default-vp-modern-get-queue-enable \
ksym-default-vp-modern-get-queue-reset \
ksym-default-vp-modern-get-queue-size \
ksym-default-vp-modern-get-status \
ksym-default-vp-modern-map-vq-notify \
ksym-default-vp-modern-probe \
ksym-default-vp-modern-queue-address \
ksym-default-vp-modern-queue-vector \
ksym-default-vp-modern-remove \
ksym-default-vp-modern-set-extended-features \
ksym-default-vp-modern-set-queue-enable \
ksym-default-vp-modern-set-queue-reset \
ksym-default-vp-modern-set-queue-size \
ksym-default-vp-modern-set-status \
ksym-default-vp3054-i2c-probe \
ksym-default-vp3054-i2c-remove \
ksym-default-vpanic \
ksym-default-vprintk \
ksym-default-vprintk-default \
ksym-default-vprintk-emit \
ksym-default-vpu-get-plat-device \
ksym-default-vpu-get-vdec-hw-capa \
ksym-default-vpu-get-venc-hw-capa \
ksym-default-vpu-ipi-register \
ksym-default-vpu-ipi-send \
ksym-default-vpu-load-firmware \
ksym-default-vpu-mapping-dm-addr \
ksym-default-vpu-wdt-reg-handler \
ksym-default-vq-meta-prefetch \
ksym-default-vrealloc-node-align-noprof \
ksym-default-vring-create-virtqueue \
ksym-default-vring-create-virtqueue-map \
ksym-default-vring-del-virtqueue \
ksym-default-vring-interrupt \
ksym-default-vring-new-virtqueue \
ksym-default-vring-notification-data \
ksym-default-vring-transport-features \
ksym-default-vringh-complete-iotlb \
ksym-default-vringh-complete-kern \
ksym-default-vringh-complete-multi-user \
ksym-default-vringh-complete-user \
ksym-default-vringh-getdesc-iotlb \
ksym-default-vringh-getdesc-kern \
ksym-default-vringh-getdesc-user \
ksym-default-vringh-init-iotlb \
ksym-default-vringh-init-iotlb-va \
ksym-default-vringh-init-kern \
ksym-default-vringh-init-user \
ksym-default-vringh-iov-pull-iotlb \
ksym-default-vringh-iov-pull-user \
ksym-default-vringh-iov-push-iotlb \
ksym-default-vringh-iov-push-user \
ksym-default-vringh-kiov-advance \
ksym-default-vringh-need-notify-iotlb \
ksym-default-vringh-need-notify-kern \
ksym-default-vringh-need-notify-user \
ksym-default-vringh-notify-disable-kern \
ksym-default-vringh-notify-disable-user \
ksym-default-vringh-notify-enable-kern \
ksym-default-vringh-notify-enable-user \
ksym-default-vringh-set-iotlb \
ksym-default-vsc73xx-is-addr-valid \
ksym-default-vsc73xx-probe \
ksym-default-vsc73xx-remove \
ksym-default-vsc73xx-shutdown \
ksym-default-vsc7514-regfields \
ksym-default-vsc7514-regmap \
ksym-default-vsc7514-vcap-props \
ksym-default-vscnprintf \
ksym-default-vsnprintf \
ksym-default-vsock-add-pending \
ksym-default-vsock-add-tap \
ksym-default-vsock-addr-bound \
ksym-default-vsock-addr-cast \
ksym-default-vsock-addr-equals-addr \
ksym-default-vsock-addr-init \
ksym-default-vsock-addr-unbind \
ksym-default-vsock-addr-validate \
ksym-default-vsock-assign-transport \
ksym-default-vsock-bind-table \
ksym-default-vsock-connected-table \
ksym-default-vsock-connectible-has-data \
ksym-default-vsock-connectible-recvmsg \
ksym-default-vsock-core-get-transport \
ksym-default-vsock-core-register \
ksym-default-vsock-core-unregister \
ksym-default-vsock-create-connected \
ksym-default-vsock-data-ready \
ksym-default-vsock-deliver-tap \
ksym-default-vsock-dgram-recvmsg \
ksym-default-vsock-enqueue-accept \
ksym-default-vsock-find-bound-socket \
ksym-default-vsock-find-bound-socket-net \
ksym-default-vsock-find-cid \
ksym-default-vsock-find-connected-socket \
ksym-default-vsock-find-connected-socket-net \
ksym-default-vsock-for-each-connected-socket \
ksym-default-vsock-insert-connected \
ksym-default-vsock-linger \
ksym-default-vsock-pending-to-accept \
ksym-default-vsock-remove-bound \
ksym-default-vsock-remove-connected \
ksym-default-vsock-remove-pending \
ksym-default-vsock-remove-sock \
ksym-default-vsock-remove-tap \
ksym-default-vsock-stream-has-data \
ksym-default-vsock-stream-has-space \
ksym-default-vsock-table-lock \
ksym-default-vsp1-du-atomic-begin \
ksym-default-vsp1-du-atomic-flush \
ksym-default-vsp1-du-atomic-update \
ksym-default-vsp1-du-disable \
ksym-default-vsp1-du-enable \
ksym-default-vsp1-du-init \
ksym-default-vsp1-du-map-sg \
ksym-default-vsp1-du-unmap-sg \
ksym-default-vsp1-isp-alloc-buffer \
ksym-default-vsp1-isp-free-buffer \
ksym-default-vsp1-isp-get-bus-master \
ksym-default-vsp1-isp-init \
ksym-default-vsp1-isp-job-prepare \
ksym-default-vsp1-isp-job-release \
ksym-default-vsp1-isp-job-run \
ksym-default-vsp1-isp-start-streaming \
ksym-default-vsp1-isp-stop-streaming \
ksym-default-vsprintf \
ksym-default-vsscanf \
ksym-default-vt-get-leds \
ksym-default-vtime-guest-enter \
ksym-default-vtime-guest-exit \
ksym-default-vunmap \
ksym-default-vxlan-dev-create \
ksym-default-vxlan-fdb-clear-offload \
ksym-default-vxlan-fdb-find-uc \
ksym-default-vxlan-fdb-replay \
ksym-default-vzalloc-node-noprof \
ksym-default-vzalloc-noprof \
ksym-default-w1-add-master-device \
ksym-default-w1-calc-crc8 \
ksym-default-w1-ds2780-eeprom-cmd \
ksym-default-w1-ds2780-io \
ksym-default-w1-ds2781-eeprom-cmd \
ksym-default-w1-ds2781-io \
ksym-default-w1-next-pullup \
ksym-default-w1-read-8 \
ksym-default-w1-read-block \
ksym-default-w1-register-family \
ksym-default-w1-remove-master-device \
ksym-default-w1-reset-bus \
ksym-default-w1-reset-resume-command \
ksym-default-w1-reset-select-slave \
ksym-default-w1-touch-bit \
ksym-default-w1-touch-block \
ksym-default-w1-triplet \
ksym-default-w1-unregister-family \
ksym-default-w1-write-8 \
ksym-default-w1-write-block \
ksym-default-w5100-ops-priv \
ksym-default-w5100-pm-ops \
ksym-default-w5100-probe \
ksym-default-w5100-remove \
ksym-default-wait-for-completion \
ksym-default-wait-for-completion-interruptible \
ksym-default-wait-for-completion-interruptible-timeout \
ksym-default-wait-for-completion-io \
ksym-default-wait-for-completion-io-timeout \
ksym-default-wait-for-completion-killable \
ksym-default-wait-for-completion-killable-timeout \
ksym-default-wait-for-completion-state \
ksym-default-wait-for-completion-timeout \
ksym-default-wait-for-device-probe \
ksym-default-wait-for-initramfs \
ksym-default-wait-for-key-construction \
ksym-default-wait-for-random-bytes \
ksym-default-wait-on-new-inode \
ksym-default-wait-on-page-writeback \
ksym-default-wait-woken \
ksym-default-wake-bit-function \
ksym-default-wake-up-all-idle-cpus \
ksym-default-wake-up-bit \
ksym-default-wake-up-process \
ksym-default-wake-up-var \
ksym-default-wakeme-after-rcu \
ksym-default-wakeup-source-register \
ksym-default-wakeup-source-unregister \
ksym-default-wakeup-sources-read-lock \
ksym-default-wakeup-sources-read-unlock \
ksym-default-wakeup-sources-walk-next \
ksym-default-wakeup-sources-walk-start \
ksym-default-walk-hmem-resources \
ksym-default-walk-iomem-res-desc \
ksym-default-walk-soft-reserve-res \
ksym-default-watchdog-hardlockup-miss-thresh \
ksym-default-watchdog-init-timeout \
ksym-default-watchdog-notify-pretimeout \
ksym-default-watchdog-register-device \
ksym-default-watchdog-register-governor \
ksym-default-watchdog-set-last-hw-keepalive \
ksym-default-watchdog-set-restart-priority \
ksym-default-watchdog-unregister-device \
ksym-default-watchdog-unregister-governor \
ksym-default-wb-writeout-inc \
ksym-default-wbc-account-cgroup-owner \
ksym-default-wbc-attach-fdatawrite-inode \
ksym-default-wbc-detach-inode \
ksym-default-wbt-disable-default \
ksym-default-wbt-enable-default \
ksym-default-wcd-bus-config \
ksym-default-wcd-clsh-ctrl-alloc \
ksym-default-wcd-clsh-ctrl-free \
ksym-default-wcd-clsh-ctrl-get-state \
ksym-default-wcd-clsh-ctrl-set-state \
ksym-default-wcd-clsh-set-hph-mode \
ksym-default-wcd-dt-parse-mbhc-data \
ksym-default-wcd-dt-parse-micbias-info \
ksym-default-wcd-get-micb-vout-ctl-val \
ksym-default-wcd-interrupt-callback \
ksym-default-wcd-mbhc-deinit \
ksym-default-wcd-mbhc-event-notify \
ksym-default-wcd-mbhc-get-hph-type \
ksym-default-wcd-mbhc-get-impedance \
ksym-default-wcd-mbhc-init \
ksym-default-wcd-mbhc-set-hph-type \
ksym-default-wcd-mbhc-start \
ksym-default-wcd-mbhc-stop \
ksym-default-wcd-mbhc-typec-report-plug \
ksym-default-wcd-mbhc-typec-report-unplug \
ksym-default-wcd-sdw-component-ops \
ksym-default-wcd-update-status \
ksym-default-wcd938x-sdw-free \
ksym-default-wcd938x-sdw-hw-params \
ksym-default-wcd938x-sdw-set-sdw-stream \
ksym-default-wcd939x-sdw-free \
ksym-default-wcd939x-sdw-hw-params \
ksym-default-wcd939x-sdw-set-sdw-stream \
ksym-default-wdev-chandef \
ksym-default-wdev-to-ieee80211-vif \
ksym-default-widget-in-list \
ksym-default-wiphy-apply-custom-regulatory \
ksym-default-wiphy-delayed-work-cancel \
ksym-default-wiphy-delayed-work-flush \
ksym-default-wiphy-delayed-work-pending \
ksym-default-wiphy-delayed-work-queue \
ksym-default-wiphy-delayed-work-timer \
ksym-default-wiphy-free \
ksym-default-wiphy-hrtimer-work-cancel \
ksym-default-wiphy-hrtimer-work-flush \
ksym-default-wiphy-hrtimer-work-pending \
ksym-default-wiphy-hrtimer-work-queue \
ksym-default-wiphy-hrtimer-work-timer \
ksym-default-wiphy-new-nm \
ksym-default-wiphy-read-of-freq-limits \
ksym-default-wiphy-register \
ksym-default-wiphy-rfkill-set-hw-state-reason \
ksym-default-wiphy-rfkill-start-polling \
ksym-default-wiphy-to-ieee80211-hw \
ksym-default-wiphy-unregister \
ksym-default-wiphy-work-cancel \
ksym-default-wiphy-work-flush \
ksym-default-wiphy-work-queue \
ksym-default-wireless-nlevent-flush \
ksym-default-wireless-send-event \
ksym-default-wl1251-alloc-hw \
ksym-default-wl1251-free-hw \
ksym-default-wl1251-init-ieee80211 \
ksym-default-wl1271-acx-init-mem-config \
ksym-default-wl1271-acx-pm-config \
ksym-default-wl1271-acx-set-ht-capabilities \
ksym-default-wl1271-acx-sleep-auth \
ksym-default-wl1271-cmd-configure \
ksym-default-wl1271-cmd-data-path \
ksym-default-wl1271-cmd-send \
ksym-default-wl1271-cmd-test \
ksym-default-wl1271-debugfs-update-stats \
ksym-default-wl1271-format-buffer \
ksym-default-wl1271-free-tx-id \
ksym-default-wl1271-tx-flush \
ksym-default-wl1271-tx-min-rate-get \
ksym-default-wl12xx-acx-mem-cfg \
ksym-default-wl12xx-cmd-build-probe-req \
ksym-default-wl12xx-debug-level \
ksym-default-wl12xx-is-dummy-packet \
ksym-default-wlcore-alloc-hw \
ksym-default-wlcore-boot-run-firmware \
ksym-default-wlcore-boot-upload-firmware \
ksym-default-wlcore-boot-upload-nvs \
ksym-default-wlcore-calc-packet-alignment \
ksym-default-wlcore-cmd-generic-cfg \
ksym-default-wlcore-cmd-wait-for-event-or-timeout \
ksym-default-wlcore-disable-interrupts \
ksym-default-wlcore-disable-interrupts-nosync \
ksym-default-wlcore-enable-interrupts \
ksym-default-wlcore-event-ba-rx-constraint \
ksym-default-wlcore-event-beacon-loss \
ksym-default-wlcore-event-channel-switch \
ksym-default-wlcore-event-dummy-packet \
ksym-default-wlcore-event-fw-logger \
ksym-default-wlcore-event-inactive-sta \
ksym-default-wlcore-event-max-tx-failure \
ksym-default-wlcore-event-roc-complete \
ksym-default-wlcore-event-rssi-trigger \
ksym-default-wlcore-event-sched-scan-completed \
ksym-default-wlcore-event-soft-gemini-sense \
ksym-default-wlcore-free-hw \
ksym-default-wlcore-get-native-channel-type \
ksym-default-wlcore-probe \
ksym-default-wlcore-remove \
ksym-default-wlcore-scan-sched-scan-results \
ksym-default-wlcore-scan-sched-scan-ssid-list \
ksym-default-wlcore-set-key \
ksym-default-wlcore-set-partition \
ksym-default-wlcore-set-scan-chan-params \
ksym-default-wlcore-synchronize-interrupts \
ksym-default-wlcore-translate-addr \
ksym-default-wlcore-tx-complete \
ksym-default-wm-adsp-compr-copy \
ksym-default-wm-adsp-compr-free \
ksym-default-wm-adsp-compr-get-caps \
ksym-default-wm-adsp-compr-handle-irq \
ksym-default-wm-adsp-compr-open \
ksym-default-wm-adsp-compr-pointer \
ksym-default-wm-adsp-compr-set-params \
ksym-default-wm-adsp-compr-trigger \
ksym-default-wm-adsp-control-add \
ksym-default-wm-adsp-early-event \
ksym-default-wm-adsp-event \
ksym-default-wm-adsp-fw-enum \
ksym-default-wm-adsp-fw-get \
ksym-default-wm-adsp-fw-put \
ksym-default-wm-adsp-hibernate \
ksym-default-wm-adsp-power-down \
ksym-default-wm-adsp-power-up \
ksym-default-wm-adsp-read-ctl \
ksym-default-wm-adsp-run \
ksym-default-wm-adsp-stop \
ksym-default-wm-adsp-write-ctl \
ksym-default-wm-adsp1-event \
ksym-default-wm-adsp1-init \
ksym-default-wm-adsp2-bus-error \
ksym-default-wm-adsp2-component-probe \
ksym-default-wm-adsp2-component-remove \
ksym-default-wm-adsp2-init \
ksym-default-wm-adsp2-preloader-get \
ksym-default-wm-adsp2-preloader-put \
ksym-default-wm-adsp2-remove \
ksym-default-wm-adsp2-set-dspclk \
ksym-default-wm-halo-bus-error \
ksym-default-wm-halo-init \
ksym-default-wm-halo-wdt-expire \
ksym-default-wm-hubs-add-analogue-controls \
ksym-default-wm-hubs-add-analogue-routes \
ksym-default-wm-hubs-dcs-done \
ksym-default-wm-hubs-handle-analogue-pdata \
ksym-default-wm-hubs-hpl-mux \
ksym-default-wm-hubs-hpr-mux \
ksym-default-wm-hubs-set-bias-level \
ksym-default-wm-hubs-spkmix-tlv \
ksym-default-wm-hubs-update-class-w \
ksym-default-wm-hubs-vmid-ena \
ksym-default-wm1811-regmap-config \
ksym-default-wm8804-pm \
ksym-default-wm8804-probe \
ksym-default-wm8804-regmap-config \
ksym-default-wm8804-remove \
ksym-default-wm8903-mic-detect \
ksym-default-wm8958-mic-detect \
ksym-default-wm8958-regmap-config \
ksym-default-wm8962-mic-detect \
ksym-default-wm8994-base-regmap-config \
ksym-default-wm8994-irq-exit \
ksym-default-wm8994-irq-init \
ksym-default-wm8994-mic-detect \
ksym-default-wm8994-regmap-config \
ksym-default-wm9705-codec \
ksym-default-wm9712-codec \
ksym-default-wm9713-codec \
ksym-default-wm97xx-config-gpio \
ksym-default-wm97xx-get-gpio \
ksym-default-wm97xx-read-aux-adc \
ksym-default-wm97xx-reg-read \
ksym-default-wm97xx-reg-write \
ksym-default-wm97xx-register-mach-ops \
ksym-default-wm97xx-set-gpio \
ksym-default-wm97xx-set-suspend-mode \
ksym-default-wm97xx-unregister-mach-ops \
ksym-default-woken-wake-bit-function \
ksym-default-woken-wake-function \
ksym-default-work-busy \
ksym-default-work-on-cpu-key \
ksym-default-workqueue-congested \
ksym-default-workqueue-set-max-active \
ksym-default-would-dump \
ksym-default-wp-shared-mapping-range \
ksym-default-wpan-phy-find \
ksym-default-wpan-phy-for-each \
ksym-default-wpan-phy-free \
ksym-default-wpan-phy-new \
ksym-default-wpan-phy-register \
ksym-default-wpan-phy-unregister \
ksym-default-wrap-directory-iterator \
ksym-default-write-bytes-to-xdr-buf \
ksym-default-write-dirty-buffer \
ksym-default-write-dst \
ksym-default-write-inode-now \
ksym-default-writeback-inodes-sb \
ksym-default-writeback-inodes-sb-nr \
ksym-default-writeback-iter \
ksym-default-wsa-macro-set-spkr-mode \
ksym-default-ww-mutex-lock \
ksym-default-ww-mutex-lock-interruptible \
ksym-default-ww-mutex-trylock \
ksym-default-ww-mutex-unlock \
ksym-default-wwan-create-port \
ksym-default-wwan-port-get-drvdata \
ksym-default-wwan-port-rx \
ksym-default-wwan-port-txoff \
ksym-default-wwan-port-txon \
ksym-default-wwan-register-ops \
ksym-default-wwan-remove-port \
ksym-default-wwan-unregister-ops \
ksym-default-wx-change-mtu \
ksym-default-wx-check-flash-load \
ksym-default-wx-clean-all-rx-rings \
ksym-default-wx-clean-all-tx-rings \
ksym-default-wx-clear-hw-cntrs \
ksym-default-wx-clear-interrupt-scheme \
ksym-default-wx-configure \
ksym-default-wx-configure-rx \
ksym-default-wx-configure-vectors \
ksym-default-wx-configure-vf \
ksym-default-wx-control-hw \
ksym-default-wx-decode-ptype \
ksym-default-wx-disable-pcie-master \
ksym-default-wx-disable-rx \
ksym-default-wx-disable-rx-queue \
ksym-default-wx-disable-sec-rx-path \
ksym-default-wx-disable-sriov \
ksym-default-wx-disable-vf-rx-tx \
ksym-default-wx-enable-rx-queue \
ksym-default-wx-enable-sec-rx-path \
ksym-default-wx-fc-enable \
ksym-default-wx-features-check \
ksym-default-wx-fix-features \
ksym-default-wx-flush-sw-mac-table \
ksym-default-wx-free-irq \
ksym-default-wx-free-isb-resources \
ksym-default-wx-free-resources \
ksym-default-wx-get-channels \
ksym-default-wx-get-coalesce \
ksym-default-wx-get-drvinfo \
ksym-default-wx-get-ethtool-stats \
ksym-default-wx-get-fw-version-vf \
ksym-default-wx-get-link-ksettings \
ksym-default-wx-get-link-state-vf \
ksym-default-wx-get-mac-addr \
ksym-default-wx-get-mac-addr-vf \
ksym-default-wx-get-mac-stats \
ksym-default-wx-get-msglevel \
ksym-default-wx-get-pause-stats \
ksym-default-wx-get-pauseparam \
ksym-default-wx-get-pcie-msix-counts \
ksym-default-wx-get-ptp-stats \
ksym-default-wx-get-queues-vf \
ksym-default-wx-get-ringparam \
ksym-default-wx-get-rxfh \
ksym-default-wx-get-rxfh-fields \
ksym-default-wx-get-rxfh-key-size \
ksym-default-wx-get-sset-count \
ksym-default-wx-get-stats64 \
ksym-default-wx-get-strings \
ksym-default-wx-get-ts-info \
ksym-default-wx-get-wol \
ksym-default-wx-host-interface-command \
ksym-default-wx-hwtstamp-get \
ksym-default-wx-hwtstamp-set \
ksym-default-wx-init-eeprom-params \
ksym-default-wx-init-hw-vf \
ksym-default-wx-init-interrupt-scheme \
ksym-default-wx-init-mbx-params-vf \
ksym-default-wx-init-rx-addrs \
ksym-default-wx-intr-enable \
ksym-default-wx-irq-disable \
ksym-default-wx-mac-set-default-filter \
ksym-default-wx-misc-isb \
ksym-default-wx-mng-present \
ksym-default-wx-msg-task \
ksym-default-wx-msix-clean-rings \
ksym-default-wx-napi-disable-all \
ksym-default-wx-napi-enable-all \
ksym-default-wx-negotiate-api-version \
ksym-default-wx-negotiate-api-vf \
ksym-default-wx-nway-reset \
ksym-default-wx-pci-sriov-configure \
ksym-default-wx-phy-read-reg-mdi-c22 \
ksym-default-wx-phy-read-reg-mdi-c45 \
ksym-default-wx-phy-write-reg-mdi-c22 \
ksym-default-wx-phy-write-reg-mdi-c45 \
ksym-default-wx-ping-all-vfs-with-link-status \
ksym-default-wx-ptp-check-pps-event \
ksym-default-wx-ptp-init \
ksym-default-wx-ptp-reset \
ksym-default-wx-ptp-reset-cyclecounter \
ksym-default-wx-ptp-stop \
ksym-default-wx-ptp-suspend \
ksym-default-wx-read-ee-hostif \
ksym-default-wx-read-ee-hostif-buffer \
ksym-default-wx-request-msix-irqs-vf \
ksym-default-wx-reset-hw-vf \
ksym-default-wx-reset-interrupt-capability \
ksym-default-wx-reset-mac \
ksym-default-wx-reset-misc \
ksym-default-wx-reset-vf \
ksym-default-wx-rlpml-set-vf \
ksym-default-wx-rss-indir-size \
ksym-default-wx-service-event-complete \
ksym-default-wx-service-event-schedule \
ksym-default-wx-service-timer \
ksym-default-wx-set-all-vfs \
ksym-default-wx-set-channels \
ksym-default-wx-set-coalesce \
ksym-default-wx-set-ethtool-ops-vf \
ksym-default-wx-set-features \
ksym-default-wx-set-link-ksettings \
ksym-default-wx-set-mac \
ksym-default-wx-set-mac-vf \
ksym-default-wx-set-msglevel \
ksym-default-wx-set-pauseparam \
ksym-default-wx-set-rar-vf \
ksym-default-wx-set-ring \
ksym-default-wx-set-rx-mode \
ksym-default-wx-set-rx-mode-vf \
ksym-default-wx-set-rxfh \
ksym-default-wx-set-rxfh-fields \
ksym-default-wx-set-uc-addr-vf \
ksym-default-wx-set-vfta-vf \
ksym-default-wx-set-wol \
ksym-default-wx-setup-isb-resources \
ksym-default-wx-setup-resources \
ksym-default-wx-start-hw \
ksym-default-wx-stop-adapter \
ksym-default-wx-stop-adapter-vf \
ksym-default-wx-sw-init \
ksym-default-wx-update-mc-addr-list-vf \
ksym-default-wx-update-stats \
ksym-default-wx-update-xcast-mode-vf \
ksym-default-wx-vlan-rx-add-vid \
ksym-default-wx-vlan-rx-kill-vid \
ksym-default-wx-xmit-frame \
ksym-default-wxvf-close \
ksym-default-wxvf-init-service \
ksym-default-wxvf-open \
ksym-default-wxvf-remove \
ksym-default-wxvf-resume \
ksym-default-wxvf-shutdown \
ksym-default-wxvf-suspend \
ksym-default-wxvf-watchdog-update-link \
ksym-default-x509-cert-parse \
ksym-default-x509-decode-time \
ksym-default-x509-free-certificate \
ksym-default-x509-load-certificate-list \
ksym-default-xa-clear-mark \
ksym-default-xa-delete-node \
ksym-default-xa-destroy \
ksym-default-xa-erase \
ksym-default-xa-extract \
ksym-default-xa-find \
ksym-default-xa-find-after \
ksym-default-xa-get-mark \
ksym-default-xa-get-order \
ksym-default-xa-load \
ksym-default-xa-set-mark \
ksym-default-xa-store \
ksym-default-xa-store-range \
ksym-default-xas-clear-mark \
ksym-default-xas-create-range \
ksym-default-xas-destroy \
ksym-default-xas-find \
ksym-default-xas-find-conflict \
ksym-default-xas-find-marked \
ksym-default-xas-get-mark \
ksym-default-xas-get-order \
ksym-default-xas-init-marks \
ksym-default-xas-load \
ksym-default-xas-nomem \
ksym-default-xas-pause \
ksym-default-xas-set-mark \
ksym-default-xas-split \
ksym-default-xas-split-alloc \
ksym-default-xas-store \
ksym-default-xas-try-split \
ksym-default-xas-try-split-min-order \
ksym-default-xattr-full-name \
ksym-default-xattr-supports-user-prefix \
ksym-default-xc2028-attach \
ksym-default-xc4000-attach \
ksym-default-xc5000-attach \
ksym-default-xchacha20poly1305-decrypt \
ksym-default-xchacha20poly1305-encrypt \
ksym-default-xcv-init-hw \
ksym-default-xcv-setup-link \
ksym-default-xdma-disable-user-irq \
ksym-default-xdma-enable-user-irq \
ksym-default-xdma-get-user-irq \
ksym-default-xdp-attachment-setup \
ksym-default-xdp-build-skb-from-buff \
ksym-default-xdp-build-skb-from-frame \
ksym-default-xdp-build-skb-from-zc \
ksym-default-xdp-convert-zc-to-xdp-frame \
ksym-default-xdp-do-flush \
ksym-default-xdp-do-redirect \
ksym-default-xdp-do-redirect-frame \
ksym-default-xdp-features-clear-redirect-target \
ksym-default-xdp-features-clear-redirect-target-locked \
ksym-default-xdp-features-set-redirect-target \
ksym-default-xdp-features-set-redirect-target-locked \
ksym-default-xdp-master-redirect \
ksym-default-xdp-reg-mem-model \
ksym-default-xdp-reg-page-pool \
ksym-default-xdp-return-buff \
ksym-default-xdp-return-frag \
ksym-default-xdp-return-frame \
ksym-default-xdp-return-frame-bulk \
ksym-default-xdp-return-frame-rx-napi \
ksym-default-xdp-rxq-info-attach-page-pool \
ksym-default-xdp-rxq-info-is-reg \
ksym-default-xdp-rxq-info-reg-mem-model \
ksym-default-xdp-rxq-info-unreg \
ksym-default-xdp-rxq-info-unreg-mem-model \
ksym-default-xdp-rxq-info-unused \
ksym-default-xdp-set-features-flag \
ksym-default-xdp-set-features-flag-locked \
ksym-default-xdp-unreg-mem-model \
ksym-default-xdp-unreg-page-pool \
ksym-default-xdp-warn \
ksym-default-xdr-buf-from-iov \
ksym-default-xdr-buf-subsegment \
ksym-default-xdr-buf-to-bvec \
ksym-default-xdr-buf-to-sg \
ksym-default-xdr-buf-to-sg-alloc \
ksym-default-xdr-buf-trim \
ksym-default-xdr-decode-array2 \
ksym-default-xdr-decode-word \
ksym-default-xdr-encode-array2 \
ksym-default-xdr-encode-netobj \
ksym-default-xdr-encode-opaque \
ksym-default-xdr-encode-opaque-fixed \
ksym-default-xdr-encode-string \
ksym-default-xdr-encode-word \
ksym-default-xdr-enter-page \
ksym-default-xdr-finish-decode \
ksym-default-xdr-init-decode \
ksym-default-xdr-init-decode-pages \
ksym-default-xdr-init-encode \
ksym-default-xdr-init-encode-pages \
ksym-default-xdr-inline-decode \
ksym-default-xdr-inline-pages \
ksym-default-xdr-page-pos \
ksym-default-xdr-read-pages \
ksym-default-xdr-reserve-space \
ksym-default-xdr-reserve-space-vec \
ksym-default-xdr-restrict-buflen \
ksym-default-xdr-set-pagelen \
ksym-default-xdr-stream-decode-opaque-auth \
ksym-default-xdr-stream-decode-string-dup \
ksym-default-xdr-stream-encode-opaque-auth \
ksym-default-xdr-stream-move-subsegment \
ksym-default-xdr-stream-pos \
ksym-default-xdr-stream-subsegment \
ksym-default-xdr-stream-zero \
ksym-default-xdr-terminate-string \
ksym-default-xdr-truncate-decode \
ksym-default-xdr-truncate-encode \
ksym-default-xdr-write-pages \
ksym-default-xe-sriov-vfio-data-read \
ksym-default-xe-sriov-vfio-data-write \
ksym-default-xe-sriov-vfio-error \
ksym-default-xe-sriov-vfio-flr-prepare \
ksym-default-xe-sriov-vfio-get-pf \
ksym-default-xe-sriov-vfio-migration-supported \
ksym-default-xe-sriov-vfio-resume-data-enter \
ksym-default-xe-sriov-vfio-resume-data-exit \
ksym-default-xe-sriov-vfio-resume-device \
ksym-default-xe-sriov-vfio-stop-copy-enter \
ksym-default-xe-sriov-vfio-stop-copy-exit \
ksym-default-xe-sriov-vfio-stop-copy-size \
ksym-default-xe-sriov-vfio-suspend-device \
ksym-default-xe-sriov-vfio-wait-flr-done \
ksym-default-xfer-to-guest-mode-handle-work \
ksym-default-xfrm-aalg-get-byid \
ksym-default-xfrm-aalg-get-byidx \
ksym-default-xfrm-aalg-get-byname \
ksym-default-xfrm-aead-get-byname \
ksym-default-xfrm-alloc-spi \
ksym-default-xfrm-audit-policy-add \
ksym-default-xfrm-audit-policy-delete \
ksym-default-xfrm-audit-state-add \
ksym-default-xfrm-audit-state-delete \
ksym-default-xfrm-audit-state-icvfail \
ksym-default-xfrm-audit-state-notfound \
ksym-default-xfrm-audit-state-notfound-simple \
ksym-default-xfrm-audit-state-replay \
ksym-default-xfrm-audit-state-replay-overflow \
ksym-default-xfrm-bpf-md-dst \
ksym-default-xfrm-calg-get-byid \
ksym-default-xfrm-calg-get-byname \
ksym-default-xfrm-count-pfkey-auth-supported \
ksym-default-xfrm-count-pfkey-enc-supported \
ksym-default-xfrm-dev-offload-ok \
ksym-default-xfrm-dev-policy-add \
ksym-default-xfrm-dev-policy-flush \
ksym-default-xfrm-dev-resume \
ksym-default-xfrm-dev-state-add \
ksym-default-xfrm-dev-state-delete \
ksym-default-xfrm-dev-state-flush \
ksym-default-xfrm-dst-ifdown \
ksym-default-xfrm-ealg-get-byid \
ksym-default-xfrm-ealg-get-byidx \
ksym-default-xfrm-ealg-get-byname \
ksym-default-xfrm-find-acq \
ksym-default-xfrm-find-acq-byseq \
ksym-default-xfrm-flush-gc \
ksym-default-xfrm-get-acqseq \
ksym-default-xfrm-if-register-cb \
ksym-default-xfrm-if-unregister-cb \
ksym-default-xfrm-init-replay \
ksym-default-xfrm-init-state \
ksym-default-xfrm-input \
ksym-default-xfrm-input-register-afinfo \
ksym-default-xfrm-input-resume \
ksym-default-xfrm-input-state-lookup \
ksym-default-xfrm-input-unregister-afinfo \
ksym-default-xfrm-local-error \
ksym-default-xfrm-lookup \
ksym-default-xfrm-lookup-route \
ksym-default-xfrm-lookup-with-ifid \
ksym-default-xfrm-migrate \
ksym-default-xfrm-migrate-state-find \
ksym-default-xfrm-msg-min \
ksym-default-xfrm-nat-keepalive-fini \
ksym-default-xfrm-nat-keepalive-init \
ksym-default-xfrm-output \
ksym-default-xfrm-output-resume \
ksym-default-xfrm-parse-spi \
ksym-default-xfrm-policy-alloc \
ksym-default-xfrm-policy-byid \
ksym-default-xfrm-policy-bysel-ctx \
ksym-default-xfrm-policy-delete \
ksym-default-xfrm-policy-destroy \
ksym-default-xfrm-policy-flush \
ksym-default-xfrm-policy-hash-rebuild \
ksym-default-xfrm-policy-insert \
ksym-default-xfrm-policy-register-afinfo \
ksym-default-xfrm-policy-unregister-afinfo \
ksym-default-xfrm-policy-walk \
ksym-default-xfrm-policy-walk-done \
ksym-default-xfrm-policy-walk-init \
ksym-default-xfrm-probe-algs \
ksym-default-xfrm-register-km \
ksym-default-xfrm-register-mode-cbs \
ksym-default-xfrm-register-type \
ksym-default-xfrm-register-type-offload \
ksym-default-xfrm-replay-seqhi \
ksym-default-xfrm-sad-getinfo \
ksym-default-xfrm-set-type-offload \
ksym-default-xfrm-spd-getinfo \
ksym-default-xfrm-state-add \
ksym-default-xfrm-state-afinfo-get-rcu \
ksym-default-xfrm-state-alloc \
ksym-default-xfrm-state-check-expire \
ksym-default-xfrm-state-delete \
ksym-default-xfrm-state-flush \
ksym-default-xfrm-state-free \
ksym-default-xfrm-state-insert \
ksym-default-xfrm-state-lookup \
ksym-default-xfrm-state-lookup-byaddr \
ksym-default-xfrm-state-lookup-byspi \
ksym-default-xfrm-state-migrate \
ksym-default-xfrm-state-migrate-create \
ksym-default-xfrm-state-migrate-install \
ksym-default-xfrm-state-mtu \
ksym-default-xfrm-state-register-afinfo \
ksym-default-xfrm-state-unregister-afinfo \
ksym-default-xfrm-state-update \
ksym-default-xfrm-state-walk \
ksym-default-xfrm-state-walk-done \
ksym-default-xfrm-state-walk-init \
ksym-default-xfrm-stateonly-find \
ksym-default-xfrm-trans-queue \
ksym-default-xfrm-trans-queue-net \
ksym-default-xfrm-unregister-km \
ksym-default-xfrm-unregister-mode-cbs \
ksym-default-xfrm-unregister-type \
ksym-default-xfrm-unregister-type-offload \
ksym-default-xfrm-user-policy \
ksym-default-xfrm4-gro-udp-encap-rcv \
ksym-default-xfrm4-protocol-deregister \
ksym-default-xfrm4-protocol-register \
ksym-default-xfrm4-rcv \
ksym-default-xfrm4-rcv-encap \
ksym-default-xfrm4-tunnel-check-size \
ksym-default-xfrm4-tunnel-deregister \
ksym-default-xfrm4-tunnel-register \
ksym-default-xfrm4-udp-encap-rcv \
ksym-default-xfrm6-input-addr \
ksym-default-xfrm6-protocol-deregister \
ksym-default-xfrm6-protocol-register \
ksym-default-xfrm6-rcv \
ksym-default-xfrm6-rcv-encap \
ksym-default-xfrm6-rcv-spi \
ksym-default-xfrm6-rcv-tnl \
ksym-default-xfrm6-tunnel-alloc-spi \
ksym-default-xfrm6-tunnel-check-size \
ksym-default-xfrm6-tunnel-deregister \
ksym-default-xfrm6-tunnel-register \
ksym-default-xfrm6-tunnel-spi-lookup \
ksym-default-xfrma-policy \
ksym-default-xgene-enet-phy-register \
ksym-default-xgene-mdio-rd-mac \
ksym-default-xgene-mdio-rgmii-read \
ksym-default-xgene-mdio-rgmii-write \
ksym-default-xgene-mdio-wr-mac \
ksym-default-xhci-add-endpoint \
ksym-default-xhci-check-bandwidth \
ksym-default-xhci-create-secondary-interrupter \
ksym-default-xhci-dbg-trace \
ksym-default-xhci-drop-endpoint \
ksym-default-xhci-ext-cap-init \
ksym-default-xhci-gen-setup \
ksym-default-xhci-get-endpoint-index \
ksym-default-xhci-get-ep-ctx \
ksym-default-xhci-hub-control \
ksym-default-xhci-init-driver \
ksym-default-xhci-initialize-ring-info \
ksym-default-xhci-msi-irq \
ksym-default-xhci-pci-common-probe \
ksym-default-xhci-pci-remove \
ksym-default-xhci-plat-pm-ops \
ksym-default-xhci-plat-probe \
ksym-default-xhci-plat-remove \
ksym-default-xhci-port-state-to-neutral \
ksym-default-xhci-portsc-readl \
ksym-default-xhci-portsc-writel \
ksym-default-xhci-remove-secondary-interrupter \
ksym-default-xhci-reset-bandwidth \
ksym-default-xhci-resume \
ksym-default-xhci-run \
ksym-default-xhci-shutdown \
ksym-default-xhci-sideband-add-endpoint \
ksym-default-xhci-sideband-check \
ksym-default-xhci-sideband-create-interrupter \
ksym-default-xhci-sideband-get-endpoint-buffer \
ksym-default-xhci-sideband-get-event-buffer \
ksym-default-xhci-sideband-interrupter-id \
ksym-default-xhci-sideband-notify-ep-ring-free \
ksym-default-xhci-sideband-register \
ksym-default-xhci-sideband-remove-endpoint \
ksym-default-xhci-sideband-remove-interrupter \
ksym-default-xhci-sideband-stop-endpoint \
ksym-default-xhci-sideband-unregister \
ksym-default-xhci-stop \
ksym-default-xhci-stop-endpoint-sync \
ksym-default-xhci-suspend \
ksym-default-xhci-update-hub-device \
ksym-default-xilinx-core-probe \
ksym-default-xilinx-vdma-channel-set-config \
ksym-default-xillybus-cleanup-chrdev \
ksym-default-xillybus-endpoint-discovery \
ksym-default-xillybus-endpoint-remove \
ksym-default-xillybus-find-inode \
ksym-default-xillybus-init-chrdev \
ksym-default-xillybus-init-endpoint \
ksym-default-xillybus-isr \
ksym-default-xlnx-get-crypto-dev-data \
ksym-default-xlnx-register-event \
ksym-default-xlnx-unregister-event \
ksym-default-xor-gen \
ksym-default-xp-alloc \
ksym-default-xp-alloc-batch \
ksym-default-xp-can-alloc \
ksym-default-xp-dma-map \
ksym-default-xp-dma-unmap \
ksym-default-xp-fill-cb \
ksym-default-xp-free \
ksym-default-xp-raw-get-ctx \
ksym-default-xp-raw-get-data \
ksym-default-xp-raw-get-dma \
ksym-default-xp-set-rxq-info \
ksym-default-xpcs-config-eee-mult-fact \
ksym-default-xpcs-create-fwnode \
ksym-default-xpcs-create-mdiodev \
ksym-default-xpcs-create-pcs-mdiodev \
ksym-default-xpcs-destroy \
ksym-default-xpcs-destroy-pcs \
ksym-default-xpcs-get-an-mode \
ksym-default-xpcs-to-phylink-pcs \
ksym-default-xprt-add-backlog \
ksym-default-xprt-add-backlog-noncongested \
ksym-default-xprt-adjust-cwnd \
ksym-default-xprt-alloc \
ksym-default-xprt-alloc-slot \
ksym-default-xprt-complete-rqst \
ksym-default-xprt-destroy-backchannel \
ksym-default-xprt-disconnect-done \
ksym-default-xprt-enqueue-bc-request \
ksym-default-xprt-find-transport-ident \
ksym-default-xprt-force-disconnect \
ksym-default-xprt-free \
ksym-default-xprt-free-slot \
ksym-default-xprt-get \
ksym-default-xprt-lock-connect \
ksym-default-xprt-lookup-rqst \
ksym-default-xprt-pin-rqst \
ksym-default-xprt-put \
ksym-default-xprt-reconnect-backoff \
ksym-default-xprt-reconnect-delay \
ksym-default-xprt-register-transport \
ksym-default-xprt-release-rqst-cong \
ksym-default-xprt-release-xprt \
ksym-default-xprt-release-xprt-cong \
ksym-default-xprt-request-get-cong \
ksym-default-xprt-reserve-xprt \
ksym-default-xprt-reserve-xprt-cong \
ksym-default-xprt-setup-backchannel \
ksym-default-xprt-svc-destroy-nullify-bc \
ksym-default-xprt-svc-shutdown-bc \
ksym-default-xprt-unlock-connect \
ksym-default-xprt-unpin-rqst \
ksym-default-xprt-unregister-transport \
ksym-default-xprt-update-rtt \
ksym-default-xprt-wait-for-buffer-space \
ksym-default-xprt-wait-for-reply-request-def \
ksym-default-xprt-wait-for-reply-request-rtt \
ksym-default-xprt-wake-pending-tasks \
ksym-default-xprt-wake-up-backlog \
ksym-default-xprt-write-space \
ksym-default-xprtiod-workqueue \
ksym-default-xrs7003e-info \
ksym-default-xrs7003f-info \
ksym-default-xrs7004e-info \
ksym-default-xrs7004f-info \
ksym-default-xrs700x-switch-alloc \
ksym-default-xrs700x-switch-register \
ksym-default-xrs700x-switch-remove \
ksym-default-xrs700x-switch-shutdown \
ksym-default-xsk-clear-rx-need-wakeup \
ksym-default-xsk-clear-tx-need-wakeup \
ksym-default-xsk-get-pool-from-qid \
ksym-default-xsk-set-rx-need-wakeup \
ksym-default-xsk-set-tx-need-wakeup \
ksym-default-xsk-tx-completed \
ksym-default-xsk-tx-peek-desc \
ksym-default-xsk-tx-peek-release-desc-batch \
ksym-default-xsk-tx-release \
ksym-default-xsk-uses-need-wakeup \
ksym-default-xspi-dirmap-write \
ksym-default-xt-alloc-entry-offsets \
ksym-default-xt-alloc-table-info \
ksym-default-xt-check-entry-offsets \
ksym-default-xt-check-hooks-match \
ksym-default-xt-check-hooks-target \
ksym-default-xt-check-match \
ksym-default-xt-check-proc-name \
ksym-default-xt-check-table-hooks \
ksym-default-xt-check-target \
ksym-default-xt-compat-add-offset \
ksym-default-xt-compat-calc-jump \
ksym-default-xt-compat-check-entry-offsets \
ksym-default-xt-compat-flush-offsets \
ksym-default-xt-compat-init-offsets \
ksym-default-xt-compat-lock \
ksym-default-xt-compat-match-from-user \
ksym-default-xt-compat-match-offset \
ksym-default-xt-compat-match-to-user \
ksym-default-xt-compat-target-from-user \
ksym-default-xt-compat-target-offset \
ksym-default-xt-compat-target-to-user \
ksym-default-xt-compat-unlock \
ksym-default-xt-copy-counters \
ksym-default-xt-counters-alloc \
ksym-default-xt-data-to-user \
ksym-default-xt-find-jump-offset \
ksym-default-xt-find-match \
ksym-default-xt-find-revision \
ksym-default-xt-find-table \
ksym-default-xt-find-table-lock \
ksym-default-xt-free-table-info \
ksym-default-xt-hook-ops-alloc \
ksym-default-xt-match-to-user \
ksym-default-xt-percpu-counter-alloc \
ksym-default-xt-percpu-counter-free \
ksym-default-xt-proto-fini \
ksym-default-xt-proto-init \
ksym-default-xt-rateest-lookup \
ksym-default-xt-rateest-put \
ksym-default-xt-recseq \
ksym-default-xt-register-match \
ksym-default-xt-register-matches \
ksym-default-xt-register-table \
ksym-default-xt-register-target \
ksym-default-xt-register-targets \
ksym-default-xt-register-template \
ksym-default-xt-replace-table \
ksym-default-xt-request-find-match \
ksym-default-xt-request-find-table-lock \
ksym-default-xt-request-find-target \
ksym-default-xt-table-unlock \
ksym-default-xt-target-to-user \
ksym-default-xt-tee-enabled \
ksym-default-xt-unregister-match \
ksym-default-xt-unregister-matches \
ksym-default-xt-unregister-table-exit \
ksym-default-xt-unregister-table-pre-exit \
ksym-default-xt-unregister-target \
ksym-default-xt-unregister-targets \
ksym-default-xt-unregister-template \
ksym-default-xvip-cleanup-resources \
ksym-default-xvip-clr-and-set \
ksym-default-xvip-clr-or-set \
ksym-default-xvip-enum-frame-size \
ksym-default-xvip-enum-mbus-code \
ksym-default-xvip-get-format-by-code \
ksym-default-xvip-get-format-by-fourcc \
ksym-default-xvip-init-resources \
ksym-default-xvip-of-get-format \
ksym-default-xvip-set-format-size \
ksym-default-xvtc-generator-start \
ksym-default-xvtc-generator-stop \
ksym-default-xvtc-of-get \
ksym-default-xvtc-put \
ksym-default-xxh32 \
ksym-default-xxh64 \
ksym-default-xxh64-digest \
ksym-default-xxh64-reset \
ksym-default-xxh64-update \
ksym-default-xz-dec-end \
ksym-default-xz-dec-init \
ksym-default-xz-dec-microlzma-alloc \
ksym-default-xz-dec-microlzma-end \
ksym-default-xz-dec-microlzma-reset \
ksym-default-xz-dec-microlzma-run \
ksym-default-xz-dec-reset \
ksym-default-xz-dec-run \
ksym-default-yield \
ksym-default-yield-to \
ksym-default-yoga-c630-ec-read16 \
ksym-default-yoga-c630-ec-read8 \
ksym-default-yoga-c630-ec-register-notify \
ksym-default-yoga-c630-ec-ucsi-get-version \
ksym-default-yoga-c630-ec-ucsi-read \
ksym-default-yoga-c630-ec-ucsi-write \
ksym-default-yoga-c630-ec-unregister-notify \
ksym-default-zap-special-vma-range \
ksym-default-zd1301-demod-get-dvb-frontend \
ksym-default-zd1301-demod-get-i2c-adapter \
ksym-default-zero-fill-bio \
ksym-default-zero-page-pfn \
ksym-default-zerocopy-sg-from-iter \
ksym-default-zgid \
ksym-default-zl10036-attach \
ksym-default-zl10039-attach \
ksym-default-zl10353-attach \
ksym-default-zl3073x-dev-probe \
ksym-default-zl3073x-devm-alloc \
ksym-default-zl3073x-regmap-config \
ksym-default-zlib-deflate \
ksym-default-zlib-deflate-dfltcc-enabled \
ksym-default-zlib-deflate-workspacesize \
ksym-default-zlib-deflateEnd \
ksym-default-zlib-deflateInit2 \
ksym-default-zlib-deflateReset \
ksym-default-zlib-inflate \
ksym-default-zlib-inflate-blob \
ksym-default-zlib-inflate-workspacesize \
ksym-default-zlib-inflateEnd \
ksym-default-zlib-inflateIncomp \
ksym-default-zlib-inflateInit2 \
ksym-default-zlib-inflateReset \
ksym-default-zone-device-page-init \
ksym-default-zpa2326-isreg-precious \
ksym-default-zpa2326-isreg-readable \
ksym-default-zpa2326-isreg-writeable \
ksym-default-zpa2326-pm-ops \
ksym-default-zpa2326-probe \
ksym-default-zpa2326-remove \
ksym-default-zs-compact \
ksym-default-zs-create-pool \
ksym-default-zs-destroy-pool \
ksym-default-zs-free \
ksym-default-zs-get-total-pages \
ksym-default-zs-huge-class-size \
ksym-default-zs-lookup-class-index \
ksym-default-zs-malloc \
ksym-default-zs-obj-read-begin \
ksym-default-zs-obj-read-end \
ksym-default-zs-obj-read-sg-begin \
ksym-default-zs-obj-read-sg-end \
ksym-default-zs-obj-write \
ksym-default-zs-pool-stats \
ksym-default-zstd-cctx-set-param \
ksym-default-zstd-cctx-workspace-bound \
ksym-default-zstd-cctx-workspace-bound-with-ext-seq-prod \
ksym-default-zstd-compress-bound \
ksym-default-zstd-compress-cctx \
ksym-default-zstd-compress-sequences-and-literals \
ksym-default-zstd-compress-stream \
ksym-default-zstd-compress-using-cdict \
ksym-default-zstd-create-cctx-advanced \
ksym-default-zstd-create-cdict-byreference \
ksym-default-zstd-create-dctx-advanced \
ksym-default-zstd-create-ddict-byreference \
ksym-default-zstd-cstream-workspace-bound \
ksym-default-zstd-cstream-workspace-bound-with-ext-seq-prod \
ksym-default-zstd-dctx-workspace-bound \
ksym-default-zstd-decompress-dctx \
ksym-default-zstd-decompress-stream \
ksym-default-zstd-decompress-using-ddict \
ksym-default-zstd-default-clevel \
ksym-default-zstd-dstream-workspace-bound \
ksym-default-zstd-end-stream \
ksym-default-zstd-find-frame-compressed-size \
ksym-default-zstd-flush-stream \
ksym-default-zstd-free-cctx \
ksym-default-zstd-free-cdict \
ksym-default-zstd-free-dctx \
ksym-default-zstd-free-ddict \
ksym-default-zstd-get-cparams \
ksym-default-zstd-get-error-code \
ksym-default-zstd-get-error-name \
ksym-default-zstd-get-frame-header \
ksym-default-zstd-get-params \
ksym-default-zstd-init-cctx \
ksym-default-zstd-init-cstream \
ksym-default-zstd-init-dctx \
ksym-default-zstd-init-dstream \
ksym-default-zstd-is-error \
ksym-default-zstd-max-clevel \
ksym-default-zstd-min-clevel \
ksym-default-zstd-register-sequence-producer \
ksym-default-zstd-reset-cstream \
ksym-default-zstd-reset-dstream \
ksym-default-zynqmp-pm-aes-engine \
ksym-default-zynqmp-pm-bootmode-read \
ksym-default-zynqmp-pm-bootmode-write \
ksym-default-zynqmp-pm-clock-disable \
ksym-default-zynqmp-pm-clock-enable \
ksym-default-zynqmp-pm-clock-getdivider \
ksym-default-zynqmp-pm-clock-getparent \
ksym-default-zynqmp-pm-clock-getstate \
ksym-default-zynqmp-pm-clock-setdivider \
ksym-default-zynqmp-pm-clock-setparent \
ksym-default-zynqmp-pm-efuse-access \
ksym-default-zynqmp-pm-feature \
ksym-default-zynqmp-pm-force-pwrdwn \
ksym-default-zynqmp-pm-fpga-get-config-status \
ksym-default-zynqmp-pm-fpga-get-status \
ksym-default-zynqmp-pm-fpga-load \
ksym-default-zynqmp-pm-get-api-version \
ksym-default-zynqmp-pm-get-chipid \
ksym-default-zynqmp-pm-get-family-info \
ksym-default-zynqmp-pm-get-node-status \
ksym-default-zynqmp-pm-get-pll-frac-data \
ksym-default-zynqmp-pm-get-pll-frac-mode \
ksym-default-zynqmp-pm-get-rpu-mode \
ksym-default-zynqmp-pm-get-rpu-node-status \
ksym-default-zynqmp-pm-get-ufs-calibration-values \
ksym-default-zynqmp-pm-is-function-supported \
ksym-default-zynqmp-pm-is-mphy-tx-rx-config-ready \
ksym-default-zynqmp-pm-is-sram-init-done \
ksym-default-zynqmp-pm-load-pdi \
ksym-default-zynqmp-pm-ospi-mux-select \
ksym-default-zynqmp-pm-pinctrl-get-config \
ksym-default-zynqmp-pm-pinctrl-release \
ksym-default-zynqmp-pm-pinctrl-request \
ksym-default-zynqmp-pm-pinctrl-set-config \
ksym-default-zynqmp-pm-pinctrl-set-function \
ksym-default-zynqmp-pm-query-data \
ksym-default-zynqmp-pm-read-ggs \
ksym-default-zynqmp-pm-read-pggs \
ksym-default-zynqmp-pm-register-notifier \
ksym-default-zynqmp-pm-release-node \
ksym-default-zynqmp-pm-request-node \
ksym-default-zynqmp-pm-request-wake \
ksym-default-zynqmp-pm-reset-assert \
ksym-default-zynqmp-pm-reset-get-status \
ksym-default-zynqmp-pm-sd-dll-reset \
ksym-default-zynqmp-pm-sec-mask-write-reg \
ksym-default-zynqmp-pm-sec-read-reg \
ksym-default-zynqmp-pm-set-gem-config \
ksym-default-zynqmp-pm-set-pll-frac-data \
ksym-default-zynqmp-pm-set-pll-frac-mode \
ksym-default-zynqmp-pm-set-requirement \
ksym-default-zynqmp-pm-set-rpu-mode \
ksym-default-zynqmp-pm-set-sd-config \
ksym-default-zynqmp-pm-set-sd-tapdelay \
ksym-default-zynqmp-pm-set-sram-bypass \
ksym-default-zynqmp-pm-set-suspend-mode \
ksym-default-zynqmp-pm-set-tapdelay-bypass \
ksym-default-zynqmp-pm-set-tcm-config \
ksym-default-zynqmp-pm-sha-hash \
ksym-default-zynqmp-pm-write-ggs \
ksym-default-zynqmp-pm-write-pggs \
multiversion-kernel"

RDEPENDS:${PN} += "/usr/bin/sh \
awk \
coreutils \
distribution-release \
kmod-zstd \
modutils \
suse-kernel-rpm-scriptlets \
suse-module-tools"

inherit rpm
