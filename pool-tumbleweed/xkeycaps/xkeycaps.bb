SUMMARY = "A graphical frontend for 'xmodmap'"
DESCRIPTION = "'xkeycaps' is a graphical front-end to 'xmodmap'. It opens a window \
that looks like a keyboard. Moving the mouse over a key shows what \
KeySyms and Modifier bits that key generates. Clicking on a key \
simulates KeyPress/KeyRelease events on the window of your choice. It \
is possible to change the KeySyms and Modifiers generated by a key \
through a mouse-based interface. This program can also write an input \
file for xmodmap to recreate your changes in future sessions."
LICENSE = "MIT"

PV = "2.46"

RPM_NAME = "xkeycaps-2.46-975.5.aarch64.rpm"
RPM_HASH = "709ad871d07696d1e31a3dc85baa26eeabab2feb484a125718606c49392f7a35bce5610c72314abd3819142cceef505384f698d2d5ab090ae08c0a12d5238f4e"

RPROVIDES:${PN} += "xkeycaps"

RDEPENDS:${PN} += "libX11.so.6 \
libXaw.so.7 \
libXmu.so.6 \
libXt.so.6 \
libc.so.6"

inherit rpm
