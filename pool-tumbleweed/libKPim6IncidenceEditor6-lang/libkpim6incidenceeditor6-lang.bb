SUMMARY = "Translations for package libKPim6IncidenceEditor6"
DESCRIPTION = "Provides translations for the 'libKPim6IncidenceEditor6' package."
LICENSE = "GPL-2.0-or-later & LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6IncidenceEditor6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "bd560eebc1597b9f6d26a1a12a72077facf32628d135ff2af026ed04a992f1e740aad70ae4d2dcb4307d34234224622b7e8f2c336bc8593951dd2f60c81fe0cd"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6IncidenceEditor6-lang \
libKPim6IncidenceEditor6-lang-all \
locale-libKPim6IncidenceEditor6-ar \
locale-libKPim6IncidenceEditor6-ast \
locale-libKPim6IncidenceEditor6-bg \
locale-libKPim6IncidenceEditor6-bs \
locale-libKPim6IncidenceEditor6-ca \
locale-libKPim6IncidenceEditor6-ca@valencia \
locale-libKPim6IncidenceEditor6-cs \
locale-libKPim6IncidenceEditor6-da \
locale-libKPim6IncidenceEditor6-de \
locale-libKPim6IncidenceEditor6-el \
locale-libKPim6IncidenceEditor6-en-GB \
locale-libKPim6IncidenceEditor6-eo \
locale-libKPim6IncidenceEditor6-es \
locale-libKPim6IncidenceEditor6-et \
locale-libKPim6IncidenceEditor6-eu \
locale-libKPim6IncidenceEditor6-fi \
locale-libKPim6IncidenceEditor6-fr \
locale-libKPim6IncidenceEditor6-ga \
locale-libKPim6IncidenceEditor6-gl \
locale-libKPim6IncidenceEditor6-hi \
locale-libKPim6IncidenceEditor6-hu \
locale-libKPim6IncidenceEditor6-ia \
locale-libKPim6IncidenceEditor6-it \
locale-libKPim6IncidenceEditor6-ja \
locale-libKPim6IncidenceEditor6-ka \
locale-libKPim6IncidenceEditor6-kk \
locale-libKPim6IncidenceEditor6-ko \
locale-libKPim6IncidenceEditor6-lt \
locale-libKPim6IncidenceEditor6-mai \
locale-libKPim6IncidenceEditor6-mr \
locale-libKPim6IncidenceEditor6-nb \
locale-libKPim6IncidenceEditor6-nds \
locale-libKPim6IncidenceEditor6-nl \
locale-libKPim6IncidenceEditor6-pa \
locale-libKPim6IncidenceEditor6-pl \
locale-libKPim6IncidenceEditor6-pt \
locale-libKPim6IncidenceEditor6-pt-BR \
locale-libKPim6IncidenceEditor6-ro \
locale-libKPim6IncidenceEditor6-ru \
locale-libKPim6IncidenceEditor6-sk \
locale-libKPim6IncidenceEditor6-sl \
locale-libKPim6IncidenceEditor6-sv \
locale-libKPim6IncidenceEditor6-ta \
locale-libKPim6IncidenceEditor6-tr \
locale-libKPim6IncidenceEditor6-ug \
locale-libKPim6IncidenceEditor6-uk \
locale-libKPim6IncidenceEditor6-zh-CN \
locale-libKPim6IncidenceEditor6-zh-TW"

RDEPENDS:${PN} += "libKPim6IncidenceEditor6"

inherit rpm
