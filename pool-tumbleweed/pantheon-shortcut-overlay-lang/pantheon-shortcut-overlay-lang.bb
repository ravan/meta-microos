SUMMARY = "Translations for package pantheon-shortcut-overlay"
DESCRIPTION = "Provides translations for the 'pantheon-shortcut-overlay' package."
LICENSE = "GPL-3.0-or-later"

PV = "8.1.0"

RPM_NAME = "pantheon-shortcut-overlay-lang-8.1.0-1.5.noarch.rpm"
RPM_HASH = "5e026b8313fd8217d839a73b113274fae63b8d512a220af313c814fa66ae3f1fca22c14d4457a57a08e0ad22b2b1e4e68828cb96d9c37d00d346fa81e0002e27"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "locale-pantheon-shortcut-overlay-af \
locale-pantheon-shortcut-overlay-ar \
locale-pantheon-shortcut-overlay-as \
locale-pantheon-shortcut-overlay-ast \
locale-pantheon-shortcut-overlay-az \
locale-pantheon-shortcut-overlay-be \
locale-pantheon-shortcut-overlay-bg \
locale-pantheon-shortcut-overlay-bn \
locale-pantheon-shortcut-overlay-br \
locale-pantheon-shortcut-overlay-bs \
locale-pantheon-shortcut-overlay-ca \
locale-pantheon-shortcut-overlay-ca@valencia \
locale-pantheon-shortcut-overlay-cs \
locale-pantheon-shortcut-overlay-cy \
locale-pantheon-shortcut-overlay-da \
locale-pantheon-shortcut-overlay-de \
locale-pantheon-shortcut-overlay-dz \
locale-pantheon-shortcut-overlay-el \
locale-pantheon-shortcut-overlay-en-AU \
locale-pantheon-shortcut-overlay-en-CA \
locale-pantheon-shortcut-overlay-en-GB \
locale-pantheon-shortcut-overlay-eo \
locale-pantheon-shortcut-overlay-es \
locale-pantheon-shortcut-overlay-et \
locale-pantheon-shortcut-overlay-eu \
locale-pantheon-shortcut-overlay-fa \
locale-pantheon-shortcut-overlay-fi \
locale-pantheon-shortcut-overlay-fr \
locale-pantheon-shortcut-overlay-fr-CA \
locale-pantheon-shortcut-overlay-ga \
locale-pantheon-shortcut-overlay-gd \
locale-pantheon-shortcut-overlay-gl \
locale-pantheon-shortcut-overlay-gu \
locale-pantheon-shortcut-overlay-he \
locale-pantheon-shortcut-overlay-hi \
locale-pantheon-shortcut-overlay-hr \
locale-pantheon-shortcut-overlay-hu \
locale-pantheon-shortcut-overlay-ia \
locale-pantheon-shortcut-overlay-id \
locale-pantheon-shortcut-overlay-is \
locale-pantheon-shortcut-overlay-it \
locale-pantheon-shortcut-overlay-ja \
locale-pantheon-shortcut-overlay-ka \
locale-pantheon-shortcut-overlay-kk \
locale-pantheon-shortcut-overlay-km \
locale-pantheon-shortcut-overlay-kn \
locale-pantheon-shortcut-overlay-ko \
locale-pantheon-shortcut-overlay-lt \
locale-pantheon-shortcut-overlay-lv \
locale-pantheon-shortcut-overlay-mk \
locale-pantheon-shortcut-overlay-ml \
locale-pantheon-shortcut-overlay-mr \
locale-pantheon-shortcut-overlay-ms \
locale-pantheon-shortcut-overlay-nb \
locale-pantheon-shortcut-overlay-ne \
locale-pantheon-shortcut-overlay-nl \
locale-pantheon-shortcut-overlay-nn \
locale-pantheon-shortcut-overlay-oc \
locale-pantheon-shortcut-overlay-or \
locale-pantheon-shortcut-overlay-pa \
locale-pantheon-shortcut-overlay-pl \
locale-pantheon-shortcut-overlay-pt \
locale-pantheon-shortcut-overlay-pt-BR \
locale-pantheon-shortcut-overlay-ro \
locale-pantheon-shortcut-overlay-ru \
locale-pantheon-shortcut-overlay-si \
locale-pantheon-shortcut-overlay-sk \
locale-pantheon-shortcut-overlay-sl \
locale-pantheon-shortcut-overlay-sq \
locale-pantheon-shortcut-overlay-sr \
locale-pantheon-shortcut-overlay-sr@latin \
locale-pantheon-shortcut-overlay-sv \
locale-pantheon-shortcut-overlay-ta \
locale-pantheon-shortcut-overlay-te \
locale-pantheon-shortcut-overlay-th \
locale-pantheon-shortcut-overlay-tr \
locale-pantheon-shortcut-overlay-ug \
locale-pantheon-shortcut-overlay-uk \
locale-pantheon-shortcut-overlay-vi \
locale-pantheon-shortcut-overlay-wa \
locale-pantheon-shortcut-overlay-zh \
locale-pantheon-shortcut-overlay-zh-CN \
locale-pantheon-shortcut-overlay-zh-HK \
locale-pantheon-shortcut-overlay-zh-TW \
pantheon-shortcut-overlay-lang \
pantheon-shortcut-overlay-lang-all"

RDEPENDS:${PN} += "pantheon-shortcut-overlay"

inherit rpm
