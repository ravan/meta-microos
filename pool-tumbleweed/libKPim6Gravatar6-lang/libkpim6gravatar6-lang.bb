SUMMARY = "Translations for package libKPim6Gravatar6"
DESCRIPTION = "Provides translations for the 'libKPim6Gravatar6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6Gravatar6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "5a935fb2db342bc94d8edcc16fa418e2c6d1a5672862019e98ad9edaee591b06189a09e931990516a51a885105f08b984e54498a6f8fb76ebca34b9f0c792c99"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6Gravatar6-lang \
libKPim6Gravatar6-lang-all \
locale-libKPim6Gravatar6-ar \
locale-libKPim6Gravatar6-ast \
locale-libKPim6Gravatar6-bg \
locale-libKPim6Gravatar6-ca \
locale-libKPim6Gravatar6-ca@valencia \
locale-libKPim6Gravatar6-cs \
locale-libKPim6Gravatar6-da \
locale-libKPim6Gravatar6-de \
locale-libKPim6Gravatar6-el \
locale-libKPim6Gravatar6-en-GB \
locale-libKPim6Gravatar6-eo \
locale-libKPim6Gravatar6-es \
locale-libKPim6Gravatar6-et \
locale-libKPim6Gravatar6-eu \
locale-libKPim6Gravatar6-fi \
locale-libKPim6Gravatar6-fr \
locale-libKPim6Gravatar6-ga \
locale-libKPim6Gravatar6-gl \
locale-libKPim6Gravatar6-he \
locale-libKPim6Gravatar6-hi \
locale-libKPim6Gravatar6-hu \
locale-libKPim6Gravatar6-ia \
locale-libKPim6Gravatar6-is \
locale-libKPim6Gravatar6-it \
locale-libKPim6Gravatar6-ja \
locale-libKPim6Gravatar6-ka \
locale-libKPim6Gravatar6-ko \
locale-libKPim6Gravatar6-lt \
locale-libKPim6Gravatar6-lv \
locale-libKPim6Gravatar6-nl \
locale-libKPim6Gravatar6-nn \
locale-libKPim6Gravatar6-pl \
locale-libKPim6Gravatar6-pt \
locale-libKPim6Gravatar6-pt-BR \
locale-libKPim6Gravatar6-ro \
locale-libKPim6Gravatar6-ru \
locale-libKPim6Gravatar6-sk \
locale-libKPim6Gravatar6-sl \
locale-libKPim6Gravatar6-sr \
locale-libKPim6Gravatar6-sr@ijekavian \
locale-libKPim6Gravatar6-sr@ijekavianlatin \
locale-libKPim6Gravatar6-sr@latin \
locale-libKPim6Gravatar6-sv \
locale-libKPim6Gravatar6-ta \
locale-libKPim6Gravatar6-tr \
locale-libKPim6Gravatar6-ug \
locale-libKPim6Gravatar6-uk \
locale-libKPim6Gravatar6-zh-CN \
locale-libKPim6Gravatar6-zh-TW"

RDEPENDS:${PN} += "libKPim6Gravatar6"

inherit rpm
