SUMMARY = "Translations for package libKF6UnitConversion6"
DESCRIPTION = "Provides translations for the 'libKF6UnitConversion6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6UnitConversion6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "428c4523c53e85714395eaed6e5d4a61b93abd926e16ce02542b9bebe76ca27647fa3d755993ed14640463e7c9d3429d7a0acdab4122dc86d42a38e55b0bd953"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6UnitConversion6-lang \
libKF6UnitConversion6-lang-all \
locale-libKF6UnitConversion6-ar \
locale-libKF6UnitConversion6-ast \
locale-libKF6UnitConversion6-az \
locale-libKF6UnitConversion6-bg \
locale-libKF6UnitConversion6-bs \
locale-libKF6UnitConversion6-ca \
locale-libKF6UnitConversion6-ca@valencia \
locale-libKF6UnitConversion6-cs \
locale-libKF6UnitConversion6-da \
locale-libKF6UnitConversion6-de \
locale-libKF6UnitConversion6-el \
locale-libKF6UnitConversion6-en-GB \
locale-libKF6UnitConversion6-eo \
locale-libKF6UnitConversion6-es \
locale-libKF6UnitConversion6-et \
locale-libKF6UnitConversion6-eu \
locale-libKF6UnitConversion6-fi \
locale-libKF6UnitConversion6-fr \
locale-libKF6UnitConversion6-ga \
locale-libKF6UnitConversion6-gd \
locale-libKF6UnitConversion6-gl \
locale-libKF6UnitConversion6-hi \
locale-libKF6UnitConversion6-hr \
locale-libKF6UnitConversion6-hu \
locale-libKF6UnitConversion6-ia \
locale-libKF6UnitConversion6-id \
locale-libKF6UnitConversion6-is \
locale-libKF6UnitConversion6-it \
locale-libKF6UnitConversion6-ja \
locale-libKF6UnitConversion6-ka \
locale-libKF6UnitConversion6-kk \
locale-libKF6UnitConversion6-ko \
locale-libKF6UnitConversion6-lt \
locale-libKF6UnitConversion6-lv \
locale-libKF6UnitConversion6-ml \
locale-libKF6UnitConversion6-mr \
locale-libKF6UnitConversion6-ms \
locale-libKF6UnitConversion6-nb \
locale-libKF6UnitConversion6-nds \
locale-libKF6UnitConversion6-nl \
locale-libKF6UnitConversion6-nn \
locale-libKF6UnitConversion6-pa \
locale-libKF6UnitConversion6-pl \
locale-libKF6UnitConversion6-pt \
locale-libKF6UnitConversion6-pt-BR \
locale-libKF6UnitConversion6-ro \
locale-libKF6UnitConversion6-ru \
locale-libKF6UnitConversion6-sk \
locale-libKF6UnitConversion6-sl \
locale-libKF6UnitConversion6-sr \
locale-libKF6UnitConversion6-sr@ijekavian \
locale-libKF6UnitConversion6-sr@ijekavianlatin \
locale-libKF6UnitConversion6-sr@latin \
locale-libKF6UnitConversion6-sv \
locale-libKF6UnitConversion6-ta \
locale-libKF6UnitConversion6-th \
locale-libKF6UnitConversion6-tr \
locale-libKF6UnitConversion6-ug \
locale-libKF6UnitConversion6-uk \
locale-libKF6UnitConversion6-zh-CN \
locale-libKF6UnitConversion6-zh-TW"

RDEPENDS:${PN} += "libKF6UnitConversion6"

inherit rpm
