SUMMARY = "Translations for package libKPim6CalendarSupport6"
DESCRIPTION = "Provides translations for the 'libKPim6CalendarSupport6' package."
LICENSE = "GPL-2.0-or-later & LGPL-2.1-or-later"

PV = "26.08.1"

RPM_NAME = "libKPim6CalendarSupport6-lang-26.08.1-1.1.noarch.rpm"
RPM_HASH = "f5177a17c525c377f4985b9f3843dbefe897161d8bee208c2b26676950a0a6d88df034539c8d7d26b19e8c67de84faefe5621d547043cb6e0937e05a28546865"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKPim6CalendarSupport6-lang \
libKPim6CalendarSupport6-lang-all \
locale-libKPim6CalendarSupport6-af \
locale-libKPim6CalendarSupport6-ar \
locale-libKPim6CalendarSupport6-ast \
locale-libKPim6CalendarSupport6-az \
locale-libKPim6CalendarSupport6-be \
locale-libKPim6CalendarSupport6-bg \
locale-libKPim6CalendarSupport6-br \
locale-libKPim6CalendarSupport6-bs \
locale-libKPim6CalendarSupport6-ca \
locale-libKPim6CalendarSupport6-ca@valencia \
locale-libKPim6CalendarSupport6-cs \
locale-libKPim6CalendarSupport6-cy \
locale-libKPim6CalendarSupport6-da \
locale-libKPim6CalendarSupport6-de \
locale-libKPim6CalendarSupport6-el \
locale-libKPim6CalendarSupport6-en-GB \
locale-libKPim6CalendarSupport6-eo \
locale-libKPim6CalendarSupport6-es \
locale-libKPim6CalendarSupport6-et \
locale-libKPim6CalendarSupport6-eu \
locale-libKPim6CalendarSupport6-fa \
locale-libKPim6CalendarSupport6-fi \
locale-libKPim6CalendarSupport6-fr \
locale-libKPim6CalendarSupport6-ga \
locale-libKPim6CalendarSupport6-gl \
locale-libKPim6CalendarSupport6-he \
locale-libKPim6CalendarSupport6-hi \
locale-libKPim6CalendarSupport6-hr \
locale-libKPim6CalendarSupport6-hu \
locale-libKPim6CalendarSupport6-ia \
locale-libKPim6CalendarSupport6-id \
locale-libKPim6CalendarSupport6-is \
locale-libKPim6CalendarSupport6-it \
locale-libKPim6CalendarSupport6-ja \
locale-libKPim6CalendarSupport6-ka \
locale-libKPim6CalendarSupport6-kk \
locale-libKPim6CalendarSupport6-km \
locale-libKPim6CalendarSupport6-ko \
locale-libKPim6CalendarSupport6-lt \
locale-libKPim6CalendarSupport6-lv \
locale-libKPim6CalendarSupport6-mai \
locale-libKPim6CalendarSupport6-mk \
locale-libKPim6CalendarSupport6-mr \
locale-libKPim6CalendarSupport6-ms \
locale-libKPim6CalendarSupport6-nb \
locale-libKPim6CalendarSupport6-nds \
locale-libKPim6CalendarSupport6-ne \
locale-libKPim6CalendarSupport6-nl \
locale-libKPim6CalendarSupport6-nn \
locale-libKPim6CalendarSupport6-pa \
locale-libKPim6CalendarSupport6-pl \
locale-libKPim6CalendarSupport6-pt \
locale-libKPim6CalendarSupport6-pt-BR \
locale-libKPim6CalendarSupport6-ro \
locale-libKPim6CalendarSupport6-ru \
locale-libKPim6CalendarSupport6-si \
locale-libKPim6CalendarSupport6-sk \
locale-libKPim6CalendarSupport6-sl \
locale-libKPim6CalendarSupport6-sq \
locale-libKPim6CalendarSupport6-sr \
locale-libKPim6CalendarSupport6-sr@ijekavian \
locale-libKPim6CalendarSupport6-sr@ijekavianlatin \
locale-libKPim6CalendarSupport6-sr@latin \
locale-libKPim6CalendarSupport6-sv \
locale-libKPim6CalendarSupport6-ta \
locale-libKPim6CalendarSupport6-th \
locale-libKPim6CalendarSupport6-tr \
locale-libKPim6CalendarSupport6-ug \
locale-libKPim6CalendarSupport6-uk \
locale-libKPim6CalendarSupport6-wa \
locale-libKPim6CalendarSupport6-zh-CN \
locale-libKPim6CalendarSupport6-zh-TW"

RDEPENDS:${PN} += "libKPim6CalendarSupport6"

inherit rpm
