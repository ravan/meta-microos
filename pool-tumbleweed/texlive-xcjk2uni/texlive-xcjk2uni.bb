SUMMARY = "Convert CJK characters to Unicode, in pdfTeX"
DESCRIPTION = "The package provides commands to convert CJK characters to \
Unicode in non-UTF-8 encoding; it provides hooks to support \
hyperref in producing correct bookmarks. The bundle also \
provides /ToUnicode mapping file(s) for a CJK subfont; these \
can be used with the cmap package, allowing searches of, and \
cut-and-paste operations on a PDF file generated by pdfTeX."
LICENSE = "LPPL-1.0"

PV = "2026.226.1.0svn54958"

RPM_NAME = "texlive-xcjk2uni-2026.226.1.0svn54958-59.4.noarch.rpm"
RPM_HASH = "1e51305832ef471962130804a108cf8c0bea54995f74f10afd0bc7d4a21ead0614ab94a99b66f93524c1ee54609b91ad35ca7a22c432ce0e1ad367d95a16fb72"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "tex-xCJK2uni-UBg5plus.def \
tex-xCJK2uni-UBig5.def \
tex-xCJK2uni-UGB.def \
tex-xCJK2uni-UGBK.def \
tex-xCJK2uni-UJIS.def \
tex-xCJK2uni-UKS.def \
tex-xCJK2uni.sty \
texlive-xcjk2uni"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
ed \
findutils \
grep \
sed \
tex-expl3.sty \
texlive \
texlive-filesystem \
texlive-kpathsea \
texlive-kpathsea-bin \
texlive-scripts \
texlive-scripts-bin"

inherit rpm
