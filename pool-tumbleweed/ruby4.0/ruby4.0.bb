SUMMARY = "An Interpreted Object-Oriented Scripting Language"
DESCRIPTION = "Ruby is an interpreted scripting language for object-oriented programming. It \
has many features for processing text files and performing system management \
tasks (as in Perl).  It is extensible. \
 \
* Ruby features: \
 \
- Simple Syntax \
 \
- *Normal* Object-Oriented features (class, method calls, for \
   example) \
 \
- *Advanced* Object-Oriented features(Mix-in, Singleton-method, for \
   example) \
 \
- Operator Overloading \
 \
- Exception Handling \
 \
- Iterators and Closures \
 \
- Garbage Collection \
 \
- Dynamic Loading of Object Files (on some architectures)"
LICENSE = "BSD-2-Clause | Ruby"

PV = "4.0.6"

RPM_NAME = "ruby4.0-4.0.6-2.1.aarch64.rpm"
RPM_HASH = "07540a05d5f8e8b17036e784bb8e8504fd527f8cf429a19af9c44e031e2796767c49b594023c7534adb07d002704ed032e8860c7650ac3f390ea1189f27a7263"

RPROVIDES:${PN} += "rpm-macro-rb-build-ruby-abis \
rpm-macro-rb-build-versions \
rpm-macro-rb-default-ruby \
rpm-macro-rb-default-ruby-abi \
rpm-macro-rb-default-ruby-suffix \
rpm-macro-rubydevelruby40 \
rpm-macro-rubydevelxruby40 \
rpm-macro-rubygemsruby40 \
rpm-macro-rubygemsxruby40 \
rpm-macro-rubyruby40 \
rpm-macro-rubyxruby40 \
ruby-abi \
ruby-default \
ruby4.0 \
ruby4.0-stdlib \
ruby4.0-without-jemalloc \
ruby4.0-without-yjit \
rubygem-abbrev \
rubygem-base64 \
rubygem-benchmark \
rubygem-bigdecimal \
rubygem-bundler \
rubygem-csv \
rubygem-date \
rubygem-debug \
rubygem-delegate \
rubygem-did-you-mean \
rubygem-digest \
rubygem-drb \
rubygem-english \
rubygem-erb \
rubygem-error-highlight \
rubygem-etc \
rubygem-fcntl \
rubygem-fiddle \
rubygem-fileutils \
rubygem-find \
rubygem-forwardable \
rubygem-getoptlong \
rubygem-io-console \
rubygem-io-nonblock \
rubygem-io-wait \
rubygem-ipaddr \
rubygem-irb \
rubygem-json \
rubygem-logger \
rubygem-matrix \
rubygem-minitest \
rubygem-mutex-m \
rubygem-net-ftp \
rubygem-net-http \
rubygem-net-imap \
rubygem-net-pop \
rubygem-net-protocol \
rubygem-net-smtp \
rubygem-nkf \
rubygem-observer \
rubygem-open-uri \
rubygem-open3 \
rubygem-openssl \
rubygem-optparse \
rubygem-ostruct \
rubygem-power-assert \
rubygem-pp \
rubygem-prettyprint \
rubygem-prime \
rubygem-prism \
rubygem-pstore \
rubygem-psych \
rubygem-racc \
rubygem-rake \
rubygem-rbs \
rubygem-rdoc \
rubygem-readline \
rubygem-reline \
rubygem-repl-type-completor \
rubygem-resolv \
rubygem-resolv-replace \
rubygem-rexml \
rubygem-rinda \
rubygem-rss \
rubygem-ruby-4.0.0-abbrev \
rubygem-ruby-4.0.0-abbrev-0 \
rubygem-ruby-4.0.0-abbrev-0.1 \
rubygem-ruby-4.0.0-abbrev-0.1.2 \
rubygem-ruby-4.0.0-base64 \
rubygem-ruby-4.0.0-base64-0 \
rubygem-ruby-4.0.0-base64-0.3 \
rubygem-ruby-4.0.0-base64-0.3.0 \
rubygem-ruby-4.0.0-benchmark \
rubygem-ruby-4.0.0-benchmark-0 \
rubygem-ruby-4.0.0-benchmark-0.5 \
rubygem-ruby-4.0.0-benchmark-0.5.0 \
rubygem-ruby-4.0.0-bigdecimal \
rubygem-ruby-4.0.0-bigdecimal-4 \
rubygem-ruby-4.0.0-bigdecimal-4.0 \
rubygem-ruby-4.0.0-bigdecimal-4.0.1 \
rubygem-ruby-4.0.0-bundler \
rubygem-ruby-4.0.0-bundler-4 \
rubygem-ruby-4.0.0-bundler-4.0 \
rubygem-ruby-4.0.0-bundler-4.0.16 \
rubygem-ruby-4.0.0-csv \
rubygem-ruby-4.0.0-csv-3 \
rubygem-ruby-4.0.0-csv-3.3 \
rubygem-ruby-4.0.0-csv-3.3.5 \
rubygem-ruby-4.0.0-date \
rubygem-ruby-4.0.0-date-3 \
rubygem-ruby-4.0.0-date-3.5 \
rubygem-ruby-4.0.0-date-3.5.1 \
rubygem-ruby-4.0.0-debug \
rubygem-ruby-4.0.0-debug-1 \
rubygem-ruby-4.0.0-debug-1.11 \
rubygem-ruby-4.0.0-debug-1.11.1 \
rubygem-ruby-4.0.0-delegate \
rubygem-ruby-4.0.0-delegate-0 \
rubygem-ruby-4.0.0-delegate-0.6 \
rubygem-ruby-4.0.0-delegate-0.6.1 \
rubygem-ruby-4.0.0-did-you-mean \
rubygem-ruby-4.0.0-did-you-mean-2 \
rubygem-ruby-4.0.0-did-you-mean-2.0 \
rubygem-ruby-4.0.0-did-you-mean-2.0.0 \
rubygem-ruby-4.0.0-digest \
rubygem-ruby-4.0.0-digest-3 \
rubygem-ruby-4.0.0-digest-3.2 \
rubygem-ruby-4.0.0-digest-3.2.1 \
rubygem-ruby-4.0.0-drb \
rubygem-ruby-4.0.0-drb-2 \
rubygem-ruby-4.0.0-drb-2.2 \
rubygem-ruby-4.0.0-drb-2.2.3 \
rubygem-ruby-4.0.0-english \
rubygem-ruby-4.0.0-english-0 \
rubygem-ruby-4.0.0-english-0.8 \
rubygem-ruby-4.0.0-english-0.8.1 \
rubygem-ruby-4.0.0-erb \
rubygem-ruby-4.0.0-erb-6 \
rubygem-ruby-4.0.0-erb-6.0 \
rubygem-ruby-4.0.0-erb-6.0.1 \
rubygem-ruby-4.0.0-erb-6.0.1.1 \
rubygem-ruby-4.0.0-error-highlight \
rubygem-ruby-4.0.0-error-highlight-0 \
rubygem-ruby-4.0.0-error-highlight-0.7 \
rubygem-ruby-4.0.0-error-highlight-0.7.2 \
rubygem-ruby-4.0.0-etc \
rubygem-ruby-4.0.0-etc-1 \
rubygem-ruby-4.0.0-etc-1.4 \
rubygem-ruby-4.0.0-etc-1.4.6 \
rubygem-ruby-4.0.0-fcntl \
rubygem-ruby-4.0.0-fcntl-1 \
rubygem-ruby-4.0.0-fcntl-1.3 \
rubygem-ruby-4.0.0-fcntl-1.3.0 \
rubygem-ruby-4.0.0-fiddle \
rubygem-ruby-4.0.0-fiddle-1 \
rubygem-ruby-4.0.0-fiddle-1.1 \
rubygem-ruby-4.0.0-fiddle-1.1.8 \
rubygem-ruby-4.0.0-fileutils \
rubygem-ruby-4.0.0-fileutils-1 \
rubygem-ruby-4.0.0-fileutils-1.8 \
rubygem-ruby-4.0.0-fileutils-1.8.0 \
rubygem-ruby-4.0.0-find \
rubygem-ruby-4.0.0-find-0 \
rubygem-ruby-4.0.0-find-0.2 \
rubygem-ruby-4.0.0-find-0.2.0 \
rubygem-ruby-4.0.0-forwardable \
rubygem-ruby-4.0.0-forwardable-1 \
rubygem-ruby-4.0.0-forwardable-1.4 \
rubygem-ruby-4.0.0-forwardable-1.4.0 \
rubygem-ruby-4.0.0-getoptlong \
rubygem-ruby-4.0.0-getoptlong-0 \
rubygem-ruby-4.0.0-getoptlong-0.2 \
rubygem-ruby-4.0.0-getoptlong-0.2.1 \
rubygem-ruby-4.0.0-io-console \
rubygem-ruby-4.0.0-io-console-0 \
rubygem-ruby-4.0.0-io-console-0.8 \
rubygem-ruby-4.0.0-io-console-0.8.2 \
rubygem-ruby-4.0.0-io-nonblock \
rubygem-ruby-4.0.0-io-nonblock-0 \
rubygem-ruby-4.0.0-io-nonblock-0.3 \
rubygem-ruby-4.0.0-io-nonblock-0.3.2 \
rubygem-ruby-4.0.0-io-wait \
rubygem-ruby-4.0.0-io-wait-0 \
rubygem-ruby-4.0.0-io-wait-0.4 \
rubygem-ruby-4.0.0-io-wait-0.4.0 \
rubygem-ruby-4.0.0-ipaddr \
rubygem-ruby-4.0.0-ipaddr-1 \
rubygem-ruby-4.0.0-ipaddr-1.2 \
rubygem-ruby-4.0.0-ipaddr-1.2.8 \
rubygem-ruby-4.0.0-irb \
rubygem-ruby-4.0.0-irb-1 \
rubygem-ruby-4.0.0-irb-1.16 \
rubygem-ruby-4.0.0-irb-1.16.0 \
rubygem-ruby-4.0.0-json \
rubygem-ruby-4.0.0-json-2 \
rubygem-ruby-4.0.0-json-2.18 \
rubygem-ruby-4.0.0-json-2.18.0 \
rubygem-ruby-4.0.0-logger \
rubygem-ruby-4.0.0-logger-1 \
rubygem-ruby-4.0.0-logger-1.7 \
rubygem-ruby-4.0.0-logger-1.7.0 \
rubygem-ruby-4.0.0-matrix \
rubygem-ruby-4.0.0-matrix-0 \
rubygem-ruby-4.0.0-matrix-0.4 \
rubygem-ruby-4.0.0-matrix-0.4.3 \
rubygem-ruby-4.0.0-minitest \
rubygem-ruby-4.0.0-minitest-6 \
rubygem-ruby-4.0.0-minitest-6.0 \
rubygem-ruby-4.0.0-minitest-6.0.0 \
rubygem-ruby-4.0.0-mutex-m \
rubygem-ruby-4.0.0-mutex-m-0 \
rubygem-ruby-4.0.0-mutex-m-0.3 \
rubygem-ruby-4.0.0-mutex-m-0.3.0 \
rubygem-ruby-4.0.0-net-ftp \
rubygem-ruby-4.0.0-net-ftp-0 \
rubygem-ruby-4.0.0-net-ftp-0.3 \
rubygem-ruby-4.0.0-net-ftp-0.3.9 \
rubygem-ruby-4.0.0-net-http \
rubygem-ruby-4.0.0-net-http-0 \
rubygem-ruby-4.0.0-net-http-0.9 \
rubygem-ruby-4.0.0-net-http-0.9.1 \
rubygem-ruby-4.0.0-net-imap \
rubygem-ruby-4.0.0-net-imap-0 \
rubygem-ruby-4.0.0-net-imap-0.6 \
rubygem-ruby-4.0.0-net-imap-0.6.4 \
rubygem-ruby-4.0.0-net-imap-0.6.4.1 \
rubygem-ruby-4.0.0-net-pop \
rubygem-ruby-4.0.0-net-pop-0 \
rubygem-ruby-4.0.0-net-pop-0.1 \
rubygem-ruby-4.0.0-net-pop-0.1.2 \
rubygem-ruby-4.0.0-net-protocol \
rubygem-ruby-4.0.0-net-protocol-0 \
rubygem-ruby-4.0.0-net-protocol-0.2 \
rubygem-ruby-4.0.0-net-protocol-0.2.2 \
rubygem-ruby-4.0.0-net-smtp \
rubygem-ruby-4.0.0-net-smtp-0 \
rubygem-ruby-4.0.0-net-smtp-0.5 \
rubygem-ruby-4.0.0-net-smtp-0.5.1 \
rubygem-ruby-4.0.0-nkf \
rubygem-ruby-4.0.0-nkf-0 \
rubygem-ruby-4.0.0-nkf-0.2 \
rubygem-ruby-4.0.0-nkf-0.2.0 \
rubygem-ruby-4.0.0-observer \
rubygem-ruby-4.0.0-observer-0 \
rubygem-ruby-4.0.0-observer-0.1 \
rubygem-ruby-4.0.0-observer-0.1.2 \
rubygem-ruby-4.0.0-open-uri \
rubygem-ruby-4.0.0-open-uri-0 \
rubygem-ruby-4.0.0-open-uri-0.5 \
rubygem-ruby-4.0.0-open-uri-0.5.0 \
rubygem-ruby-4.0.0-open3 \
rubygem-ruby-4.0.0-open3-0 \
rubygem-ruby-4.0.0-open3-0.2 \
rubygem-ruby-4.0.0-open3-0.2.1 \
rubygem-ruby-4.0.0-openssl \
rubygem-ruby-4.0.0-openssl-4 \
rubygem-ruby-4.0.0-openssl-4.0 \
rubygem-ruby-4.0.0-openssl-4.0.2 \
rubygem-ruby-4.0.0-optparse \
rubygem-ruby-4.0.0-optparse-0 \
rubygem-ruby-4.0.0-optparse-0.8 \
rubygem-ruby-4.0.0-optparse-0.8.1 \
rubygem-ruby-4.0.0-ostruct \
rubygem-ruby-4.0.0-ostruct-0 \
rubygem-ruby-4.0.0-ostruct-0.6 \
rubygem-ruby-4.0.0-ostruct-0.6.3 \
rubygem-ruby-4.0.0-power-assert \
rubygem-ruby-4.0.0-power-assert-3 \
rubygem-ruby-4.0.0-power-assert-3.0 \
rubygem-ruby-4.0.0-power-assert-3.0.1 \
rubygem-ruby-4.0.0-pp \
rubygem-ruby-4.0.0-pp-0 \
rubygem-ruby-4.0.0-pp-0.6 \
rubygem-ruby-4.0.0-pp-0.6.3 \
rubygem-ruby-4.0.0-prettyprint \
rubygem-ruby-4.0.0-prettyprint-0 \
rubygem-ruby-4.0.0-prettyprint-0.2 \
rubygem-ruby-4.0.0-prettyprint-0.2.0 \
rubygem-ruby-4.0.0-prime \
rubygem-ruby-4.0.0-prime-0 \
rubygem-ruby-4.0.0-prime-0.1 \
rubygem-ruby-4.0.0-prime-0.1.4 \
rubygem-ruby-4.0.0-prism \
rubygem-ruby-4.0.0-prism-1 \
rubygem-ruby-4.0.0-prism-1.8 \
rubygem-ruby-4.0.0-prism-1.8.1 \
rubygem-ruby-4.0.0-pstore \
rubygem-ruby-4.0.0-pstore-0 \
rubygem-ruby-4.0.0-pstore-0.2 \
rubygem-ruby-4.0.0-pstore-0.2.1 \
rubygem-ruby-4.0.0-psych \
rubygem-ruby-4.0.0-psych-5 \
rubygem-ruby-4.0.0-psych-5.3 \
rubygem-ruby-4.0.0-psych-5.3.1 \
rubygem-ruby-4.0.0-racc \
rubygem-ruby-4.0.0-racc-1 \
rubygem-ruby-4.0.0-racc-1.8 \
rubygem-ruby-4.0.0-racc-1.8.1 \
rubygem-ruby-4.0.0-rake \
rubygem-ruby-4.0.0-rake-13 \
rubygem-ruby-4.0.0-rake-13.3 \
rubygem-ruby-4.0.0-rake-13.3.1 \
rubygem-ruby-4.0.0-rbs \
rubygem-ruby-4.0.0-rbs-3 \
rubygem-ruby-4.0.0-rbs-3.10 \
rubygem-ruby-4.0.0-rbs-3.10.0 \
rubygem-ruby-4.0.0-rdoc \
rubygem-ruby-4.0.0-rdoc-7 \
rubygem-ruby-4.0.0-rdoc-7.0 \
rubygem-ruby-4.0.0-rdoc-7.0.4 \
rubygem-ruby-4.0.0-readline \
rubygem-ruby-4.0.0-readline-0 \
rubygem-ruby-4.0.0-readline-0.0 \
rubygem-ruby-4.0.0-readline-0.0.4 \
rubygem-ruby-4.0.0-reline \
rubygem-ruby-4.0.0-reline-0 \
rubygem-ruby-4.0.0-reline-0.6 \
rubygem-ruby-4.0.0-reline-0.6.3 \
rubygem-ruby-4.0.0-repl-type-completor \
rubygem-ruby-4.0.0-repl-type-completor-0 \
rubygem-ruby-4.0.0-repl-type-completor-0.1 \
rubygem-ruby-4.0.0-repl-type-completor-0.1.12 \
rubygem-ruby-4.0.0-resolv \
rubygem-ruby-4.0.0-resolv-0 \
rubygem-ruby-4.0.0-resolv-0.7 \
rubygem-ruby-4.0.0-resolv-0.7.0 \
rubygem-ruby-4.0.0-resolv-replace \
rubygem-ruby-4.0.0-resolv-replace-0 \
rubygem-ruby-4.0.0-resolv-replace-0.1 \
rubygem-ruby-4.0.0-resolv-replace-0.1.1 \
rubygem-ruby-4.0.0-rexml \
rubygem-ruby-4.0.0-rexml-3 \
rubygem-ruby-4.0.0-rexml-3.4 \
rubygem-ruby-4.0.0-rexml-3.4.4 \
rubygem-ruby-4.0.0-rinda \
rubygem-ruby-4.0.0-rinda-0 \
rubygem-ruby-4.0.0-rinda-0.2 \
rubygem-ruby-4.0.0-rinda-0.2.0 \
rubygem-ruby-4.0.0-rss \
rubygem-ruby-4.0.0-rss-0 \
rubygem-ruby-4.0.0-rss-0.3 \
rubygem-ruby-4.0.0-rss-0.3.2 \
rubygem-ruby-4.0.0-ruby2-keywords \
rubygem-ruby-4.0.0-ruby2-keywords-0 \
rubygem-ruby-4.0.0-ruby2-keywords-0.0 \
rubygem-ruby-4.0.0-ruby2-keywords-0.0.5 \
rubygem-ruby-4.0.0-securerandom \
rubygem-ruby-4.0.0-securerandom-0 \
rubygem-ruby-4.0.0-securerandom-0.4 \
rubygem-ruby-4.0.0-securerandom-0.4.1 \
rubygem-ruby-4.0.0-shellwords \
rubygem-ruby-4.0.0-shellwords-0 \
rubygem-ruby-4.0.0-shellwords-0.2 \
rubygem-ruby-4.0.0-shellwords-0.2.2 \
rubygem-ruby-4.0.0-singleton \
rubygem-ruby-4.0.0-singleton-0 \
rubygem-ruby-4.0.0-singleton-0.3 \
rubygem-ruby-4.0.0-singleton-0.3.0 \
rubygem-ruby-4.0.0-stringio \
rubygem-ruby-4.0.0-stringio-3 \
rubygem-ruby-4.0.0-stringio-3.2 \
rubygem-ruby-4.0.0-stringio-3.2.0 \
rubygem-ruby-4.0.0-strscan \
rubygem-ruby-4.0.0-strscan-3 \
rubygem-ruby-4.0.0-strscan-3.1 \
rubygem-ruby-4.0.0-strscan-3.1.6 \
rubygem-ruby-4.0.0-syntax-suggest \
rubygem-ruby-4.0.0-syntax-suggest-2 \
rubygem-ruby-4.0.0-syntax-suggest-2.0 \
rubygem-ruby-4.0.0-syntax-suggest-2.0.3 \
rubygem-ruby-4.0.0-syslog \
rubygem-ruby-4.0.0-syslog-0 \
rubygem-ruby-4.0.0-syslog-0.3 \
rubygem-ruby-4.0.0-syslog-0.3.0 \
rubygem-ruby-4.0.0-tempfile \
rubygem-ruby-4.0.0-tempfile-0 \
rubygem-ruby-4.0.0-tempfile-0.3 \
rubygem-ruby-4.0.0-tempfile-0.3.1 \
rubygem-ruby-4.0.0-test-unit \
rubygem-ruby-4.0.0-test-unit-3 \
rubygem-ruby-4.0.0-test-unit-3.7 \
rubygem-ruby-4.0.0-test-unit-3.7.5 \
rubygem-ruby-4.0.0-time \
rubygem-ruby-4.0.0-time-0 \
rubygem-ruby-4.0.0-time-0.4 \
rubygem-ruby-4.0.0-time-0.4.2 \
rubygem-ruby-4.0.0-timeout \
rubygem-ruby-4.0.0-timeout-0 \
rubygem-ruby-4.0.0-timeout-0.6 \
rubygem-ruby-4.0.0-timeout-0.6.0 \
rubygem-ruby-4.0.0-tmpdir \
rubygem-ruby-4.0.0-tmpdir-0 \
rubygem-ruby-4.0.0-tmpdir-0.3 \
rubygem-ruby-4.0.0-tmpdir-0.3.1 \
rubygem-ruby-4.0.0-tsort \
rubygem-ruby-4.0.0-tsort-0 \
rubygem-ruby-4.0.0-tsort-0.2 \
rubygem-ruby-4.0.0-tsort-0.2.0 \
rubygem-ruby-4.0.0-typeprof \
rubygem-ruby-4.0.0-typeprof-0 \
rubygem-ruby-4.0.0-typeprof-0.31 \
rubygem-ruby-4.0.0-typeprof-0.31.1 \
rubygem-ruby-4.0.0-un \
rubygem-ruby-4.0.0-un-0 \
rubygem-ruby-4.0.0-un-0.3 \
rubygem-ruby-4.0.0-un-0.3.0 \
rubygem-ruby-4.0.0-uri \
rubygem-ruby-4.0.0-uri-1 \
rubygem-ruby-4.0.0-uri-1.1 \
rubygem-ruby-4.0.0-uri-1.1.1 \
rubygem-ruby-4.0.0-weakref \
rubygem-ruby-4.0.0-weakref-0 \
rubygem-ruby-4.0.0-weakref-0.1 \
rubygem-ruby-4.0.0-weakref-0.1.4 \
rubygem-ruby-4.0.0-yaml \
rubygem-ruby-4.0.0-yaml-0 \
rubygem-ruby-4.0.0-yaml-0.4 \
rubygem-ruby-4.0.0-yaml-0.4.0 \
rubygem-ruby-4.0.0-zlib \
rubygem-ruby-4.0.0-zlib-3 \
rubygem-ruby-4.0.0-zlib-3.2 \
rubygem-ruby-4.0.0-zlib-3.2.3 \
rubygem-ruby2-keywords \
rubygem-securerandom \
rubygem-shellwords \
rubygem-singleton \
rubygem-stringio \
rubygem-strscan \
rubygem-syntax-suggest \
rubygem-syslog \
rubygem-tempfile \
rubygem-test-unit \
rubygem-time \
rubygem-timeout \
rubygem-tmpdir \
rubygem-tsort \
rubygem-typeprof \
rubygem-un \
rubygem-uri \
rubygem-weakref \
rubygem-yaml \
rubygem-zlib"

RDEPENDS:${PN} += "/usr/bin/env \
alts \
ld-linux-aarch64.so.1 \
libc.so.6 \
libcrypt.so.1 \
libcrypto.so.3 \
libffi.so.8 \
libgmp.so.10 \
libm.so.6 \
libruby4-0-4-0 \
libruby4.0.so.4.0 \
libssl.so.3 \
libyaml-0.so.2 \
libz.so.1 \
ruby-common"

inherit rpm
