SUMMARY = "Translations for package libKF6Bookmarks6"
DESCRIPTION = "Provides translations for the 'libKF6Bookmarks6' package."
LICENSE = "LGPL-2.1-or-later"

PV = "6.30.0"

RPM_NAME = "libKF6Bookmarks6-lang-6.30.0-1.1.noarch.rpm"
RPM_HASH = "00a8a2cbe6438b9f6170e42ba637b40ec8314bcf702cc34bba98dee83f83ecc70300a16ac9761d61ddbf8fae68cedf38c4622015039ced7ac905787cd3389b8a"
REPO_ARCH = "noarch"

RPROVIDES:${PN} += "libKF6Bookmarks6-lang \
libKF6Bookmarks6-lang-all \
locale-libKF6Bookmarks6-af \
locale-libKF6Bookmarks6-ar \
locale-libKF6Bookmarks6-ast \
locale-libKF6Bookmarks6-az \
locale-libKF6Bookmarks6-be \
locale-libKF6Bookmarks6-be@latin \
locale-libKF6Bookmarks6-bg \
locale-libKF6Bookmarks6-bn \
locale-libKF6Bookmarks6-br \
locale-libKF6Bookmarks6-bs \
locale-libKF6Bookmarks6-ca \
locale-libKF6Bookmarks6-ca@valencia \
locale-libKF6Bookmarks6-cs \
locale-libKF6Bookmarks6-cy \
locale-libKF6Bookmarks6-da \
locale-libKF6Bookmarks6-de \
locale-libKF6Bookmarks6-el \
locale-libKF6Bookmarks6-en-GB \
locale-libKF6Bookmarks6-eo \
locale-libKF6Bookmarks6-es \
locale-libKF6Bookmarks6-et \
locale-libKF6Bookmarks6-eu \
locale-libKF6Bookmarks6-fa \
locale-libKF6Bookmarks6-fi \
locale-libKF6Bookmarks6-fr \
locale-libKF6Bookmarks6-ga \
locale-libKF6Bookmarks6-gd \
locale-libKF6Bookmarks6-gl \
locale-libKF6Bookmarks6-gu \
locale-libKF6Bookmarks6-he \
locale-libKF6Bookmarks6-hi \
locale-libKF6Bookmarks6-hr \
locale-libKF6Bookmarks6-hu \
locale-libKF6Bookmarks6-ia \
locale-libKF6Bookmarks6-id \
locale-libKF6Bookmarks6-is \
locale-libKF6Bookmarks6-it \
locale-libKF6Bookmarks6-ja \
locale-libKF6Bookmarks6-ka \
locale-libKF6Bookmarks6-kk \
locale-libKF6Bookmarks6-km \
locale-libKF6Bookmarks6-ko \
locale-libKF6Bookmarks6-lt \
locale-libKF6Bookmarks6-lv \
locale-libKF6Bookmarks6-mai \
locale-libKF6Bookmarks6-mk \
locale-libKF6Bookmarks6-ml \
locale-libKF6Bookmarks6-mr \
locale-libKF6Bookmarks6-ms \
locale-libKF6Bookmarks6-nb \
locale-libKF6Bookmarks6-nds \
locale-libKF6Bookmarks6-ne \
locale-libKF6Bookmarks6-nl \
locale-libKF6Bookmarks6-nn \
locale-libKF6Bookmarks6-oc \
locale-libKF6Bookmarks6-pa \
locale-libKF6Bookmarks6-pl \
locale-libKF6Bookmarks6-pt \
locale-libKF6Bookmarks6-pt-BR \
locale-libKF6Bookmarks6-ro \
locale-libKF6Bookmarks6-ru \
locale-libKF6Bookmarks6-sk \
locale-libKF6Bookmarks6-sl \
locale-libKF6Bookmarks6-sq \
locale-libKF6Bookmarks6-sr \
locale-libKF6Bookmarks6-sr@ijekavian \
locale-libKF6Bookmarks6-sr@ijekavianlatin \
locale-libKF6Bookmarks6-sr@latin \
locale-libKF6Bookmarks6-sv \
locale-libKF6Bookmarks6-ta \
locale-libKF6Bookmarks6-th \
locale-libKF6Bookmarks6-tr \
locale-libKF6Bookmarks6-ug \
locale-libKF6Bookmarks6-uk \
locale-libKF6Bookmarks6-vi \
locale-libKF6Bookmarks6-wa \
locale-libKF6Bookmarks6-zh-CN \
locale-libKF6Bookmarks6-zh-TW"

RDEPENDS:${PN} += "libKF6Bookmarks6"

inherit rpm
