SUMMARY = "A kernel module to create V4L2 loopback devices"
DESCRIPTION = "This module allows you to create 'virtual video devices'. Normal (v4l2) \
applications will read these devices as if they were ordinary video \
devices, but the video will not be read from e.g. a capture card but \
instead it is generated by another application."
LICENSE = "GPL-2.0-or-later"

PV = "0.15.4_k7.2.4_1"

RPM_NAME = "v4l2loopback-kmp-64kb-0.15.4_k7.2.4_1-2.2.aarch64.rpm"
RPM_HASH = "0adddee7e17510e7e8a5642e3a00c35a68e1ead434a65c9f519bcdaa96b61be2cd3e26279c52a16df5a96cfdd59d09c43fafe6cac961a55e11a53bc3f25469f1"

RPROVIDES:${PN} += "kmod-v4l2loopback.ko \
multiversion-kernel \
v4l2loopback-kmp \
v4l2loopback-kmp-64kb \
v4l2loopback-kmp-64kb-k7.2.4-1"

RDEPENDS:${PN} += "/usr/bin/sh \
coreutils \
grep \
kernel-64kb \
ksym-64kb----ratelimit \
ksym-64kb---arch-copy-from-user \
ksym-64kb---arch-copy-to-user \
ksym-64kb---check-object-size \
ksym-64kb---init-waitqueue-head \
ksym-64kb---kmalloc-cache-noprof \
ksym-64kb---list-add-valid-or-report \
ksym-64kb---list-del-entry-valid-or-report \
ksym-64kb---msecs-to-jiffies \
ksym-64kb---stack-chk-fail \
ksym-64kb---video-register-device \
ksym-64kb---wake-up \
ksym-64kb--dev-err \
ksym-64kb--dev-warn \
ksym-64kb--printk \
ksym-64kb--raw-spin-lock \
ksym-64kb--raw-spin-lock-bh \
ksym-64kb--raw-spin-unlock \
ksym-64kb--raw-spin-unlock-bh \
ksym-64kb-alt-cb-patch-nops \
ksym-64kb-device-create-file \
ksym-64kb-device-remove-file \
ksym-64kb-dynamic-might-resched \
ksym-64kb-finish-wait \
ksym-64kb-idr-alloc \
ksym-64kb-idr-destroy \
ksym-64kb-idr-find \
ksym-64kb-idr-for-each \
ksym-64kb-idr-remove \
ksym-64kb-init-wait-entry \
ksym-64kb-jiffies \
ksym-64kb-kfree \
ksym-64kb-kmalloc-caches \
ksym-64kb-kstrtoull \
ksym-64kb-ktime-get-ts64 \
ksym-64kb-memcpy \
ksym-64kb-memset \
ksym-64kb-misc-deregister \
ksym-64kb-misc-register \
ksym-64kb-mod-timer \
ksym-64kb-module-layout \
ksym-64kb-mutex-init-generic \
ksym-64kb-mutex-lock \
ksym-64kb-mutex-lock-killable \
ksym-64kb-mutex-unlock \
ksym-64kb-nonseekable-open \
ksym-64kb-noop-llseek \
ksym-64kb-param-array-ops \
ksym-64kb-param-ops-bool \
ksym-64kb-param-ops-charp \
ksym-64kb-param-ops-int \
ksym-64kb-prepare-to-wait-event \
ksym-64kb-random-kmalloc-seed \
ksym-64kb-schedule \
ksym-64kb-snprintf \
ksym-64kb-sprintf \
ksym-64kb-sscanf \
ksym-64kb-timer-delete-sync \
ksym-64kb-timer-init-key \
ksym-64kb-v4l2-ctrl-handler-free \
ksym-64kb-v4l2-ctrl-handler-init-class \
ksym-64kb-v4l2-ctrl-handler-setup \
ksym-64kb-v4l2-ctrl-new-custom \
ksym-64kb-v4l2-ctrl-subscribe-event \
ksym-64kb-v4l2-device-register \
ksym-64kb-v4l2-device-unregister \
ksym-64kb-v4l2-event-pending \
ksym-64kb-v4l2-event-queue \
ksym-64kb-v4l2-event-subscribe \
ksym-64kb-v4l2-event-unsubscribe \
ksym-64kb-v4l2-fh-add \
ksym-64kb-v4l2-fh-del \
ksym-64kb-v4l2-fh-exit \
ksym-64kb-v4l2-fh-init \
ksym-64kb-v4l2-fill-pixfmt \
ksym-64kb-v4l2-fill-pixfmt-mp \
ksym-64kb-v4l2-format-info \
ksym-64kb-validate-usercopy-range \
ksym-64kb-vfree \
ksym-64kb-video-devdata \
ksym-64kb-video-device-alloc \
ksym-64kb-video-device-release \
ksym-64kb-video-ioctl2 \
ksym-64kb-video-unregister-device \
ksym-64kb-vm-insert-page \
ksym-64kb-vmalloc-noprof \
ksym-64kb-vmalloc-to-page \
ksym-64kb-vzalloc-noprof \
suse-kernel-rpm-scriptlets"

inherit rpm
